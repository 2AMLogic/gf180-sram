v {xschem version=3.4.7 file_version=1.2
* row_path -- MACHINE-GENERATED by design/generate_periphery.py;
* do not hand-edit, re-run the generator (see design/README.md).
* Row path (periphery record row 4): row = A[7:2]; two 3->8
* predecoders (A[7:5] gated with wl_en, A[4:2]) then a 2-input AND per
* row whose output stage is the wordline driver.
}
G {}
K {}
V {}
S {}
E {}
C {and4.sym} 0 460 0 0 {name=Xph0}
N -40 420 -60 420 {}
C {lab_pin.sym} -60 420 0 0 {name=l1 lab=aqb7}
N -40 440 -60 440 {}
C {lab_pin.sym} -60 440 0 0 {name=l2 lab=aqb6}
N -40 460 -60 460 {}
C {lab_pin.sym} -60 460 0 0 {name=l3 lab=aqb5}
N -40 480 -60 480 {}
C {lab_pin.sym} -60 480 0 0 {name=l4 lab=wl_en}
N 40 420 60 420 {}
C {lab_pin.sym} 60 420 0 0 {name=l5 lab=ph0}
N 0 380 0 360 {}
C {lab_pin.sym} 0 360 0 0 {name=l6 lab=VDD}
N 0 540 0 560 {}
C {lab_pin.sym} 0 560 0 0 {name=l7 lab=VSS}
C {and4.sym} 0 780 0 0 {name=Xph1}
N -40 740 -60 740 {}
C {lab_pin.sym} -60 740 0 0 {name=l8 lab=aqb7}
N -40 760 -60 760 {}
C {lab_pin.sym} -60 760 0 0 {name=l9 lab=aqb6}
N -40 780 -60 780 {}
C {lab_pin.sym} -60 780 0 0 {name=l10 lab=aq5}
N -40 800 -60 800 {}
C {lab_pin.sym} -60 800 0 0 {name=l11 lab=wl_en}
N 40 740 60 740 {}
C {lab_pin.sym} 60 740 0 0 {name=l12 lab=ph1}
N 0 700 0 680 {}
C {lab_pin.sym} 0 680 0 0 {name=l13 lab=VDD}
N 0 860 0 880 {}
C {lab_pin.sym} 0 880 0 0 {name=l14 lab=VSS}
C {and4.sym} 0 1100 0 0 {name=Xph2}
N -40 1060 -60 1060 {}
C {lab_pin.sym} -60 1060 0 0 {name=l15 lab=aqb7}
N -40 1080 -60 1080 {}
C {lab_pin.sym} -60 1080 0 0 {name=l16 lab=aq6}
N -40 1100 -60 1100 {}
C {lab_pin.sym} -60 1100 0 0 {name=l17 lab=aqb5}
N -40 1120 -60 1120 {}
C {lab_pin.sym} -60 1120 0 0 {name=l18 lab=wl_en}
N 40 1060 60 1060 {}
C {lab_pin.sym} 60 1060 0 0 {name=l19 lab=ph2}
N 0 1020 0 1000 {}
C {lab_pin.sym} 0 1000 0 0 {name=l20 lab=VDD}
N 0 1180 0 1200 {}
C {lab_pin.sym} 0 1200 0 0 {name=l21 lab=VSS}
C {and4.sym} 0 1420 0 0 {name=Xph3}
N -40 1380 -60 1380 {}
C {lab_pin.sym} -60 1380 0 0 {name=l22 lab=aqb7}
N -40 1400 -60 1400 {}
C {lab_pin.sym} -60 1400 0 0 {name=l23 lab=aq6}
N -40 1420 -60 1420 {}
C {lab_pin.sym} -60 1420 0 0 {name=l24 lab=aq5}
N -40 1440 -60 1440 {}
C {lab_pin.sym} -60 1440 0 0 {name=l25 lab=wl_en}
N 40 1380 60 1380 {}
C {lab_pin.sym} 60 1380 0 0 {name=l26 lab=ph3}
N 0 1340 0 1320 {}
C {lab_pin.sym} 0 1320 0 0 {name=l27 lab=VDD}
N 0 1500 0 1520 {}
C {lab_pin.sym} 0 1520 0 0 {name=l28 lab=VSS}
C {and4.sym} 0 1740 0 0 {name=Xph4}
N -40 1700 -60 1700 {}
C {lab_pin.sym} -60 1700 0 0 {name=l29 lab=aq7}
N -40 1720 -60 1720 {}
C {lab_pin.sym} -60 1720 0 0 {name=l30 lab=aqb6}
N -40 1740 -60 1740 {}
C {lab_pin.sym} -60 1740 0 0 {name=l31 lab=aqb5}
N -40 1760 -60 1760 {}
C {lab_pin.sym} -60 1760 0 0 {name=l32 lab=wl_en}
N 40 1700 60 1700 {}
C {lab_pin.sym} 60 1700 0 0 {name=l33 lab=ph4}
N 0 1660 0 1640 {}
C {lab_pin.sym} 0 1640 0 0 {name=l34 lab=VDD}
N 0 1820 0 1840 {}
C {lab_pin.sym} 0 1840 0 0 {name=l35 lab=VSS}
C {and4.sym} 0 2060 0 0 {name=Xph5}
N -40 2020 -60 2020 {}
C {lab_pin.sym} -60 2020 0 0 {name=l36 lab=aq7}
N -40 2040 -60 2040 {}
C {lab_pin.sym} -60 2040 0 0 {name=l37 lab=aqb6}
N -40 2060 -60 2060 {}
C {lab_pin.sym} -60 2060 0 0 {name=l38 lab=aq5}
N -40 2080 -60 2080 {}
C {lab_pin.sym} -60 2080 0 0 {name=l39 lab=wl_en}
N 40 2020 60 2020 {}
C {lab_pin.sym} 60 2020 0 0 {name=l40 lab=ph5}
N 0 1980 0 1960 {}
C {lab_pin.sym} 0 1960 0 0 {name=l41 lab=VDD}
N 0 2140 0 2160 {}
C {lab_pin.sym} 0 2160 0 0 {name=l42 lab=VSS}
C {and4.sym} 0 2380 0 0 {name=Xph6}
N -40 2340 -60 2340 {}
C {lab_pin.sym} -60 2340 0 0 {name=l43 lab=aq7}
N -40 2360 -60 2360 {}
C {lab_pin.sym} -60 2360 0 0 {name=l44 lab=aq6}
N -40 2380 -60 2380 {}
C {lab_pin.sym} -60 2380 0 0 {name=l45 lab=aqb5}
N -40 2400 -60 2400 {}
C {lab_pin.sym} -60 2400 0 0 {name=l46 lab=wl_en}
N 40 2340 60 2340 {}
C {lab_pin.sym} 60 2340 0 0 {name=l47 lab=ph6}
N 0 2300 0 2280 {}
C {lab_pin.sym} 0 2280 0 0 {name=l48 lab=VDD}
N 0 2460 0 2480 {}
C {lab_pin.sym} 0 2480 0 0 {name=l49 lab=VSS}
C {and4.sym} 0 2700 0 0 {name=Xph7}
N -40 2660 -60 2660 {}
C {lab_pin.sym} -60 2660 0 0 {name=l50 lab=aq7}
N -40 2680 -60 2680 {}
C {lab_pin.sym} -60 2680 0 0 {name=l51 lab=aq6}
N -40 2700 -60 2700 {}
C {lab_pin.sym} -60 2700 0 0 {name=l52 lab=aq5}
N -40 2720 -60 2720 {}
C {lab_pin.sym} -60 2720 0 0 {name=l53 lab=wl_en}
N 40 2660 60 2660 {}
C {lab_pin.sym} 60 2660 0 0 {name=l54 lab=ph7}
N 0 2620 0 2600 {}
C {lab_pin.sym} 0 2600 0 0 {name=l55 lab=VDD}
N 0 2780 0 2800 {}
C {lab_pin.sym} 0 2800 0 0 {name=l56 lab=VSS}
C {and3.sym} 0 3010 0 0 {name=Xpl0}
N -40 2980 -60 2980 {}
C {lab_pin.sym} -60 2980 0 0 {name=l57 lab=aqb4}
N -40 3000 -60 3000 {}
C {lab_pin.sym} -60 3000 0 0 {name=l58 lab=aqb3}
N -40 3020 -60 3020 {}
C {lab_pin.sym} -60 3020 0 0 {name=l59 lab=aqb2}
N 40 2980 60 2980 {}
C {lab_pin.sym} 60 2980 0 0 {name=l60 lab=pl0}
N 0 2940 0 2920 {}
C {lab_pin.sym} 0 2920 0 0 {name=l61 lab=VDD}
N 0 3080 0 3100 {}
C {lab_pin.sym} 0 3100 0 0 {name=l62 lab=VSS}
C {and3.sym} 0 3310 0 0 {name=Xpl1}
N -40 3280 -60 3280 {}
C {lab_pin.sym} -60 3280 0 0 {name=l63 lab=aqb4}
N -40 3300 -60 3300 {}
C {lab_pin.sym} -60 3300 0 0 {name=l64 lab=aqb3}
N -40 3320 -60 3320 {}
C {lab_pin.sym} -60 3320 0 0 {name=l65 lab=aq2}
N 40 3280 60 3280 {}
C {lab_pin.sym} 60 3280 0 0 {name=l66 lab=pl1}
N 0 3240 0 3220 {}
C {lab_pin.sym} 0 3220 0 0 {name=l67 lab=VDD}
N 0 3380 0 3400 {}
C {lab_pin.sym} 0 3400 0 0 {name=l68 lab=VSS}
C {and3.sym} 0 3610 0 0 {name=Xpl2}
N -40 3580 -60 3580 {}
C {lab_pin.sym} -60 3580 0 0 {name=l69 lab=aqb4}
N -40 3600 -60 3600 {}
C {lab_pin.sym} -60 3600 0 0 {name=l70 lab=aq3}
N -40 3620 -60 3620 {}
C {lab_pin.sym} -60 3620 0 0 {name=l71 lab=aqb2}
N 40 3580 60 3580 {}
C {lab_pin.sym} 60 3580 0 0 {name=l72 lab=pl2}
N 0 3540 0 3520 {}
C {lab_pin.sym} 0 3520 0 0 {name=l73 lab=VDD}
N 0 3680 0 3700 {}
C {lab_pin.sym} 0 3700 0 0 {name=l74 lab=VSS}
C {and3.sym} 0 3910 0 0 {name=Xpl3}
N -40 3880 -60 3880 {}
C {lab_pin.sym} -60 3880 0 0 {name=l75 lab=aqb4}
N -40 3900 -60 3900 {}
C {lab_pin.sym} -60 3900 0 0 {name=l76 lab=aq3}
N -40 3920 -60 3920 {}
C {lab_pin.sym} -60 3920 0 0 {name=l77 lab=aq2}
N 40 3880 60 3880 {}
C {lab_pin.sym} 60 3880 0 0 {name=l78 lab=pl3}
N 0 3840 0 3820 {}
C {lab_pin.sym} 0 3820 0 0 {name=l79 lab=VDD}
N 0 3980 0 4000 {}
C {lab_pin.sym} 0 4000 0 0 {name=l80 lab=VSS}
C {and3.sym} 0 4210 0 0 {name=Xpl4}
N -40 4180 -60 4180 {}
C {lab_pin.sym} -60 4180 0 0 {name=l81 lab=aq4}
N -40 4200 -60 4200 {}
C {lab_pin.sym} -60 4200 0 0 {name=l82 lab=aqb3}
N -40 4220 -60 4220 {}
C {lab_pin.sym} -60 4220 0 0 {name=l83 lab=aqb2}
N 40 4180 60 4180 {}
C {lab_pin.sym} 60 4180 0 0 {name=l84 lab=pl4}
N 0 4140 0 4120 {}
C {lab_pin.sym} 0 4120 0 0 {name=l85 lab=VDD}
N 0 4280 0 4300 {}
C {lab_pin.sym} 0 4300 0 0 {name=l86 lab=VSS}
C {and3.sym} 0 4510 0 0 {name=Xpl5}
N -40 4480 -60 4480 {}
C {lab_pin.sym} -60 4480 0 0 {name=l87 lab=aq4}
N -40 4500 -60 4500 {}
C {lab_pin.sym} -60 4500 0 0 {name=l88 lab=aqb3}
N -40 4520 -60 4520 {}
C {lab_pin.sym} -60 4520 0 0 {name=l89 lab=aq2}
N 40 4480 60 4480 {}
C {lab_pin.sym} 60 4480 0 0 {name=l90 lab=pl5}
N 0 4440 0 4420 {}
C {lab_pin.sym} 0 4420 0 0 {name=l91 lab=VDD}
N 0 4580 0 4600 {}
C {lab_pin.sym} 0 4600 0 0 {name=l92 lab=VSS}
C {and3.sym} 0 4810 0 0 {name=Xpl6}
N -40 4780 -60 4780 {}
C {lab_pin.sym} -60 4780 0 0 {name=l93 lab=aq4}
N -40 4800 -60 4800 {}
C {lab_pin.sym} -60 4800 0 0 {name=l94 lab=aq3}
N -40 4820 -60 4820 {}
C {lab_pin.sym} -60 4820 0 0 {name=l95 lab=aqb2}
N 40 4780 60 4780 {}
C {lab_pin.sym} 60 4780 0 0 {name=l96 lab=pl6}
N 0 4740 0 4720 {}
C {lab_pin.sym} 0 4720 0 0 {name=l97 lab=VDD}
N 0 4880 0 4900 {}
C {lab_pin.sym} 0 4900 0 0 {name=l98 lab=VSS}
C {and3.sym} 0 5110 0 0 {name=Xpl7}
N -40 5080 -60 5080 {}
C {lab_pin.sym} -60 5080 0 0 {name=l99 lab=aq4}
N -40 5100 -60 5100 {}
C {lab_pin.sym} -60 5100 0 0 {name=l100 lab=aq3}
N -40 5120 -60 5120 {}
C {lab_pin.sym} -60 5120 0 0 {name=l101 lab=aq2}
N 40 5080 60 5080 {}
C {lab_pin.sym} 60 5080 0 0 {name=l102 lab=pl7}
N 0 5040 0 5020 {}
C {lab_pin.sym} 0 5020 0 0 {name=l103 lab=VDD}
N 0 5180 0 5200 {}
C {lab_pin.sym} 0 5200 0 0 {name=l104 lab=VSS}
C {rowdrv.sym} 0 5400 0 0 {name=Xrow0}
N -40 5380 -60 5380 {}
C {lab_pin.sym} -60 5380 0 0 {name=l105 lab=ph0}
N -40 5400 -60 5400 {}
C {lab_pin.sym} -60 5400 0 0 {name=l106 lab=pl0}
N 40 5380 60 5380 {}
C {lab_pin.sym} 60 5380 0 0 {name=l107 lab=wl0}
N 0 5340 0 5320 {}
C {lab_pin.sym} 0 5320 0 0 {name=l108 lab=VDD}
N 0 5460 0 5480 {}
C {lab_pin.sym} 0 5480 0 0 {name=l109 lab=VSS}
C {rowdrv.sym} 0 5680 0 0 {name=Xrow1}
N -40 5660 -60 5660 {}
C {lab_pin.sym} -60 5660 0 0 {name=l110 lab=ph0}
N -40 5680 -60 5680 {}
C {lab_pin.sym} -60 5680 0 0 {name=l111 lab=pl1}
N 40 5660 60 5660 {}
C {lab_pin.sym} 60 5660 0 0 {name=l112 lab=wl1}
N 0 5620 0 5600 {}
C {lab_pin.sym} 0 5600 0 0 {name=l113 lab=VDD}
N 0 5740 0 5760 {}
C {lab_pin.sym} 0 5760 0 0 {name=l114 lab=VSS}
C {rowdrv.sym} 0 5960 0 0 {name=Xrow2}
N -40 5940 -60 5940 {}
C {lab_pin.sym} -60 5940 0 0 {name=l115 lab=ph0}
N -40 5960 -60 5960 {}
C {lab_pin.sym} -60 5960 0 0 {name=l116 lab=pl2}
N 40 5940 60 5940 {}
C {lab_pin.sym} 60 5940 0 0 {name=l117 lab=wl2}
N 0 5900 0 5880 {}
C {lab_pin.sym} 0 5880 0 0 {name=l118 lab=VDD}
N 0 6020 0 6040 {}
C {lab_pin.sym} 0 6040 0 0 {name=l119 lab=VSS}
C {rowdrv.sym} 0 6240 0 0 {name=Xrow3}
N -40 6220 -60 6220 {}
C {lab_pin.sym} -60 6220 0 0 {name=l120 lab=ph0}
N -40 6240 -60 6240 {}
C {lab_pin.sym} -60 6240 0 0 {name=l121 lab=pl3}
N 40 6220 60 6220 {}
C {lab_pin.sym} 60 6220 0 0 {name=l122 lab=wl3}
N 0 6180 0 6160 {}
C {lab_pin.sym} 0 6160 0 0 {name=l123 lab=VDD}
N 0 6300 0 6320 {}
C {lab_pin.sym} 0 6320 0 0 {name=l124 lab=VSS}
C {rowdrv.sym} 0 6520 0 0 {name=Xrow4}
N -40 6500 -60 6500 {}
C {lab_pin.sym} -60 6500 0 0 {name=l125 lab=ph0}
N -40 6520 -60 6520 {}
C {lab_pin.sym} -60 6520 0 0 {name=l126 lab=pl4}
N 40 6500 60 6500 {}
C {lab_pin.sym} 60 6500 0 0 {name=l127 lab=wl4}
N 0 6460 0 6440 {}
C {lab_pin.sym} 0 6440 0 0 {name=l128 lab=VDD}
N 0 6580 0 6600 {}
C {lab_pin.sym} 0 6600 0 0 {name=l129 lab=VSS}
C {rowdrv.sym} 0 6800 0 0 {name=Xrow5}
N -40 6780 -60 6780 {}
C {lab_pin.sym} -60 6780 0 0 {name=l130 lab=ph0}
N -40 6800 -60 6800 {}
C {lab_pin.sym} -60 6800 0 0 {name=l131 lab=pl5}
N 40 6780 60 6780 {}
C {lab_pin.sym} 60 6780 0 0 {name=l132 lab=wl5}
N 0 6740 0 6720 {}
C {lab_pin.sym} 0 6720 0 0 {name=l133 lab=VDD}
N 0 6860 0 6880 {}
C {lab_pin.sym} 0 6880 0 0 {name=l134 lab=VSS}
C {rowdrv.sym} 0 7080 0 0 {name=Xrow6}
N -40 7060 -60 7060 {}
C {lab_pin.sym} -60 7060 0 0 {name=l135 lab=ph0}
N -40 7080 -60 7080 {}
C {lab_pin.sym} -60 7080 0 0 {name=l136 lab=pl6}
N 40 7060 60 7060 {}
C {lab_pin.sym} 60 7060 0 0 {name=l137 lab=wl6}
N 0 7020 0 7000 {}
C {lab_pin.sym} 0 7000 0 0 {name=l138 lab=VDD}
N 0 7140 0 7160 {}
C {lab_pin.sym} 0 7160 0 0 {name=l139 lab=VSS}
C {rowdrv.sym} 0 7360 0 0 {name=Xrow7}
N -40 7340 -60 7340 {}
C {lab_pin.sym} -60 7340 0 0 {name=l140 lab=ph0}
N -40 7360 -60 7360 {}
C {lab_pin.sym} -60 7360 0 0 {name=l141 lab=pl7}
N 40 7340 60 7340 {}
C {lab_pin.sym} 60 7340 0 0 {name=l142 lab=wl7}
N 0 7300 0 7280 {}
C {lab_pin.sym} 0 7280 0 0 {name=l143 lab=VDD}
N 0 7420 0 7440 {}
C {lab_pin.sym} 0 7440 0 0 {name=l144 lab=VSS}
C {rowdrv.sym} 0 7640 0 0 {name=Xrow8}
N -40 7620 -60 7620 {}
C {lab_pin.sym} -60 7620 0 0 {name=l145 lab=ph1}
N -40 7640 -60 7640 {}
C {lab_pin.sym} -60 7640 0 0 {name=l146 lab=pl0}
N 40 7620 60 7620 {}
C {lab_pin.sym} 60 7620 0 0 {name=l147 lab=wl8}
N 0 7580 0 7560 {}
C {lab_pin.sym} 0 7560 0 0 {name=l148 lab=VDD}
N 0 7700 0 7720 {}
C {lab_pin.sym} 0 7720 0 0 {name=l149 lab=VSS}
C {rowdrv.sym} 0 7920 0 0 {name=Xrow9}
N -40 7900 -60 7900 {}
C {lab_pin.sym} -60 7900 0 0 {name=l150 lab=ph1}
N -40 7920 -60 7920 {}
C {lab_pin.sym} -60 7920 0 0 {name=l151 lab=pl1}
N 40 7900 60 7900 {}
C {lab_pin.sym} 60 7900 0 0 {name=l152 lab=wl9}
N 0 7860 0 7840 {}
C {lab_pin.sym} 0 7840 0 0 {name=l153 lab=VDD}
N 0 7980 0 8000 {}
C {lab_pin.sym} 0 8000 0 0 {name=l154 lab=VSS}
C {rowdrv.sym} 0 8200 0 0 {name=Xrow10}
N -40 8180 -60 8180 {}
C {lab_pin.sym} -60 8180 0 0 {name=l155 lab=ph1}
N -40 8200 -60 8200 {}
C {lab_pin.sym} -60 8200 0 0 {name=l156 lab=pl2}
N 40 8180 60 8180 {}
C {lab_pin.sym} 60 8180 0 0 {name=l157 lab=wl10}
N 0 8140 0 8120 {}
C {lab_pin.sym} 0 8120 0 0 {name=l158 lab=VDD}
N 0 8260 0 8280 {}
C {lab_pin.sym} 0 8280 0 0 {name=l159 lab=VSS}
C {rowdrv.sym} 0 8480 0 0 {name=Xrow11}
N -40 8460 -60 8460 {}
C {lab_pin.sym} -60 8460 0 0 {name=l160 lab=ph1}
N -40 8480 -60 8480 {}
C {lab_pin.sym} -60 8480 0 0 {name=l161 lab=pl3}
N 40 8460 60 8460 {}
C {lab_pin.sym} 60 8460 0 0 {name=l162 lab=wl11}
N 0 8420 0 8400 {}
C {lab_pin.sym} 0 8400 0 0 {name=l163 lab=VDD}
N 0 8540 0 8560 {}
C {lab_pin.sym} 0 8560 0 0 {name=l164 lab=VSS}
C {rowdrv.sym} 0 8760 0 0 {name=Xrow12}
N -40 8740 -60 8740 {}
C {lab_pin.sym} -60 8740 0 0 {name=l165 lab=ph1}
N -40 8760 -60 8760 {}
C {lab_pin.sym} -60 8760 0 0 {name=l166 lab=pl4}
N 40 8740 60 8740 {}
C {lab_pin.sym} 60 8740 0 0 {name=l167 lab=wl12}
N 0 8700 0 8680 {}
C {lab_pin.sym} 0 8680 0 0 {name=l168 lab=VDD}
N 0 8820 0 8840 {}
C {lab_pin.sym} 0 8840 0 0 {name=l169 lab=VSS}
C {rowdrv.sym} 0 9040 0 0 {name=Xrow13}
N -40 9020 -60 9020 {}
C {lab_pin.sym} -60 9020 0 0 {name=l170 lab=ph1}
N -40 9040 -60 9040 {}
C {lab_pin.sym} -60 9040 0 0 {name=l171 lab=pl5}
N 40 9020 60 9020 {}
C {lab_pin.sym} 60 9020 0 0 {name=l172 lab=wl13}
N 0 8980 0 8960 {}
C {lab_pin.sym} 0 8960 0 0 {name=l173 lab=VDD}
N 0 9100 0 9120 {}
C {lab_pin.sym} 0 9120 0 0 {name=l174 lab=VSS}
C {rowdrv.sym} 0 9320 0 0 {name=Xrow14}
N -40 9300 -60 9300 {}
C {lab_pin.sym} -60 9300 0 0 {name=l175 lab=ph1}
N -40 9320 -60 9320 {}
C {lab_pin.sym} -60 9320 0 0 {name=l176 lab=pl6}
N 40 9300 60 9300 {}
C {lab_pin.sym} 60 9300 0 0 {name=l177 lab=wl14}
N 0 9260 0 9240 {}
C {lab_pin.sym} 0 9240 0 0 {name=l178 lab=VDD}
N 0 9380 0 9400 {}
C {lab_pin.sym} 0 9400 0 0 {name=l179 lab=VSS}
C {rowdrv.sym} 0 9600 0 0 {name=Xrow15}
N -40 9580 -60 9580 {}
C {lab_pin.sym} -60 9580 0 0 {name=l180 lab=ph1}
N -40 9600 -60 9600 {}
C {lab_pin.sym} -60 9600 0 0 {name=l181 lab=pl7}
N 40 9580 60 9580 {}
C {lab_pin.sym} 60 9580 0 0 {name=l182 lab=wl15}
N 0 9540 0 9520 {}
C {lab_pin.sym} 0 9520 0 0 {name=l183 lab=VDD}
N 0 9660 0 9680 {}
C {lab_pin.sym} 0 9680 0 0 {name=l184 lab=VSS}
C {rowdrv.sym} 0 9880 0 0 {name=Xrow16}
N -40 9860 -60 9860 {}
C {lab_pin.sym} -60 9860 0 0 {name=l185 lab=ph2}
N -40 9880 -60 9880 {}
C {lab_pin.sym} -60 9880 0 0 {name=l186 lab=pl0}
N 40 9860 60 9860 {}
C {lab_pin.sym} 60 9860 0 0 {name=l187 lab=wl16}
N 0 9820 0 9800 {}
C {lab_pin.sym} 0 9800 0 0 {name=l188 lab=VDD}
N 0 9940 0 9960 {}
C {lab_pin.sym} 0 9960 0 0 {name=l189 lab=VSS}
C {rowdrv.sym} 0 10160 0 0 {name=Xrow17}
N -40 10140 -60 10140 {}
C {lab_pin.sym} -60 10140 0 0 {name=l190 lab=ph2}
N -40 10160 -60 10160 {}
C {lab_pin.sym} -60 10160 0 0 {name=l191 lab=pl1}
N 40 10140 60 10140 {}
C {lab_pin.sym} 60 10140 0 0 {name=l192 lab=wl17}
N 0 10100 0 10080 {}
C {lab_pin.sym} 0 10080 0 0 {name=l193 lab=VDD}
N 0 10220 0 10240 {}
C {lab_pin.sym} 0 10240 0 0 {name=l194 lab=VSS}
C {rowdrv.sym} 0 10440 0 0 {name=Xrow18}
N -40 10420 -60 10420 {}
C {lab_pin.sym} -60 10420 0 0 {name=l195 lab=ph2}
N -40 10440 -60 10440 {}
C {lab_pin.sym} -60 10440 0 0 {name=l196 lab=pl2}
N 40 10420 60 10420 {}
C {lab_pin.sym} 60 10420 0 0 {name=l197 lab=wl18}
N 0 10380 0 10360 {}
C {lab_pin.sym} 0 10360 0 0 {name=l198 lab=VDD}
N 0 10500 0 10520 {}
C {lab_pin.sym} 0 10520 0 0 {name=l199 lab=VSS}
C {rowdrv.sym} 0 10720 0 0 {name=Xrow19}
N -40 10700 -60 10700 {}
C {lab_pin.sym} -60 10700 0 0 {name=l200 lab=ph2}
N -40 10720 -60 10720 {}
C {lab_pin.sym} -60 10720 0 0 {name=l201 lab=pl3}
N 40 10700 60 10700 {}
C {lab_pin.sym} 60 10700 0 0 {name=l202 lab=wl19}
N 0 10660 0 10640 {}
C {lab_pin.sym} 0 10640 0 0 {name=l203 lab=VDD}
N 0 10780 0 10800 {}
C {lab_pin.sym} 0 10800 0 0 {name=l204 lab=VSS}
C {rowdrv.sym} 0 11000 0 0 {name=Xrow20}
N -40 10980 -60 10980 {}
C {lab_pin.sym} -60 10980 0 0 {name=l205 lab=ph2}
N -40 11000 -60 11000 {}
C {lab_pin.sym} -60 11000 0 0 {name=l206 lab=pl4}
N 40 10980 60 10980 {}
C {lab_pin.sym} 60 10980 0 0 {name=l207 lab=wl20}
N 0 10940 0 10920 {}
C {lab_pin.sym} 0 10920 0 0 {name=l208 lab=VDD}
N 0 11060 0 11080 {}
C {lab_pin.sym} 0 11080 0 0 {name=l209 lab=VSS}
C {rowdrv.sym} 0 11280 0 0 {name=Xrow21}
N -40 11260 -60 11260 {}
C {lab_pin.sym} -60 11260 0 0 {name=l210 lab=ph2}
N -40 11280 -60 11280 {}
C {lab_pin.sym} -60 11280 0 0 {name=l211 lab=pl5}
N 40 11260 60 11260 {}
C {lab_pin.sym} 60 11260 0 0 {name=l212 lab=wl21}
N 0 11220 0 11200 {}
C {lab_pin.sym} 0 11200 0 0 {name=l213 lab=VDD}
N 0 11340 0 11360 {}
C {lab_pin.sym} 0 11360 0 0 {name=l214 lab=VSS}
C {rowdrv.sym} 0 11560 0 0 {name=Xrow22}
N -40 11540 -60 11540 {}
C {lab_pin.sym} -60 11540 0 0 {name=l215 lab=ph2}
N -40 11560 -60 11560 {}
C {lab_pin.sym} -60 11560 0 0 {name=l216 lab=pl6}
N 40 11540 60 11540 {}
C {lab_pin.sym} 60 11540 0 0 {name=l217 lab=wl22}
N 0 11500 0 11480 {}
C {lab_pin.sym} 0 11480 0 0 {name=l218 lab=VDD}
N 0 11620 0 11640 {}
C {lab_pin.sym} 0 11640 0 0 {name=l219 lab=VSS}
C {rowdrv.sym} 0 11840 0 0 {name=Xrow23}
N -40 11820 -60 11820 {}
C {lab_pin.sym} -60 11820 0 0 {name=l220 lab=ph2}
N -40 11840 -60 11840 {}
C {lab_pin.sym} -60 11840 0 0 {name=l221 lab=pl7}
N 40 11820 60 11820 {}
C {lab_pin.sym} 60 11820 0 0 {name=l222 lab=wl23}
N 0 11780 0 11760 {}
C {lab_pin.sym} 0 11760 0 0 {name=l223 lab=VDD}
N 0 11900 0 11920 {}
C {lab_pin.sym} 0 11920 0 0 {name=l224 lab=VSS}
C {rowdrv.sym} 0 12120 0 0 {name=Xrow24}
N -40 12100 -60 12100 {}
C {lab_pin.sym} -60 12100 0 0 {name=l225 lab=ph3}
N -40 12120 -60 12120 {}
C {lab_pin.sym} -60 12120 0 0 {name=l226 lab=pl0}
N 40 12100 60 12100 {}
C {lab_pin.sym} 60 12100 0 0 {name=l227 lab=wl24}
N 0 12060 0 12040 {}
C {lab_pin.sym} 0 12040 0 0 {name=l228 lab=VDD}
N 0 12180 0 12200 {}
C {lab_pin.sym} 0 12200 0 0 {name=l229 lab=VSS}
C {rowdrv.sym} 0 12400 0 0 {name=Xrow25}
N -40 12380 -60 12380 {}
C {lab_pin.sym} -60 12380 0 0 {name=l230 lab=ph3}
N -40 12400 -60 12400 {}
C {lab_pin.sym} -60 12400 0 0 {name=l231 lab=pl1}
N 40 12380 60 12380 {}
C {lab_pin.sym} 60 12380 0 0 {name=l232 lab=wl25}
N 0 12340 0 12320 {}
C {lab_pin.sym} 0 12320 0 0 {name=l233 lab=VDD}
N 0 12460 0 12480 {}
C {lab_pin.sym} 0 12480 0 0 {name=l234 lab=VSS}
C {rowdrv.sym} 0 12680 0 0 {name=Xrow26}
N -40 12660 -60 12660 {}
C {lab_pin.sym} -60 12660 0 0 {name=l235 lab=ph3}
N -40 12680 -60 12680 {}
C {lab_pin.sym} -60 12680 0 0 {name=l236 lab=pl2}
N 40 12660 60 12660 {}
C {lab_pin.sym} 60 12660 0 0 {name=l237 lab=wl26}
N 0 12620 0 12600 {}
C {lab_pin.sym} 0 12600 0 0 {name=l238 lab=VDD}
N 0 12740 0 12760 {}
C {lab_pin.sym} 0 12760 0 0 {name=l239 lab=VSS}
C {rowdrv.sym} 0 12960 0 0 {name=Xrow27}
N -40 12940 -60 12940 {}
C {lab_pin.sym} -60 12940 0 0 {name=l240 lab=ph3}
N -40 12960 -60 12960 {}
C {lab_pin.sym} -60 12960 0 0 {name=l241 lab=pl3}
N 40 12940 60 12940 {}
C {lab_pin.sym} 60 12940 0 0 {name=l242 lab=wl27}
N 0 12900 0 12880 {}
C {lab_pin.sym} 0 12880 0 0 {name=l243 lab=VDD}
N 0 13020 0 13040 {}
C {lab_pin.sym} 0 13040 0 0 {name=l244 lab=VSS}
C {rowdrv.sym} 0 13240 0 0 {name=Xrow28}
N -40 13220 -60 13220 {}
C {lab_pin.sym} -60 13220 0 0 {name=l245 lab=ph3}
N -40 13240 -60 13240 {}
C {lab_pin.sym} -60 13240 0 0 {name=l246 lab=pl4}
N 40 13220 60 13220 {}
C {lab_pin.sym} 60 13220 0 0 {name=l247 lab=wl28}
N 0 13180 0 13160 {}
C {lab_pin.sym} 0 13160 0 0 {name=l248 lab=VDD}
N 0 13300 0 13320 {}
C {lab_pin.sym} 0 13320 0 0 {name=l249 lab=VSS}
C {rowdrv.sym} 0 13520 0 0 {name=Xrow29}
N -40 13500 -60 13500 {}
C {lab_pin.sym} -60 13500 0 0 {name=l250 lab=ph3}
N -40 13520 -60 13520 {}
C {lab_pin.sym} -60 13520 0 0 {name=l251 lab=pl5}
N 40 13500 60 13500 {}
C {lab_pin.sym} 60 13500 0 0 {name=l252 lab=wl29}
N 0 13460 0 13440 {}
C {lab_pin.sym} 0 13440 0 0 {name=l253 lab=VDD}
N 0 13580 0 13600 {}
C {lab_pin.sym} 0 13600 0 0 {name=l254 lab=VSS}
C {rowdrv.sym} 0 13800 0 0 {name=Xrow30}
N -40 13780 -60 13780 {}
C {lab_pin.sym} -60 13780 0 0 {name=l255 lab=ph3}
N -40 13800 -60 13800 {}
C {lab_pin.sym} -60 13800 0 0 {name=l256 lab=pl6}
N 40 13780 60 13780 {}
C {lab_pin.sym} 60 13780 0 0 {name=l257 lab=wl30}
N 0 13740 0 13720 {}
C {lab_pin.sym} 0 13720 0 0 {name=l258 lab=VDD}
N 0 13860 0 13880 {}
C {lab_pin.sym} 0 13880 0 0 {name=l259 lab=VSS}
C {rowdrv.sym} 0 14080 0 0 {name=Xrow31}
N -40 14060 -60 14060 {}
C {lab_pin.sym} -60 14060 0 0 {name=l260 lab=ph3}
N -40 14080 -60 14080 {}
C {lab_pin.sym} -60 14080 0 0 {name=l261 lab=pl7}
N 40 14060 60 14060 {}
C {lab_pin.sym} 60 14060 0 0 {name=l262 lab=wl31}
N 0 14020 0 14000 {}
C {lab_pin.sym} 0 14000 0 0 {name=l263 lab=VDD}
N 0 14140 0 14160 {}
C {lab_pin.sym} 0 14160 0 0 {name=l264 lab=VSS}
C {rowdrv.sym} 0 14360 0 0 {name=Xrow32}
N -40 14340 -60 14340 {}
C {lab_pin.sym} -60 14340 0 0 {name=l265 lab=ph4}
N -40 14360 -60 14360 {}
C {lab_pin.sym} -60 14360 0 0 {name=l266 lab=pl0}
N 40 14340 60 14340 {}
C {lab_pin.sym} 60 14340 0 0 {name=l267 lab=wl32}
N 0 14300 0 14280 {}
C {lab_pin.sym} 0 14280 0 0 {name=l268 lab=VDD}
N 0 14420 0 14440 {}
C {lab_pin.sym} 0 14440 0 0 {name=l269 lab=VSS}
C {rowdrv.sym} 0 14640 0 0 {name=Xrow33}
N -40 14620 -60 14620 {}
C {lab_pin.sym} -60 14620 0 0 {name=l270 lab=ph4}
N -40 14640 -60 14640 {}
C {lab_pin.sym} -60 14640 0 0 {name=l271 lab=pl1}
N 40 14620 60 14620 {}
C {lab_pin.sym} 60 14620 0 0 {name=l272 lab=wl33}
N 0 14580 0 14560 {}
C {lab_pin.sym} 0 14560 0 0 {name=l273 lab=VDD}
N 0 14700 0 14720 {}
C {lab_pin.sym} 0 14720 0 0 {name=l274 lab=VSS}
C {rowdrv.sym} 0 14920 0 0 {name=Xrow34}
N -40 14900 -60 14900 {}
C {lab_pin.sym} -60 14900 0 0 {name=l275 lab=ph4}
N -40 14920 -60 14920 {}
C {lab_pin.sym} -60 14920 0 0 {name=l276 lab=pl2}
N 40 14900 60 14900 {}
C {lab_pin.sym} 60 14900 0 0 {name=l277 lab=wl34}
N 0 14860 0 14840 {}
C {lab_pin.sym} 0 14840 0 0 {name=l278 lab=VDD}
N 0 14980 0 15000 {}
C {lab_pin.sym} 0 15000 0 0 {name=l279 lab=VSS}
C {rowdrv.sym} 0 15200 0 0 {name=Xrow35}
N -40 15180 -60 15180 {}
C {lab_pin.sym} -60 15180 0 0 {name=l280 lab=ph4}
N -40 15200 -60 15200 {}
C {lab_pin.sym} -60 15200 0 0 {name=l281 lab=pl3}
N 40 15180 60 15180 {}
C {lab_pin.sym} 60 15180 0 0 {name=l282 lab=wl35}
N 0 15140 0 15120 {}
C {lab_pin.sym} 0 15120 0 0 {name=l283 lab=VDD}
N 0 15260 0 15280 {}
C {lab_pin.sym} 0 15280 0 0 {name=l284 lab=VSS}
C {rowdrv.sym} 0 15480 0 0 {name=Xrow36}
N -40 15460 -60 15460 {}
C {lab_pin.sym} -60 15460 0 0 {name=l285 lab=ph4}
N -40 15480 -60 15480 {}
C {lab_pin.sym} -60 15480 0 0 {name=l286 lab=pl4}
N 40 15460 60 15460 {}
C {lab_pin.sym} 60 15460 0 0 {name=l287 lab=wl36}
N 0 15420 0 15400 {}
C {lab_pin.sym} 0 15400 0 0 {name=l288 lab=VDD}
N 0 15540 0 15560 {}
C {lab_pin.sym} 0 15560 0 0 {name=l289 lab=VSS}
C {rowdrv.sym} 0 15760 0 0 {name=Xrow37}
N -40 15740 -60 15740 {}
C {lab_pin.sym} -60 15740 0 0 {name=l290 lab=ph4}
N -40 15760 -60 15760 {}
C {lab_pin.sym} -60 15760 0 0 {name=l291 lab=pl5}
N 40 15740 60 15740 {}
C {lab_pin.sym} 60 15740 0 0 {name=l292 lab=wl37}
N 0 15700 0 15680 {}
C {lab_pin.sym} 0 15680 0 0 {name=l293 lab=VDD}
N 0 15820 0 15840 {}
C {lab_pin.sym} 0 15840 0 0 {name=l294 lab=VSS}
C {rowdrv.sym} 0 16040 0 0 {name=Xrow38}
N -40 16020 -60 16020 {}
C {lab_pin.sym} -60 16020 0 0 {name=l295 lab=ph4}
N -40 16040 -60 16040 {}
C {lab_pin.sym} -60 16040 0 0 {name=l296 lab=pl6}
N 40 16020 60 16020 {}
C {lab_pin.sym} 60 16020 0 0 {name=l297 lab=wl38}
N 0 15980 0 15960 {}
C {lab_pin.sym} 0 15960 0 0 {name=l298 lab=VDD}
N 0 16100 0 16120 {}
C {lab_pin.sym} 0 16120 0 0 {name=l299 lab=VSS}
C {rowdrv.sym} 0 16320 0 0 {name=Xrow39}
N -40 16300 -60 16300 {}
C {lab_pin.sym} -60 16300 0 0 {name=l300 lab=ph4}
N -40 16320 -60 16320 {}
C {lab_pin.sym} -60 16320 0 0 {name=l301 lab=pl7}
N 40 16300 60 16300 {}
C {lab_pin.sym} 60 16300 0 0 {name=l302 lab=wl39}
N 0 16260 0 16240 {}
C {lab_pin.sym} 0 16240 0 0 {name=l303 lab=VDD}
N 0 16380 0 16400 {}
C {lab_pin.sym} 0 16400 0 0 {name=l304 lab=VSS}
C {rowdrv.sym} 0 16600 0 0 {name=Xrow40}
N -40 16580 -60 16580 {}
C {lab_pin.sym} -60 16580 0 0 {name=l305 lab=ph5}
N -40 16600 -60 16600 {}
C {lab_pin.sym} -60 16600 0 0 {name=l306 lab=pl0}
N 40 16580 60 16580 {}
C {lab_pin.sym} 60 16580 0 0 {name=l307 lab=wl40}
N 0 16540 0 16520 {}
C {lab_pin.sym} 0 16520 0 0 {name=l308 lab=VDD}
N 0 16660 0 16680 {}
C {lab_pin.sym} 0 16680 0 0 {name=l309 lab=VSS}
C {rowdrv.sym} 0 16880 0 0 {name=Xrow41}
N -40 16860 -60 16860 {}
C {lab_pin.sym} -60 16860 0 0 {name=l310 lab=ph5}
N -40 16880 -60 16880 {}
C {lab_pin.sym} -60 16880 0 0 {name=l311 lab=pl1}
N 40 16860 60 16860 {}
C {lab_pin.sym} 60 16860 0 0 {name=l312 lab=wl41}
N 0 16820 0 16800 {}
C {lab_pin.sym} 0 16800 0 0 {name=l313 lab=VDD}
N 0 16940 0 16960 {}
C {lab_pin.sym} 0 16960 0 0 {name=l314 lab=VSS}
C {rowdrv.sym} 0 17160 0 0 {name=Xrow42}
N -40 17140 -60 17140 {}
C {lab_pin.sym} -60 17140 0 0 {name=l315 lab=ph5}
N -40 17160 -60 17160 {}
C {lab_pin.sym} -60 17160 0 0 {name=l316 lab=pl2}
N 40 17140 60 17140 {}
C {lab_pin.sym} 60 17140 0 0 {name=l317 lab=wl42}
N 0 17100 0 17080 {}
C {lab_pin.sym} 0 17080 0 0 {name=l318 lab=VDD}
N 0 17220 0 17240 {}
C {lab_pin.sym} 0 17240 0 0 {name=l319 lab=VSS}
C {rowdrv.sym} 0 17440 0 0 {name=Xrow43}
N -40 17420 -60 17420 {}
C {lab_pin.sym} -60 17420 0 0 {name=l320 lab=ph5}
N -40 17440 -60 17440 {}
C {lab_pin.sym} -60 17440 0 0 {name=l321 lab=pl3}
N 40 17420 60 17420 {}
C {lab_pin.sym} 60 17420 0 0 {name=l322 lab=wl43}
N 0 17380 0 17360 {}
C {lab_pin.sym} 0 17360 0 0 {name=l323 lab=VDD}
N 0 17500 0 17520 {}
C {lab_pin.sym} 0 17520 0 0 {name=l324 lab=VSS}
C {rowdrv.sym} 0 17720 0 0 {name=Xrow44}
N -40 17700 -60 17700 {}
C {lab_pin.sym} -60 17700 0 0 {name=l325 lab=ph5}
N -40 17720 -60 17720 {}
C {lab_pin.sym} -60 17720 0 0 {name=l326 lab=pl4}
N 40 17700 60 17700 {}
C {lab_pin.sym} 60 17700 0 0 {name=l327 lab=wl44}
N 0 17660 0 17640 {}
C {lab_pin.sym} 0 17640 0 0 {name=l328 lab=VDD}
N 0 17780 0 17800 {}
C {lab_pin.sym} 0 17800 0 0 {name=l329 lab=VSS}
C {rowdrv.sym} 0 18000 0 0 {name=Xrow45}
N -40 17980 -60 17980 {}
C {lab_pin.sym} -60 17980 0 0 {name=l330 lab=ph5}
N -40 18000 -60 18000 {}
C {lab_pin.sym} -60 18000 0 0 {name=l331 lab=pl5}
N 40 17980 60 17980 {}
C {lab_pin.sym} 60 17980 0 0 {name=l332 lab=wl45}
N 0 17940 0 17920 {}
C {lab_pin.sym} 0 17920 0 0 {name=l333 lab=VDD}
N 0 18060 0 18080 {}
C {lab_pin.sym} 0 18080 0 0 {name=l334 lab=VSS}
C {rowdrv.sym} 0 18280 0 0 {name=Xrow46}
N -40 18260 -60 18260 {}
C {lab_pin.sym} -60 18260 0 0 {name=l335 lab=ph5}
N -40 18280 -60 18280 {}
C {lab_pin.sym} -60 18280 0 0 {name=l336 lab=pl6}
N 40 18260 60 18260 {}
C {lab_pin.sym} 60 18260 0 0 {name=l337 lab=wl46}
N 0 18220 0 18200 {}
C {lab_pin.sym} 0 18200 0 0 {name=l338 lab=VDD}
N 0 18340 0 18360 {}
C {lab_pin.sym} 0 18360 0 0 {name=l339 lab=VSS}
C {rowdrv.sym} 0 18560 0 0 {name=Xrow47}
N -40 18540 -60 18540 {}
C {lab_pin.sym} -60 18540 0 0 {name=l340 lab=ph5}
N -40 18560 -60 18560 {}
C {lab_pin.sym} -60 18560 0 0 {name=l341 lab=pl7}
N 40 18540 60 18540 {}
C {lab_pin.sym} 60 18540 0 0 {name=l342 lab=wl47}
N 0 18500 0 18480 {}
C {lab_pin.sym} 0 18480 0 0 {name=l343 lab=VDD}
N 0 18620 0 18640 {}
C {lab_pin.sym} 0 18640 0 0 {name=l344 lab=VSS}
C {rowdrv.sym} 0 18840 0 0 {name=Xrow48}
N -40 18820 -60 18820 {}
C {lab_pin.sym} -60 18820 0 0 {name=l345 lab=ph6}
N -40 18840 -60 18840 {}
C {lab_pin.sym} -60 18840 0 0 {name=l346 lab=pl0}
N 40 18820 60 18820 {}
C {lab_pin.sym} 60 18820 0 0 {name=l347 lab=wl48}
N 0 18780 0 18760 {}
C {lab_pin.sym} 0 18760 0 0 {name=l348 lab=VDD}
N 0 18900 0 18920 {}
C {lab_pin.sym} 0 18920 0 0 {name=l349 lab=VSS}
C {rowdrv.sym} 0 19120 0 0 {name=Xrow49}
N -40 19100 -60 19100 {}
C {lab_pin.sym} -60 19100 0 0 {name=l350 lab=ph6}
N -40 19120 -60 19120 {}
C {lab_pin.sym} -60 19120 0 0 {name=l351 lab=pl1}
N 40 19100 60 19100 {}
C {lab_pin.sym} 60 19100 0 0 {name=l352 lab=wl49}
N 0 19060 0 19040 {}
C {lab_pin.sym} 0 19040 0 0 {name=l353 lab=VDD}
N 0 19180 0 19200 {}
C {lab_pin.sym} 0 19200 0 0 {name=l354 lab=VSS}
C {rowdrv.sym} 0 19400 0 0 {name=Xrow50}
N -40 19380 -60 19380 {}
C {lab_pin.sym} -60 19380 0 0 {name=l355 lab=ph6}
N -40 19400 -60 19400 {}
C {lab_pin.sym} -60 19400 0 0 {name=l356 lab=pl2}
N 40 19380 60 19380 {}
C {lab_pin.sym} 60 19380 0 0 {name=l357 lab=wl50}
N 0 19340 0 19320 {}
C {lab_pin.sym} 0 19320 0 0 {name=l358 lab=VDD}
N 0 19460 0 19480 {}
C {lab_pin.sym} 0 19480 0 0 {name=l359 lab=VSS}
C {rowdrv.sym} 0 19680 0 0 {name=Xrow51}
N -40 19660 -60 19660 {}
C {lab_pin.sym} -60 19660 0 0 {name=l360 lab=ph6}
N -40 19680 -60 19680 {}
C {lab_pin.sym} -60 19680 0 0 {name=l361 lab=pl3}
N 40 19660 60 19660 {}
C {lab_pin.sym} 60 19660 0 0 {name=l362 lab=wl51}
N 0 19620 0 19600 {}
C {lab_pin.sym} 0 19600 0 0 {name=l363 lab=VDD}
N 0 19740 0 19760 {}
C {lab_pin.sym} 0 19760 0 0 {name=l364 lab=VSS}
C {rowdrv.sym} 0 19960 0 0 {name=Xrow52}
N -40 19940 -60 19940 {}
C {lab_pin.sym} -60 19940 0 0 {name=l365 lab=ph6}
N -40 19960 -60 19960 {}
C {lab_pin.sym} -60 19960 0 0 {name=l366 lab=pl4}
N 40 19940 60 19940 {}
C {lab_pin.sym} 60 19940 0 0 {name=l367 lab=wl52}
N 0 19900 0 19880 {}
C {lab_pin.sym} 0 19880 0 0 {name=l368 lab=VDD}
N 0 20020 0 20040 {}
C {lab_pin.sym} 0 20040 0 0 {name=l369 lab=VSS}
C {rowdrv.sym} 0 20240 0 0 {name=Xrow53}
N -40 20220 -60 20220 {}
C {lab_pin.sym} -60 20220 0 0 {name=l370 lab=ph6}
N -40 20240 -60 20240 {}
C {lab_pin.sym} -60 20240 0 0 {name=l371 lab=pl5}
N 40 20220 60 20220 {}
C {lab_pin.sym} 60 20220 0 0 {name=l372 lab=wl53}
N 0 20180 0 20160 {}
C {lab_pin.sym} 0 20160 0 0 {name=l373 lab=VDD}
N 0 20300 0 20320 {}
C {lab_pin.sym} 0 20320 0 0 {name=l374 lab=VSS}
C {rowdrv.sym} 0 20520 0 0 {name=Xrow54}
N -40 20500 -60 20500 {}
C {lab_pin.sym} -60 20500 0 0 {name=l375 lab=ph6}
N -40 20520 -60 20520 {}
C {lab_pin.sym} -60 20520 0 0 {name=l376 lab=pl6}
N 40 20500 60 20500 {}
C {lab_pin.sym} 60 20500 0 0 {name=l377 lab=wl54}
N 0 20460 0 20440 {}
C {lab_pin.sym} 0 20440 0 0 {name=l378 lab=VDD}
N 0 20580 0 20600 {}
C {lab_pin.sym} 0 20600 0 0 {name=l379 lab=VSS}
C {rowdrv.sym} 0 20800 0 0 {name=Xrow55}
N -40 20780 -60 20780 {}
C {lab_pin.sym} -60 20780 0 0 {name=l380 lab=ph6}
N -40 20800 -60 20800 {}
C {lab_pin.sym} -60 20800 0 0 {name=l381 lab=pl7}
N 40 20780 60 20780 {}
C {lab_pin.sym} 60 20780 0 0 {name=l382 lab=wl55}
N 0 20740 0 20720 {}
C {lab_pin.sym} 0 20720 0 0 {name=l383 lab=VDD}
N 0 20860 0 20880 {}
C {lab_pin.sym} 0 20880 0 0 {name=l384 lab=VSS}
C {rowdrv.sym} 0 21080 0 0 {name=Xrow56}
N -40 21060 -60 21060 {}
C {lab_pin.sym} -60 21060 0 0 {name=l385 lab=ph7}
N -40 21080 -60 21080 {}
C {lab_pin.sym} -60 21080 0 0 {name=l386 lab=pl0}
N 40 21060 60 21060 {}
C {lab_pin.sym} 60 21060 0 0 {name=l387 lab=wl56}
N 0 21020 0 21000 {}
C {lab_pin.sym} 0 21000 0 0 {name=l388 lab=VDD}
N 0 21140 0 21160 {}
C {lab_pin.sym} 0 21160 0 0 {name=l389 lab=VSS}
C {rowdrv.sym} 0 21360 0 0 {name=Xrow57}
N -40 21340 -60 21340 {}
C {lab_pin.sym} -60 21340 0 0 {name=l390 lab=ph7}
N -40 21360 -60 21360 {}
C {lab_pin.sym} -60 21360 0 0 {name=l391 lab=pl1}
N 40 21340 60 21340 {}
C {lab_pin.sym} 60 21340 0 0 {name=l392 lab=wl57}
N 0 21300 0 21280 {}
C {lab_pin.sym} 0 21280 0 0 {name=l393 lab=VDD}
N 0 21420 0 21440 {}
C {lab_pin.sym} 0 21440 0 0 {name=l394 lab=VSS}
C {rowdrv.sym} 0 21640 0 0 {name=Xrow58}
N -40 21620 -60 21620 {}
C {lab_pin.sym} -60 21620 0 0 {name=l395 lab=ph7}
N -40 21640 -60 21640 {}
C {lab_pin.sym} -60 21640 0 0 {name=l396 lab=pl2}
N 40 21620 60 21620 {}
C {lab_pin.sym} 60 21620 0 0 {name=l397 lab=wl58}
N 0 21580 0 21560 {}
C {lab_pin.sym} 0 21560 0 0 {name=l398 lab=VDD}
N 0 21700 0 21720 {}
C {lab_pin.sym} 0 21720 0 0 {name=l399 lab=VSS}
C {rowdrv.sym} 0 21920 0 0 {name=Xrow59}
N -40 21900 -60 21900 {}
C {lab_pin.sym} -60 21900 0 0 {name=l400 lab=ph7}
N -40 21920 -60 21920 {}
C {lab_pin.sym} -60 21920 0 0 {name=l401 lab=pl3}
N 40 21900 60 21900 {}
C {lab_pin.sym} 60 21900 0 0 {name=l402 lab=wl59}
N 0 21860 0 21840 {}
C {lab_pin.sym} 0 21840 0 0 {name=l403 lab=VDD}
N 0 21980 0 22000 {}
C {lab_pin.sym} 0 22000 0 0 {name=l404 lab=VSS}
C {rowdrv.sym} 0 22200 0 0 {name=Xrow60}
N -40 22180 -60 22180 {}
C {lab_pin.sym} -60 22180 0 0 {name=l405 lab=ph7}
N -40 22200 -60 22200 {}
C {lab_pin.sym} -60 22200 0 0 {name=l406 lab=pl4}
N 40 22180 60 22180 {}
C {lab_pin.sym} 60 22180 0 0 {name=l407 lab=wl60}
N 0 22140 0 22120 {}
C {lab_pin.sym} 0 22120 0 0 {name=l408 lab=VDD}
N 0 22260 0 22280 {}
C {lab_pin.sym} 0 22280 0 0 {name=l409 lab=VSS}
C {rowdrv.sym} 0 22480 0 0 {name=Xrow61}
N -40 22460 -60 22460 {}
C {lab_pin.sym} -60 22460 0 0 {name=l410 lab=ph7}
N -40 22480 -60 22480 {}
C {lab_pin.sym} -60 22480 0 0 {name=l411 lab=pl5}
N 40 22460 60 22460 {}
C {lab_pin.sym} 60 22460 0 0 {name=l412 lab=wl61}
N 0 22420 0 22400 {}
C {lab_pin.sym} 0 22400 0 0 {name=l413 lab=VDD}
N 0 22540 0 22560 {}
C {lab_pin.sym} 0 22560 0 0 {name=l414 lab=VSS}
C {rowdrv.sym} 0 22760 0 0 {name=Xrow62}
N -40 22740 -60 22740 {}
C {lab_pin.sym} -60 22740 0 0 {name=l415 lab=ph7}
N -40 22760 -60 22760 {}
C {lab_pin.sym} -60 22760 0 0 {name=l416 lab=pl6}
N 40 22740 60 22740 {}
C {lab_pin.sym} 60 22740 0 0 {name=l417 lab=wl62}
N 0 22700 0 22680 {}
C {lab_pin.sym} 0 22680 0 0 {name=l418 lab=VDD}
N 0 22820 0 22840 {}
C {lab_pin.sym} 0 22840 0 0 {name=l419 lab=VSS}
C {rowdrv.sym} 0 23040 0 0 {name=Xrow63}
N -40 23020 -60 23020 {}
C {lab_pin.sym} -60 23020 0 0 {name=l420 lab=ph7}
N -40 23040 -60 23040 {}
C {lab_pin.sym} -60 23040 0 0 {name=l421 lab=pl7}
N 40 23020 60 23020 {}
C {lab_pin.sym} 60 23020 0 0 {name=l422 lab=wl63}
N 0 22980 0 22960 {}
C {lab_pin.sym} 0 22960 0 0 {name=l423 lab=VDD}
N 0 23100 0 23120 {}
C {lab_pin.sym} 0 23120 0 0 {name=l424 lab=VSS}
C {ipin.sym} -400 -200 0 0 {name=p425 lab=aq2}
C {ipin.sym} -400 -260 0 0 {name=p426 lab=aq3}
C {ipin.sym} -400 -320 0 0 {name=p427 lab=aq4}
C {ipin.sym} -400 -380 0 0 {name=p428 lab=aq5}
C {ipin.sym} -400 -440 0 0 {name=p429 lab=aq6}
C {ipin.sym} -400 -500 0 0 {name=p430 lab=aq7}
C {ipin.sym} -400 -560 0 0 {name=p431 lab=aqb2}
C {ipin.sym} -400 -620 0 0 {name=p432 lab=aqb3}
C {ipin.sym} -400 -680 0 0 {name=p433 lab=aqb4}
C {ipin.sym} -400 -740 0 0 {name=p434 lab=aqb5}
C {ipin.sym} -400 -800 0 0 {name=p435 lab=aqb6}
C {ipin.sym} -400 -860 0 0 {name=p436 lab=aqb7}
C {ipin.sym} -400 -920 0 0 {name=p437 lab=wl_en}
C {opin.sym} -700 -200 0 0 {name=p438 lab=wl0}
C {opin.sym} -700 -260 0 0 {name=p439 lab=wl1}
C {opin.sym} -700 -320 0 0 {name=p440 lab=wl2}
C {opin.sym} -700 -380 0 0 {name=p441 lab=wl3}
C {opin.sym} -700 -440 0 0 {name=p442 lab=wl4}
C {opin.sym} -700 -500 0 0 {name=p443 lab=wl5}
C {opin.sym} -700 -560 0 0 {name=p444 lab=wl6}
C {opin.sym} -700 -620 0 0 {name=p445 lab=wl7}
C {opin.sym} -700 -680 0 0 {name=p446 lab=wl8}
C {opin.sym} -700 -740 0 0 {name=p447 lab=wl9}
C {opin.sym} -700 -800 0 0 {name=p448 lab=wl10}
C {opin.sym} -700 -860 0 0 {name=p449 lab=wl11}
C {opin.sym} -700 -920 0 0 {name=p450 lab=wl12}
C {opin.sym} -700 -980 0 0 {name=p451 lab=wl13}
C {opin.sym} -700 -1040 0 0 {name=p452 lab=wl14}
C {opin.sym} -700 -1100 0 0 {name=p453 lab=wl15}
C {opin.sym} -700 -1160 0 0 {name=p454 lab=wl16}
C {opin.sym} -700 -1220 0 0 {name=p455 lab=wl17}
C {opin.sym} -700 -1280 0 0 {name=p456 lab=wl18}
C {opin.sym} -700 -1340 0 0 {name=p457 lab=wl19}
C {opin.sym} -700 -1400 0 0 {name=p458 lab=wl20}
C {opin.sym} -700 -1460 0 0 {name=p459 lab=wl21}
C {opin.sym} -700 -1520 0 0 {name=p460 lab=wl22}
C {opin.sym} -700 -1580 0 0 {name=p461 lab=wl23}
C {opin.sym} -700 -1640 0 0 {name=p462 lab=wl24}
C {opin.sym} -700 -1700 0 0 {name=p463 lab=wl25}
C {opin.sym} -700 -1760 0 0 {name=p464 lab=wl26}
C {opin.sym} -700 -1820 0 0 {name=p465 lab=wl27}
C {opin.sym} -700 -1880 0 0 {name=p466 lab=wl28}
C {opin.sym} -700 -1940 0 0 {name=p467 lab=wl29}
C {opin.sym} -700 -2000 0 0 {name=p468 lab=wl30}
C {opin.sym} -700 -2060 0 0 {name=p469 lab=wl31}
C {opin.sym} -700 -2120 0 0 {name=p470 lab=wl32}
C {opin.sym} -700 -2180 0 0 {name=p471 lab=wl33}
C {opin.sym} -700 -2240 0 0 {name=p472 lab=wl34}
C {opin.sym} -700 -2300 0 0 {name=p473 lab=wl35}
C {opin.sym} -700 -2360 0 0 {name=p474 lab=wl36}
C {opin.sym} -700 -2420 0 0 {name=p475 lab=wl37}
C {opin.sym} -700 -2480 0 0 {name=p476 lab=wl38}
C {opin.sym} -700 -2540 0 0 {name=p477 lab=wl39}
C {opin.sym} -700 -2600 0 0 {name=p478 lab=wl40}
C {opin.sym} -700 -2660 0 0 {name=p479 lab=wl41}
C {opin.sym} -700 -2720 0 0 {name=p480 lab=wl42}
C {opin.sym} -700 -2780 0 0 {name=p481 lab=wl43}
C {opin.sym} -700 -2840 0 0 {name=p482 lab=wl44}
C {opin.sym} -700 -2900 0 0 {name=p483 lab=wl45}
C {opin.sym} -700 -2960 0 0 {name=p484 lab=wl46}
C {opin.sym} -700 -3020 0 0 {name=p485 lab=wl47}
C {opin.sym} -700 -3080 0 0 {name=p486 lab=wl48}
C {opin.sym} -700 -3140 0 0 {name=p487 lab=wl49}
C {opin.sym} -700 -3200 0 0 {name=p488 lab=wl50}
C {opin.sym} -700 -3260 0 0 {name=p489 lab=wl51}
C {opin.sym} -700 -3320 0 0 {name=p490 lab=wl52}
C {opin.sym} -700 -3380 0 0 {name=p491 lab=wl53}
C {opin.sym} -700 -3440 0 0 {name=p492 lab=wl54}
C {opin.sym} -700 -3500 0 0 {name=p493 lab=wl55}
C {opin.sym} -700 -3560 0 0 {name=p494 lab=wl56}
C {opin.sym} -700 -3620 0 0 {name=p495 lab=wl57}
C {opin.sym} -700 -3680 0 0 {name=p496 lab=wl58}
C {opin.sym} -700 -3740 0 0 {name=p497 lab=wl59}
C {opin.sym} -700 -3800 0 0 {name=p498 lab=wl60}
C {opin.sym} -700 -3860 0 0 {name=p499 lab=wl61}
C {opin.sym} -700 -3920 0 0 {name=p500 lab=wl62}
C {opin.sym} -700 -3980 0 0 {name=p501 lab=wl63}
C {iopin.sym} -1000 -200 0 0 {name=p502 lab=VDD}
C {iopin.sym} -1000 -260 0 0 {name=p503 lab=VSS}
