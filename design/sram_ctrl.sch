v {xschem version=3.4.7 file_version=1.2
* sram_ctrl -- MACHINE-GENERATED by design/generate_periphery.py;
* do not hand-edit, re-run the generator (see design/README.md).
* Control: input flops on rising CLK (A, CEN, GWEN), then a self-timed
* access (periphery record rows 10-11). p starts at the CLK rising edge
* and ends after the N_PULSE-stage delay chain; wl_en = p & delayed p &
* enable, so decode settles before the wordline fires and the pulse
* end is set by the delay path, not by the CLK falling edge. s_en
* (read only) fires N_BL stages after wl_en; q_clk (read only) strobes
* the Q registers N_QCLK stages after s_en; wpn is the active-low
* write pulse (write only).
}
G {}
K {}
V {}
S {}
E {}
C {inv.sym} 0 440 0 0 {name=Xcb1}
N -40 420 -60 420 {}
C {lab_pin.sym} -60 420 0 0 {name=l1 lab=CLK}
N 40 420 60 420 {}
C {lab_pin.sym} 60 420 0 0 {name=l2 lab=clkb}
N 0 380 0 360 {}
C {lab_pin.sym} 0 360 0 0 {name=l3 lab=VDD}
N 0 500 0 520 {}
C {lab_pin.sym} 0 520 0 0 {name=l4 lab=VSS}
C {inv_x16.sym} 0 720 0 0 {name=Xcb2}
N -40 700 -60 700 {}
C {lab_pin.sym} -60 700 0 0 {name=l5 lab=clkb}
N 40 700 60 700 {}
C {lab_pin.sym} 60 700 0 0 {name=l6 lab=clk_buf}
N 0 660 0 640 {}
C {lab_pin.sym} 0 640 0 0 {name=l7 lab=VDD}
N 0 780 0 800 {}
C {lab_pin.sym} 0 800 0 0 {name=l8 lab=VSS}
C {dff.sym} 0 1000 0 0 {name=Xfa0}
N -40 980 -60 980 {}
C {lab_pin.sym} -60 980 0 0 {name=l9 lab=A0}
N -40 1000 -60 1000 {}
C {lab_pin.sym} -60 1000 0 0 {name=l10 lab=clk_buf}
N 40 980 60 980 {}
C {lab_pin.sym} 60 980 0 0 {name=l11 lab=aq0}
N 40 1000 60 1000 {}
C {lab_pin.sym} 60 1000 0 0 {name=l12 lab=aqb0}
N 0 940 0 920 {}
C {lab_pin.sym} 0 920 0 0 {name=l13 lab=VDD}
N 0 1060 0 1080 {}
C {lab_pin.sym} 0 1080 0 0 {name=l14 lab=VSS}
C {dff.sym} 0 1280 0 0 {name=Xfa1}
N -40 1260 -60 1260 {}
C {lab_pin.sym} -60 1260 0 0 {name=l15 lab=A1}
N -40 1280 -60 1280 {}
C {lab_pin.sym} -60 1280 0 0 {name=l16 lab=clk_buf}
N 40 1260 60 1260 {}
C {lab_pin.sym} 60 1260 0 0 {name=l17 lab=aq1}
N 40 1280 60 1280 {}
C {lab_pin.sym} 60 1280 0 0 {name=l18 lab=aqb1}
N 0 1220 0 1200 {}
C {lab_pin.sym} 0 1200 0 0 {name=l19 lab=VDD}
N 0 1340 0 1360 {}
C {lab_pin.sym} 0 1360 0 0 {name=l20 lab=VSS}
C {dff.sym} 0 1560 0 0 {name=Xfa2}
N -40 1540 -60 1540 {}
C {lab_pin.sym} -60 1540 0 0 {name=l21 lab=A2}
N -40 1560 -60 1560 {}
C {lab_pin.sym} -60 1560 0 0 {name=l22 lab=clk_buf}
N 40 1540 60 1540 {}
C {lab_pin.sym} 60 1540 0 0 {name=l23 lab=aq2}
N 40 1560 60 1560 {}
C {lab_pin.sym} 60 1560 0 0 {name=l24 lab=aqb2}
N 0 1500 0 1480 {}
C {lab_pin.sym} 0 1480 0 0 {name=l25 lab=VDD}
N 0 1620 0 1640 {}
C {lab_pin.sym} 0 1640 0 0 {name=l26 lab=VSS}
C {dff.sym} 0 1840 0 0 {name=Xfa3}
N -40 1820 -60 1820 {}
C {lab_pin.sym} -60 1820 0 0 {name=l27 lab=A3}
N -40 1840 -60 1840 {}
C {lab_pin.sym} -60 1840 0 0 {name=l28 lab=clk_buf}
N 40 1820 60 1820 {}
C {lab_pin.sym} 60 1820 0 0 {name=l29 lab=aq3}
N 40 1840 60 1840 {}
C {lab_pin.sym} 60 1840 0 0 {name=l30 lab=aqb3}
N 0 1780 0 1760 {}
C {lab_pin.sym} 0 1760 0 0 {name=l31 lab=VDD}
N 0 1900 0 1920 {}
C {lab_pin.sym} 0 1920 0 0 {name=l32 lab=VSS}
C {dff.sym} 0 2120 0 0 {name=Xfa4}
N -40 2100 -60 2100 {}
C {lab_pin.sym} -60 2100 0 0 {name=l33 lab=A4}
N -40 2120 -60 2120 {}
C {lab_pin.sym} -60 2120 0 0 {name=l34 lab=clk_buf}
N 40 2100 60 2100 {}
C {lab_pin.sym} 60 2100 0 0 {name=l35 lab=aq4}
N 40 2120 60 2120 {}
C {lab_pin.sym} 60 2120 0 0 {name=l36 lab=aqb4}
N 0 2060 0 2040 {}
C {lab_pin.sym} 0 2040 0 0 {name=l37 lab=VDD}
N 0 2180 0 2200 {}
C {lab_pin.sym} 0 2200 0 0 {name=l38 lab=VSS}
C {dff.sym} 0 2400 0 0 {name=Xfa5}
N -40 2380 -60 2380 {}
C {lab_pin.sym} -60 2380 0 0 {name=l39 lab=A5}
N -40 2400 -60 2400 {}
C {lab_pin.sym} -60 2400 0 0 {name=l40 lab=clk_buf}
N 40 2380 60 2380 {}
C {lab_pin.sym} 60 2380 0 0 {name=l41 lab=aq5}
N 40 2400 60 2400 {}
C {lab_pin.sym} 60 2400 0 0 {name=l42 lab=aqb5}
N 0 2340 0 2320 {}
C {lab_pin.sym} 0 2320 0 0 {name=l43 lab=VDD}
N 0 2460 0 2480 {}
C {lab_pin.sym} 0 2480 0 0 {name=l44 lab=VSS}
C {dff.sym} 0 2680 0 0 {name=Xfa6}
N -40 2660 -60 2660 {}
C {lab_pin.sym} -60 2660 0 0 {name=l45 lab=A6}
N -40 2680 -60 2680 {}
C {lab_pin.sym} -60 2680 0 0 {name=l46 lab=clk_buf}
N 40 2660 60 2660 {}
C {lab_pin.sym} 60 2660 0 0 {name=l47 lab=aq6}
N 40 2680 60 2680 {}
C {lab_pin.sym} 60 2680 0 0 {name=l48 lab=aqb6}
N 0 2620 0 2600 {}
C {lab_pin.sym} 0 2600 0 0 {name=l49 lab=VDD}
N 0 2740 0 2760 {}
C {lab_pin.sym} 0 2760 0 0 {name=l50 lab=VSS}
C {dff.sym} 0 2960 0 0 {name=Xfa7}
N -40 2940 -60 2940 {}
C {lab_pin.sym} -60 2940 0 0 {name=l51 lab=A7}
N -40 2960 -60 2960 {}
C {lab_pin.sym} -60 2960 0 0 {name=l52 lab=clk_buf}
N 40 2940 60 2940 {}
C {lab_pin.sym} 60 2940 0 0 {name=l53 lab=aq7}
N 40 2960 60 2960 {}
C {lab_pin.sym} 60 2960 0 0 {name=l54 lab=aqb7}
N 0 2900 0 2880 {}
C {lab_pin.sym} 0 2880 0 0 {name=l55 lab=VDD}
N 0 3020 0 3040 {}
C {lab_pin.sym} 0 3040 0 0 {name=l56 lab=VSS}
C {dff.sym} 0 3240 0 0 {name=Xfcen}
N -40 3220 -60 3220 {}
C {lab_pin.sym} -60 3220 0 0 {name=l57 lab=CEN}
N -40 3240 -60 3240 {}
C {lab_pin.sym} -60 3240 0 0 {name=l58 lab=clk_buf}
N 40 3220 60 3220 {}
C {lab_pin.sym} 60 3220 0 0 {name=l59 lab=cenq}
N 40 3240 60 3240 {}
C {lab_pin.sym} 60 3240 0 0 {name=l60 lab=en_q}
N 0 3180 0 3160 {}
C {lab_pin.sym} 0 3160 0 0 {name=l61 lab=VDD}
N 0 3300 0 3320 {}
C {lab_pin.sym} 0 3320 0 0 {name=l62 lab=VSS}
C {dff.sym} 0 3520 0 0 {name=Xfgw}
N -40 3500 -60 3500 {}
C {lab_pin.sym} -60 3500 0 0 {name=l63 lab=GWEN}
N -40 3520 -60 3520 {}
C {lab_pin.sym} -60 3520 0 0 {name=l64 lab=clk_buf}
N 40 3500 60 3500 {}
C {lab_pin.sym} 60 3500 0 0 {name=l65 lab=gwq}
N 40 3520 60 3520 {}
C {lab_pin.sym} 60 3520 0 0 {name=l66 lab=gwqb}
N 0 3460 0 3440 {}
C {lab_pin.sym} 0 3440 0 0 {name=l67 lab=VDD}
N 0 3580 0 3600 {}
C {lab_pin.sym} 0 3600 0 0 {name=l68 lab=VSS}
C {and2.sym} 0 3800 0 0 {name=Xrd}
N -40 3780 -60 3780 {}
C {lab_pin.sym} -60 3780 0 0 {name=l69 lab=en_q}
N -40 3800 -60 3800 {}
C {lab_pin.sym} -60 3800 0 0 {name=l70 lab=gwq}
N 40 3780 60 3780 {}
C {lab_pin.sym} 60 3780 0 0 {name=l71 lab=rd_q}
N 0 3740 0 3720 {}
C {lab_pin.sym} 0 3720 0 0 {name=l72 lab=VDD}
N 0 3860 0 3880 {}
C {lab_pin.sym} 0 3880 0 0 {name=l73 lab=VSS}
C {and2.sym} 0 4080 0 0 {name=Xwr}
N -40 4060 -60 4060 {}
C {lab_pin.sym} -60 4060 0 0 {name=l74 lab=en_q}
N -40 4080 -60 4080 {}
C {lab_pin.sym} -60 4080 0 0 {name=l75 lab=gwqb}
N 40 4060 60 4060 {}
C {lab_pin.sym} 60 4060 0 0 {name=l76 lab=wr_q}
N 0 4020 0 4000 {}
C {lab_pin.sym} 0 4000 0 0 {name=l77 lab=VDD}
N 0 4140 0 4160 {}
C {lab_pin.sym} 0 4160 0 0 {name=l78 lab=VSS}
C {inv_dly.sym} 0 4360 0 0 {name=Xdp0}
N -40 4340 -60 4340 {}
C {lab_pin.sym} -60 4340 0 0 {name=l79 lab=clk_buf}
N 40 4340 60 4340 {}
C {lab_pin.sym} 60 4340 0 0 {name=l80 lab=dp1}
N 0 4300 0 4280 {}
C {lab_pin.sym} 0 4280 0 0 {name=l81 lab=VDD}
N 0 4420 0 4440 {}
C {lab_pin.sym} 0 4440 0 0 {name=l82 lab=VSS}
C {inv_dly.sym} 0 4640 0 0 {name=Xdp1}
N -40 4620 -60 4620 {}
C {lab_pin.sym} -60 4620 0 0 {name=l83 lab=dp1}
N 40 4620 60 4620 {}
C {lab_pin.sym} 60 4620 0 0 {name=l84 lab=dp2}
N 0 4580 0 4560 {}
C {lab_pin.sym} 0 4560 0 0 {name=l85 lab=VDD}
N 0 4700 0 4720 {}
C {lab_pin.sym} 0 4720 0 0 {name=l86 lab=VSS}
C {inv_dly.sym} 0 4920 0 0 {name=Xdp2}
N -40 4900 -60 4900 {}
C {lab_pin.sym} -60 4900 0 0 {name=l87 lab=dp2}
N 40 4900 60 4900 {}
C {lab_pin.sym} 60 4900 0 0 {name=l88 lab=dp3}
N 0 4860 0 4840 {}
C {lab_pin.sym} 0 4840 0 0 {name=l89 lab=VDD}
N 0 4980 0 5000 {}
C {lab_pin.sym} 0 5000 0 0 {name=l90 lab=VSS}
C {inv_dly.sym} 0 5200 0 0 {name=Xdp3}
N -40 5180 -60 5180 {}
C {lab_pin.sym} -60 5180 0 0 {name=l91 lab=dp3}
N 40 5180 60 5180 {}
C {lab_pin.sym} 60 5180 0 0 {name=l92 lab=dp4}
N 0 5140 0 5120 {}
C {lab_pin.sym} 0 5120 0 0 {name=l93 lab=VDD}
N 0 5260 0 5280 {}
C {lab_pin.sym} 0 5280 0 0 {name=l94 lab=VSS}
C {inv_dly.sym} 0 5480 0 0 {name=Xdp4}
N -40 5460 -60 5460 {}
C {lab_pin.sym} -60 5460 0 0 {name=l95 lab=dp4}
N 40 5460 60 5460 {}
C {lab_pin.sym} 60 5460 0 0 {name=l96 lab=dp5}
N 0 5420 0 5400 {}
C {lab_pin.sym} 0 5400 0 0 {name=l97 lab=VDD}
N 0 5540 0 5560 {}
C {lab_pin.sym} 0 5560 0 0 {name=l98 lab=VSS}
C {inv_dly.sym} 0 5760 0 0 {name=Xdp5}
N -40 5740 -60 5740 {}
C {lab_pin.sym} -60 5740 0 0 {name=l99 lab=dp5}
N 40 5740 60 5740 {}
C {lab_pin.sym} 60 5740 0 0 {name=l100 lab=dp6}
N 0 5700 0 5680 {}
C {lab_pin.sym} 0 5680 0 0 {name=l101 lab=VDD}
N 0 5820 0 5840 {}
C {lab_pin.sym} 0 5840 0 0 {name=l102 lab=VSS}
C {inv_dly.sym} 0 6040 0 0 {name=Xdp6}
N -40 6020 -60 6020 {}
C {lab_pin.sym} -60 6020 0 0 {name=l103 lab=dp6}
N 40 6020 60 6020 {}
C {lab_pin.sym} 60 6020 0 0 {name=l104 lab=dp7}
N 0 5980 0 5960 {}
C {lab_pin.sym} 0 5960 0 0 {name=l105 lab=VDD}
N 0 6100 0 6120 {}
C {lab_pin.sym} 0 6120 0 0 {name=l106 lab=VSS}
C {inv_dly.sym} 0 6320 0 0 {name=Xdp7}
N -40 6300 -60 6300 {}
C {lab_pin.sym} -60 6300 0 0 {name=l107 lab=dp7}
N 40 6300 60 6300 {}
C {lab_pin.sym} 60 6300 0 0 {name=l108 lab=dp8}
N 0 6260 0 6240 {}
C {lab_pin.sym} 0 6240 0 0 {name=l109 lab=VDD}
N 0 6380 0 6400 {}
C {lab_pin.sym} 0 6400 0 0 {name=l110 lab=VSS}
C {inv_dly.sym} 0 6600 0 0 {name=Xdp8}
N -40 6580 -60 6580 {}
C {lab_pin.sym} -60 6580 0 0 {name=l111 lab=dp8}
N 40 6580 60 6580 {}
C {lab_pin.sym} 60 6580 0 0 {name=l112 lab=dp9}
N 0 6540 0 6520 {}
C {lab_pin.sym} 0 6520 0 0 {name=l113 lab=VDD}
N 0 6660 0 6680 {}
C {lab_pin.sym} 0 6680 0 0 {name=l114 lab=VSS}
C {inv_dly.sym} 0 6880 0 0 {name=Xdp9}
N -40 6860 -60 6860 {}
C {lab_pin.sym} -60 6860 0 0 {name=l115 lab=dp9}
N 40 6860 60 6860 {}
C {lab_pin.sym} 60 6860 0 0 {name=l116 lab=dp10}
N 0 6820 0 6800 {}
C {lab_pin.sym} 0 6800 0 0 {name=l117 lab=VDD}
N 0 6940 0 6960 {}
C {lab_pin.sym} 0 6960 0 0 {name=l118 lab=VSS}
C {inv_dly.sym} 0 7160 0 0 {name=Xdp10}
N -40 7140 -60 7140 {}
C {lab_pin.sym} -60 7140 0 0 {name=l119 lab=dp10}
N 40 7140 60 7140 {}
C {lab_pin.sym} 60 7140 0 0 {name=l120 lab=dp11}
N 0 7100 0 7080 {}
C {lab_pin.sym} 0 7080 0 0 {name=l121 lab=VDD}
N 0 7220 0 7240 {}
C {lab_pin.sym} 0 7240 0 0 {name=l122 lab=VSS}
C {inv_dly.sym} 0 7440 0 0 {name=Xdp11}
N -40 7420 -60 7420 {}
C {lab_pin.sym} -60 7420 0 0 {name=l123 lab=dp11}
N 40 7420 60 7420 {}
C {lab_pin.sym} 60 7420 0 0 {name=l124 lab=dp12}
N 0 7380 0 7360 {}
C {lab_pin.sym} 0 7360 0 0 {name=l125 lab=VDD}
N 0 7500 0 7520 {}
C {lab_pin.sym} 0 7520 0 0 {name=l126 lab=VSS}
C {inv_dly.sym} 0 7720 0 0 {name=Xdp12}
N -40 7700 -60 7700 {}
C {lab_pin.sym} -60 7700 0 0 {name=l127 lab=dp12}
N 40 7700 60 7700 {}
C {lab_pin.sym} 60 7700 0 0 {name=l128 lab=dp13}
N 0 7660 0 7640 {}
C {lab_pin.sym} 0 7640 0 0 {name=l129 lab=VDD}
N 0 7780 0 7800 {}
C {lab_pin.sym} 0 7800 0 0 {name=l130 lab=VSS}
C {inv_dly.sym} 0 8000 0 0 {name=Xdp13}
N -40 7980 -60 7980 {}
C {lab_pin.sym} -60 7980 0 0 {name=l131 lab=dp13}
N 40 7980 60 7980 {}
C {lab_pin.sym} 60 7980 0 0 {name=l132 lab=dp14}
N 0 7940 0 7920 {}
C {lab_pin.sym} 0 7920 0 0 {name=l133 lab=VDD}
N 0 8060 0 8080 {}
C {lab_pin.sym} 0 8080 0 0 {name=l134 lab=VSS}
C {inv_dly.sym} 0 8280 0 0 {name=Xdp14}
N -40 8260 -60 8260 {}
C {lab_pin.sym} -60 8260 0 0 {name=l135 lab=dp14}
N 40 8260 60 8260 {}
C {lab_pin.sym} 60 8260 0 0 {name=l136 lab=dp15}
N 0 8220 0 8200 {}
C {lab_pin.sym} 0 8200 0 0 {name=l137 lab=VDD}
N 0 8340 0 8360 {}
C {lab_pin.sym} 0 8360 0 0 {name=l138 lab=VSS}
C {inv_dly.sym} 0 8560 0 0 {name=Xdp15}
N -40 8540 -60 8540 {}
C {lab_pin.sym} -60 8540 0 0 {name=l139 lab=dp15}
N 40 8540 60 8540 {}
C {lab_pin.sym} 60 8540 0 0 {name=l140 lab=dp16}
N 0 8500 0 8480 {}
C {lab_pin.sym} 0 8480 0 0 {name=l141 lab=VDD}
N 0 8620 0 8640 {}
C {lab_pin.sym} 0 8640 0 0 {name=l142 lab=VSS}
C {inv_dly.sym} 0 8840 0 0 {name=Xdp16}
N -40 8820 -60 8820 {}
C {lab_pin.sym} -60 8820 0 0 {name=l143 lab=dp16}
N 40 8820 60 8820 {}
C {lab_pin.sym} 60 8820 0 0 {name=l144 lab=dp17}
N 0 8780 0 8760 {}
C {lab_pin.sym} 0 8760 0 0 {name=l145 lab=VDD}
N 0 8900 0 8920 {}
C {lab_pin.sym} 0 8920 0 0 {name=l146 lab=VSS}
C {inv_dly.sym} 0 9120 0 0 {name=Xdp17}
N -40 9100 -60 9100 {}
C {lab_pin.sym} -60 9100 0 0 {name=l147 lab=dp17}
N 40 9100 60 9100 {}
C {lab_pin.sym} 60 9100 0 0 {name=l148 lab=dp18}
N 0 9060 0 9040 {}
C {lab_pin.sym} 0 9040 0 0 {name=l149 lab=VDD}
N 0 9180 0 9200 {}
C {lab_pin.sym} 0 9200 0 0 {name=l150 lab=VSS}
C {inv_dly.sym} 0 9400 0 0 {name=Xdp18}
N -40 9380 -60 9380 {}
C {lab_pin.sym} -60 9380 0 0 {name=l151 lab=dp18}
N 40 9380 60 9380 {}
C {lab_pin.sym} 60 9380 0 0 {name=l152 lab=dp19}
N 0 9340 0 9320 {}
C {lab_pin.sym} 0 9320 0 0 {name=l153 lab=VDD}
N 0 9460 0 9480 {}
C {lab_pin.sym} 0 9480 0 0 {name=l154 lab=VSS}
C {inv_dly.sym} 0 9680 0 0 {name=Xdp19}
N -40 9660 -60 9660 {}
C {lab_pin.sym} -60 9660 0 0 {name=l155 lab=dp19}
N 40 9660 60 9660 {}
C {lab_pin.sym} 60 9660 0 0 {name=l156 lab=dp20}
N 0 9620 0 9600 {}
C {lab_pin.sym} 0 9600 0 0 {name=l157 lab=VDD}
N 0 9740 0 9760 {}
C {lab_pin.sym} 0 9760 0 0 {name=l158 lab=VSS}
C {inv_dly.sym} 0 9960 0 0 {name=Xdp20}
N -40 9940 -60 9940 {}
C {lab_pin.sym} -60 9940 0 0 {name=l159 lab=dp20}
N 40 9940 60 9940 {}
C {lab_pin.sym} 60 9940 0 0 {name=l160 lab=dp21}
N 0 9900 0 9880 {}
C {lab_pin.sym} 0 9880 0 0 {name=l161 lab=VDD}
N 0 10020 0 10040 {}
C {lab_pin.sym} 0 10040 0 0 {name=l162 lab=VSS}
C {inv_dly.sym} 0 10240 0 0 {name=Xdp21}
N -40 10220 -60 10220 {}
C {lab_pin.sym} -60 10220 0 0 {name=l163 lab=dp21}
N 40 10220 60 10220 {}
C {lab_pin.sym} 60 10220 0 0 {name=l164 lab=dp22}
N 0 10180 0 10160 {}
C {lab_pin.sym} 0 10160 0 0 {name=l165 lab=VDD}
N 0 10300 0 10320 {}
C {lab_pin.sym} 0 10320 0 0 {name=l166 lab=VSS}
C {inv_dly.sym} 0 10520 0 0 {name=Xdp22}
N -40 10500 -60 10500 {}
C {lab_pin.sym} -60 10500 0 0 {name=l167 lab=dp22}
N 40 10500 60 10500 {}
C {lab_pin.sym} 60 10500 0 0 {name=l168 lab=dp23}
N 0 10460 0 10440 {}
C {lab_pin.sym} 0 10440 0 0 {name=l169 lab=VDD}
N 0 10580 0 10600 {}
C {lab_pin.sym} 0 10600 0 0 {name=l170 lab=VSS}
C {inv_dly.sym} 0 10800 0 0 {name=Xdp23}
N -40 10780 -60 10780 {}
C {lab_pin.sym} -60 10780 0 0 {name=l171 lab=dp23}
N 40 10780 60 10780 {}
C {lab_pin.sym} 60 10780 0 0 {name=l172 lab=dp24}
N 0 10740 0 10720 {}
C {lab_pin.sym} 0 10720 0 0 {name=l173 lab=VDD}
N 0 10860 0 10880 {}
C {lab_pin.sym} 0 10880 0 0 {name=l174 lab=VSS}
C {inv_dly.sym} 0 11080 0 0 {name=Xdp24}
N -40 11060 -60 11060 {}
C {lab_pin.sym} -60 11060 0 0 {name=l175 lab=dp24}
N 40 11060 60 11060 {}
C {lab_pin.sym} 60 11060 0 0 {name=l176 lab=dp25}
N 0 11020 0 11000 {}
C {lab_pin.sym} 0 11000 0 0 {name=l177 lab=VDD}
N 0 11140 0 11160 {}
C {lab_pin.sym} 0 11160 0 0 {name=l178 lab=VSS}
C {inv_dly.sym} 0 11360 0 0 {name=Xdp25}
N -40 11340 -60 11340 {}
C {lab_pin.sym} -60 11340 0 0 {name=l179 lab=dp25}
N 40 11340 60 11340 {}
C {lab_pin.sym} 60 11340 0 0 {name=l180 lab=dp26}
N 0 11300 0 11280 {}
C {lab_pin.sym} 0 11280 0 0 {name=l181 lab=VDD}
N 0 11420 0 11440 {}
C {lab_pin.sym} 0 11440 0 0 {name=l182 lab=VSS}
C {inv_dly.sym} 0 11640 0 0 {name=Xdp26}
N -40 11620 -60 11620 {}
C {lab_pin.sym} -60 11620 0 0 {name=l183 lab=dp26}
N 40 11620 60 11620 {}
C {lab_pin.sym} 60 11620 0 0 {name=l184 lab=dp27}
N 0 11580 0 11560 {}
C {lab_pin.sym} 0 11560 0 0 {name=l185 lab=VDD}
N 0 11700 0 11720 {}
C {lab_pin.sym} 0 11720 0 0 {name=l186 lab=VSS}
C {inv_dly.sym} 0 11920 0 0 {name=Xdp27}
N -40 11900 -60 11900 {}
C {lab_pin.sym} -60 11900 0 0 {name=l187 lab=dp27}
N 40 11900 60 11900 {}
C {lab_pin.sym} 60 11900 0 0 {name=l188 lab=dp28}
N 0 11860 0 11840 {}
C {lab_pin.sym} 0 11840 0 0 {name=l189 lab=VDD}
N 0 11980 0 12000 {}
C {lab_pin.sym} 0 12000 0 0 {name=l190 lab=VSS}
C {inv_dly.sym} 0 12200 0 0 {name=Xdp28}
N -40 12180 -60 12180 {}
C {lab_pin.sym} -60 12180 0 0 {name=l191 lab=dp28}
N 40 12180 60 12180 {}
C {lab_pin.sym} 60 12180 0 0 {name=l192 lab=dp29}
N 0 12140 0 12120 {}
C {lab_pin.sym} 0 12120 0 0 {name=l193 lab=VDD}
N 0 12260 0 12280 {}
C {lab_pin.sym} 0 12280 0 0 {name=l194 lab=VSS}
C {inv_dly.sym} 0 12480 0 0 {name=Xdp29}
N -40 12460 -60 12460 {}
C {lab_pin.sym} -60 12460 0 0 {name=l195 lab=dp29}
N 40 12460 60 12460 {}
C {lab_pin.sym} 60 12460 0 0 {name=l196 lab=dp30}
N 0 12420 0 12400 {}
C {lab_pin.sym} 0 12400 0 0 {name=l197 lab=VDD}
N 0 12540 0 12560 {}
C {lab_pin.sym} 0 12560 0 0 {name=l198 lab=VSS}
C {inv_dly.sym} 0 12760 0 0 {name=Xdp30}
N -40 12740 -60 12740 {}
C {lab_pin.sym} -60 12740 0 0 {name=l199 lab=dp30}
N 40 12740 60 12740 {}
C {lab_pin.sym} 60 12740 0 0 {name=l200 lab=dp31}
N 0 12700 0 12680 {}
C {lab_pin.sym} 0 12680 0 0 {name=l201 lab=VDD}
N 0 12820 0 12840 {}
C {lab_pin.sym} 0 12840 0 0 {name=l202 lab=VSS}
C {inv_dly.sym} 0 13040 0 0 {name=Xdp31}
N -40 13020 -60 13020 {}
C {lab_pin.sym} -60 13020 0 0 {name=l203 lab=dp31}
N 40 13020 60 13020 {}
C {lab_pin.sym} 60 13020 0 0 {name=l204 lab=dp32}
N 0 12980 0 12960 {}
C {lab_pin.sym} 0 12960 0 0 {name=l205 lab=VDD}
N 0 13100 0 13120 {}
C {lab_pin.sym} 0 13120 0 0 {name=l206 lab=VSS}
C {inv_dly.sym} 0 13320 0 0 {name=Xdp32}
N -40 13300 -60 13300 {}
C {lab_pin.sym} -60 13300 0 0 {name=l207 lab=dp32}
N 40 13300 60 13300 {}
C {lab_pin.sym} 60 13300 0 0 {name=l208 lab=dp33}
N 0 13260 0 13240 {}
C {lab_pin.sym} 0 13240 0 0 {name=l209 lab=VDD}
N 0 13380 0 13400 {}
C {lab_pin.sym} 0 13400 0 0 {name=l210 lab=VSS}
C {inv_dly.sym} 0 13600 0 0 {name=Xdp33}
N -40 13580 -60 13580 {}
C {lab_pin.sym} -60 13580 0 0 {name=l211 lab=dp33}
N 40 13580 60 13580 {}
C {lab_pin.sym} 60 13580 0 0 {name=l212 lab=dp34}
N 0 13540 0 13520 {}
C {lab_pin.sym} 0 13520 0 0 {name=l213 lab=VDD}
N 0 13660 0 13680 {}
C {lab_pin.sym} 0 13680 0 0 {name=l214 lab=VSS}
C {inv_dly.sym} 0 13880 0 0 {name=Xdp34}
N -40 13860 -60 13860 {}
C {lab_pin.sym} -60 13860 0 0 {name=l215 lab=dp34}
N 40 13860 60 13860 {}
C {lab_pin.sym} 60 13860 0 0 {name=l216 lab=dn}
N 0 13820 0 13800 {}
C {lab_pin.sym} 0 13800 0 0 {name=l217 lab=VDD}
N 0 13940 0 13960 {}
C {lab_pin.sym} 0 13960 0 0 {name=l218 lab=VSS}
C {nand2.sym} 0 14160 0 0 {name=Xpn}
N -40 14140 -60 14140 {}
C {lab_pin.sym} -60 14140 0 0 {name=l219 lab=clk_buf}
N -40 14160 -60 14160 {}
C {lab_pin.sym} -60 14160 0 0 {name=l220 lab=dn}
N 40 14140 60 14140 {}
C {lab_pin.sym} 60 14140 0 0 {name=l221 lab=p_n}
N 0 14100 0 14080 {}
C {lab_pin.sym} 0 14080 0 0 {name=l222 lab=VDD}
N 0 14220 0 14240 {}
C {lab_pin.sym} 0 14240 0 0 {name=l223 lab=VSS}
C {inv.sym} 0 14440 0 0 {name=Xp}
N -40 14420 -60 14420 {}
C {lab_pin.sym} -60 14420 0 0 {name=l224 lab=p_n}
N 40 14420 60 14420 {}
C {lab_pin.sym} 60 14420 0 0 {name=l225 lab=p}
N 0 14380 0 14360 {}
C {lab_pin.sym} 0 14360 0 0 {name=l226 lab=VDD}
N 0 14500 0 14520 {}
C {lab_pin.sym} 0 14520 0 0 {name=l227 lab=VSS}
C {inv_dly.sym} 0 14720 0 0 {name=Xdd0}
N -40 14700 -60 14700 {}
C {lab_pin.sym} -60 14700 0 0 {name=l228 lab=p}
N 40 14700 60 14700 {}
C {lab_pin.sym} 60 14700 0 0 {name=l229 lab=dd1}
N 0 14660 0 14640 {}
C {lab_pin.sym} 0 14640 0 0 {name=l230 lab=VDD}
N 0 14780 0 14800 {}
C {lab_pin.sym} 0 14800 0 0 {name=l231 lab=VSS}
C {inv_dly.sym} 0 15000 0 0 {name=Xdd1}
N -40 14980 -60 14980 {}
C {lab_pin.sym} -60 14980 0 0 {name=l232 lab=dd1}
N 40 14980 60 14980 {}
C {lab_pin.sym} 60 14980 0 0 {name=l233 lab=dd2}
N 0 14940 0 14920 {}
C {lab_pin.sym} 0 14920 0 0 {name=l234 lab=VDD}
N 0 15060 0 15080 {}
C {lab_pin.sym} 0 15080 0 0 {name=l235 lab=VSS}
C {inv_dly.sym} 0 15280 0 0 {name=Xdd2}
N -40 15260 -60 15260 {}
C {lab_pin.sym} -60 15260 0 0 {name=l236 lab=dd2}
N 40 15260 60 15260 {}
C {lab_pin.sym} 60 15260 0 0 {name=l237 lab=dd3}
N 0 15220 0 15200 {}
C {lab_pin.sym} 0 15200 0 0 {name=l238 lab=VDD}
N 0 15340 0 15360 {}
C {lab_pin.sym} 0 15360 0 0 {name=l239 lab=VSS}
C {inv_dly.sym} 0 15560 0 0 {name=Xdd3}
N -40 15540 -60 15540 {}
C {lab_pin.sym} -60 15540 0 0 {name=l240 lab=dd3}
N 40 15540 60 15540 {}
C {lab_pin.sym} 60 15540 0 0 {name=l241 lab=dd4}
N 0 15500 0 15480 {}
C {lab_pin.sym} 0 15480 0 0 {name=l242 lab=VDD}
N 0 15620 0 15640 {}
C {lab_pin.sym} 0 15640 0 0 {name=l243 lab=VSS}
C {inv_dly.sym} 0 15840 0 0 {name=Xdd4}
N -40 15820 -60 15820 {}
C {lab_pin.sym} -60 15820 0 0 {name=l244 lab=dd4}
N 40 15820 60 15820 {}
C {lab_pin.sym} 60 15820 0 0 {name=l245 lab=dd5}
N 0 15780 0 15760 {}
C {lab_pin.sym} 0 15760 0 0 {name=l246 lab=VDD}
N 0 15900 0 15920 {}
C {lab_pin.sym} 0 15920 0 0 {name=l247 lab=VSS}
C {inv_dly.sym} 0 16120 0 0 {name=Xdd5}
N -40 16100 -60 16100 {}
C {lab_pin.sym} -60 16100 0 0 {name=l248 lab=dd5}
N 40 16100 60 16100 {}
C {lab_pin.sym} 60 16100 0 0 {name=l249 lab=p_d}
N 0 16060 0 16040 {}
C {lab_pin.sym} 0 16040 0 0 {name=l250 lab=VDD}
N 0 16180 0 16200 {}
C {lab_pin.sym} 0 16200 0 0 {name=l251 lab=VSS}
C {nand3.sym} 0 16410 0 0 {name=Xwen}
N -40 16380 -60 16380 {}
C {lab_pin.sym} -60 16380 0 0 {name=l252 lab=p}
N -40 16400 -60 16400 {}
C {lab_pin.sym} -60 16400 0 0 {name=l253 lab=p_d}
N -40 16420 -60 16420 {}
C {lab_pin.sym} -60 16420 0 0 {name=l254 lab=en_q}
N 40 16380 60 16380 {}
C {lab_pin.sym} 60 16380 0 0 {name=l255 lab=wl_en_i}
N 0 16340 0 16320 {}
C {lab_pin.sym} 0 16320 0 0 {name=l256 lab=VDD}
N 0 16480 0 16500 {}
C {lab_pin.sym} 0 16500 0 0 {name=l257 lab=VSS}
C {inv_x8.sym} 0 16700 0 0 {name=Xwe1}
N -40 16680 -60 16680 {}
C {lab_pin.sym} -60 16680 0 0 {name=l258 lab=wl_en_i}
N 40 16680 60 16680 {}
C {lab_pin.sym} 60 16680 0 0 {name=l259 lab=wl_en}
N 0 16640 0 16620 {}
C {lab_pin.sym} 0 16620 0 0 {name=l260 lab=VDD}
N 0 16760 0 16780 {}
C {lab_pin.sym} 0 16780 0 0 {name=l261 lab=VSS}
C {inv_x8.sym} 0 16980 0 0 {name=Xwe2}
N -40 16960 -60 16960 {}
C {lab_pin.sym} -60 16960 0 0 {name=l262 lab=wl_en}
N 40 16960 60 16960 {}
C {lab_pin.sym} 60 16960 0 0 {name=l263 lab=wl_en_n}
N 0 16920 0 16900 {}
C {lab_pin.sym} 0 16900 0 0 {name=l264 lab=VDD}
N 0 17040 0 17060 {}
C {lab_pin.sym} 0 17060 0 0 {name=l265 lab=VSS}
C {inv_dly.sym} 0 17260 0 0 {name=Xdb0}
N -40 17240 -60 17240 {}
C {lab_pin.sym} -60 17240 0 0 {name=l266 lab=wl_en}
N 40 17240 60 17240 {}
C {lab_pin.sym} 60 17240 0 0 {name=l267 lab=db1}
N 0 17200 0 17180 {}
C {lab_pin.sym} 0 17180 0 0 {name=l268 lab=VDD}
N 0 17320 0 17340 {}
C {lab_pin.sym} 0 17340 0 0 {name=l269 lab=VSS}
C {inv_dly.sym} 0 17540 0 0 {name=Xdb1}
N -40 17520 -60 17520 {}
C {lab_pin.sym} -60 17520 0 0 {name=l270 lab=db1}
N 40 17520 60 17520 {}
C {lab_pin.sym} 60 17520 0 0 {name=l271 lab=db2}
N 0 17480 0 17460 {}
C {lab_pin.sym} 0 17460 0 0 {name=l272 lab=VDD}
N 0 17600 0 17620 {}
C {lab_pin.sym} 0 17620 0 0 {name=l273 lab=VSS}
C {inv_dly.sym} 0 17820 0 0 {name=Xdb2}
N -40 17800 -60 17800 {}
C {lab_pin.sym} -60 17800 0 0 {name=l274 lab=db2}
N 40 17800 60 17800 {}
C {lab_pin.sym} 60 17800 0 0 {name=l275 lab=db3}
N 0 17760 0 17740 {}
C {lab_pin.sym} 0 17740 0 0 {name=l276 lab=VDD}
N 0 17880 0 17900 {}
C {lab_pin.sym} 0 17900 0 0 {name=l277 lab=VSS}
C {inv_dly.sym} 0 18100 0 0 {name=Xdb3}
N -40 18080 -60 18080 {}
C {lab_pin.sym} -60 18080 0 0 {name=l278 lab=db3}
N 40 18080 60 18080 {}
C {lab_pin.sym} 60 18080 0 0 {name=l279 lab=db4}
N 0 18040 0 18020 {}
C {lab_pin.sym} 0 18020 0 0 {name=l280 lab=VDD}
N 0 18160 0 18180 {}
C {lab_pin.sym} 0 18180 0 0 {name=l281 lab=VSS}
C {inv_dly.sym} 0 18380 0 0 {name=Xdb4}
N -40 18360 -60 18360 {}
C {lab_pin.sym} -60 18360 0 0 {name=l282 lab=db4}
N 40 18360 60 18360 {}
C {lab_pin.sym} 60 18360 0 0 {name=l283 lab=db5}
N 0 18320 0 18300 {}
C {lab_pin.sym} 0 18300 0 0 {name=l284 lab=VDD}
N 0 18440 0 18460 {}
C {lab_pin.sym} 0 18460 0 0 {name=l285 lab=VSS}
C {inv_dly.sym} 0 18660 0 0 {name=Xdb5}
N -40 18640 -60 18640 {}
C {lab_pin.sym} -60 18640 0 0 {name=l286 lab=db5}
N 40 18640 60 18640 {}
C {lab_pin.sym} 60 18640 0 0 {name=l287 lab=wl_d2}
N 0 18600 0 18580 {}
C {lab_pin.sym} 0 18580 0 0 {name=l288 lab=VDD}
N 0 18720 0 18740 {}
C {lab_pin.sym} 0 18740 0 0 {name=l289 lab=VSS}
C {nand3.sym} 0 18950 0 0 {name=Xsn}
N -40 18920 -60 18920 {}
C {lab_pin.sym} -60 18920 0 0 {name=l290 lab=wl_en}
N -40 18940 -60 18940 {}
C {lab_pin.sym} -60 18940 0 0 {name=l291 lab=wl_d2}
N -40 18960 -60 18960 {}
C {lab_pin.sym} -60 18960 0 0 {name=l292 lab=rd_q}
N 40 18920 60 18920 {}
C {lab_pin.sym} 60 18920 0 0 {name=l293 lab=s_en_i}
N 0 18880 0 18860 {}
C {lab_pin.sym} 0 18860 0 0 {name=l294 lab=VDD}
N 0 19020 0 19040 {}
C {lab_pin.sym} 0 19040 0 0 {name=l295 lab=VSS}
C {inv_x8.sym} 0 19240 0 0 {name=Xs1}
N -40 19220 -60 19220 {}
C {lab_pin.sym} -60 19220 0 0 {name=l296 lab=s_en_i}
N 40 19220 60 19220 {}
C {lab_pin.sym} 60 19220 0 0 {name=l297 lab=s_en}
N 0 19180 0 19160 {}
C {lab_pin.sym} 0 19160 0 0 {name=l298 lab=VDD}
N 0 19300 0 19320 {}
C {lab_pin.sym} 0 19320 0 0 {name=l299 lab=VSS}
C {inv_dly.sym} 0 19520 0 0 {name=Xdq0}
N -40 19500 -60 19500 {}
C {lab_pin.sym} -60 19500 0 0 {name=l300 lab=s_en}
N 40 19500 60 19500 {}
C {lab_pin.sym} 60 19500 0 0 {name=l301 lab=dq1}
N 0 19460 0 19440 {}
C {lab_pin.sym} 0 19440 0 0 {name=l302 lab=VDD}
N 0 19580 0 19600 {}
C {lab_pin.sym} 0 19600 0 0 {name=l303 lab=VSS}
C {inv_dly.sym} 0 19800 0 0 {name=Xdq1}
N -40 19780 -60 19780 {}
C {lab_pin.sym} -60 19780 0 0 {name=l304 lab=dq1}
N 40 19780 60 19780 {}
C {lab_pin.sym} 60 19780 0 0 {name=l305 lab=dq2}
N 0 19740 0 19720 {}
C {lab_pin.sym} 0 19720 0 0 {name=l306 lab=VDD}
N 0 19860 0 19880 {}
C {lab_pin.sym} 0 19880 0 0 {name=l307 lab=VSS}
C {inv_dly.sym} 0 20080 0 0 {name=Xdq2}
N -40 20060 -60 20060 {}
C {lab_pin.sym} -60 20060 0 0 {name=l308 lab=dq2}
N 40 20060 60 20060 {}
C {lab_pin.sym} 60 20060 0 0 {name=l309 lab=dq3}
N 0 20020 0 20000 {}
C {lab_pin.sym} 0 20000 0 0 {name=l310 lab=VDD}
N 0 20140 0 20160 {}
C {lab_pin.sym} 0 20160 0 0 {name=l311 lab=VSS}
C {inv_dly.sym} 0 20360 0 0 {name=Xdq3}
N -40 20340 -60 20340 {}
C {lab_pin.sym} -60 20340 0 0 {name=l312 lab=dq3}
N 40 20340 60 20340 {}
C {lab_pin.sym} 60 20340 0 0 {name=l313 lab=s_d}
N 0 20300 0 20280 {}
C {lab_pin.sym} 0 20280 0 0 {name=l314 lab=VDD}
N 0 20420 0 20440 {}
C {lab_pin.sym} 0 20440 0 0 {name=l315 lab=VSS}
C {nand2.sym} 0 20640 0 0 {name=Xqn}
N -40 20620 -60 20620 {}
C {lab_pin.sym} -60 20620 0 0 {name=l316 lab=s_en}
N -40 20640 -60 20640 {}
C {lab_pin.sym} -60 20640 0 0 {name=l317 lab=s_d}
N 40 20620 60 20620 {}
C {lab_pin.sym} 60 20620 0 0 {name=l318 lab=q_clk_i}
N 0 20580 0 20560 {}
C {lab_pin.sym} 0 20560 0 0 {name=l319 lab=VDD}
N 0 20700 0 20720 {}
C {lab_pin.sym} 0 20720 0 0 {name=l320 lab=VSS}
C {inv_x8.sym} 0 20920 0 0 {name=Xq1}
N -40 20900 -60 20900 {}
C {lab_pin.sym} -60 20900 0 0 {name=l321 lab=q_clk_i}
N 40 20900 60 20900 {}
C {lab_pin.sym} 60 20900 0 0 {name=l322 lab=q_clk}
N 0 20860 0 20840 {}
C {lab_pin.sym} 0 20840 0 0 {name=l323 lab=VDD}
N 0 20980 0 21000 {}
C {lab_pin.sym} 0 21000 0 0 {name=l324 lab=VSS}
C {nand2.sym} 0 21200 0 0 {name=Xwn}
N -40 21180 -60 21180 {}
C {lab_pin.sym} -60 21180 0 0 {name=l325 lab=wl_en}
N -40 21200 -60 21200 {}
C {lab_pin.sym} -60 21200 0 0 {name=l326 lab=wr_q}
N 40 21180 60 21180 {}
C {lab_pin.sym} 60 21180 0 0 {name=l327 lab=w_n}
N 0 21140 0 21120 {}
C {lab_pin.sym} 0 21120 0 0 {name=l328 lab=VDD}
N 0 21260 0 21280 {}
C {lab_pin.sym} 0 21280 0 0 {name=l329 lab=VSS}
C {inv_x4.sym} 0 21480 0 0 {name=Xw1}
N -40 21460 -60 21460 {}
C {lab_pin.sym} -60 21460 0 0 {name=l330 lab=w_n}
N 40 21460 60 21460 {}
C {lab_pin.sym} 60 21460 0 0 {name=l331 lab=w_p}
N 0 21420 0 21400 {}
C {lab_pin.sym} 0 21400 0 0 {name=l332 lab=VDD}
N 0 21540 0 21560 {}
C {lab_pin.sym} 0 21560 0 0 {name=l333 lab=VSS}
C {inv_x16.sym} 0 21760 0 0 {name=Xw2}
N -40 21740 -60 21740 {}
C {lab_pin.sym} -60 21740 0 0 {name=l334 lab=w_p}
N 40 21740 60 21740 {}
C {lab_pin.sym} 60 21740 0 0 {name=l335 lab=wpn}
N 0 21700 0 21680 {}
C {lab_pin.sym} 0 21680 0 0 {name=l336 lab=VDD}
N 0 21820 0 21840 {}
C {lab_pin.sym} 0 21840 0 0 {name=l337 lab=VSS}
C {ipin.sym} -400 -200 0 0 {name=p338 lab=A0}
C {ipin.sym} -400 -260 0 0 {name=p339 lab=A1}
C {ipin.sym} -400 -320 0 0 {name=p340 lab=A2}
C {ipin.sym} -400 -380 0 0 {name=p341 lab=A3}
C {ipin.sym} -400 -440 0 0 {name=p342 lab=A4}
C {ipin.sym} -400 -500 0 0 {name=p343 lab=A5}
C {ipin.sym} -400 -560 0 0 {name=p344 lab=A6}
C {ipin.sym} -400 -620 0 0 {name=p345 lab=A7}
C {ipin.sym} -400 -680 0 0 {name=p346 lab=CEN}
C {ipin.sym} -400 -740 0 0 {name=p347 lab=GWEN}
C {ipin.sym} -400 -800 0 0 {name=p348 lab=CLK}
C {opin.sym} -700 -200 0 0 {name=p349 lab=aq0}
C {opin.sym} -700 -260 0 0 {name=p350 lab=aq1}
C {opin.sym} -700 -320 0 0 {name=p351 lab=aq2}
C {opin.sym} -700 -380 0 0 {name=p352 lab=aq3}
C {opin.sym} -700 -440 0 0 {name=p353 lab=aq4}
C {opin.sym} -700 -500 0 0 {name=p354 lab=aq5}
C {opin.sym} -700 -560 0 0 {name=p355 lab=aq6}
C {opin.sym} -700 -620 0 0 {name=p356 lab=aq7}
C {opin.sym} -700 -680 0 0 {name=p357 lab=aqb0}
C {opin.sym} -700 -740 0 0 {name=p358 lab=aqb1}
C {opin.sym} -700 -800 0 0 {name=p359 lab=aqb2}
C {opin.sym} -700 -860 0 0 {name=p360 lab=aqb3}
C {opin.sym} -700 -920 0 0 {name=p361 lab=aqb4}
C {opin.sym} -700 -980 0 0 {name=p362 lab=aqb5}
C {opin.sym} -700 -1040 0 0 {name=p363 lab=aqb6}
C {opin.sym} -700 -1100 0 0 {name=p364 lab=aqb7}
C {opin.sym} -700 -1160 0 0 {name=p365 lab=clk_buf}
C {opin.sym} -700 -1220 0 0 {name=p366 lab=wl_en}
C {opin.sym} -700 -1280 0 0 {name=p367 lab=wl_en_n}
C {opin.sym} -700 -1340 0 0 {name=p368 lab=s_en}
C {opin.sym} -700 -1400 0 0 {name=p369 lab=q_clk}
C {opin.sym} -700 -1460 0 0 {name=p370 lab=wpn}
C {iopin.sym} -1000 -200 0 0 {name=p371 lab=VDD}
C {iopin.sym} -1000 -260 0 0 {name=p372 lab=VSS}
