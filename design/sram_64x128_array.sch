N 11440 8360 11460 8360 {}
C {lab_pin.sym} 11460 8360 0 0 {name=l27170 lab=VSS}
C {bitcell_6t.sym} 11600 8400 0 0 {name=Xr42c58}
N 11560 8440 11540 8440 {}
C {lab_pin.sym} 11540 8440 0 0 {name=l27171 lab=BL58}
N 11560 8400 11540 8400 {}
C {lab_pin.sym} 11540 8400 0 0 {name=l27172 lab=BLB58}
N 11560 8360 11540 8360 {}
C {lab_pin.sym} 11540 8360 0 0 {name=l27173 lab=WL42}
N 11640 8440 11660 8440 {}
C {lab_pin.sym} 11660 8440 0 0 {name=l27174 lab=VDD}
N 11640 8360 11660 8360 {}
C {lab_pin.sym} 11660 8360 0 0 {name=l27175 lab=VSS}
C {bitcell_6t.sym} 11800 8400 0 0 {name=Xr42c59}
N 11760 8440 11740 8440 {}
C {lab_pin.sym} 11740 8440 0 0 {name=l27176 lab=BL59}
N 11760 8400 11740 8400 {}
C {lab_pin.sym} 11740 8400 0 0 {name=l27177 lab=BLB59}
N 11760 8360 11740 8360 {}
C {lab_pin.sym} 11740 8360 0 0 {name=l27178 lab=WL42}
N 11840 8440 11860 8440 {}
C {lab_pin.sym} 11860 8440 0 0 {name=l27179 lab=VDD}
N 11840 8360 11860 8360 {}
C {lab_pin.sym} 11860 8360 0 0 {name=l27180 lab=VSS}
C {bitcell_6t.sym} 12000 8400 0 0 {name=Xr42c60}
N 11960 8440 11940 8440 {}
C {lab_pin.sym} 11940 8440 0 0 {name=l27181 lab=BL60}
N 11960 8400 11940 8400 {}
C {lab_pin.sym} 11940 8400 0 0 {name=l27182 lab=BLB60}
N 11960 8360 11940 8360 {}
C {lab_pin.sym} 11940 8360 0 0 {name=l27183 lab=WL42}
N 12040 8440 12060 8440 {}
C {lab_pin.sym} 12060 8440 0 0 {name=l27184 lab=VDD}
N 12040 8360 12060 8360 {}
C {lab_pin.sym} 12060 8360 0 0 {name=l27185 lab=VSS}
C {bitcell_6t.sym} 12200 8400 0 0 {name=Xr42c61}
N 12160 8440 12140 8440 {}
C {lab_pin.sym} 12140 8440 0 0 {name=l27186 lab=BL61}
N 12160 8400 12140 8400 {}
C {lab_pin.sym} 12140 8400 0 0 {name=l27187 lab=BLB61}
N 12160 8360 12140 8360 {}
C {lab_pin.sym} 12140 8360 0 0 {name=l27188 lab=WL42}
N 12240 8440 12260 8440 {}
C {lab_pin.sym} 12260 8440 0 0 {name=l27189 lab=VDD}
N 12240 8360 12260 8360 {}
C {lab_pin.sym} 12260 8360 0 0 {name=l27190 lab=VSS}
C {bitcell_6t.sym} 12400 8400 0 0 {name=Xr42c62}
N 12360 8440 12340 8440 {}
C {lab_pin.sym} 12340 8440 0 0 {name=l27191 lab=BL62}
N 12360 8400 12340 8400 {}
C {lab_pin.sym} 12340 8400 0 0 {name=l27192 lab=BLB62}
N 12360 8360 12340 8360 {}
C {lab_pin.sym} 12340 8360 0 0 {name=l27193 lab=WL42}
N 12440 8440 12460 8440 {}
C {lab_pin.sym} 12460 8440 0 0 {name=l27194 lab=VDD}
N 12440 8360 12460 8360 {}
C {lab_pin.sym} 12460 8360 0 0 {name=l27195 lab=VSS}
C {bitcell_6t.sym} 12600 8400 0 0 {name=Xr42c63}
N 12560 8440 12540 8440 {}
C {lab_pin.sym} 12540 8440 0 0 {name=l27196 lab=BL63}
N 12560 8400 12540 8400 {}
C {lab_pin.sym} 12540 8400 0 0 {name=l27197 lab=BLB63}
N 12560 8360 12540 8360 {}
C {lab_pin.sym} 12540 8360 0 0 {name=l27198 lab=WL42}
N 12640 8440 12660 8440 {}
C {lab_pin.sym} 12660 8440 0 0 {name=l27199 lab=VDD}
N 12640 8360 12660 8360 {}
C {lab_pin.sym} 12660 8360 0 0 {name=l27200 lab=VSS}
C {bitcell_6t.sym} 12800 8400 0 0 {name=Xr42c64}
N 12760 8440 12740 8440 {}
C {lab_pin.sym} 12740 8440 0 0 {name=l27201 lab=BL64}
N 12760 8400 12740 8400 {}
C {lab_pin.sym} 12740 8400 0 0 {name=l27202 lab=BLB64}
N 12760 8360 12740 8360 {}
C {lab_pin.sym} 12740 8360 0 0 {name=l27203 lab=WL42}
N 12840 8440 12860 8440 {}
C {lab_pin.sym} 12860 8440 0 0 {name=l27204 lab=VDD}
N 12840 8360 12860 8360 {}
C {lab_pin.sym} 12860 8360 0 0 {name=l27205 lab=VSS}
C {bitcell_6t.sym} 13000 8400 0 0 {name=Xr42c65}
N 12960 8440 12940 8440 {}
C {lab_pin.sym} 12940 8440 0 0 {name=l27206 lab=BL65}
N 12960 8400 12940 8400 {}
C {lab_pin.sym} 12940 8400 0 0 {name=l27207 lab=BLB65}
N 12960 8360 12940 8360 {}
C {lab_pin.sym} 12940 8360 0 0 {name=l27208 lab=WL42}
N 13040 8440 13060 8440 {}
C {lab_pin.sym} 13060 8440 0 0 {name=l27209 lab=VDD}
N 13040 8360 13060 8360 {}
C {lab_pin.sym} 13060 8360 0 0 {name=l27210 lab=VSS}
C {bitcell_6t.sym} 13200 8400 0 0 {name=Xr42c66}
N 13160 8440 13140 8440 {}
C {lab_pin.sym} 13140 8440 0 0 {name=l27211 lab=BL66}
N 13160 8400 13140 8400 {}
C {lab_pin.sym} 13140 8400 0 0 {name=l27212 lab=BLB66}
N 13160 8360 13140 8360 {}
C {lab_pin.sym} 13140 8360 0 0 {name=l27213 lab=WL42}
N 13240 8440 13260 8440 {}
C {lab_pin.sym} 13260 8440 0 0 {name=l27214 lab=VDD}
N 13240 8360 13260 8360 {}
C {lab_pin.sym} 13260 8360 0 0 {name=l27215 lab=VSS}
C {bitcell_6t.sym} 13400 8400 0 0 {name=Xr42c67}
N 13360 8440 13340 8440 {}
C {lab_pin.sym} 13340 8440 0 0 {name=l27216 lab=BL67}
N 13360 8400 13340 8400 {}
C {lab_pin.sym} 13340 8400 0 0 {name=l27217 lab=BLB67}
N 13360 8360 13340 8360 {}
C {lab_pin.sym} 13340 8360 0 0 {name=l27218 lab=WL42}
N 13440 8440 13460 8440 {}
C {lab_pin.sym} 13460 8440 0 0 {name=l27219 lab=VDD}
N 13440 8360 13460 8360 {}
C {lab_pin.sym} 13460 8360 0 0 {name=l27220 lab=VSS}
C {bitcell_6t.sym} 13600 8400 0 0 {name=Xr42c68}
N 13560 8440 13540 8440 {}
C {lab_pin.sym} 13540 8440 0 0 {name=l27221 lab=BL68}
N 13560 8400 13540 8400 {}
C {lab_pin.sym} 13540 8400 0 0 {name=l27222 lab=BLB68}
N 13560 8360 13540 8360 {}
C {lab_pin.sym} 13540 8360 0 0 {name=l27223 lab=WL42}
N 13640 8440 13660 8440 {}
C {lab_pin.sym} 13660 8440 0 0 {name=l27224 lab=VDD}
N 13640 8360 13660 8360 {}
C {lab_pin.sym} 13660 8360 0 0 {name=l27225 lab=VSS}
C {bitcell_6t.sym} 13800 8400 0 0 {name=Xr42c69}
N 13760 8440 13740 8440 {}
C {lab_pin.sym} 13740 8440 0 0 {name=l27226 lab=BL69}
N 13760 8400 13740 8400 {}
C {lab_pin.sym} 13740 8400 0 0 {name=l27227 lab=BLB69}
N 13760 8360 13740 8360 {}
C {lab_pin.sym} 13740 8360 0 0 {name=l27228 lab=WL42}
N 13840 8440 13860 8440 {}
C {lab_pin.sym} 13860 8440 0 0 {name=l27229 lab=VDD}
N 13840 8360 13860 8360 {}
C {lab_pin.sym} 13860 8360 0 0 {name=l27230 lab=VSS}
C {bitcell_6t.sym} 14000 8400 0 0 {name=Xr42c70}
N 13960 8440 13940 8440 {}
C {lab_pin.sym} 13940 8440 0 0 {name=l27231 lab=BL70}
N 13960 8400 13940 8400 {}
C {lab_pin.sym} 13940 8400 0 0 {name=l27232 lab=BLB70}
N 13960 8360 13940 8360 {}
C {lab_pin.sym} 13940 8360 0 0 {name=l27233 lab=WL42}
N 14040 8440 14060 8440 {}
C {lab_pin.sym} 14060 8440 0 0 {name=l27234 lab=VDD}
N 14040 8360 14060 8360 {}
C {lab_pin.sym} 14060 8360 0 0 {name=l27235 lab=VSS}
C {bitcell_6t.sym} 14200 8400 0 0 {name=Xr42c71}
N 14160 8440 14140 8440 {}
C {lab_pin.sym} 14140 8440 0 0 {name=l27236 lab=BL71}
N 14160 8400 14140 8400 {}
C {lab_pin.sym} 14140 8400 0 0 {name=l27237 lab=BLB71}
N 14160 8360 14140 8360 {}
C {lab_pin.sym} 14140 8360 0 0 {name=l27238 lab=WL42}
N 14240 8440 14260 8440 {}
C {lab_pin.sym} 14260 8440 0 0 {name=l27239 lab=VDD}
N 14240 8360 14260 8360 {}
C {lab_pin.sym} 14260 8360 0 0 {name=l27240 lab=VSS}
C {bitcell_6t.sym} 14400 8400 0 0 {name=Xr42c72}
N 14360 8440 14340 8440 {}
C {lab_pin.sym} 14340 8440 0 0 {name=l27241 lab=BL72}
N 14360 8400 14340 8400 {}
C {lab_pin.sym} 14340 8400 0 0 {name=l27242 lab=BLB72}
N 14360 8360 14340 8360 {}
C {lab_pin.sym} 14340 8360 0 0 {name=l27243 lab=WL42}
N 14440 8440 14460 8440 {}
C {lab_pin.sym} 14460 8440 0 0 {name=l27244 lab=VDD}
N 14440 8360 14460 8360 {}
C {lab_pin.sym} 14460 8360 0 0 {name=l27245 lab=VSS}
C {bitcell_6t.sym} 14600 8400 0 0 {name=Xr42c73}
N 14560 8440 14540 8440 {}
C {lab_pin.sym} 14540 8440 0 0 {name=l27246 lab=BL73}
N 14560 8400 14540 8400 {}
C {lab_pin.sym} 14540 8400 0 0 {name=l27247 lab=BLB73}
N 14560 8360 14540 8360 {}
C {lab_pin.sym} 14540 8360 0 0 {name=l27248 lab=WL42}
N 14640 8440 14660 8440 {}
C {lab_pin.sym} 14660 8440 0 0 {name=l27249 lab=VDD}
N 14640 8360 14660 8360 {}
C {lab_pin.sym} 14660 8360 0 0 {name=l27250 lab=VSS}
C {bitcell_6t.sym} 14800 8400 0 0 {name=Xr42c74}
N 14760 8440 14740 8440 {}
C {lab_pin.sym} 14740 8440 0 0 {name=l27251 lab=BL74}
N 14760 8400 14740 8400 {}
C {lab_pin.sym} 14740 8400 0 0 {name=l27252 lab=BLB74}
N 14760 8360 14740 8360 {}
C {lab_pin.sym} 14740 8360 0 0 {name=l27253 lab=WL42}
N 14840 8440 14860 8440 {}
C {lab_pin.sym} 14860 8440 0 0 {name=l27254 lab=VDD}
N 14840 8360 14860 8360 {}
C {lab_pin.sym} 14860 8360 0 0 {name=l27255 lab=VSS}
C {bitcell_6t.sym} 15000 8400 0 0 {name=Xr42c75}
N 14960 8440 14940 8440 {}
C {lab_pin.sym} 14940 8440 0 0 {name=l27256 lab=BL75}
N 14960 8400 14940 8400 {}
C {lab_pin.sym} 14940 8400 0 0 {name=l27257 lab=BLB75}
N 14960 8360 14940 8360 {}
C {lab_pin.sym} 14940 8360 0 0 {name=l27258 lab=WL42}
N 15040 8440 15060 8440 {}
C {lab_pin.sym} 15060 8440 0 0 {name=l27259 lab=VDD}
N 15040 8360 15060 8360 {}
C {lab_pin.sym} 15060 8360 0 0 {name=l27260 lab=VSS}
C {bitcell_6t.sym} 15200 8400 0 0 {name=Xr42c76}
N 15160 8440 15140 8440 {}
C {lab_pin.sym} 15140 8440 0 0 {name=l27261 lab=BL76}
N 15160 8400 15140 8400 {}
C {lab_pin.sym} 15140 8400 0 0 {name=l27262 lab=BLB76}
N 15160 8360 15140 8360 {}
C {lab_pin.sym} 15140 8360 0 0 {name=l27263 lab=WL42}
N 15240 8440 15260 8440 {}
C {lab_pin.sym} 15260 8440 0 0 {name=l27264 lab=VDD}
N 15240 8360 15260 8360 {}
C {lab_pin.sym} 15260 8360 0 0 {name=l27265 lab=VSS}
C {bitcell_6t.sym} 15400 8400 0 0 {name=Xr42c77}
N 15360 8440 15340 8440 {}
C {lab_pin.sym} 15340 8440 0 0 {name=l27266 lab=BL77}
N 15360 8400 15340 8400 {}
C {lab_pin.sym} 15340 8400 0 0 {name=l27267 lab=BLB77}
N 15360 8360 15340 8360 {}
C {lab_pin.sym} 15340 8360 0 0 {name=l27268 lab=WL42}
N 15440 8440 15460 8440 {}
C {lab_pin.sym} 15460 8440 0 0 {name=l27269 lab=VDD}
N 15440 8360 15460 8360 {}
C {lab_pin.sym} 15460 8360 0 0 {name=l27270 lab=VSS}
C {bitcell_6t.sym} 15600 8400 0 0 {name=Xr42c78}
N 15560 8440 15540 8440 {}
C {lab_pin.sym} 15540 8440 0 0 {name=l27271 lab=BL78}
N 15560 8400 15540 8400 {}
C {lab_pin.sym} 15540 8400 0 0 {name=l27272 lab=BLB78}
N 15560 8360 15540 8360 {}
C {lab_pin.sym} 15540 8360 0 0 {name=l27273 lab=WL42}
N 15640 8440 15660 8440 {}
C {lab_pin.sym} 15660 8440 0 0 {name=l27274 lab=VDD}
N 15640 8360 15660 8360 {}
C {lab_pin.sym} 15660 8360 0 0 {name=l27275 lab=VSS}
C {bitcell_6t.sym} 15800 8400 0 0 {name=Xr42c79}
N 15760 8440 15740 8440 {}
C {lab_pin.sym} 15740 8440 0 0 {name=l27276 lab=BL79}
N 15760 8400 15740 8400 {}
C {lab_pin.sym} 15740 8400 0 0 {name=l27277 lab=BLB79}
N 15760 8360 15740 8360 {}
C {lab_pin.sym} 15740 8360 0 0 {name=l27278 lab=WL42}
N 15840 8440 15860 8440 {}
C {lab_pin.sym} 15860 8440 0 0 {name=l27279 lab=VDD}
N 15840 8360 15860 8360 {}
C {lab_pin.sym} 15860 8360 0 0 {name=l27280 lab=VSS}
C {bitcell_6t.sym} 16000 8400 0 0 {name=Xr42c80}
N 15960 8440 15940 8440 {}
C {lab_pin.sym} 15940 8440 0 0 {name=l27281 lab=BL80}
N 15960 8400 15940 8400 {}
C {lab_pin.sym} 15940 8400 0 0 {name=l27282 lab=BLB80}
N 15960 8360 15940 8360 {}
C {lab_pin.sym} 15940 8360 0 0 {name=l27283 lab=WL42}
N 16040 8440 16060 8440 {}
C {lab_pin.sym} 16060 8440 0 0 {name=l27284 lab=VDD}
N 16040 8360 16060 8360 {}
C {lab_pin.sym} 16060 8360 0 0 {name=l27285 lab=VSS}
C {bitcell_6t.sym} 16200 8400 0 0 {name=Xr42c81}
N 16160 8440 16140 8440 {}
C {lab_pin.sym} 16140 8440 0 0 {name=l27286 lab=BL81}
N 16160 8400 16140 8400 {}
C {lab_pin.sym} 16140 8400 0 0 {name=l27287 lab=BLB81}
N 16160 8360 16140 8360 {}
C {lab_pin.sym} 16140 8360 0 0 {name=l27288 lab=WL42}
N 16240 8440 16260 8440 {}
C {lab_pin.sym} 16260 8440 0 0 {name=l27289 lab=VDD}
N 16240 8360 16260 8360 {}
C {lab_pin.sym} 16260 8360 0 0 {name=l27290 lab=VSS}
C {bitcell_6t.sym} 16400 8400 0 0 {name=Xr42c82}
N 16360 8440 16340 8440 {}
C {lab_pin.sym} 16340 8440 0 0 {name=l27291 lab=BL82}
N 16360 8400 16340 8400 {}
C {lab_pin.sym} 16340 8400 0 0 {name=l27292 lab=BLB82}
N 16360 8360 16340 8360 {}
C {lab_pin.sym} 16340 8360 0 0 {name=l27293 lab=WL42}
N 16440 8440 16460 8440 {}
C {lab_pin.sym} 16460 8440 0 0 {name=l27294 lab=VDD}
N 16440 8360 16460 8360 {}
C {lab_pin.sym} 16460 8360 0 0 {name=l27295 lab=VSS}
C {bitcell_6t.sym} 16600 8400 0 0 {name=Xr42c83}
N 16560 8440 16540 8440 {}
C {lab_pin.sym} 16540 8440 0 0 {name=l27296 lab=BL83}
N 16560 8400 16540 8400 {}
C {lab_pin.sym} 16540 8400 0 0 {name=l27297 lab=BLB83}
N 16560 8360 16540 8360 {}
C {lab_pin.sym} 16540 8360 0 0 {name=l27298 lab=WL42}
N 16640 8440 16660 8440 {}
C {lab_pin.sym} 16660 8440 0 0 {name=l27299 lab=VDD}
N 16640 8360 16660 8360 {}
C {lab_pin.sym} 16660 8360 0 0 {name=l27300 lab=VSS}
C {bitcell_6t.sym} 16800 8400 0 0 {name=Xr42c84}
N 16760 8440 16740 8440 {}
C {lab_pin.sym} 16740 8440 0 0 {name=l27301 lab=BL84}
N 16760 8400 16740 8400 {}
C {lab_pin.sym} 16740 8400 0 0 {name=l27302 lab=BLB84}
N 16760 8360 16740 8360 {}
C {lab_pin.sym} 16740 8360 0 0 {name=l27303 lab=WL42}
N 16840 8440 16860 8440 {}
C {lab_pin.sym} 16860 8440 0 0 {name=l27304 lab=VDD}
N 16840 8360 16860 8360 {}
C {lab_pin.sym} 16860 8360 0 0 {name=l27305 lab=VSS}
C {bitcell_6t.sym} 17000 8400 0 0 {name=Xr42c85}
N 16960 8440 16940 8440 {}
C {lab_pin.sym} 16940 8440 0 0 {name=l27306 lab=BL85}
N 16960 8400 16940 8400 {}
C {lab_pin.sym} 16940 8400 0 0 {name=l27307 lab=BLB85}
N 16960 8360 16940 8360 {}
C {lab_pin.sym} 16940 8360 0 0 {name=l27308 lab=WL42}
N 17040 8440 17060 8440 {}
C {lab_pin.sym} 17060 8440 0 0 {name=l27309 lab=VDD}
N 17040 8360 17060 8360 {}
C {lab_pin.sym} 17060 8360 0 0 {name=l27310 lab=VSS}
C {bitcell_6t.sym} 17200 8400 0 0 {name=Xr42c86}
N 17160 8440 17140 8440 {}
C {lab_pin.sym} 17140 8440 0 0 {name=l27311 lab=BL86}
N 17160 8400 17140 8400 {}
C {lab_pin.sym} 17140 8400 0 0 {name=l27312 lab=BLB86}
N 17160 8360 17140 8360 {}
C {lab_pin.sym} 17140 8360 0 0 {name=l27313 lab=WL42}
N 17240 8440 17260 8440 {}
C {lab_pin.sym} 17260 8440 0 0 {name=l27314 lab=VDD}
N 17240 8360 17260 8360 {}
C {lab_pin.sym} 17260 8360 0 0 {name=l27315 lab=VSS}
C {bitcell_6t.sym} 17400 8400 0 0 {name=Xr42c87}
N 17360 8440 17340 8440 {}
C {lab_pin.sym} 17340 8440 0 0 {name=l27316 lab=BL87}
N 17360 8400 17340 8400 {}
C {lab_pin.sym} 17340 8400 0 0 {name=l27317 lab=BLB87}
N 17360 8360 17340 8360 {}
C {lab_pin.sym} 17340 8360 0 0 {name=l27318 lab=WL42}
N 17440 8440 17460 8440 {}
C {lab_pin.sym} 17460 8440 0 0 {name=l27319 lab=VDD}
N 17440 8360 17460 8360 {}
C {lab_pin.sym} 17460 8360 0 0 {name=l27320 lab=VSS}
C {bitcell_6t.sym} 17600 8400 0 0 {name=Xr42c88}
N 17560 8440 17540 8440 {}
C {lab_pin.sym} 17540 8440 0 0 {name=l27321 lab=BL88}
N 17560 8400 17540 8400 {}
C {lab_pin.sym} 17540 8400 0 0 {name=l27322 lab=BLB88}
N 17560 8360 17540 8360 {}
C {lab_pin.sym} 17540 8360 0 0 {name=l27323 lab=WL42}
N 17640 8440 17660 8440 {}
C {lab_pin.sym} 17660 8440 0 0 {name=l27324 lab=VDD}
N 17640 8360 17660 8360 {}
C {lab_pin.sym} 17660 8360 0 0 {name=l27325 lab=VSS}
C {bitcell_6t.sym} 17800 8400 0 0 {name=Xr42c89}
N 17760 8440 17740 8440 {}
C {lab_pin.sym} 17740 8440 0 0 {name=l27326 lab=BL89}
N 17760 8400 17740 8400 {}
C {lab_pin.sym} 17740 8400 0 0 {name=l27327 lab=BLB89}
N 17760 8360 17740 8360 {}
C {lab_pin.sym} 17740 8360 0 0 {name=l27328 lab=WL42}
N 17840 8440 17860 8440 {}
C {lab_pin.sym} 17860 8440 0 0 {name=l27329 lab=VDD}
N 17840 8360 17860 8360 {}
C {lab_pin.sym} 17860 8360 0 0 {name=l27330 lab=VSS}
C {bitcell_6t.sym} 18000 8400 0 0 {name=Xr42c90}
N 17960 8440 17940 8440 {}
C {lab_pin.sym} 17940 8440 0 0 {name=l27331 lab=BL90}
N 17960 8400 17940 8400 {}
C {lab_pin.sym} 17940 8400 0 0 {name=l27332 lab=BLB90}
N 17960 8360 17940 8360 {}
C {lab_pin.sym} 17940 8360 0 0 {name=l27333 lab=WL42}
N 18040 8440 18060 8440 {}
C {lab_pin.sym} 18060 8440 0 0 {name=l27334 lab=VDD}
N 18040 8360 18060 8360 {}
C {lab_pin.sym} 18060 8360 0 0 {name=l27335 lab=VSS}
C {bitcell_6t.sym} 18200 8400 0 0 {name=Xr42c91}
N 18160 8440 18140 8440 {}
C {lab_pin.sym} 18140 8440 0 0 {name=l27336 lab=BL91}
N 18160 8400 18140 8400 {}
C {lab_pin.sym} 18140 8400 0 0 {name=l27337 lab=BLB91}
N 18160 8360 18140 8360 {}
C {lab_pin.sym} 18140 8360 0 0 {name=l27338 lab=WL42}
N 18240 8440 18260 8440 {}
C {lab_pin.sym} 18260 8440 0 0 {name=l27339 lab=VDD}
N 18240 8360 18260 8360 {}
C {lab_pin.sym} 18260 8360 0 0 {name=l27340 lab=VSS}
C {bitcell_6t.sym} 18400 8400 0 0 {name=Xr42c92}
N 18360 8440 18340 8440 {}
C {lab_pin.sym} 18340 8440 0 0 {name=l27341 lab=BL92}
N 18360 8400 18340 8400 {}
C {lab_pin.sym} 18340 8400 0 0 {name=l27342 lab=BLB92}
N 18360 8360 18340 8360 {}
C {lab_pin.sym} 18340 8360 0 0 {name=l27343 lab=WL42}
N 18440 8440 18460 8440 {}
C {lab_pin.sym} 18460 8440 0 0 {name=l27344 lab=VDD}
N 18440 8360 18460 8360 {}
C {lab_pin.sym} 18460 8360 0 0 {name=l27345 lab=VSS}
C {bitcell_6t.sym} 18600 8400 0 0 {name=Xr42c93}
N 18560 8440 18540 8440 {}
C {lab_pin.sym} 18540 8440 0 0 {name=l27346 lab=BL93}
N 18560 8400 18540 8400 {}
C {lab_pin.sym} 18540 8400 0 0 {name=l27347 lab=BLB93}
N 18560 8360 18540 8360 {}
C {lab_pin.sym} 18540 8360 0 0 {name=l27348 lab=WL42}
N 18640 8440 18660 8440 {}
C {lab_pin.sym} 18660 8440 0 0 {name=l27349 lab=VDD}
N 18640 8360 18660 8360 {}
C {lab_pin.sym} 18660 8360 0 0 {name=l27350 lab=VSS}
C {bitcell_6t.sym} 18800 8400 0 0 {name=Xr42c94}
N 18760 8440 18740 8440 {}
C {lab_pin.sym} 18740 8440 0 0 {name=l27351 lab=BL94}
N 18760 8400 18740 8400 {}
C {lab_pin.sym} 18740 8400 0 0 {name=l27352 lab=BLB94}
N 18760 8360 18740 8360 {}
C {lab_pin.sym} 18740 8360 0 0 {name=l27353 lab=WL42}
N 18840 8440 18860 8440 {}
C {lab_pin.sym} 18860 8440 0 0 {name=l27354 lab=VDD}
N 18840 8360 18860 8360 {}
C {lab_pin.sym} 18860 8360 0 0 {name=l27355 lab=VSS}
C {bitcell_6t.sym} 19000 8400 0 0 {name=Xr42c95}
N 18960 8440 18940 8440 {}
C {lab_pin.sym} 18940 8440 0 0 {name=l27356 lab=BL95}
N 18960 8400 18940 8400 {}
C {lab_pin.sym} 18940 8400 0 0 {name=l27357 lab=BLB95}
N 18960 8360 18940 8360 {}
C {lab_pin.sym} 18940 8360 0 0 {name=l27358 lab=WL42}
N 19040 8440 19060 8440 {}
C {lab_pin.sym} 19060 8440 0 0 {name=l27359 lab=VDD}
N 19040 8360 19060 8360 {}
C {lab_pin.sym} 19060 8360 0 0 {name=l27360 lab=VSS}
C {bitcell_6t.sym} 19200 8400 0 0 {name=Xr42c96}
N 19160 8440 19140 8440 {}
C {lab_pin.sym} 19140 8440 0 0 {name=l27361 lab=BL96}
N 19160 8400 19140 8400 {}
C {lab_pin.sym} 19140 8400 0 0 {name=l27362 lab=BLB96}
N 19160 8360 19140 8360 {}
C {lab_pin.sym} 19140 8360 0 0 {name=l27363 lab=WL42}
N 19240 8440 19260 8440 {}
C {lab_pin.sym} 19260 8440 0 0 {name=l27364 lab=VDD}
N 19240 8360 19260 8360 {}
C {lab_pin.sym} 19260 8360 0 0 {name=l27365 lab=VSS}
C {bitcell_6t.sym} 19400 8400 0 0 {name=Xr42c97}
N 19360 8440 19340 8440 {}
C {lab_pin.sym} 19340 8440 0 0 {name=l27366 lab=BL97}
N 19360 8400 19340 8400 {}
C {lab_pin.sym} 19340 8400 0 0 {name=l27367 lab=BLB97}
N 19360 8360 19340 8360 {}
C {lab_pin.sym} 19340 8360 0 0 {name=l27368 lab=WL42}
N 19440 8440 19460 8440 {}
C {lab_pin.sym} 19460 8440 0 0 {name=l27369 lab=VDD}
N 19440 8360 19460 8360 {}
C {lab_pin.sym} 19460 8360 0 0 {name=l27370 lab=VSS}
C {bitcell_6t.sym} 19600 8400 0 0 {name=Xr42c98}
N 19560 8440 19540 8440 {}
C {lab_pin.sym} 19540 8440 0 0 {name=l27371 lab=BL98}
N 19560 8400 19540 8400 {}
C {lab_pin.sym} 19540 8400 0 0 {name=l27372 lab=BLB98}
N 19560 8360 19540 8360 {}
C {lab_pin.sym} 19540 8360 0 0 {name=l27373 lab=WL42}
N 19640 8440 19660 8440 {}
C {lab_pin.sym} 19660 8440 0 0 {name=l27374 lab=VDD}
N 19640 8360 19660 8360 {}
C {lab_pin.sym} 19660 8360 0 0 {name=l27375 lab=VSS}
C {bitcell_6t.sym} 19800 8400 0 0 {name=Xr42c99}
N 19760 8440 19740 8440 {}
C {lab_pin.sym} 19740 8440 0 0 {name=l27376 lab=BL99}
N 19760 8400 19740 8400 {}
C {lab_pin.sym} 19740 8400 0 0 {name=l27377 lab=BLB99}
N 19760 8360 19740 8360 {}
C {lab_pin.sym} 19740 8360 0 0 {name=l27378 lab=WL42}
N 19840 8440 19860 8440 {}
C {lab_pin.sym} 19860 8440 0 0 {name=l27379 lab=VDD}
N 19840 8360 19860 8360 {}
C {lab_pin.sym} 19860 8360 0 0 {name=l27380 lab=VSS}
C {bitcell_6t.sym} 20000 8400 0 0 {name=Xr42c100}
N 19960 8440 19940 8440 {}
C {lab_pin.sym} 19940 8440 0 0 {name=l27381 lab=BL100}
N 19960 8400 19940 8400 {}
C {lab_pin.sym} 19940 8400 0 0 {name=l27382 lab=BLB100}
N 19960 8360 19940 8360 {}
C {lab_pin.sym} 19940 8360 0 0 {name=l27383 lab=WL42}
N 20040 8440 20060 8440 {}
C {lab_pin.sym} 20060 8440 0 0 {name=l27384 lab=VDD}
N 20040 8360 20060 8360 {}
C {lab_pin.sym} 20060 8360 0 0 {name=l27385 lab=VSS}
C {bitcell_6t.sym} 20200 8400 0 0 {name=Xr42c101}
N 20160 8440 20140 8440 {}
C {lab_pin.sym} 20140 8440 0 0 {name=l27386 lab=BL101}
N 20160 8400 20140 8400 {}
C {lab_pin.sym} 20140 8400 0 0 {name=l27387 lab=BLB101}
N 20160 8360 20140 8360 {}
C {lab_pin.sym} 20140 8360 0 0 {name=l27388 lab=WL42}
N 20240 8440 20260 8440 {}
C {lab_pin.sym} 20260 8440 0 0 {name=l27389 lab=VDD}
N 20240 8360 20260 8360 {}
C {lab_pin.sym} 20260 8360 0 0 {name=l27390 lab=VSS}
C {bitcell_6t.sym} 20400 8400 0 0 {name=Xr42c102}
N 20360 8440 20340 8440 {}
C {lab_pin.sym} 20340 8440 0 0 {name=l27391 lab=BL102}
N 20360 8400 20340 8400 {}
C {lab_pin.sym} 20340 8400 0 0 {name=l27392 lab=BLB102}
N 20360 8360 20340 8360 {}
C {lab_pin.sym} 20340 8360 0 0 {name=l27393 lab=WL42}
N 20440 8440 20460 8440 {}
C {lab_pin.sym} 20460 8440 0 0 {name=l27394 lab=VDD}
N 20440 8360 20460 8360 {}
C {lab_pin.sym} 20460 8360 0 0 {name=l27395 lab=VSS}
C {bitcell_6t.sym} 20600 8400 0 0 {name=Xr42c103}
N 20560 8440 20540 8440 {}
C {lab_pin.sym} 20540 8440 0 0 {name=l27396 lab=BL103}
N 20560 8400 20540 8400 {}
C {lab_pin.sym} 20540 8400 0 0 {name=l27397 lab=BLB103}
N 20560 8360 20540 8360 {}
C {lab_pin.sym} 20540 8360 0 0 {name=l27398 lab=WL42}
N 20640 8440 20660 8440 {}
C {lab_pin.sym} 20660 8440 0 0 {name=l27399 lab=VDD}
N 20640 8360 20660 8360 {}
C {lab_pin.sym} 20660 8360 0 0 {name=l27400 lab=VSS}
C {bitcell_6t.sym} 20800 8400 0 0 {name=Xr42c104}
N 20760 8440 20740 8440 {}
C {lab_pin.sym} 20740 8440 0 0 {name=l27401 lab=BL104}
N 20760 8400 20740 8400 {}
C {lab_pin.sym} 20740 8400 0 0 {name=l27402 lab=BLB104}
N 20760 8360 20740 8360 {}
C {lab_pin.sym} 20740 8360 0 0 {name=l27403 lab=WL42}
N 20840 8440 20860 8440 {}
C {lab_pin.sym} 20860 8440 0 0 {name=l27404 lab=VDD}
N 20840 8360 20860 8360 {}
C {lab_pin.sym} 20860 8360 0 0 {name=l27405 lab=VSS}
C {bitcell_6t.sym} 21000 8400 0 0 {name=Xr42c105}
N 20960 8440 20940 8440 {}
C {lab_pin.sym} 20940 8440 0 0 {name=l27406 lab=BL105}
N 20960 8400 20940 8400 {}
C {lab_pin.sym} 20940 8400 0 0 {name=l27407 lab=BLB105}
N 20960 8360 20940 8360 {}
C {lab_pin.sym} 20940 8360 0 0 {name=l27408 lab=WL42}
N 21040 8440 21060 8440 {}
C {lab_pin.sym} 21060 8440 0 0 {name=l27409 lab=VDD}
N 21040 8360 21060 8360 {}
C {lab_pin.sym} 21060 8360 0 0 {name=l27410 lab=VSS}
C {bitcell_6t.sym} 21200 8400 0 0 {name=Xr42c106}
N 21160 8440 21140 8440 {}
C {lab_pin.sym} 21140 8440 0 0 {name=l27411 lab=BL106}
N 21160 8400 21140 8400 {}
C {lab_pin.sym} 21140 8400 0 0 {name=l27412 lab=BLB106}
N 21160 8360 21140 8360 {}
C {lab_pin.sym} 21140 8360 0 0 {name=l27413 lab=WL42}
N 21240 8440 21260 8440 {}
C {lab_pin.sym} 21260 8440 0 0 {name=l27414 lab=VDD}
N 21240 8360 21260 8360 {}
C {lab_pin.sym} 21260 8360 0 0 {name=l27415 lab=VSS}
C {bitcell_6t.sym} 21400 8400 0 0 {name=Xr42c107}
N 21360 8440 21340 8440 {}
C {lab_pin.sym} 21340 8440 0 0 {name=l27416 lab=BL107}
N 21360 8400 21340 8400 {}
C {lab_pin.sym} 21340 8400 0 0 {name=l27417 lab=BLB107}
N 21360 8360 21340 8360 {}
C {lab_pin.sym} 21340 8360 0 0 {name=l27418 lab=WL42}
N 21440 8440 21460 8440 {}
C {lab_pin.sym} 21460 8440 0 0 {name=l27419 lab=VDD}
N 21440 8360 21460 8360 {}
C {lab_pin.sym} 21460 8360 0 0 {name=l27420 lab=VSS}
C {bitcell_6t.sym} 21600 8400 0 0 {name=Xr42c108}
N 21560 8440 21540 8440 {}
C {lab_pin.sym} 21540 8440 0 0 {name=l27421 lab=BL108}
N 21560 8400 21540 8400 {}
C {lab_pin.sym} 21540 8400 0 0 {name=l27422 lab=BLB108}
N 21560 8360 21540 8360 {}
C {lab_pin.sym} 21540 8360 0 0 {name=l27423 lab=WL42}
N 21640 8440 21660 8440 {}
C {lab_pin.sym} 21660 8440 0 0 {name=l27424 lab=VDD}
N 21640 8360 21660 8360 {}
C {lab_pin.sym} 21660 8360 0 0 {name=l27425 lab=VSS}
C {bitcell_6t.sym} 21800 8400 0 0 {name=Xr42c109}
N 21760 8440 21740 8440 {}
C {lab_pin.sym} 21740 8440 0 0 {name=l27426 lab=BL109}
N 21760 8400 21740 8400 {}
C {lab_pin.sym} 21740 8400 0 0 {name=l27427 lab=BLB109}
N 21760 8360 21740 8360 {}
C {lab_pin.sym} 21740 8360 0 0 {name=l27428 lab=WL42}
N 21840 8440 21860 8440 {}
C {lab_pin.sym} 21860 8440 0 0 {name=l27429 lab=VDD}
N 21840 8360 21860 8360 {}
C {lab_pin.sym} 21860 8360 0 0 {name=l27430 lab=VSS}
C {bitcell_6t.sym} 22000 8400 0 0 {name=Xr42c110}
N 21960 8440 21940 8440 {}
C {lab_pin.sym} 21940 8440 0 0 {name=l27431 lab=BL110}
N 21960 8400 21940 8400 {}
C {lab_pin.sym} 21940 8400 0 0 {name=l27432 lab=BLB110}
N 21960 8360 21940 8360 {}
C {lab_pin.sym} 21940 8360 0 0 {name=l27433 lab=WL42}
N 22040 8440 22060 8440 {}
C {lab_pin.sym} 22060 8440 0 0 {name=l27434 lab=VDD}
N 22040 8360 22060 8360 {}
C {lab_pin.sym} 22060 8360 0 0 {name=l27435 lab=VSS}
C {bitcell_6t.sym} 22200 8400 0 0 {name=Xr42c111}
N 22160 8440 22140 8440 {}
C {lab_pin.sym} 22140 8440 0 0 {name=l27436 lab=BL111}
N 22160 8400 22140 8400 {}
C {lab_pin.sym} 22140 8400 0 0 {name=l27437 lab=BLB111}
N 22160 8360 22140 8360 {}
C {lab_pin.sym} 22140 8360 0 0 {name=l27438 lab=WL42}
N 22240 8440 22260 8440 {}
C {lab_pin.sym} 22260 8440 0 0 {name=l27439 lab=VDD}
N 22240 8360 22260 8360 {}
C {lab_pin.sym} 22260 8360 0 0 {name=l27440 lab=VSS}
C {bitcell_6t.sym} 22400 8400 0 0 {name=Xr42c112}
N 22360 8440 22340 8440 {}
C {lab_pin.sym} 22340 8440 0 0 {name=l27441 lab=BL112}
N 22360 8400 22340 8400 {}
C {lab_pin.sym} 22340 8400 0 0 {name=l27442 lab=BLB112}
N 22360 8360 22340 8360 {}
C {lab_pin.sym} 22340 8360 0 0 {name=l27443 lab=WL42}
N 22440 8440 22460 8440 {}
C {lab_pin.sym} 22460 8440 0 0 {name=l27444 lab=VDD}
N 22440 8360 22460 8360 {}
C {lab_pin.sym} 22460 8360 0 0 {name=l27445 lab=VSS}
C {bitcell_6t.sym} 22600 8400 0 0 {name=Xr42c113}
N 22560 8440 22540 8440 {}
C {lab_pin.sym} 22540 8440 0 0 {name=l27446 lab=BL113}
N 22560 8400 22540 8400 {}
C {lab_pin.sym} 22540 8400 0 0 {name=l27447 lab=BLB113}
N 22560 8360 22540 8360 {}
C {lab_pin.sym} 22540 8360 0 0 {name=l27448 lab=WL42}
N 22640 8440 22660 8440 {}
C {lab_pin.sym} 22660 8440 0 0 {name=l27449 lab=VDD}
N 22640 8360 22660 8360 {}
C {lab_pin.sym} 22660 8360 0 0 {name=l27450 lab=VSS}
C {bitcell_6t.sym} 22800 8400 0 0 {name=Xr42c114}
N 22760 8440 22740 8440 {}
C {lab_pin.sym} 22740 8440 0 0 {name=l27451 lab=BL114}
N 22760 8400 22740 8400 {}
C {lab_pin.sym} 22740 8400 0 0 {name=l27452 lab=BLB114}
N 22760 8360 22740 8360 {}
C {lab_pin.sym} 22740 8360 0 0 {name=l27453 lab=WL42}
N 22840 8440 22860 8440 {}
C {lab_pin.sym} 22860 8440 0 0 {name=l27454 lab=VDD}
N 22840 8360 22860 8360 {}
C {lab_pin.sym} 22860 8360 0 0 {name=l27455 lab=VSS}
C {bitcell_6t.sym} 23000 8400 0 0 {name=Xr42c115}
N 22960 8440 22940 8440 {}
C {lab_pin.sym} 22940 8440 0 0 {name=l27456 lab=BL115}
N 22960 8400 22940 8400 {}
C {lab_pin.sym} 22940 8400 0 0 {name=l27457 lab=BLB115}
N 22960 8360 22940 8360 {}
C {lab_pin.sym} 22940 8360 0 0 {name=l27458 lab=WL42}
N 23040 8440 23060 8440 {}
C {lab_pin.sym} 23060 8440 0 0 {name=l27459 lab=VDD}
N 23040 8360 23060 8360 {}
C {lab_pin.sym} 23060 8360 0 0 {name=l27460 lab=VSS}
C {bitcell_6t.sym} 23200 8400 0 0 {name=Xr42c116}
N 23160 8440 23140 8440 {}
C {lab_pin.sym} 23140 8440 0 0 {name=l27461 lab=BL116}
N 23160 8400 23140 8400 {}
C {lab_pin.sym} 23140 8400 0 0 {name=l27462 lab=BLB116}
N 23160 8360 23140 8360 {}
C {lab_pin.sym} 23140 8360 0 0 {name=l27463 lab=WL42}
N 23240 8440 23260 8440 {}
C {lab_pin.sym} 23260 8440 0 0 {name=l27464 lab=VDD}
N 23240 8360 23260 8360 {}
C {lab_pin.sym} 23260 8360 0 0 {name=l27465 lab=VSS}
C {bitcell_6t.sym} 23400 8400 0 0 {name=Xr42c117}
N 23360 8440 23340 8440 {}
C {lab_pin.sym} 23340 8440 0 0 {name=l27466 lab=BL117}
N 23360 8400 23340 8400 {}
C {lab_pin.sym} 23340 8400 0 0 {name=l27467 lab=BLB117}
N 23360 8360 23340 8360 {}
C {lab_pin.sym} 23340 8360 0 0 {name=l27468 lab=WL42}
N 23440 8440 23460 8440 {}
C {lab_pin.sym} 23460 8440 0 0 {name=l27469 lab=VDD}
N 23440 8360 23460 8360 {}
C {lab_pin.sym} 23460 8360 0 0 {name=l27470 lab=VSS}
C {bitcell_6t.sym} 23600 8400 0 0 {name=Xr42c118}
N 23560 8440 23540 8440 {}
C {lab_pin.sym} 23540 8440 0 0 {name=l27471 lab=BL118}
N 23560 8400 23540 8400 {}
C {lab_pin.sym} 23540 8400 0 0 {name=l27472 lab=BLB118}
N 23560 8360 23540 8360 {}
C {lab_pin.sym} 23540 8360 0 0 {name=l27473 lab=WL42}
N 23640 8440 23660 8440 {}
C {lab_pin.sym} 23660 8440 0 0 {name=l27474 lab=VDD}
N 23640 8360 23660 8360 {}
C {lab_pin.sym} 23660 8360 0 0 {name=l27475 lab=VSS}
C {bitcell_6t.sym} 23800 8400 0 0 {name=Xr42c119}
N 23760 8440 23740 8440 {}
C {lab_pin.sym} 23740 8440 0 0 {name=l27476 lab=BL119}
N 23760 8400 23740 8400 {}
C {lab_pin.sym} 23740 8400 0 0 {name=l27477 lab=BLB119}
N 23760 8360 23740 8360 {}
C {lab_pin.sym} 23740 8360 0 0 {name=l27478 lab=WL42}
N 23840 8440 23860 8440 {}
C {lab_pin.sym} 23860 8440 0 0 {name=l27479 lab=VDD}
N 23840 8360 23860 8360 {}
C {lab_pin.sym} 23860 8360 0 0 {name=l27480 lab=VSS}
C {bitcell_6t.sym} 24000 8400 0 0 {name=Xr42c120}
N 23960 8440 23940 8440 {}
C {lab_pin.sym} 23940 8440 0 0 {name=l27481 lab=BL120}
N 23960 8400 23940 8400 {}
C {lab_pin.sym} 23940 8400 0 0 {name=l27482 lab=BLB120}
N 23960 8360 23940 8360 {}
C {lab_pin.sym} 23940 8360 0 0 {name=l27483 lab=WL42}
N 24040 8440 24060 8440 {}
C {lab_pin.sym} 24060 8440 0 0 {name=l27484 lab=VDD}
N 24040 8360 24060 8360 {}
C {lab_pin.sym} 24060 8360 0 0 {name=l27485 lab=VSS}
C {bitcell_6t.sym} 24200 8400 0 0 {name=Xr42c121}
N 24160 8440 24140 8440 {}
C {lab_pin.sym} 24140 8440 0 0 {name=l27486 lab=BL121}
N 24160 8400 24140 8400 {}
C {lab_pin.sym} 24140 8400 0 0 {name=l27487 lab=BLB121}
N 24160 8360 24140 8360 {}
C {lab_pin.sym} 24140 8360 0 0 {name=l27488 lab=WL42}
N 24240 8440 24260 8440 {}
C {lab_pin.sym} 24260 8440 0 0 {name=l27489 lab=VDD}
N 24240 8360 24260 8360 {}
C {lab_pin.sym} 24260 8360 0 0 {name=l27490 lab=VSS}
C {bitcell_6t.sym} 24400 8400 0 0 {name=Xr42c122}
N 24360 8440 24340 8440 {}
C {lab_pin.sym} 24340 8440 0 0 {name=l27491 lab=BL122}
N 24360 8400 24340 8400 {}
C {lab_pin.sym} 24340 8400 0 0 {name=l27492 lab=BLB122}
N 24360 8360 24340 8360 {}
C {lab_pin.sym} 24340 8360 0 0 {name=l27493 lab=WL42}
N 24440 8440 24460 8440 {}
C {lab_pin.sym} 24460 8440 0 0 {name=l27494 lab=VDD}
N 24440 8360 24460 8360 {}
C {lab_pin.sym} 24460 8360 0 0 {name=l27495 lab=VSS}
C {bitcell_6t.sym} 24600 8400 0 0 {name=Xr42c123}
N 24560 8440 24540 8440 {}
C {lab_pin.sym} 24540 8440 0 0 {name=l27496 lab=BL123}
N 24560 8400 24540 8400 {}
C {lab_pin.sym} 24540 8400 0 0 {name=l27497 lab=BLB123}
N 24560 8360 24540 8360 {}
C {lab_pin.sym} 24540 8360 0 0 {name=l27498 lab=WL42}
N 24640 8440 24660 8440 {}
C {lab_pin.sym} 24660 8440 0 0 {name=l27499 lab=VDD}
N 24640 8360 24660 8360 {}
C {lab_pin.sym} 24660 8360 0 0 {name=l27500 lab=VSS}
C {bitcell_6t.sym} 24800 8400 0 0 {name=Xr42c124}
N 24760 8440 24740 8440 {}
C {lab_pin.sym} 24740 8440 0 0 {name=l27501 lab=BL124}
N 24760 8400 24740 8400 {}
C {lab_pin.sym} 24740 8400 0 0 {name=l27502 lab=BLB124}
N 24760 8360 24740 8360 {}
C {lab_pin.sym} 24740 8360 0 0 {name=l27503 lab=WL42}
N 24840 8440 24860 8440 {}
C {lab_pin.sym} 24860 8440 0 0 {name=l27504 lab=VDD}
N 24840 8360 24860 8360 {}
C {lab_pin.sym} 24860 8360 0 0 {name=l27505 lab=VSS}
C {bitcell_6t.sym} 25000 8400 0 0 {name=Xr42c125}
N 24960 8440 24940 8440 {}
C {lab_pin.sym} 24940 8440 0 0 {name=l27506 lab=BL125}
N 24960 8400 24940 8400 {}
C {lab_pin.sym} 24940 8400 0 0 {name=l27507 lab=BLB125}
N 24960 8360 24940 8360 {}
C {lab_pin.sym} 24940 8360 0 0 {name=l27508 lab=WL42}
N 25040 8440 25060 8440 {}
C {lab_pin.sym} 25060 8440 0 0 {name=l27509 lab=VDD}
N 25040 8360 25060 8360 {}
C {lab_pin.sym} 25060 8360 0 0 {name=l27510 lab=VSS}
C {bitcell_6t.sym} 25200 8400 0 0 {name=Xr42c126}
N 25160 8440 25140 8440 {}
C {lab_pin.sym} 25140 8440 0 0 {name=l27511 lab=BL126}
N 25160 8400 25140 8400 {}
C {lab_pin.sym} 25140 8400 0 0 {name=l27512 lab=BLB126}
N 25160 8360 25140 8360 {}
C {lab_pin.sym} 25140 8360 0 0 {name=l27513 lab=WL42}
N 25240 8440 25260 8440 {}
C {lab_pin.sym} 25260 8440 0 0 {name=l27514 lab=VDD}
N 25240 8360 25260 8360 {}
C {lab_pin.sym} 25260 8360 0 0 {name=l27515 lab=VSS}
C {bitcell_6t.sym} 25400 8400 0 0 {name=Xr42c127}
N 25360 8440 25340 8440 {}
C {lab_pin.sym} 25340 8440 0 0 {name=l27516 lab=BL127}
N 25360 8400 25340 8400 {}
C {lab_pin.sym} 25340 8400 0 0 {name=l27517 lab=BLB127}
N 25360 8360 25340 8360 {}
C {lab_pin.sym} 25340 8360 0 0 {name=l27518 lab=WL42}
N 25440 8440 25460 8440 {}
C {lab_pin.sym} 25460 8440 0 0 {name=l27519 lab=VDD}
N 25440 8360 25460 8360 {}
C {lab_pin.sym} 25460 8360 0 0 {name=l27520 lab=VSS}
C {bitcell_6t.sym} 0 8600 0 0 {name=Xr43c0}
N -40 8640 -60 8640 {}
C {lab_pin.sym} -60 8640 0 0 {name=l27521 lab=BL0}
N -40 8600 -60 8600 {}
C {lab_pin.sym} -60 8600 0 0 {name=l27522 lab=BLB0}
N -40 8560 -60 8560 {}
C {lab_pin.sym} -60 8560 0 0 {name=l27523 lab=WL43}
N 40 8640 60 8640 {}
C {lab_pin.sym} 60 8640 0 0 {name=l27524 lab=VDD}
N 40 8560 60 8560 {}
C {lab_pin.sym} 60 8560 0 0 {name=l27525 lab=VSS}
C {bitcell_6t.sym} 200 8600 0 0 {name=Xr43c1}
N 160 8640 140 8640 {}
C {lab_pin.sym} 140 8640 0 0 {name=l27526 lab=BL1}
N 160 8600 140 8600 {}
C {lab_pin.sym} 140 8600 0 0 {name=l27527 lab=BLB1}
N 160 8560 140 8560 {}
C {lab_pin.sym} 140 8560 0 0 {name=l27528 lab=WL43}
N 240 8640 260 8640 {}
C {lab_pin.sym} 260 8640 0 0 {name=l27529 lab=VDD}
N 240 8560 260 8560 {}
C {lab_pin.sym} 260 8560 0 0 {name=l27530 lab=VSS}
C {bitcell_6t.sym} 400 8600 0 0 {name=Xr43c2}
N 360 8640 340 8640 {}
C {lab_pin.sym} 340 8640 0 0 {name=l27531 lab=BL2}
N 360 8600 340 8600 {}
C {lab_pin.sym} 340 8600 0 0 {name=l27532 lab=BLB2}
N 360 8560 340 8560 {}
C {lab_pin.sym} 340 8560 0 0 {name=l27533 lab=WL43}
N 440 8640 460 8640 {}
C {lab_pin.sym} 460 8640 0 0 {name=l27534 lab=VDD}
N 440 8560 460 8560 {}
C {lab_pin.sym} 460 8560 0 0 {name=l27535 lab=VSS}
C {bitcell_6t.sym} 600 8600 0 0 {name=Xr43c3}
N 560 8640 540 8640 {}
C {lab_pin.sym} 540 8640 0 0 {name=l27536 lab=BL3}
N 560 8600 540 8600 {}
C {lab_pin.sym} 540 8600 0 0 {name=l27537 lab=BLB3}
N 560 8560 540 8560 {}
C {lab_pin.sym} 540 8560 0 0 {name=l27538 lab=WL43}
N 640 8640 660 8640 {}
C {lab_pin.sym} 660 8640 0 0 {name=l27539 lab=VDD}
N 640 8560 660 8560 {}
C {lab_pin.sym} 660 8560 0 0 {name=l27540 lab=VSS}
C {bitcell_6t.sym} 800 8600 0 0 {name=Xr43c4}
N 760 8640 740 8640 {}
C {lab_pin.sym} 740 8640 0 0 {name=l27541 lab=BL4}
N 760 8600 740 8600 {}
C {lab_pin.sym} 740 8600 0 0 {name=l27542 lab=BLB4}
N 760 8560 740 8560 {}
C {lab_pin.sym} 740 8560 0 0 {name=l27543 lab=WL43}
N 840 8640 860 8640 {}
C {lab_pin.sym} 860 8640 0 0 {name=l27544 lab=VDD}
N 840 8560 860 8560 {}
C {lab_pin.sym} 860 8560 0 0 {name=l27545 lab=VSS}
C {bitcell_6t.sym} 1000 8600 0 0 {name=Xr43c5}
N 960 8640 940 8640 {}
C {lab_pin.sym} 940 8640 0 0 {name=l27546 lab=BL5}
N 960 8600 940 8600 {}
C {lab_pin.sym} 940 8600 0 0 {name=l27547 lab=BLB5}
N 960 8560 940 8560 {}
C {lab_pin.sym} 940 8560 0 0 {name=l27548 lab=WL43}
N 1040 8640 1060 8640 {}
C {lab_pin.sym} 1060 8640 0 0 {name=l27549 lab=VDD}
N 1040 8560 1060 8560 {}
C {lab_pin.sym} 1060 8560 0 0 {name=l27550 lab=VSS}
C {bitcell_6t.sym} 1200 8600 0 0 {name=Xr43c6}
N 1160 8640 1140 8640 {}
C {lab_pin.sym} 1140 8640 0 0 {name=l27551 lab=BL6}
N 1160 8600 1140 8600 {}
C {lab_pin.sym} 1140 8600 0 0 {name=l27552 lab=BLB6}
N 1160 8560 1140 8560 {}
C {lab_pin.sym} 1140 8560 0 0 {name=l27553 lab=WL43}
N 1240 8640 1260 8640 {}
C {lab_pin.sym} 1260 8640 0 0 {name=l27554 lab=VDD}
N 1240 8560 1260 8560 {}
C {lab_pin.sym} 1260 8560 0 0 {name=l27555 lab=VSS}
C {bitcell_6t.sym} 1400 8600 0 0 {name=Xr43c7}
N 1360 8640 1340 8640 {}
C {lab_pin.sym} 1340 8640 0 0 {name=l27556 lab=BL7}
N 1360 8600 1340 8600 {}
C {lab_pin.sym} 1340 8600 0 0 {name=l27557 lab=BLB7}
N 1360 8560 1340 8560 {}
C {lab_pin.sym} 1340 8560 0 0 {name=l27558 lab=WL43}
N 1440 8640 1460 8640 {}
C {lab_pin.sym} 1460 8640 0 0 {name=l27559 lab=VDD}
N 1440 8560 1460 8560 {}
C {lab_pin.sym} 1460 8560 0 0 {name=l27560 lab=VSS}
C {bitcell_6t.sym} 1600 8600 0 0 {name=Xr43c8}
N 1560 8640 1540 8640 {}
C {lab_pin.sym} 1540 8640 0 0 {name=l27561 lab=BL8}
N 1560 8600 1540 8600 {}
C {lab_pin.sym} 1540 8600 0 0 {name=l27562 lab=BLB8}
N 1560 8560 1540 8560 {}
C {lab_pin.sym} 1540 8560 0 0 {name=l27563 lab=WL43}
N 1640 8640 1660 8640 {}
C {lab_pin.sym} 1660 8640 0 0 {name=l27564 lab=VDD}
N 1640 8560 1660 8560 {}
C {lab_pin.sym} 1660 8560 0 0 {name=l27565 lab=VSS}
C {bitcell_6t.sym} 1800 8600 0 0 {name=Xr43c9}
N 1760 8640 1740 8640 {}
C {lab_pin.sym} 1740 8640 0 0 {name=l27566 lab=BL9}
N 1760 8600 1740 8600 {}
C {lab_pin.sym} 1740 8600 0 0 {name=l27567 lab=BLB9}
N 1760 8560 1740 8560 {}
C {lab_pin.sym} 1740 8560 0 0 {name=l27568 lab=WL43}
N 1840 8640 1860 8640 {}
C {lab_pin.sym} 1860 8640 0 0 {name=l27569 lab=VDD}
N 1840 8560 1860 8560 {}
C {lab_pin.sym} 1860 8560 0 0 {name=l27570 lab=VSS}
C {bitcell_6t.sym} 2000 8600 0 0 {name=Xr43c10}
N 1960 8640 1940 8640 {}
C {lab_pin.sym} 1940 8640 0 0 {name=l27571 lab=BL10}
N 1960 8600 1940 8600 {}
C {lab_pin.sym} 1940 8600 0 0 {name=l27572 lab=BLB10}
N 1960 8560 1940 8560 {}
C {lab_pin.sym} 1940 8560 0 0 {name=l27573 lab=WL43}
N 2040 8640 2060 8640 {}
C {lab_pin.sym} 2060 8640 0 0 {name=l27574 lab=VDD}
N 2040 8560 2060 8560 {}
C {lab_pin.sym} 2060 8560 0 0 {name=l27575 lab=VSS}
C {bitcell_6t.sym} 2200 8600 0 0 {name=Xr43c11}
N 2160 8640 2140 8640 {}
C {lab_pin.sym} 2140 8640 0 0 {name=l27576 lab=BL11}
N 2160 8600 2140 8600 {}
C {lab_pin.sym} 2140 8600 0 0 {name=l27577 lab=BLB11}
N 2160 8560 2140 8560 {}
C {lab_pin.sym} 2140 8560 0 0 {name=l27578 lab=WL43}
N 2240 8640 2260 8640 {}
C {lab_pin.sym} 2260 8640 0 0 {name=l27579 lab=VDD}
N 2240 8560 2260 8560 {}
C {lab_pin.sym} 2260 8560 0 0 {name=l27580 lab=VSS}
C {bitcell_6t.sym} 2400 8600 0 0 {name=Xr43c12}
N 2360 8640 2340 8640 {}
C {lab_pin.sym} 2340 8640 0 0 {name=l27581 lab=BL12}
N 2360 8600 2340 8600 {}
C {lab_pin.sym} 2340 8600 0 0 {name=l27582 lab=BLB12}
N 2360 8560 2340 8560 {}
C {lab_pin.sym} 2340 8560 0 0 {name=l27583 lab=WL43}
N 2440 8640 2460 8640 {}
C {lab_pin.sym} 2460 8640 0 0 {name=l27584 lab=VDD}
N 2440 8560 2460 8560 {}
C {lab_pin.sym} 2460 8560 0 0 {name=l27585 lab=VSS}
C {bitcell_6t.sym} 2600 8600 0 0 {name=Xr43c13}
N 2560 8640 2540 8640 {}
C {lab_pin.sym} 2540 8640 0 0 {name=l27586 lab=BL13}
N 2560 8600 2540 8600 {}
C {lab_pin.sym} 2540 8600 0 0 {name=l27587 lab=BLB13}
N 2560 8560 2540 8560 {}
C {lab_pin.sym} 2540 8560 0 0 {name=l27588 lab=WL43}
N 2640 8640 2660 8640 {}
C {lab_pin.sym} 2660 8640 0 0 {name=l27589 lab=VDD}
N 2640 8560 2660 8560 {}
C {lab_pin.sym} 2660 8560 0 0 {name=l27590 lab=VSS}
C {bitcell_6t.sym} 2800 8600 0 0 {name=Xr43c14}
N 2760 8640 2740 8640 {}
C {lab_pin.sym} 2740 8640 0 0 {name=l27591 lab=BL14}
N 2760 8600 2740 8600 {}
C {lab_pin.sym} 2740 8600 0 0 {name=l27592 lab=BLB14}
N 2760 8560 2740 8560 {}
C {lab_pin.sym} 2740 8560 0 0 {name=l27593 lab=WL43}
N 2840 8640 2860 8640 {}
C {lab_pin.sym} 2860 8640 0 0 {name=l27594 lab=VDD}
N 2840 8560 2860 8560 {}
C {lab_pin.sym} 2860 8560 0 0 {name=l27595 lab=VSS}
C {bitcell_6t.sym} 3000 8600 0 0 {name=Xr43c15}
N 2960 8640 2940 8640 {}
C {lab_pin.sym} 2940 8640 0 0 {name=l27596 lab=BL15}
N 2960 8600 2940 8600 {}
C {lab_pin.sym} 2940 8600 0 0 {name=l27597 lab=BLB15}
N 2960 8560 2940 8560 {}
C {lab_pin.sym} 2940 8560 0 0 {name=l27598 lab=WL43}
N 3040 8640 3060 8640 {}
C {lab_pin.sym} 3060 8640 0 0 {name=l27599 lab=VDD}
N 3040 8560 3060 8560 {}
C {lab_pin.sym} 3060 8560 0 0 {name=l27600 lab=VSS}
C {bitcell_6t.sym} 3200 8600 0 0 {name=Xr43c16}
N 3160 8640 3140 8640 {}
C {lab_pin.sym} 3140 8640 0 0 {name=l27601 lab=BL16}
N 3160 8600 3140 8600 {}
C {lab_pin.sym} 3140 8600 0 0 {name=l27602 lab=BLB16}
N 3160 8560 3140 8560 {}
C {lab_pin.sym} 3140 8560 0 0 {name=l27603 lab=WL43}
N 3240 8640 3260 8640 {}
C {lab_pin.sym} 3260 8640 0 0 {name=l27604 lab=VDD}
N 3240 8560 3260 8560 {}
C {lab_pin.sym} 3260 8560 0 0 {name=l27605 lab=VSS}
C {bitcell_6t.sym} 3400 8600 0 0 {name=Xr43c17}
N 3360 8640 3340 8640 {}
C {lab_pin.sym} 3340 8640 0 0 {name=l27606 lab=BL17}
N 3360 8600 3340 8600 {}
C {lab_pin.sym} 3340 8600 0 0 {name=l27607 lab=BLB17}
N 3360 8560 3340 8560 {}
C {lab_pin.sym} 3340 8560 0 0 {name=l27608 lab=WL43}
N 3440 8640 3460 8640 {}
C {lab_pin.sym} 3460 8640 0 0 {name=l27609 lab=VDD}
N 3440 8560 3460 8560 {}
C {lab_pin.sym} 3460 8560 0 0 {name=l27610 lab=VSS}
C {bitcell_6t.sym} 3600 8600 0 0 {name=Xr43c18}
N 3560 8640 3540 8640 {}
C {lab_pin.sym} 3540 8640 0 0 {name=l27611 lab=BL18}
N 3560 8600 3540 8600 {}
C {lab_pin.sym} 3540 8600 0 0 {name=l27612 lab=BLB18}
N 3560 8560 3540 8560 {}
C {lab_pin.sym} 3540 8560 0 0 {name=l27613 lab=WL43}
N 3640 8640 3660 8640 {}
C {lab_pin.sym} 3660 8640 0 0 {name=l27614 lab=VDD}
N 3640 8560 3660 8560 {}
C {lab_pin.sym} 3660 8560 0 0 {name=l27615 lab=VSS}
C {bitcell_6t.sym} 3800 8600 0 0 {name=Xr43c19}
N 3760 8640 3740 8640 {}
C {lab_pin.sym} 3740 8640 0 0 {name=l27616 lab=BL19}
N 3760 8600 3740 8600 {}
C {lab_pin.sym} 3740 8600 0 0 {name=l27617 lab=BLB19}
N 3760 8560 3740 8560 {}
C {lab_pin.sym} 3740 8560 0 0 {name=l27618 lab=WL43}
N 3840 8640 3860 8640 {}
C {lab_pin.sym} 3860 8640 0 0 {name=l27619 lab=VDD}
N 3840 8560 3860 8560 {}
C {lab_pin.sym} 3860 8560 0 0 {name=l27620 lab=VSS}
C {bitcell_6t.sym} 4000 8600 0 0 {name=Xr43c20}
N 3960 8640 3940 8640 {}
C {lab_pin.sym} 3940 8640 0 0 {name=l27621 lab=BL20}
N 3960 8600 3940 8600 {}
C {lab_pin.sym} 3940 8600 0 0 {name=l27622 lab=BLB20}
N 3960 8560 3940 8560 {}
C {lab_pin.sym} 3940 8560 0 0 {name=l27623 lab=WL43}
N 4040 8640 4060 8640 {}
C {lab_pin.sym} 4060 8640 0 0 {name=l27624 lab=VDD}
N 4040 8560 4060 8560 {}
C {lab_pin.sym} 4060 8560 0 0 {name=l27625 lab=VSS}
C {bitcell_6t.sym} 4200 8600 0 0 {name=Xr43c21}
N 4160 8640 4140 8640 {}
C {lab_pin.sym} 4140 8640 0 0 {name=l27626 lab=BL21}
N 4160 8600 4140 8600 {}
C {lab_pin.sym} 4140 8600 0 0 {name=l27627 lab=BLB21}
N 4160 8560 4140 8560 {}
C {lab_pin.sym} 4140 8560 0 0 {name=l27628 lab=WL43}
N 4240 8640 4260 8640 {}
C {lab_pin.sym} 4260 8640 0 0 {name=l27629 lab=VDD}
N 4240 8560 4260 8560 {}
C {lab_pin.sym} 4260 8560 0 0 {name=l27630 lab=VSS}
C {bitcell_6t.sym} 4400 8600 0 0 {name=Xr43c22}
N 4360 8640 4340 8640 {}
C {lab_pin.sym} 4340 8640 0 0 {name=l27631 lab=BL22}
N 4360 8600 4340 8600 {}
C {lab_pin.sym} 4340 8600 0 0 {name=l27632 lab=BLB22}
N 4360 8560 4340 8560 {}
C {lab_pin.sym} 4340 8560 0 0 {name=l27633 lab=WL43}
N 4440 8640 4460 8640 {}
C {lab_pin.sym} 4460 8640 0 0 {name=l27634 lab=VDD}
N 4440 8560 4460 8560 {}
C {lab_pin.sym} 4460 8560 0 0 {name=l27635 lab=VSS}
C {bitcell_6t.sym} 4600 8600 0 0 {name=Xr43c23}
N 4560 8640 4540 8640 {}
C {lab_pin.sym} 4540 8640 0 0 {name=l27636 lab=BL23}
N 4560 8600 4540 8600 {}
C {lab_pin.sym} 4540 8600 0 0 {name=l27637 lab=BLB23}
N 4560 8560 4540 8560 {}
C {lab_pin.sym} 4540 8560 0 0 {name=l27638 lab=WL43}
N 4640 8640 4660 8640 {}
C {lab_pin.sym} 4660 8640 0 0 {name=l27639 lab=VDD}
N 4640 8560 4660 8560 {}
C {lab_pin.sym} 4660 8560 0 0 {name=l27640 lab=VSS}
C {bitcell_6t.sym} 4800 8600 0 0 {name=Xr43c24}
N 4760 8640 4740 8640 {}
C {lab_pin.sym} 4740 8640 0 0 {name=l27641 lab=BL24}
N 4760 8600 4740 8600 {}
C {lab_pin.sym} 4740 8600 0 0 {name=l27642 lab=BLB24}
N 4760 8560 4740 8560 {}
C {lab_pin.sym} 4740 8560 0 0 {name=l27643 lab=WL43}
N 4840 8640 4860 8640 {}
C {lab_pin.sym} 4860 8640 0 0 {name=l27644 lab=VDD}
N 4840 8560 4860 8560 {}
C {lab_pin.sym} 4860 8560 0 0 {name=l27645 lab=VSS}
C {bitcell_6t.sym} 5000 8600 0 0 {name=Xr43c25}
N 4960 8640 4940 8640 {}
C {lab_pin.sym} 4940 8640 0 0 {name=l27646 lab=BL25}
N 4960 8600 4940 8600 {}
C {lab_pin.sym} 4940 8600 0 0 {name=l27647 lab=BLB25}
N 4960 8560 4940 8560 {}
C {lab_pin.sym} 4940 8560 0 0 {name=l27648 lab=WL43}
N 5040 8640 5060 8640 {}
C {lab_pin.sym} 5060 8640 0 0 {name=l27649 lab=VDD}
N 5040 8560 5060 8560 {}
C {lab_pin.sym} 5060 8560 0 0 {name=l27650 lab=VSS}
C {bitcell_6t.sym} 5200 8600 0 0 {name=Xr43c26}
N 5160 8640 5140 8640 {}
C {lab_pin.sym} 5140 8640 0 0 {name=l27651 lab=BL26}
N 5160 8600 5140 8600 {}
C {lab_pin.sym} 5140 8600 0 0 {name=l27652 lab=BLB26}
N 5160 8560 5140 8560 {}
C {lab_pin.sym} 5140 8560 0 0 {name=l27653 lab=WL43}
N 5240 8640 5260 8640 {}
C {lab_pin.sym} 5260 8640 0 0 {name=l27654 lab=VDD}
N 5240 8560 5260 8560 {}
C {lab_pin.sym} 5260 8560 0 0 {name=l27655 lab=VSS}
C {bitcell_6t.sym} 5400 8600 0 0 {name=Xr43c27}
N 5360 8640 5340 8640 {}
C {lab_pin.sym} 5340 8640 0 0 {name=l27656 lab=BL27}
N 5360 8600 5340 8600 {}
C {lab_pin.sym} 5340 8600 0 0 {name=l27657 lab=BLB27}
N 5360 8560 5340 8560 {}
C {lab_pin.sym} 5340 8560 0 0 {name=l27658 lab=WL43}
N 5440 8640 5460 8640 {}
C {lab_pin.sym} 5460 8640 0 0 {name=l27659 lab=VDD}
N 5440 8560 5460 8560 {}
C {lab_pin.sym} 5460 8560 0 0 {name=l27660 lab=VSS}
C {bitcell_6t.sym} 5600 8600 0 0 {name=Xr43c28}
N 5560 8640 5540 8640 {}
C {lab_pin.sym} 5540 8640 0 0 {name=l27661 lab=BL28}
N 5560 8600 5540 8600 {}
C {lab_pin.sym} 5540 8600 0 0 {name=l27662 lab=BLB28}
N 5560 8560 5540 8560 {}
C {lab_pin.sym} 5540 8560 0 0 {name=l27663 lab=WL43}
N 5640 8640 5660 8640 {}
C {lab_pin.sym} 5660 8640 0 0 {name=l27664 lab=VDD}
N 5640 8560 5660 8560 {}
C {lab_pin.sym} 5660 8560 0 0 {name=l27665 lab=VSS}
C {bitcell_6t.sym} 5800 8600 0 0 {name=Xr43c29}
N 5760 8640 5740 8640 {}
C {lab_pin.sym} 5740 8640 0 0 {name=l27666 lab=BL29}
N 5760 8600 5740 8600 {}
C {lab_pin.sym} 5740 8600 0 0 {name=l27667 lab=BLB29}
N 5760 8560 5740 8560 {}
C {lab_pin.sym} 5740 8560 0 0 {name=l27668 lab=WL43}
N 5840 8640 5860 8640 {}
C {lab_pin.sym} 5860 8640 0 0 {name=l27669 lab=VDD}
N 5840 8560 5860 8560 {}
C {lab_pin.sym} 5860 8560 0 0 {name=l27670 lab=VSS}
C {bitcell_6t.sym} 6000 8600 0 0 {name=Xr43c30}
N 5960 8640 5940 8640 {}
C {lab_pin.sym} 5940 8640 0 0 {name=l27671 lab=BL30}
N 5960 8600 5940 8600 {}
C {lab_pin.sym} 5940 8600 0 0 {name=l27672 lab=BLB30}
N 5960 8560 5940 8560 {}
C {lab_pin.sym} 5940 8560 0 0 {name=l27673 lab=WL43}
N 6040 8640 6060 8640 {}
C {lab_pin.sym} 6060 8640 0 0 {name=l27674 lab=VDD}
N 6040 8560 6060 8560 {}
C {lab_pin.sym} 6060 8560 0 0 {name=l27675 lab=VSS}
C {bitcell_6t.sym} 6200 8600 0 0 {name=Xr43c31}
N 6160 8640 6140 8640 {}
C {lab_pin.sym} 6140 8640 0 0 {name=l27676 lab=BL31}
N 6160 8600 6140 8600 {}
C {lab_pin.sym} 6140 8600 0 0 {name=l27677 lab=BLB31}
N 6160 8560 6140 8560 {}
C {lab_pin.sym} 6140 8560 0 0 {name=l27678 lab=WL43}
N 6240 8640 6260 8640 {}
C {lab_pin.sym} 6260 8640 0 0 {name=l27679 lab=VDD}
N 6240 8560 6260 8560 {}
C {lab_pin.sym} 6260 8560 0 0 {name=l27680 lab=VSS}
C {bitcell_6t.sym} 6400 8600 0 0 {name=Xr43c32}
N 6360 8640 6340 8640 {}
C {lab_pin.sym} 6340 8640 0 0 {name=l27681 lab=BL32}
N 6360 8600 6340 8600 {}
C {lab_pin.sym} 6340 8600 0 0 {name=l27682 lab=BLB32}
N 6360 8560 6340 8560 {}
C {lab_pin.sym} 6340 8560 0 0 {name=l27683 lab=WL43}
N 6440 8640 6460 8640 {}
C {lab_pin.sym} 6460 8640 0 0 {name=l27684 lab=VDD}
N 6440 8560 6460 8560 {}
C {lab_pin.sym} 6460 8560 0 0 {name=l27685 lab=VSS}
C {bitcell_6t.sym} 6600 8600 0 0 {name=Xr43c33}
N 6560 8640 6540 8640 {}
C {lab_pin.sym} 6540 8640 0 0 {name=l27686 lab=BL33}
N 6560 8600 6540 8600 {}
C {lab_pin.sym} 6540 8600 0 0 {name=l27687 lab=BLB33}
N 6560 8560 6540 8560 {}
C {lab_pin.sym} 6540 8560 0 0 {name=l27688 lab=WL43}
N 6640 8640 6660 8640 {}
C {lab_pin.sym} 6660 8640 0 0 {name=l27689 lab=VDD}
N 6640 8560 6660 8560 {}
C {lab_pin.sym} 6660 8560 0 0 {name=l27690 lab=VSS}
C {bitcell_6t.sym} 6800 8600 0 0 {name=Xr43c34}
N 6760 8640 6740 8640 {}
C {lab_pin.sym} 6740 8640 0 0 {name=l27691 lab=BL34}
N 6760 8600 6740 8600 {}
C {lab_pin.sym} 6740 8600 0 0 {name=l27692 lab=BLB34}
N 6760 8560 6740 8560 {}
C {lab_pin.sym} 6740 8560 0 0 {name=l27693 lab=WL43}
N 6840 8640 6860 8640 {}
C {lab_pin.sym} 6860 8640 0 0 {name=l27694 lab=VDD}
N 6840 8560 6860 8560 {}
C {lab_pin.sym} 6860 8560 0 0 {name=l27695 lab=VSS}
C {bitcell_6t.sym} 7000 8600 0 0 {name=Xr43c35}
N 6960 8640 6940 8640 {}
C {lab_pin.sym} 6940 8640 0 0 {name=l27696 lab=BL35}
N 6960 8600 6940 8600 {}
C {lab_pin.sym} 6940 8600 0 0 {name=l27697 lab=BLB35}
N 6960 8560 6940 8560 {}
C {lab_pin.sym} 6940 8560 0 0 {name=l27698 lab=WL43}
N 7040 8640 7060 8640 {}
C {lab_pin.sym} 7060 8640 0 0 {name=l27699 lab=VDD}
N 7040 8560 7060 8560 {}
C {lab_pin.sym} 7060 8560 0 0 {name=l27700 lab=VSS}
C {bitcell_6t.sym} 7200 8600 0 0 {name=Xr43c36}
N 7160 8640 7140 8640 {}
C {lab_pin.sym} 7140 8640 0 0 {name=l27701 lab=BL36}
N 7160 8600 7140 8600 {}
C {lab_pin.sym} 7140 8600 0 0 {name=l27702 lab=BLB36}
N 7160 8560 7140 8560 {}
C {lab_pin.sym} 7140 8560 0 0 {name=l27703 lab=WL43}
N 7240 8640 7260 8640 {}
C {lab_pin.sym} 7260 8640 0 0 {name=l27704 lab=VDD}
N 7240 8560 7260 8560 {}
C {lab_pin.sym} 7260 8560 0 0 {name=l27705 lab=VSS}
C {bitcell_6t.sym} 7400 8600 0 0 {name=Xr43c37}
N 7360 8640 7340 8640 {}
C {lab_pin.sym} 7340 8640 0 0 {name=l27706 lab=BL37}
N 7360 8600 7340 8600 {}
C {lab_pin.sym} 7340 8600 0 0 {name=l27707 lab=BLB37}
N 7360 8560 7340 8560 {}
C {lab_pin.sym} 7340 8560 0 0 {name=l27708 lab=WL43}
N 7440 8640 7460 8640 {}
C {lab_pin.sym} 7460 8640 0 0 {name=l27709 lab=VDD}
N 7440 8560 7460 8560 {}
C {lab_pin.sym} 7460 8560 0 0 {name=l27710 lab=VSS}
C {bitcell_6t.sym} 7600 8600 0 0 {name=Xr43c38}
N 7560 8640 7540 8640 {}
C {lab_pin.sym} 7540 8640 0 0 {name=l27711 lab=BL38}
N 7560 8600 7540 8600 {}
C {lab_pin.sym} 7540 8600 0 0 {name=l27712 lab=BLB38}
N 7560 8560 7540 8560 {}
C {lab_pin.sym} 7540 8560 0 0 {name=l27713 lab=WL43}
N 7640 8640 7660 8640 {}
C {lab_pin.sym} 7660 8640 0 0 {name=l27714 lab=VDD}
N 7640 8560 7660 8560 {}
C {lab_pin.sym} 7660 8560 0 0 {name=l27715 lab=VSS}
C {bitcell_6t.sym} 7800 8600 0 0 {name=Xr43c39}
N 7760 8640 7740 8640 {}
C {lab_pin.sym} 7740 8640 0 0 {name=l27716 lab=BL39}
N 7760 8600 7740 8600 {}
C {lab_pin.sym} 7740 8600 0 0 {name=l27717 lab=BLB39}
N 7760 8560 7740 8560 {}
C {lab_pin.sym} 7740 8560 0 0 {name=l27718 lab=WL43}
N 7840 8640 7860 8640 {}
C {lab_pin.sym} 7860 8640 0 0 {name=l27719 lab=VDD}
N 7840 8560 7860 8560 {}
C {lab_pin.sym} 7860 8560 0 0 {name=l27720 lab=VSS}
C {bitcell_6t.sym} 8000 8600 0 0 {name=Xr43c40}
N 7960 8640 7940 8640 {}
C {lab_pin.sym} 7940 8640 0 0 {name=l27721 lab=BL40}
N 7960 8600 7940 8600 {}
C {lab_pin.sym} 7940 8600 0 0 {name=l27722 lab=BLB40}
N 7960 8560 7940 8560 {}
C {lab_pin.sym} 7940 8560 0 0 {name=l27723 lab=WL43}
N 8040 8640 8060 8640 {}
C {lab_pin.sym} 8060 8640 0 0 {name=l27724 lab=VDD}
N 8040 8560 8060 8560 {}
C {lab_pin.sym} 8060 8560 0 0 {name=l27725 lab=VSS}
C {bitcell_6t.sym} 8200 8600 0 0 {name=Xr43c41}
N 8160 8640 8140 8640 {}
C {lab_pin.sym} 8140 8640 0 0 {name=l27726 lab=BL41}
N 8160 8600 8140 8600 {}
C {lab_pin.sym} 8140 8600 0 0 {name=l27727 lab=BLB41}
N 8160 8560 8140 8560 {}
C {lab_pin.sym} 8140 8560 0 0 {name=l27728 lab=WL43}
N 8240 8640 8260 8640 {}
C {lab_pin.sym} 8260 8640 0 0 {name=l27729 lab=VDD}
N 8240 8560 8260 8560 {}
C {lab_pin.sym} 8260 8560 0 0 {name=l27730 lab=VSS}
C {bitcell_6t.sym} 8400 8600 0 0 {name=Xr43c42}
N 8360 8640 8340 8640 {}
C {lab_pin.sym} 8340 8640 0 0 {name=l27731 lab=BL42}
N 8360 8600 8340 8600 {}
C {lab_pin.sym} 8340 8600 0 0 {name=l27732 lab=BLB42}
N 8360 8560 8340 8560 {}
C {lab_pin.sym} 8340 8560 0 0 {name=l27733 lab=WL43}
N 8440 8640 8460 8640 {}
C {lab_pin.sym} 8460 8640 0 0 {name=l27734 lab=VDD}
N 8440 8560 8460 8560 {}
C {lab_pin.sym} 8460 8560 0 0 {name=l27735 lab=VSS}
C {bitcell_6t.sym} 8600 8600 0 0 {name=Xr43c43}
N 8560 8640 8540 8640 {}
C {lab_pin.sym} 8540 8640 0 0 {name=l27736 lab=BL43}
N 8560 8600 8540 8600 {}
C {lab_pin.sym} 8540 8600 0 0 {name=l27737 lab=BLB43}
N 8560 8560 8540 8560 {}
C {lab_pin.sym} 8540 8560 0 0 {name=l27738 lab=WL43}
N 8640 8640 8660 8640 {}
C {lab_pin.sym} 8660 8640 0 0 {name=l27739 lab=VDD}
N 8640 8560 8660 8560 {}
C {lab_pin.sym} 8660 8560 0 0 {name=l27740 lab=VSS}
C {bitcell_6t.sym} 8800 8600 0 0 {name=Xr43c44}
N 8760 8640 8740 8640 {}
C {lab_pin.sym} 8740 8640 0 0 {name=l27741 lab=BL44}
N 8760 8600 8740 8600 {}
C {lab_pin.sym} 8740 8600 0 0 {name=l27742 lab=BLB44}
N 8760 8560 8740 8560 {}
C {lab_pin.sym} 8740 8560 0 0 {name=l27743 lab=WL43}
N 8840 8640 8860 8640 {}
C {lab_pin.sym} 8860 8640 0 0 {name=l27744 lab=VDD}
N 8840 8560 8860 8560 {}
C {lab_pin.sym} 8860 8560 0 0 {name=l27745 lab=VSS}
C {bitcell_6t.sym} 9000 8600 0 0 {name=Xr43c45}
N 8960 8640 8940 8640 {}
C {lab_pin.sym} 8940 8640 0 0 {name=l27746 lab=BL45}
N 8960 8600 8940 8600 {}
C {lab_pin.sym} 8940 8600 0 0 {name=l27747 lab=BLB45}
N 8960 8560 8940 8560 {}
C {lab_pin.sym} 8940 8560 0 0 {name=l27748 lab=WL43}
N 9040 8640 9060 8640 {}
C {lab_pin.sym} 9060 8640 0 0 {name=l27749 lab=VDD}
N 9040 8560 9060 8560 {}
C {lab_pin.sym} 9060 8560 0 0 {name=l27750 lab=VSS}
C {bitcell_6t.sym} 9200 8600 0 0 {name=Xr43c46}
N 9160 8640 9140 8640 {}
C {lab_pin.sym} 9140 8640 0 0 {name=l27751 lab=BL46}
N 9160 8600 9140 8600 {}
C {lab_pin.sym} 9140 8600 0 0 {name=l27752 lab=BLB46}
N 9160 8560 9140 8560 {}
C {lab_pin.sym} 9140 8560 0 0 {name=l27753 lab=WL43}
N 9240 8640 9260 8640 {}
C {lab_pin.sym} 9260 8640 0 0 {name=l27754 lab=VDD}
N 9240 8560 9260 8560 {}
C {lab_pin.sym} 9260 8560 0 0 {name=l27755 lab=VSS}
C {bitcell_6t.sym} 9400 8600 0 0 {name=Xr43c47}
N 9360 8640 9340 8640 {}
C {lab_pin.sym} 9340 8640 0 0 {name=l27756 lab=BL47}
N 9360 8600 9340 8600 {}
C {lab_pin.sym} 9340 8600 0 0 {name=l27757 lab=BLB47}
N 9360 8560 9340 8560 {}
C {lab_pin.sym} 9340 8560 0 0 {name=l27758 lab=WL43}
N 9440 8640 9460 8640 {}
C {lab_pin.sym} 9460 8640 0 0 {name=l27759 lab=VDD}
N 9440 8560 9460 8560 {}
C {lab_pin.sym} 9460 8560 0 0 {name=l27760 lab=VSS}
C {bitcell_6t.sym} 9600 8600 0 0 {name=Xr43c48}
N 9560 8640 9540 8640 {}
C {lab_pin.sym} 9540 8640 0 0 {name=l27761 lab=BL48}
N 9560 8600 9540 8600 {}
C {lab_pin.sym} 9540 8600 0 0 {name=l27762 lab=BLB48}
N 9560 8560 9540 8560 {}
C {lab_pin.sym} 9540 8560 0 0 {name=l27763 lab=WL43}
N 9640 8640 9660 8640 {}
C {lab_pin.sym} 9660 8640 0 0 {name=l27764 lab=VDD}
N 9640 8560 9660 8560 {}
C {lab_pin.sym} 9660 8560 0 0 {name=l27765 lab=VSS}
C {bitcell_6t.sym} 9800 8600 0 0 {name=Xr43c49}
N 9760 8640 9740 8640 {}
C {lab_pin.sym} 9740 8640 0 0 {name=l27766 lab=BL49}
N 9760 8600 9740 8600 {}
C {lab_pin.sym} 9740 8600 0 0 {name=l27767 lab=BLB49}
N 9760 8560 9740 8560 {}
C {lab_pin.sym} 9740 8560 0 0 {name=l27768 lab=WL43}
N 9840 8640 9860 8640 {}
C {lab_pin.sym} 9860 8640 0 0 {name=l27769 lab=VDD}
N 9840 8560 9860 8560 {}
C {lab_pin.sym} 9860 8560 0 0 {name=l27770 lab=VSS}
C {bitcell_6t.sym} 10000 8600 0 0 {name=Xr43c50}
N 9960 8640 9940 8640 {}
C {lab_pin.sym} 9940 8640 0 0 {name=l27771 lab=BL50}
N 9960 8600 9940 8600 {}
C {lab_pin.sym} 9940 8600 0 0 {name=l27772 lab=BLB50}
N 9960 8560 9940 8560 {}
C {lab_pin.sym} 9940 8560 0 0 {name=l27773 lab=WL43}
N 10040 8640 10060 8640 {}
C {lab_pin.sym} 10060 8640 0 0 {name=l27774 lab=VDD}
N 10040 8560 10060 8560 {}
C {lab_pin.sym} 10060 8560 0 0 {name=l27775 lab=VSS}
C {bitcell_6t.sym} 10200 8600 0 0 {name=Xr43c51}
N 10160 8640 10140 8640 {}
C {lab_pin.sym} 10140 8640 0 0 {name=l27776 lab=BL51}
N 10160 8600 10140 8600 {}
C {lab_pin.sym} 10140 8600 0 0 {name=l27777 lab=BLB51}
N 10160 8560 10140 8560 {}
C {lab_pin.sym} 10140 8560 0 0 {name=l27778 lab=WL43}
N 10240 8640 10260 8640 {}
C {lab_pin.sym} 10260 8640 0 0 {name=l27779 lab=VDD}
N 10240 8560 10260 8560 {}
C {lab_pin.sym} 10260 8560 0 0 {name=l27780 lab=VSS}
C {bitcell_6t.sym} 10400 8600 0 0 {name=Xr43c52}
N 10360 8640 10340 8640 {}
C {lab_pin.sym} 10340 8640 0 0 {name=l27781 lab=BL52}
N 10360 8600 10340 8600 {}
C {lab_pin.sym} 10340 8600 0 0 {name=l27782 lab=BLB52}
N 10360 8560 10340 8560 {}
C {lab_pin.sym} 10340 8560 0 0 {name=l27783 lab=WL43}
N 10440 8640 10460 8640 {}
C {lab_pin.sym} 10460 8640 0 0 {name=l27784 lab=VDD}
N 10440 8560 10460 8560 {}
C {lab_pin.sym} 10460 8560 0 0 {name=l27785 lab=VSS}
C {bitcell_6t.sym} 10600 8600 0 0 {name=Xr43c53}
N 10560 8640 10540 8640 {}
C {lab_pin.sym} 10540 8640 0 0 {name=l27786 lab=BL53}
N 10560 8600 10540 8600 {}
C {lab_pin.sym} 10540 8600 0 0 {name=l27787 lab=BLB53}
N 10560 8560 10540 8560 {}
C {lab_pin.sym} 10540 8560 0 0 {name=l27788 lab=WL43}
N 10640 8640 10660 8640 {}
C {lab_pin.sym} 10660 8640 0 0 {name=l27789 lab=VDD}
N 10640 8560 10660 8560 {}
C {lab_pin.sym} 10660 8560 0 0 {name=l27790 lab=VSS}
C {bitcell_6t.sym} 10800 8600 0 0 {name=Xr43c54}
N 10760 8640 10740 8640 {}
C {lab_pin.sym} 10740 8640 0 0 {name=l27791 lab=BL54}
N 10760 8600 10740 8600 {}
C {lab_pin.sym} 10740 8600 0 0 {name=l27792 lab=BLB54}
N 10760 8560 10740 8560 {}
C {lab_pin.sym} 10740 8560 0 0 {name=l27793 lab=WL43}
N 10840 8640 10860 8640 {}
C {lab_pin.sym} 10860 8640 0 0 {name=l27794 lab=VDD}
N 10840 8560 10860 8560 {}
C {lab_pin.sym} 10860 8560 0 0 {name=l27795 lab=VSS}
C {bitcell_6t.sym} 11000 8600 0 0 {name=Xr43c55}
N 10960 8640 10940 8640 {}
C {lab_pin.sym} 10940 8640 0 0 {name=l27796 lab=BL55}
N 10960 8600 10940 8600 {}
C {lab_pin.sym} 10940 8600 0 0 {name=l27797 lab=BLB55}
N 10960 8560 10940 8560 {}
C {lab_pin.sym} 10940 8560 0 0 {name=l27798 lab=WL43}
N 11040 8640 11060 8640 {}
C {lab_pin.sym} 11060 8640 0 0 {name=l27799 lab=VDD}
N 11040 8560 11060 8560 {}
C {lab_pin.sym} 11060 8560 0 0 {name=l27800 lab=VSS}
C {bitcell_6t.sym} 11200 8600 0 0 {name=Xr43c56}
N 11160 8640 11140 8640 {}
C {lab_pin.sym} 11140 8640 0 0 {name=l27801 lab=BL56}
N 11160 8600 11140 8600 {}
C {lab_pin.sym} 11140 8600 0 0 {name=l27802 lab=BLB56}
N 11160 8560 11140 8560 {}
C {lab_pin.sym} 11140 8560 0 0 {name=l27803 lab=WL43}
N 11240 8640 11260 8640 {}
C {lab_pin.sym} 11260 8640 0 0 {name=l27804 lab=VDD}
N 11240 8560 11260 8560 {}
C {lab_pin.sym} 11260 8560 0 0 {name=l27805 lab=VSS}
C {bitcell_6t.sym} 11400 8600 0 0 {name=Xr43c57}
N 11360 8640 11340 8640 {}
C {lab_pin.sym} 11340 8640 0 0 {name=l27806 lab=BL57}
N 11360 8600 11340 8600 {}
C {lab_pin.sym} 11340 8600 0 0 {name=l27807 lab=BLB57}
N 11360 8560 11340 8560 {}
C {lab_pin.sym} 11340 8560 0 0 {name=l27808 lab=WL43}
N 11440 8640 11460 8640 {}
C {lab_pin.sym} 11460 8640 0 0 {name=l27809 lab=VDD}
N 11440 8560 11460 8560 {}
C {lab_pin.sym} 11460 8560 0 0 {name=l27810 lab=VSS}
C {bitcell_6t.sym} 11600 8600 0 0 {name=Xr43c58}
N 11560 8640 11540 8640 {}
C {lab_pin.sym} 11540 8640 0 0 {name=l27811 lab=BL58}
N 11560 8600 11540 8600 {}
C {lab_pin.sym} 11540 8600 0 0 {name=l27812 lab=BLB58}
N 11560 8560 11540 8560 {}
C {lab_pin.sym} 11540 8560 0 0 {name=l27813 lab=WL43}
N 11640 8640 11660 8640 {}
C {lab_pin.sym} 11660 8640 0 0 {name=l27814 lab=VDD}
N 11640 8560 11660 8560 {}
C {lab_pin.sym} 11660 8560 0 0 {name=l27815 lab=VSS}
C {bitcell_6t.sym} 11800 8600 0 0 {name=Xr43c59}
N 11760 8640 11740 8640 {}
C {lab_pin.sym} 11740 8640 0 0 {name=l27816 lab=BL59}
N 11760 8600 11740 8600 {}
C {lab_pin.sym} 11740 8600 0 0 {name=l27817 lab=BLB59}
N 11760 8560 11740 8560 {}
C {lab_pin.sym} 11740 8560 0 0 {name=l27818 lab=WL43}
N 11840 8640 11860 8640 {}
C {lab_pin.sym} 11860 8640 0 0 {name=l27819 lab=VDD}
N 11840 8560 11860 8560 {}
C {lab_pin.sym} 11860 8560 0 0 {name=l27820 lab=VSS}
C {bitcell_6t.sym} 12000 8600 0 0 {name=Xr43c60}
N 11960 8640 11940 8640 {}
C {lab_pin.sym} 11940 8640 0 0 {name=l27821 lab=BL60}
N 11960 8600 11940 8600 {}
C {lab_pin.sym} 11940 8600 0 0 {name=l27822 lab=BLB60}
N 11960 8560 11940 8560 {}
C {lab_pin.sym} 11940 8560 0 0 {name=l27823 lab=WL43}
N 12040 8640 12060 8640 {}
C {lab_pin.sym} 12060 8640 0 0 {name=l27824 lab=VDD}
N 12040 8560 12060 8560 {}
C {lab_pin.sym} 12060 8560 0 0 {name=l27825 lab=VSS}
C {bitcell_6t.sym} 12200 8600 0 0 {name=Xr43c61}
N 12160 8640 12140 8640 {}
C {lab_pin.sym} 12140 8640 0 0 {name=l27826 lab=BL61}
N 12160 8600 12140 8600 {}
C {lab_pin.sym} 12140 8600 0 0 {name=l27827 lab=BLB61}
N 12160 8560 12140 8560 {}
C {lab_pin.sym} 12140 8560 0 0 {name=l27828 lab=WL43}
N 12240 8640 12260 8640 {}
C {lab_pin.sym} 12260 8640 0 0 {name=l27829 lab=VDD}
N 12240 8560 12260 8560 {}
C {lab_pin.sym} 12260 8560 0 0 {name=l27830 lab=VSS}
C {bitcell_6t.sym} 12400 8600 0 0 {name=Xr43c62}
N 12360 8640 12340 8640 {}
C {lab_pin.sym} 12340 8640 0 0 {name=l27831 lab=BL62}
N 12360 8600 12340 8600 {}
C {lab_pin.sym} 12340 8600 0 0 {name=l27832 lab=BLB62}
N 12360 8560 12340 8560 {}
C {lab_pin.sym} 12340 8560 0 0 {name=l27833 lab=WL43}
N 12440 8640 12460 8640 {}
C {lab_pin.sym} 12460 8640 0 0 {name=l27834 lab=VDD}
N 12440 8560 12460 8560 {}
C {lab_pin.sym} 12460 8560 0 0 {name=l27835 lab=VSS}
C {bitcell_6t.sym} 12600 8600 0 0 {name=Xr43c63}
N 12560 8640 12540 8640 {}
C {lab_pin.sym} 12540 8640 0 0 {name=l27836 lab=BL63}
N 12560 8600 12540 8600 {}
C {lab_pin.sym} 12540 8600 0 0 {name=l27837 lab=BLB63}
N 12560 8560 12540 8560 {}
C {lab_pin.sym} 12540 8560 0 0 {name=l27838 lab=WL43}
N 12640 8640 12660 8640 {}
C {lab_pin.sym} 12660 8640 0 0 {name=l27839 lab=VDD}
N 12640 8560 12660 8560 {}
C {lab_pin.sym} 12660 8560 0 0 {name=l27840 lab=VSS}
C {bitcell_6t.sym} 12800 8600 0 0 {name=Xr43c64}
N 12760 8640 12740 8640 {}
C {lab_pin.sym} 12740 8640 0 0 {name=l27841 lab=BL64}
N 12760 8600 12740 8600 {}
C {lab_pin.sym} 12740 8600 0 0 {name=l27842 lab=BLB64}
N 12760 8560 12740 8560 {}
C {lab_pin.sym} 12740 8560 0 0 {name=l27843 lab=WL43}
N 12840 8640 12860 8640 {}
C {lab_pin.sym} 12860 8640 0 0 {name=l27844 lab=VDD}
N 12840 8560 12860 8560 {}
C {lab_pin.sym} 12860 8560 0 0 {name=l27845 lab=VSS}
C {bitcell_6t.sym} 13000 8600 0 0 {name=Xr43c65}
N 12960 8640 12940 8640 {}
C {lab_pin.sym} 12940 8640 0 0 {name=l27846 lab=BL65}
N 12960 8600 12940 8600 {}
C {lab_pin.sym} 12940 8600 0 0 {name=l27847 lab=BLB65}
N 12960 8560 12940 8560 {}
C {lab_pin.sym} 12940 8560 0 0 {name=l27848 lab=WL43}
N 13040 8640 13060 8640 {}
C {lab_pin.sym} 13060 8640 0 0 {name=l27849 lab=VDD}
N 13040 8560 13060 8560 {}
C {lab_pin.sym} 13060 8560 0 0 {name=l27850 lab=VSS}
C {bitcell_6t.sym} 13200 8600 0 0 {name=Xr43c66}
N 13160 8640 13140 8640 {}
C {lab_pin.sym} 13140 8640 0 0 {name=l27851 lab=BL66}
N 13160 8600 13140 8600 {}
C {lab_pin.sym} 13140 8600 0 0 {name=l27852 lab=BLB66}
N 13160 8560 13140 8560 {}
C {lab_pin.sym} 13140 8560 0 0 {name=l27853 lab=WL43}
N 13240 8640 13260 8640 {}
C {lab_pin.sym} 13260 8640 0 0 {name=l27854 lab=VDD}
N 13240 8560 13260 8560 {}
C {lab_pin.sym} 13260 8560 0 0 {name=l27855 lab=VSS}
C {bitcell_6t.sym} 13400 8600 0 0 {name=Xr43c67}
N 13360 8640 13340 8640 {}
C {lab_pin.sym} 13340 8640 0 0 {name=l27856 lab=BL67}
N 13360 8600 13340 8600 {}
C {lab_pin.sym} 13340 8600 0 0 {name=l27857 lab=BLB67}
N 13360 8560 13340 8560 {}
C {lab_pin.sym} 13340 8560 0 0 {name=l27858 lab=WL43}
N 13440 8640 13460 8640 {}
C {lab_pin.sym} 13460 8640 0 0 {name=l27859 lab=VDD}
N 13440 8560 13460 8560 {}
C {lab_pin.sym} 13460 8560 0 0 {name=l27860 lab=VSS}
C {bitcell_6t.sym} 13600 8600 0 0 {name=Xr43c68}
N 13560 8640 13540 8640 {}
C {lab_pin.sym} 13540 8640 0 0 {name=l27861 lab=BL68}
N 13560 8600 13540 8600 {}
C {lab_pin.sym} 13540 8600 0 0 {name=l27862 lab=BLB68}
N 13560 8560 13540 8560 {}
C {lab_pin.sym} 13540 8560 0 0 {name=l27863 lab=WL43}
N 13640 8640 13660 8640 {}
C {lab_pin.sym} 13660 8640 0 0 {name=l27864 lab=VDD}
N 13640 8560 13660 8560 {}
C {lab_pin.sym} 13660 8560 0 0 {name=l27865 lab=VSS}
C {bitcell_6t.sym} 13800 8600 0 0 {name=Xr43c69}
N 13760 8640 13740 8640 {}
C {lab_pin.sym} 13740 8640 0 0 {name=l27866 lab=BL69}
N 13760 8600 13740 8600 {}
C {lab_pin.sym} 13740 8600 0 0 {name=l27867 lab=BLB69}
N 13760 8560 13740 8560 {}
C {lab_pin.sym} 13740 8560 0 0 {name=l27868 lab=WL43}
N 13840 8640 13860 8640 {}
C {lab_pin.sym} 13860 8640 0 0 {name=l27869 lab=VDD}
N 13840 8560 13860 8560 {}
C {lab_pin.sym} 13860 8560 0 0 {name=l27870 lab=VSS}
C {bitcell_6t.sym} 14000 8600 0 0 {name=Xr43c70}
N 13960 8640 13940 8640 {}
C {lab_pin.sym} 13940 8640 0 0 {name=l27871 lab=BL70}
N 13960 8600 13940 8600 {}
C {lab_pin.sym} 13940 8600 0 0 {name=l27872 lab=BLB70}
N 13960 8560 13940 8560 {}
C {lab_pin.sym} 13940 8560 0 0 {name=l27873 lab=WL43}
N 14040 8640 14060 8640 {}
C {lab_pin.sym} 14060 8640 0 0 {name=l27874 lab=VDD}
N 14040 8560 14060 8560 {}
C {lab_pin.sym} 14060 8560 0 0 {name=l27875 lab=VSS}
C {bitcell_6t.sym} 14200 8600 0 0 {name=Xr43c71}
N 14160 8640 14140 8640 {}
C {lab_pin.sym} 14140 8640 0 0 {name=l27876 lab=BL71}
N 14160 8600 14140 8600 {}
C {lab_pin.sym} 14140 8600 0 0 {name=l27877 lab=BLB71}
N 14160 8560 14140 8560 {}
C {lab_pin.sym} 14140 8560 0 0 {name=l27878 lab=WL43}
N 14240 8640 14260 8640 {}
C {lab_pin.sym} 14260 8640 0 0 {name=l27879 lab=VDD}
N 14240 8560 14260 8560 {}
C {lab_pin.sym} 14260 8560 0 0 {name=l27880 lab=VSS}
C {bitcell_6t.sym} 14400 8600 0 0 {name=Xr43c72}
N 14360 8640 14340 8640 {}
C {lab_pin.sym} 14340 8640 0 0 {name=l27881 lab=BL72}
N 14360 8600 14340 8600 {}
C {lab_pin.sym} 14340 8600 0 0 {name=l27882 lab=BLB72}
N 14360 8560 14340 8560 {}
C {lab_pin.sym} 14340 8560 0 0 {name=l27883 lab=WL43}
N 14440 8640 14460 8640 {}
C {lab_pin.sym} 14460 8640 0 0 {name=l27884 lab=VDD}
N 14440 8560 14460 8560 {}
C {lab_pin.sym} 14460 8560 0 0 {name=l27885 lab=VSS}
C {bitcell_6t.sym} 14600 8600 0 0 {name=Xr43c73}
N 14560 8640 14540 8640 {}
C {lab_pin.sym} 14540 8640 0 0 {name=l27886 lab=BL73}
N 14560 8600 14540 8600 {}
C {lab_pin.sym} 14540 8600 0 0 {name=l27887 lab=BLB73}
N 14560 8560 14540 8560 {}
C {lab_pin.sym} 14540 8560 0 0 {name=l27888 lab=WL43}
N 14640 8640 14660 8640 {}
C {lab_pin.sym} 14660 8640 0 0 {name=l27889 lab=VDD}
N 14640 8560 14660 8560 {}
C {lab_pin.sym} 14660 8560 0 0 {name=l27890 lab=VSS}
C {bitcell_6t.sym} 14800 8600 0 0 {name=Xr43c74}
N 14760 8640 14740 8640 {}
C {lab_pin.sym} 14740 8640 0 0 {name=l27891 lab=BL74}
N 14760 8600 14740 8600 {}
C {lab_pin.sym} 14740 8600 0 0 {name=l27892 lab=BLB74}
N 14760 8560 14740 8560 {}
C {lab_pin.sym} 14740 8560 0 0 {name=l27893 lab=WL43}
N 14840 8640 14860 8640 {}
C {lab_pin.sym} 14860 8640 0 0 {name=l27894 lab=VDD}
N 14840 8560 14860 8560 {}
C {lab_pin.sym} 14860 8560 0 0 {name=l27895 lab=VSS}
C {bitcell_6t.sym} 15000 8600 0 0 {name=Xr43c75}
N 14960 8640 14940 8640 {}
C {lab_pin.sym} 14940 8640 0 0 {name=l27896 lab=BL75}
N 14960 8600 14940 8600 {}
C {lab_pin.sym} 14940 8600 0 0 {name=l27897 lab=BLB75}
N 14960 8560 14940 8560 {}
C {lab_pin.sym} 14940 8560 0 0 {name=l27898 lab=WL43}
N 15040 8640 15060 8640 {}
C {lab_pin.sym} 15060 8640 0 0 {name=l27899 lab=VDD}
N 15040 8560 15060 8560 {}
C {lab_pin.sym} 15060 8560 0 0 {name=l27900 lab=VSS}
C {bitcell_6t.sym} 15200 8600 0 0 {name=Xr43c76}
N 15160 8640 15140 8640 {}
C {lab_pin.sym} 15140 8640 0 0 {name=l27901 lab=BL76}
N 15160 8600 15140 8600 {}
C {lab_pin.sym} 15140 8600 0 0 {name=l27902 lab=BLB76}
N 15160 8560 15140 8560 {}
C {lab_pin.sym} 15140 8560 0 0 {name=l27903 lab=WL43}
N 15240 8640 15260 8640 {}
C {lab_pin.sym} 15260 8640 0 0 {name=l27904 lab=VDD}
N 15240 8560 15260 8560 {}
C {lab_pin.sym} 15260 8560 0 0 {name=l27905 lab=VSS}
C {bitcell_6t.sym} 15400 8600 0 0 {name=Xr43c77}
N 15360 8640 15340 8640 {}
C {lab_pin.sym} 15340 8640 0 0 {name=l27906 lab=BL77}
N 15360 8600 15340 8600 {}
C {lab_pin.sym} 15340 8600 0 0 {name=l27907 lab=BLB77}
N 15360 8560 15340 8560 {}
C {lab_pin.sym} 15340 8560 0 0 {name=l27908 lab=WL43}
N 15440 8640 15460 8640 {}
C {lab_pin.sym} 15460 8640 0 0 {name=l27909 lab=VDD}
N 15440 8560 15460 8560 {}
C {lab_pin.sym} 15460 8560 0 0 {name=l27910 lab=VSS}
C {bitcell_6t.sym} 15600 8600 0 0 {name=Xr43c78}
N 15560 8640 15540 8640 {}
C {lab_pin.sym} 15540 8640 0 0 {name=l27911 lab=BL78}
N 15560 8600 15540 8600 {}
C {lab_pin.sym} 15540 8600 0 0 {name=l27912 lab=BLB78}
N 15560 8560 15540 8560 {}
C {lab_pin.sym} 15540 8560 0 0 {name=l27913 lab=WL43}
N 15640 8640 15660 8640 {}
C {lab_pin.sym} 15660 8640 0 0 {name=l27914 lab=VDD}
N 15640 8560 15660 8560 {}
C {lab_pin.sym} 15660 8560 0 0 {name=l27915 lab=VSS}
C {bitcell_6t.sym} 15800 8600 0 0 {name=Xr43c79}
N 15760 8640 15740 8640 {}
C {lab_pin.sym} 15740 8640 0 0 {name=l27916 lab=BL79}
N 15760 8600 15740 8600 {}
C {lab_pin.sym} 15740 8600 0 0 {name=l27917 lab=BLB79}
N 15760 8560 15740 8560 {}
C {lab_pin.sym} 15740 8560 0 0 {name=l27918 lab=WL43}
N 15840 8640 15860 8640 {}
C {lab_pin.sym} 15860 8640 0 0 {name=l27919 lab=VDD}
N 15840 8560 15860 8560 {}
C {lab_pin.sym} 15860 8560 0 0 {name=l27920 lab=VSS}
C {bitcell_6t.sym} 16000 8600 0 0 {name=Xr43c80}
N 15960 8640 15940 8640 {}
C {lab_pin.sym} 15940 8640 0 0 {name=l27921 lab=BL80}
N 15960 8600 15940 8600 {}
C {lab_pin.sym} 15940 8600 0 0 {name=l27922 lab=BLB80}
N 15960 8560 15940 8560 {}
C {lab_pin.sym} 15940 8560 0 0 {name=l27923 lab=WL43}
N 16040 8640 16060 8640 {}
C {lab_pin.sym} 16060 8640 0 0 {name=l27924 lab=VDD}
N 16040 8560 16060 8560 {}
C {lab_pin.sym} 16060 8560 0 0 {name=l27925 lab=VSS}
C {bitcell_6t.sym} 16200 8600 0 0 {name=Xr43c81}
N 16160 8640 16140 8640 {}
C {lab_pin.sym} 16140 8640 0 0 {name=l27926 lab=BL81}
N 16160 8600 16140 8600 {}
C {lab_pin.sym} 16140 8600 0 0 {name=l27927 lab=BLB81}
N 16160 8560 16140 8560 {}
C {lab_pin.sym} 16140 8560 0 0 {name=l27928 lab=WL43}
N 16240 8640 16260 8640 {}
C {lab_pin.sym} 16260 8640 0 0 {name=l27929 lab=VDD}
N 16240 8560 16260 8560 {}
C {lab_pin.sym} 16260 8560 0 0 {name=l27930 lab=VSS}
C {bitcell_6t.sym} 16400 8600 0 0 {name=Xr43c82}
N 16360 8640 16340 8640 {}
C {lab_pin.sym} 16340 8640 0 0 {name=l27931 lab=BL82}
N 16360 8600 16340 8600 {}
C {lab_pin.sym} 16340 8600 0 0 {name=l27932 lab=BLB82}
N 16360 8560 16340 8560 {}
C {lab_pin.sym} 16340 8560 0 0 {name=l27933 lab=WL43}
N 16440 8640 16460 8640 {}
C {lab_pin.sym} 16460 8640 0 0 {name=l27934 lab=VDD}
N 16440 8560 16460 8560 {}
C {lab_pin.sym} 16460 8560 0 0 {name=l27935 lab=VSS}
C {bitcell_6t.sym} 16600 8600 0 0 {name=Xr43c83}
N 16560 8640 16540 8640 {}
C {lab_pin.sym} 16540 8640 0 0 {name=l27936 lab=BL83}
N 16560 8600 16540 8600 {}
C {lab_pin.sym} 16540 8600 0 0 {name=l27937 lab=BLB83}
N 16560 8560 16540 8560 {}
C {lab_pin.sym} 16540 8560 0 0 {name=l27938 lab=WL43}
N 16640 8640 16660 8640 {}
C {lab_pin.sym} 16660 8640 0 0 {name=l27939 lab=VDD}
N 16640 8560 16660 8560 {}
C {lab_pin.sym} 16660 8560 0 0 {name=l27940 lab=VSS}
C {bitcell_6t.sym} 16800 8600 0 0 {name=Xr43c84}
N 16760 8640 16740 8640 {}
C {lab_pin.sym} 16740 8640 0 0 {name=l27941 lab=BL84}
N 16760 8600 16740 8600 {}
C {lab_pin.sym} 16740 8600 0 0 {name=l27942 lab=BLB84}
N 16760 8560 16740 8560 {}
C {lab_pin.sym} 16740 8560 0 0 {name=l27943 lab=WL43}
N 16840 8640 16860 8640 {}
C {lab_pin.sym} 16860 8640 0 0 {name=l27944 lab=VDD}
N 16840 8560 16860 8560 {}
C {lab_pin.sym} 16860 8560 0 0 {name=l27945 lab=VSS}
C {bitcell_6t.sym} 17000 8600 0 0 {name=Xr43c85}
N 16960 8640 16940 8640 {}
C {lab_pin.sym} 16940 8640 0 0 {name=l27946 lab=BL85}
N 16960 8600 16940 8600 {}
C {lab_pin.sym} 16940 8600 0 0 {name=l27947 lab=BLB85}
N 16960 8560 16940 8560 {}
C {lab_pin.sym} 16940 8560 0 0 {name=l27948 lab=WL43}
N 17040 8640 17060 8640 {}
C {lab_pin.sym} 17060 8640 0 0 {name=l27949 lab=VDD}
N 17040 8560 17060 8560 {}
C {lab_pin.sym} 17060 8560 0 0 {name=l27950 lab=VSS}
C {bitcell_6t.sym} 17200 8600 0 0 {name=Xr43c86}
N 17160 8640 17140 8640 {}
C {lab_pin.sym} 17140 8640 0 0 {name=l27951 lab=BL86}
N 17160 8600 17140 8600 {}
C {lab_pin.sym} 17140 8600 0 0 {name=l27952 lab=BLB86}
N 17160 8560 17140 8560 {}
C {lab_pin.sym} 17140 8560 0 0 {name=l27953 lab=WL43}
N 17240 8640 17260 8640 {}
C {lab_pin.sym} 17260 8640 0 0 {name=l27954 lab=VDD}
N 17240 8560 17260 8560 {}
C {lab_pin.sym} 17260 8560 0 0 {name=l27955 lab=VSS}
C {bitcell_6t.sym} 17400 8600 0 0 {name=Xr43c87}
N 17360 8640 17340 8640 {}
C {lab_pin.sym} 17340 8640 0 0 {name=l27956 lab=BL87}
N 17360 8600 17340 8600 {}
C {lab_pin.sym} 17340 8600 0 0 {name=l27957 lab=BLB87}
N 17360 8560 17340 8560 {}
C {lab_pin.sym} 17340 8560 0 0 {name=l27958 lab=WL43}
N 17440 8640 17460 8640 {}
C {lab_pin.sym} 17460 8640 0 0 {name=l27959 lab=VDD}
N 17440 8560 17460 8560 {}
C {lab_pin.sym} 17460 8560 0 0 {name=l27960 lab=VSS}
C {bitcell_6t.sym} 17600 8600 0 0 {name=Xr43c88}
N 17560 8640 17540 8640 {}
C {lab_pin.sym} 17540 8640 0 0 {name=l27961 lab=BL88}
N 17560 8600 17540 8600 {}
C {lab_pin.sym} 17540 8600 0 0 {name=l27962 lab=BLB88}
N 17560 8560 17540 8560 {}
C {lab_pin.sym} 17540 8560 0 0 {name=l27963 lab=WL43}
N 17640 8640 17660 8640 {}
C {lab_pin.sym} 17660 8640 0 0 {name=l27964 lab=VDD}
N 17640 8560 17660 8560 {}
C {lab_pin.sym} 17660 8560 0 0 {name=l27965 lab=VSS}
C {bitcell_6t.sym} 17800 8600 0 0 {name=Xr43c89}
N 17760 8640 17740 8640 {}
C {lab_pin.sym} 17740 8640 0 0 {name=l27966 lab=BL89}
N 17760 8600 17740 8600 {}
C {lab_pin.sym} 17740 8600 0 0 {name=l27967 lab=BLB89}
N 17760 8560 17740 8560 {}
C {lab_pin.sym} 17740 8560 0 0 {name=l27968 lab=WL43}
N 17840 8640 17860 8640 {}
C {lab_pin.sym} 17860 8640 0 0 {name=l27969 lab=VDD}
N 17840 8560 17860 8560 {}
C {lab_pin.sym} 17860 8560 0 0 {name=l27970 lab=VSS}
C {bitcell_6t.sym} 18000 8600 0 0 {name=Xr43c90}
N 17960 8640 17940 8640 {}
C {lab_pin.sym} 17940 8640 0 0 {name=l27971 lab=BL90}
N 17960 8600 17940 8600 {}
C {lab_pin.sym} 17940 8600 0 0 {name=l27972 lab=BLB90}
N 17960 8560 17940 8560 {}
C {lab_pin.sym} 17940 8560 0 0 {name=l27973 lab=WL43}
N 18040 8640 18060 8640 {}
C {lab_pin.sym} 18060 8640 0 0 {name=l27974 lab=VDD}
N 18040 8560 18060 8560 {}
C {lab_pin.sym} 18060 8560 0 0 {name=l27975 lab=VSS}
C {bitcell_6t.sym} 18200 8600 0 0 {name=Xr43c91}
N 18160 8640 18140 8640 {}
C {lab_pin.sym} 18140 8640 0 0 {name=l27976 lab=BL91}
N 18160 8600 18140 8600 {}
C {lab_pin.sym} 18140 8600 0 0 {name=l27977 lab=BLB91}
N 18160 8560 18140 8560 {}
C {lab_pin.sym} 18140 8560 0 0 {name=l27978 lab=WL43}
N 18240 8640 18260 8640 {}
C {lab_pin.sym} 18260 8640 0 0 {name=l27979 lab=VDD}
N 18240 8560 18260 8560 {}
C {lab_pin.sym} 18260 8560 0 0 {name=l27980 lab=VSS}
C {bitcell_6t.sym} 18400 8600 0 0 {name=Xr43c92}
N 18360 8640 18340 8640 {}
C {lab_pin.sym} 18340 8640 0 0 {name=l27981 lab=BL92}
N 18360 8600 18340 8600 {}
C {lab_pin.sym} 18340 8600 0 0 {name=l27982 lab=BLB92}
N 18360 8560 18340 8560 {}
C {lab_pin.sym} 18340 8560 0 0 {name=l27983 lab=WL43}
N 18440 8640 18460 8640 {}
C {lab_pin.sym} 18460 8640 0 0 {name=l27984 lab=VDD}
N 18440 8560 18460 8560 {}
C {lab_pin.sym} 18460 8560 0 0 {name=l27985 lab=VSS}
C {bitcell_6t.sym} 18600 8600 0 0 {name=Xr43c93}
N 18560 8640 18540 8640 {}
C {lab_pin.sym} 18540 8640 0 0 {name=l27986 lab=BL93}
N 18560 8600 18540 8600 {}
C {lab_pin.sym} 18540 8600 0 0 {name=l27987 lab=BLB93}
N 18560 8560 18540 8560 {}
C {lab_pin.sym} 18540 8560 0 0 {name=l27988 lab=WL43}
N 18640 8640 18660 8640 {}
C {lab_pin.sym} 18660 8640 0 0 {name=l27989 lab=VDD}
N 18640 8560 18660 8560 {}
C {lab_pin.sym} 18660 8560 0 0 {name=l27990 lab=VSS}
C {bitcell_6t.sym} 18800 8600 0 0 {name=Xr43c94}
N 18760 8640 18740 8640 {}
C {lab_pin.sym} 18740 8640 0 0 {name=l27991 lab=BL94}
N 18760 8600 18740 8600 {}
C {lab_pin.sym} 18740 8600 0 0 {name=l27992 lab=BLB94}
N 18760 8560 18740 8560 {}
C {lab_pin.sym} 18740 8560 0 0 {name=l27993 lab=WL43}
N 18840 8640 18860 8640 {}
C {lab_pin.sym} 18860 8640 0 0 {name=l27994 lab=VDD}
N 18840 8560 18860 8560 {}
C {lab_pin.sym} 18860 8560 0 0 {name=l27995 lab=VSS}
C {bitcell_6t.sym} 19000 8600 0 0 {name=Xr43c95}
N 18960 8640 18940 8640 {}
C {lab_pin.sym} 18940 8640 0 0 {name=l27996 lab=BL95}
N 18960 8600 18940 8600 {}
C {lab_pin.sym} 18940 8600 0 0 {name=l27997 lab=BLB95}
N 18960 8560 18940 8560 {}
C {lab_pin.sym} 18940 8560 0 0 {name=l27998 lab=WL43}
N 19040 8640 19060 8640 {}
C {lab_pin.sym} 19060 8640 0 0 {name=l27999 lab=VDD}
N 19040 8560 19060 8560 {}
C {lab_pin.sym} 19060 8560 0 0 {name=l28000 lab=VSS}
C {bitcell_6t.sym} 19200 8600 0 0 {name=Xr43c96}
N 19160 8640 19140 8640 {}
C {lab_pin.sym} 19140 8640 0 0 {name=l28001 lab=BL96}
N 19160 8600 19140 8600 {}
C {lab_pin.sym} 19140 8600 0 0 {name=l28002 lab=BLB96}
N 19160 8560 19140 8560 {}
C {lab_pin.sym} 19140 8560 0 0 {name=l28003 lab=WL43}
N 19240 8640 19260 8640 {}
C {lab_pin.sym} 19260 8640 0 0 {name=l28004 lab=VDD}
N 19240 8560 19260 8560 {}
C {lab_pin.sym} 19260 8560 0 0 {name=l28005 lab=VSS}
C {bitcell_6t.sym} 19400 8600 0 0 {name=Xr43c97}
N 19360 8640 19340 8640 {}
C {lab_pin.sym} 19340 8640 0 0 {name=l28006 lab=BL97}
N 19360 8600 19340 8600 {}
C {lab_pin.sym} 19340 8600 0 0 {name=l28007 lab=BLB97}
N 19360 8560 19340 8560 {}
C {lab_pin.sym} 19340 8560 0 0 {name=l28008 lab=WL43}
N 19440 8640 19460 8640 {}
C {lab_pin.sym} 19460 8640 0 0 {name=l28009 lab=VDD}
N 19440 8560 19460 8560 {}
C {lab_pin.sym} 19460 8560 0 0 {name=l28010 lab=VSS}
C {bitcell_6t.sym} 19600 8600 0 0 {name=Xr43c98}
N 19560 8640 19540 8640 {}
C {lab_pin.sym} 19540 8640 0 0 {name=l28011 lab=BL98}
N 19560 8600 19540 8600 {}
C {lab_pin.sym} 19540 8600 0 0 {name=l28012 lab=BLB98}
N 19560 8560 19540 8560 {}
C {lab_pin.sym} 19540 8560 0 0 {name=l28013 lab=WL43}
N 19640 8640 19660 8640 {}
C {lab_pin.sym} 19660 8640 0 0 {name=l28014 lab=VDD}
N 19640 8560 19660 8560 {}
C {lab_pin.sym} 19660 8560 0 0 {name=l28015 lab=VSS}
C {bitcell_6t.sym} 19800 8600 0 0 {name=Xr43c99}
N 19760 8640 19740 8640 {}
C {lab_pin.sym} 19740 8640 0 0 {name=l28016 lab=BL99}
N 19760 8600 19740 8600 {}
C {lab_pin.sym} 19740 8600 0 0 {name=l28017 lab=BLB99}
N 19760 8560 19740 8560 {}
C {lab_pin.sym} 19740 8560 0 0 {name=l28018 lab=WL43}
N 19840 8640 19860 8640 {}
C {lab_pin.sym} 19860 8640 0 0 {name=l28019 lab=VDD}
N 19840 8560 19860 8560 {}
C {lab_pin.sym} 19860 8560 0 0 {name=l28020 lab=VSS}
C {bitcell_6t.sym} 20000 8600 0 0 {name=Xr43c100}
N 19960 8640 19940 8640 {}
C {lab_pin.sym} 19940 8640 0 0 {name=l28021 lab=BL100}
N 19960 8600 19940 8600 {}
C {lab_pin.sym} 19940 8600 0 0 {name=l28022 lab=BLB100}
N 19960 8560 19940 8560 {}
C {lab_pin.sym} 19940 8560 0 0 {name=l28023 lab=WL43}
N 20040 8640 20060 8640 {}
C {lab_pin.sym} 20060 8640 0 0 {name=l28024 lab=VDD}
N 20040 8560 20060 8560 {}
C {lab_pin.sym} 20060 8560 0 0 {name=l28025 lab=VSS}
C {bitcell_6t.sym} 20200 8600 0 0 {name=Xr43c101}
N 20160 8640 20140 8640 {}
C {lab_pin.sym} 20140 8640 0 0 {name=l28026 lab=BL101}
N 20160 8600 20140 8600 {}
C {lab_pin.sym} 20140 8600 0 0 {name=l28027 lab=BLB101}
N 20160 8560 20140 8560 {}
C {lab_pin.sym} 20140 8560 0 0 {name=l28028 lab=WL43}
N 20240 8640 20260 8640 {}
C {lab_pin.sym} 20260 8640 0 0 {name=l28029 lab=VDD}
N 20240 8560 20260 8560 {}
C {lab_pin.sym} 20260 8560 0 0 {name=l28030 lab=VSS}
C {bitcell_6t.sym} 20400 8600 0 0 {name=Xr43c102}
N 20360 8640 20340 8640 {}
C {lab_pin.sym} 20340 8640 0 0 {name=l28031 lab=BL102}
N 20360 8600 20340 8600 {}
C {lab_pin.sym} 20340 8600 0 0 {name=l28032 lab=BLB102}
N 20360 8560 20340 8560 {}
C {lab_pin.sym} 20340 8560 0 0 {name=l28033 lab=WL43}
N 20440 8640 20460 8640 {}
C {lab_pin.sym} 20460 8640 0 0 {name=l28034 lab=VDD}
N 20440 8560 20460 8560 {}
C {lab_pin.sym} 20460 8560 0 0 {name=l28035 lab=VSS}
C {bitcell_6t.sym} 20600 8600 0 0 {name=Xr43c103}
N 20560 8640 20540 8640 {}
C {lab_pin.sym} 20540 8640 0 0 {name=l28036 lab=BL103}
N 20560 8600 20540 8600 {}
C {lab_pin.sym} 20540 8600 0 0 {name=l28037 lab=BLB103}
N 20560 8560 20540 8560 {}
C {lab_pin.sym} 20540 8560 0 0 {name=l28038 lab=WL43}
N 20640 8640 20660 8640 {}
C {lab_pin.sym} 20660 8640 0 0 {name=l28039 lab=VDD}
N 20640 8560 20660 8560 {}
C {lab_pin.sym} 20660 8560 0 0 {name=l28040 lab=VSS}
C {bitcell_6t.sym} 20800 8600 0 0 {name=Xr43c104}
N 20760 8640 20740 8640 {}
C {lab_pin.sym} 20740 8640 0 0 {name=l28041 lab=BL104}
N 20760 8600 20740 8600 {}
C {lab_pin.sym} 20740 8600 0 0 {name=l28042 lab=BLB104}
N 20760 8560 20740 8560 {}
C {lab_pin.sym} 20740 8560 0 0 {name=l28043 lab=WL43}
N 20840 8640 20860 8640 {}
C {lab_pin.sym} 20860 8640 0 0 {name=l28044 lab=VDD}
N 20840 8560 20860 8560 {}
C {lab_pin.sym} 20860 8560 0 0 {name=l28045 lab=VSS}
C {bitcell_6t.sym} 21000 8600 0 0 {name=Xr43c105}
N 20960 8640 20940 8640 {}
C {lab_pin.sym} 20940 8640 0 0 {name=l28046 lab=BL105}
N 20960 8600 20940 8600 {}
C {lab_pin.sym} 20940 8600 0 0 {name=l28047 lab=BLB105}
N 20960 8560 20940 8560 {}
C {lab_pin.sym} 20940 8560 0 0 {name=l28048 lab=WL43}
N 21040 8640 21060 8640 {}
C {lab_pin.sym} 21060 8640 0 0 {name=l28049 lab=VDD}
N 21040 8560 21060 8560 {}
C {lab_pin.sym} 21060 8560 0 0 {name=l28050 lab=VSS}
C {bitcell_6t.sym} 21200 8600 0 0 {name=Xr43c106}
N 21160 8640 21140 8640 {}
C {lab_pin.sym} 21140 8640 0 0 {name=l28051 lab=BL106}
N 21160 8600 21140 8600 {}
C {lab_pin.sym} 21140 8600 0 0 {name=l28052 lab=BLB106}
N 21160 8560 21140 8560 {}
C {lab_pin.sym} 21140 8560 0 0 {name=l28053 lab=WL43}
N 21240 8640 21260 8640 {}
C {lab_pin.sym} 21260 8640 0 0 {name=l28054 lab=VDD}
N 21240 8560 21260 8560 {}
C {lab_pin.sym} 21260 8560 0 0 {name=l28055 lab=VSS}
C {bitcell_6t.sym} 21400 8600 0 0 {name=Xr43c107}
N 21360 8640 21340 8640 {}
C {lab_pin.sym} 21340 8640 0 0 {name=l28056 lab=BL107}
N 21360 8600 21340 8600 {}
C {lab_pin.sym} 21340 8600 0 0 {name=l28057 lab=BLB107}
N 21360 8560 21340 8560 {}
C {lab_pin.sym} 21340 8560 0 0 {name=l28058 lab=WL43}
N 21440 8640 21460 8640 {}
C {lab_pin.sym} 21460 8640 0 0 {name=l28059 lab=VDD}
N 21440 8560 21460 8560 {}
C {lab_pin.sym} 21460 8560 0 0 {name=l28060 lab=VSS}
C {bitcell_6t.sym} 21600 8600 0 0 {name=Xr43c108}
N 21560 8640 21540 8640 {}
C {lab_pin.sym} 21540 8640 0 0 {name=l28061 lab=BL108}
N 21560 8600 21540 8600 {}
C {lab_pin.sym} 21540 8600 0 0 {name=l28062 lab=BLB108}
N 21560 8560 21540 8560 {}
C {lab_pin.sym} 21540 8560 0 0 {name=l28063 lab=WL43}
N 21640 8640 21660 8640 {}
C {lab_pin.sym} 21660 8640 0 0 {name=l28064 lab=VDD}
N 21640 8560 21660 8560 {}
C {lab_pin.sym} 21660 8560 0 0 {name=l28065 lab=VSS}
C {bitcell_6t.sym} 21800 8600 0 0 {name=Xr43c109}
N 21760 8640 21740 8640 {}
C {lab_pin.sym} 21740 8640 0 0 {name=l28066 lab=BL109}
N 21760 8600 21740 8600 {}
C {lab_pin.sym} 21740 8600 0 0 {name=l28067 lab=BLB109}
N 21760 8560 21740 8560 {}
C {lab_pin.sym} 21740 8560 0 0 {name=l28068 lab=WL43}
N 21840 8640 21860 8640 {}
C {lab_pin.sym} 21860 8640 0 0 {name=l28069 lab=VDD}
N 21840 8560 21860 8560 {}
C {lab_pin.sym} 21860 8560 0 0 {name=l28070 lab=VSS}
C {bitcell_6t.sym} 22000 8600 0 0 {name=Xr43c110}
N 21960 8640 21940 8640 {}
C {lab_pin.sym} 21940 8640 0 0 {name=l28071 lab=BL110}
N 21960 8600 21940 8600 {}
C {lab_pin.sym} 21940 8600 0 0 {name=l28072 lab=BLB110}
N 21960 8560 21940 8560 {}
C {lab_pin.sym} 21940 8560 0 0 {name=l28073 lab=WL43}
N 22040 8640 22060 8640 {}
C {lab_pin.sym} 22060 8640 0 0 {name=l28074 lab=VDD}
N 22040 8560 22060 8560 {}
C {lab_pin.sym} 22060 8560 0 0 {name=l28075 lab=VSS}
C {bitcell_6t.sym} 22200 8600 0 0 {name=Xr43c111}
N 22160 8640 22140 8640 {}
C {lab_pin.sym} 22140 8640 0 0 {name=l28076 lab=BL111}
N 22160 8600 22140 8600 {}
C {lab_pin.sym} 22140 8600 0 0 {name=l28077 lab=BLB111}
N 22160 8560 22140 8560 {}
C {lab_pin.sym} 22140 8560 0 0 {name=l28078 lab=WL43}
N 22240 8640 22260 8640 {}
C {lab_pin.sym} 22260 8640 0 0 {name=l28079 lab=VDD}
N 22240 8560 22260 8560 {}
C {lab_pin.sym} 22260 8560 0 0 {name=l28080 lab=VSS}
C {bitcell_6t.sym} 22400 8600 0 0 {name=Xr43c112}
N 22360 8640 22340 8640 {}
C {lab_pin.sym} 22340 8640 0 0 {name=l28081 lab=BL112}
N 22360 8600 22340 8600 {}
C {lab_pin.sym} 22340 8600 0 0 {name=l28082 lab=BLB112}
N 22360 8560 22340 8560 {}
C {lab_pin.sym} 22340 8560 0 0 {name=l28083 lab=WL43}
N 22440 8640 22460 8640 {}
C {lab_pin.sym} 22460 8640 0 0 {name=l28084 lab=VDD}
N 22440 8560 22460 8560 {}
C {lab_pin.sym} 22460 8560 0 0 {name=l28085 lab=VSS}
C {bitcell_6t.sym} 22600 8600 0 0 {name=Xr43c113}
N 22560 8640 22540 8640 {}
C {lab_pin.sym} 22540 8640 0 0 {name=l28086 lab=BL113}
N 22560 8600 22540 8600 {}
C {lab_pin.sym} 22540 8600 0 0 {name=l28087 lab=BLB113}
N 22560 8560 22540 8560 {}
C {lab_pin.sym} 22540 8560 0 0 {name=l28088 lab=WL43}
N 22640 8640 22660 8640 {}
C {lab_pin.sym} 22660 8640 0 0 {name=l28089 lab=VDD}
N 22640 8560 22660 8560 {}
C {lab_pin.sym} 22660 8560 0 0 {name=l28090 lab=VSS}
C {bitcell_6t.sym} 22800 8600 0 0 {name=Xr43c114}
N 22760 8640 22740 8640 {}
C {lab_pin.sym} 22740 8640 0 0 {name=l28091 lab=BL114}
N 22760 8600 22740 8600 {}
C {lab_pin.sym} 22740 8600 0 0 {name=l28092 lab=BLB114}
N 22760 8560 22740 8560 {}
C {lab_pin.sym} 22740 8560 0 0 {name=l28093 lab=WL43}
N 22840 8640 22860 8640 {}
C {lab_pin.sym} 22860 8640 0 0 {name=l28094 lab=VDD}
N 22840 8560 22860 8560 {}
C {lab_pin.sym} 22860 8560 0 0 {name=l28095 lab=VSS}
C {bitcell_6t.sym} 23000 8600 0 0 {name=Xr43c115}
N 22960 8640 22940 8640 {}
C {lab_pin.sym} 22940 8640 0 0 {name=l28096 lab=BL115}
N 22960 8600 22940 8600 {}
C {lab_pin.sym} 22940 8600 0 0 {name=l28097 lab=BLB115}
N 22960 8560 22940 8560 {}
C {lab_pin.sym} 22940 8560 0 0 {name=l28098 lab=WL43}
N 23040 8640 23060 8640 {}
C {lab_pin.sym} 23060 8640 0 0 {name=l28099 lab=VDD}
N 23040 8560 23060 8560 {}
C {lab_pin.sym} 23060 8560 0 0 {name=l28100 lab=VSS}
C {bitcell_6t.sym} 23200 8600 0 0 {name=Xr43c116}
N 23160 8640 23140 8640 {}
C {lab_pin.sym} 23140 8640 0 0 {name=l28101 lab=BL116}
N 23160 8600 23140 8600 {}
C {lab_pin.sym} 23140 8600 0 0 {name=l28102 lab=BLB116}
N 23160 8560 23140 8560 {}
C {lab_pin.sym} 23140 8560 0 0 {name=l28103 lab=WL43}
N 23240 8640 23260 8640 {}
C {lab_pin.sym} 23260 8640 0 0 {name=l28104 lab=VDD}
N 23240 8560 23260 8560 {}
C {lab_pin.sym} 23260 8560 0 0 {name=l28105 lab=VSS}
C {bitcell_6t.sym} 23400 8600 0 0 {name=Xr43c117}
N 23360 8640 23340 8640 {}
C {lab_pin.sym} 23340 8640 0 0 {name=l28106 lab=BL117}
N 23360 8600 23340 8600 {}
C {lab_pin.sym} 23340 8600 0 0 {name=l28107 lab=BLB117}
N 23360 8560 23340 8560 {}
C {lab_pin.sym} 23340 8560 0 0 {name=l28108 lab=WL43}
N 23440 8640 23460 8640 {}
C {lab_pin.sym} 23460 8640 0 0 {name=l28109 lab=VDD}
N 23440 8560 23460 8560 {}
C {lab_pin.sym} 23460 8560 0 0 {name=l28110 lab=VSS}
C {bitcell_6t.sym} 23600 8600 0 0 {name=Xr43c118}
N 23560 8640 23540 8640 {}
C {lab_pin.sym} 23540 8640 0 0 {name=l28111 lab=BL118}
N 23560 8600 23540 8600 {}
C {lab_pin.sym} 23540 8600 0 0 {name=l28112 lab=BLB118}
N 23560 8560 23540 8560 {}
C {lab_pin.sym} 23540 8560 0 0 {name=l28113 lab=WL43}
N 23640 8640 23660 8640 {}
C {lab_pin.sym} 23660 8640 0 0 {name=l28114 lab=VDD}
N 23640 8560 23660 8560 {}
C {lab_pin.sym} 23660 8560 0 0 {name=l28115 lab=VSS}
C {bitcell_6t.sym} 23800 8600 0 0 {name=Xr43c119}
N 23760 8640 23740 8640 {}
C {lab_pin.sym} 23740 8640 0 0 {name=l28116 lab=BL119}
N 23760 8600 23740 8600 {}
C {lab_pin.sym} 23740 8600 0 0 {name=l28117 lab=BLB119}
N 23760 8560 23740 8560 {}
C {lab_pin.sym} 23740 8560 0 0 {name=l28118 lab=WL43}
N 23840 8640 23860 8640 {}
C {lab_pin.sym} 23860 8640 0 0 {name=l28119 lab=VDD}
N 23840 8560 23860 8560 {}
C {lab_pin.sym} 23860 8560 0 0 {name=l28120 lab=VSS}
C {bitcell_6t.sym} 24000 8600 0 0 {name=Xr43c120}
N 23960 8640 23940 8640 {}
C {lab_pin.sym} 23940 8640 0 0 {name=l28121 lab=BL120}
N 23960 8600 23940 8600 {}
C {lab_pin.sym} 23940 8600 0 0 {name=l28122 lab=BLB120}
N 23960 8560 23940 8560 {}
C {lab_pin.sym} 23940 8560 0 0 {name=l28123 lab=WL43}
N 24040 8640 24060 8640 {}
C {lab_pin.sym} 24060 8640 0 0 {name=l28124 lab=VDD}
N 24040 8560 24060 8560 {}
C {lab_pin.sym} 24060 8560 0 0 {name=l28125 lab=VSS}
C {bitcell_6t.sym} 24200 8600 0 0 {name=Xr43c121}
N 24160 8640 24140 8640 {}
C {lab_pin.sym} 24140 8640 0 0 {name=l28126 lab=BL121}
N 24160 8600 24140 8600 {}
C {lab_pin.sym} 24140 8600 0 0 {name=l28127 lab=BLB121}
N 24160 8560 24140 8560 {}
C {lab_pin.sym} 24140 8560 0 0 {name=l28128 lab=WL43}
N 24240 8640 24260 8640 {}
C {lab_pin.sym} 24260 8640 0 0 {name=l28129 lab=VDD}
N 24240 8560 24260 8560 {}
C {lab_pin.sym} 24260 8560 0 0 {name=l28130 lab=VSS}
C {bitcell_6t.sym} 24400 8600 0 0 {name=Xr43c122}
N 24360 8640 24340 8640 {}
C {lab_pin.sym} 24340 8640 0 0 {name=l28131 lab=BL122}
N 24360 8600 24340 8600 {}
C {lab_pin.sym} 24340 8600 0 0 {name=l28132 lab=BLB122}
N 24360 8560 24340 8560 {}
C {lab_pin.sym} 24340 8560 0 0 {name=l28133 lab=WL43}
N 24440 8640 24460 8640 {}
C {lab_pin.sym} 24460 8640 0 0 {name=l28134 lab=VDD}
N 24440 8560 24460 8560 {}
C {lab_pin.sym} 24460 8560 0 0 {name=l28135 lab=VSS}
C {bitcell_6t.sym} 24600 8600 0 0 {name=Xr43c123}
N 24560 8640 24540 8640 {}
C {lab_pin.sym} 24540 8640 0 0 {name=l28136 lab=BL123}
N 24560 8600 24540 8600 {}
C {lab_pin.sym} 24540 8600 0 0 {name=l28137 lab=BLB123}
N 24560 8560 24540 8560 {}
C {lab_pin.sym} 24540 8560 0 0 {name=l28138 lab=WL43}
N 24640 8640 24660 8640 {}
C {lab_pin.sym} 24660 8640 0 0 {name=l28139 lab=VDD}
N 24640 8560 24660 8560 {}
C {lab_pin.sym} 24660 8560 0 0 {name=l28140 lab=VSS}
C {bitcell_6t.sym} 24800 8600 0 0 {name=Xr43c124}
N 24760 8640 24740 8640 {}
C {lab_pin.sym} 24740 8640 0 0 {name=l28141 lab=BL124}
N 24760 8600 24740 8600 {}
C {lab_pin.sym} 24740 8600 0 0 {name=l28142 lab=BLB124}
N 24760 8560 24740 8560 {}
C {lab_pin.sym} 24740 8560 0 0 {name=l28143 lab=WL43}
N 24840 8640 24860 8640 {}
C {lab_pin.sym} 24860 8640 0 0 {name=l28144 lab=VDD}
N 24840 8560 24860 8560 {}
C {lab_pin.sym} 24860 8560 0 0 {name=l28145 lab=VSS}
C {bitcell_6t.sym} 25000 8600 0 0 {name=Xr43c125}
N 24960 8640 24940 8640 {}
C {lab_pin.sym} 24940 8640 0 0 {name=l28146 lab=BL125}
N 24960 8600 24940 8600 {}
C {lab_pin.sym} 24940 8600 0 0 {name=l28147 lab=BLB125}
N 24960 8560 24940 8560 {}
C {lab_pin.sym} 24940 8560 0 0 {name=l28148 lab=WL43}
N 25040 8640 25060 8640 {}
C {lab_pin.sym} 25060 8640 0 0 {name=l28149 lab=VDD}
N 25040 8560 25060 8560 {}
C {lab_pin.sym} 25060 8560 0 0 {name=l28150 lab=VSS}
C {bitcell_6t.sym} 25200 8600 0 0 {name=Xr43c126}
N 25160 8640 25140 8640 {}
C {lab_pin.sym} 25140 8640 0 0 {name=l28151 lab=BL126}
N 25160 8600 25140 8600 {}
C {lab_pin.sym} 25140 8600 0 0 {name=l28152 lab=BLB126}
N 25160 8560 25140 8560 {}
C {lab_pin.sym} 25140 8560 0 0 {name=l28153 lab=WL43}
N 25240 8640 25260 8640 {}
C {lab_pin.sym} 25260 8640 0 0 {name=l28154 lab=VDD}
N 25240 8560 25260 8560 {}
C {lab_pin.sym} 25260 8560 0 0 {name=l28155 lab=VSS}
C {bitcell_6t.sym} 25400 8600 0 0 {name=Xr43c127}
N 25360 8640 25340 8640 {}
C {lab_pin.sym} 25340 8640 0 0 {name=l28156 lab=BL127}
N 25360 8600 25340 8600 {}
C {lab_pin.sym} 25340 8600 0 0 {name=l28157 lab=BLB127}
N 25360 8560 25340 8560 {}
C {lab_pin.sym} 25340 8560 0 0 {name=l28158 lab=WL43}
N 25440 8640 25460 8640 {}
C {lab_pin.sym} 25460 8640 0 0 {name=l28159 lab=VDD}
N 25440 8560 25460 8560 {}
C {lab_pin.sym} 25460 8560 0 0 {name=l28160 lab=VSS}
C {bitcell_6t.sym} 0 8800 0 0 {name=Xr44c0}
N -40 8840 -60 8840 {}
C {lab_pin.sym} -60 8840 0 0 {name=l28161 lab=BL0}
N -40 8800 -60 8800 {}
C {lab_pin.sym} -60 8800 0 0 {name=l28162 lab=BLB0}
N -40 8760 -60 8760 {}
C {lab_pin.sym} -60 8760 0 0 {name=l28163 lab=WL44}
N 40 8840 60 8840 {}
C {lab_pin.sym} 60 8840 0 0 {name=l28164 lab=VDD}
N 40 8760 60 8760 {}
C {lab_pin.sym} 60 8760 0 0 {name=l28165 lab=VSS}
C {bitcell_6t.sym} 200 8800 0 0 {name=Xr44c1}
N 160 8840 140 8840 {}
C {lab_pin.sym} 140 8840 0 0 {name=l28166 lab=BL1}
N 160 8800 140 8800 {}
C {lab_pin.sym} 140 8800 0 0 {name=l28167 lab=BLB1}
N 160 8760 140 8760 {}
C {lab_pin.sym} 140 8760 0 0 {name=l28168 lab=WL44}
N 240 8840 260 8840 {}
C {lab_pin.sym} 260 8840 0 0 {name=l28169 lab=VDD}
N 240 8760 260 8760 {}
C {lab_pin.sym} 260 8760 0 0 {name=l28170 lab=VSS}
C {bitcell_6t.sym} 400 8800 0 0 {name=Xr44c2}
N 360 8840 340 8840 {}
C {lab_pin.sym} 340 8840 0 0 {name=l28171 lab=BL2}
N 360 8800 340 8800 {}
C {lab_pin.sym} 340 8800 0 0 {name=l28172 lab=BLB2}
N 360 8760 340 8760 {}
C {lab_pin.sym} 340 8760 0 0 {name=l28173 lab=WL44}
N 440 8840 460 8840 {}
C {lab_pin.sym} 460 8840 0 0 {name=l28174 lab=VDD}
N 440 8760 460 8760 {}
C {lab_pin.sym} 460 8760 0 0 {name=l28175 lab=VSS}
C {bitcell_6t.sym} 600 8800 0 0 {name=Xr44c3}
N 560 8840 540 8840 {}
C {lab_pin.sym} 540 8840 0 0 {name=l28176 lab=BL3}
N 560 8800 540 8800 {}
C {lab_pin.sym} 540 8800 0 0 {name=l28177 lab=BLB3}
N 560 8760 540 8760 {}
C {lab_pin.sym} 540 8760 0 0 {name=l28178 lab=WL44}
N 640 8840 660 8840 {}
C {lab_pin.sym} 660 8840 0 0 {name=l28179 lab=VDD}
N 640 8760 660 8760 {}
C {lab_pin.sym} 660 8760 0 0 {name=l28180 lab=VSS}
C {bitcell_6t.sym} 800 8800 0 0 {name=Xr44c4}
N 760 8840 740 8840 {}
C {lab_pin.sym} 740 8840 0 0 {name=l28181 lab=BL4}
N 760 8800 740 8800 {}
C {lab_pin.sym} 740 8800 0 0 {name=l28182 lab=BLB4}
N 760 8760 740 8760 {}
C {lab_pin.sym} 740 8760 0 0 {name=l28183 lab=WL44}
N 840 8840 860 8840 {}
C {lab_pin.sym} 860 8840 0 0 {name=l28184 lab=VDD}
N 840 8760 860 8760 {}
C {lab_pin.sym} 860 8760 0 0 {name=l28185 lab=VSS}
C {bitcell_6t.sym} 1000 8800 0 0 {name=Xr44c5}
N 960 8840 940 8840 {}
C {lab_pin.sym} 940 8840 0 0 {name=l28186 lab=BL5}
N 960 8800 940 8800 {}
C {lab_pin.sym} 940 8800 0 0 {name=l28187 lab=BLB5}
N 960 8760 940 8760 {}
C {lab_pin.sym} 940 8760 0 0 {name=l28188 lab=WL44}
N 1040 8840 1060 8840 {}
C {lab_pin.sym} 1060 8840 0 0 {name=l28189 lab=VDD}
N 1040 8760 1060 8760 {}
C {lab_pin.sym} 1060 8760 0 0 {name=l28190 lab=VSS}
C {bitcell_6t.sym} 1200 8800 0 0 {name=Xr44c6}
N 1160 8840 1140 8840 {}
C {lab_pin.sym} 1140 8840 0 0 {name=l28191 lab=BL6}
N 1160 8800 1140 8800 {}
C {lab_pin.sym} 1140 8800 0 0 {name=l28192 lab=BLB6}
N 1160 8760 1140 8760 {}
C {lab_pin.sym} 1140 8760 0 0 {name=l28193 lab=WL44}
N 1240 8840 1260 8840 {}
C {lab_pin.sym} 1260 8840 0 0 {name=l28194 lab=VDD}
N 1240 8760 1260 8760 {}
C {lab_pin.sym} 1260 8760 0 0 {name=l28195 lab=VSS}
C {bitcell_6t.sym} 1400 8800 0 0 {name=Xr44c7}
N 1360 8840 1340 8840 {}
C {lab_pin.sym} 1340 8840 0 0 {name=l28196 lab=BL7}
N 1360 8800 1340 8800 {}
C {lab_pin.sym} 1340 8800 0 0 {name=l28197 lab=BLB7}
N 1360 8760 1340 8760 {}
C {lab_pin.sym} 1340 8760 0 0 {name=l28198 lab=WL44}
N 1440 8840 1460 8840 {}
C {lab_pin.sym} 1460 8840 0 0 {name=l28199 lab=VDD}
N 1440 8760 1460 8760 {}
C {lab_pin.sym} 1460 8760 0 0 {name=l28200 lab=VSS}
C {bitcell_6t.sym} 1600 8800 0 0 {name=Xr44c8}
N 1560 8840 1540 8840 {}
C {lab_pin.sym} 1540 8840 0 0 {name=l28201 lab=BL8}
N 1560 8800 1540 8800 {}
C {lab_pin.sym} 1540 8800 0 0 {name=l28202 lab=BLB8}
N 1560 8760 1540 8760 {}
C {lab_pin.sym} 1540 8760 0 0 {name=l28203 lab=WL44}
N 1640 8840 1660 8840 {}
C {lab_pin.sym} 1660 8840 0 0 {name=l28204 lab=VDD}
N 1640 8760 1660 8760 {}
C {lab_pin.sym} 1660 8760 0 0 {name=l28205 lab=VSS}
C {bitcell_6t.sym} 1800 8800 0 0 {name=Xr44c9}
N 1760 8840 1740 8840 {}
C {lab_pin.sym} 1740 8840 0 0 {name=l28206 lab=BL9}
N 1760 8800 1740 8800 {}
C {lab_pin.sym} 1740 8800 0 0 {name=l28207 lab=BLB9}
N 1760 8760 1740 8760 {}
C {lab_pin.sym} 1740 8760 0 0 {name=l28208 lab=WL44}
N 1840 8840 1860 8840 {}
C {lab_pin.sym} 1860 8840 0 0 {name=l28209 lab=VDD}
N 1840 8760 1860 8760 {}
C {lab_pin.sym} 1860 8760 0 0 {name=l28210 lab=VSS}
C {bitcell_6t.sym} 2000 8800 0 0 {name=Xr44c10}
N 1960 8840 1940 8840 {}
C {lab_pin.sym} 1940 8840 0 0 {name=l28211 lab=BL10}
N 1960 8800 1940 8800 {}
C {lab_pin.sym} 1940 8800 0 0 {name=l28212 lab=BLB10}
N 1960 8760 1940 8760 {}
C {lab_pin.sym} 1940 8760 0 0 {name=l28213 lab=WL44}
N 2040 8840 2060 8840 {}
C {lab_pin.sym} 2060 8840 0 0 {name=l28214 lab=VDD}
N 2040 8760 2060 8760 {}
C {lab_pin.sym} 2060 8760 0 0 {name=l28215 lab=VSS}
C {bitcell_6t.sym} 2200 8800 0 0 {name=Xr44c11}
N 2160 8840 2140 8840 {}
C {lab_pin.sym} 2140 8840 0 0 {name=l28216 lab=BL11}
N 2160 8800 2140 8800 {}
C {lab_pin.sym} 2140 8800 0 0 {name=l28217 lab=BLB11}
N 2160 8760 2140 8760 {}
C {lab_pin.sym} 2140 8760 0 0 {name=l28218 lab=WL44}
N 2240 8840 2260 8840 {}
C {lab_pin.sym} 2260 8840 0 0 {name=l28219 lab=VDD}
N 2240 8760 2260 8760 {}
C {lab_pin.sym} 2260 8760 0 0 {name=l28220 lab=VSS}
C {bitcell_6t.sym} 2400 8800 0 0 {name=Xr44c12}
N 2360 8840 2340 8840 {}
C {lab_pin.sym} 2340 8840 0 0 {name=l28221 lab=BL12}
N 2360 8800 2340 8800 {}
C {lab_pin.sym} 2340 8800 0 0 {name=l28222 lab=BLB12}
N 2360 8760 2340 8760 {}
C {lab_pin.sym} 2340 8760 0 0 {name=l28223 lab=WL44}
N 2440 8840 2460 8840 {}
C {lab_pin.sym} 2460 8840 0 0 {name=l28224 lab=VDD}
N 2440 8760 2460 8760 {}
C {lab_pin.sym} 2460 8760 0 0 {name=l28225 lab=VSS}
C {bitcell_6t.sym} 2600 8800 0 0 {name=Xr44c13}
N 2560 8840 2540 8840 {}
C {lab_pin.sym} 2540 8840 0 0 {name=l28226 lab=BL13}
N 2560 8800 2540 8800 {}
C {lab_pin.sym} 2540 8800 0 0 {name=l28227 lab=BLB13}
N 2560 8760 2540 8760 {}
C {lab_pin.sym} 2540 8760 0 0 {name=l28228 lab=WL44}
N 2640 8840 2660 8840 {}
C {lab_pin.sym} 2660 8840 0 0 {name=l28229 lab=VDD}
N 2640 8760 2660 8760 {}
C {lab_pin.sym} 2660 8760 0 0 {name=l28230 lab=VSS}
C {bitcell_6t.sym} 2800 8800 0 0 {name=Xr44c14}
N 2760 8840 2740 8840 {}
C {lab_pin.sym} 2740 8840 0 0 {name=l28231 lab=BL14}
N 2760 8800 2740 8800 {}
C {lab_pin.sym} 2740 8800 0 0 {name=l28232 lab=BLB14}
N 2760 8760 2740 8760 {}
C {lab_pin.sym} 2740 8760 0 0 {name=l28233 lab=WL44}
N 2840 8840 2860 8840 {}
C {lab_pin.sym} 2860 8840 0 0 {name=l28234 lab=VDD}
N 2840 8760 2860 8760 {}
C {lab_pin.sym} 2860 8760 0 0 {name=l28235 lab=VSS}
C {bitcell_6t.sym} 3000 8800 0 0 {name=Xr44c15}
N 2960 8840 2940 8840 {}
C {lab_pin.sym} 2940 8840 0 0 {name=l28236 lab=BL15}
N 2960 8800 2940 8800 {}
C {lab_pin.sym} 2940 8800 0 0 {name=l28237 lab=BLB15}
N 2960 8760 2940 8760 {}
C {lab_pin.sym} 2940 8760 0 0 {name=l28238 lab=WL44}
N 3040 8840 3060 8840 {}
C {lab_pin.sym} 3060 8840 0 0 {name=l28239 lab=VDD}
N 3040 8760 3060 8760 {}
C {lab_pin.sym} 3060 8760 0 0 {name=l28240 lab=VSS}
C {bitcell_6t.sym} 3200 8800 0 0 {name=Xr44c16}
N 3160 8840 3140 8840 {}
C {lab_pin.sym} 3140 8840 0 0 {name=l28241 lab=BL16}
N 3160 8800 3140 8800 {}
C {lab_pin.sym} 3140 8800 0 0 {name=l28242 lab=BLB16}
N 3160 8760 3140 8760 {}
C {lab_pin.sym} 3140 8760 0 0 {name=l28243 lab=WL44}
N 3240 8840 3260 8840 {}
C {lab_pin.sym} 3260 8840 0 0 {name=l28244 lab=VDD}
N 3240 8760 3260 8760 {}
C {lab_pin.sym} 3260 8760 0 0 {name=l28245 lab=VSS}
C {bitcell_6t.sym} 3400 8800 0 0 {name=Xr44c17}
N 3360 8840 3340 8840 {}
C {lab_pin.sym} 3340 8840 0 0 {name=l28246 lab=BL17}
N 3360 8800 3340 8800 {}
C {lab_pin.sym} 3340 8800 0 0 {name=l28247 lab=BLB17}
N 3360 8760 3340 8760 {}
C {lab_pin.sym} 3340 8760 0 0 {name=l28248 lab=WL44}
N 3440 8840 3460 8840 {}
C {lab_pin.sym} 3460 8840 0 0 {name=l28249 lab=VDD}
N 3440 8760 3460 8760 {}
C {lab_pin.sym} 3460 8760 0 0 {name=l28250 lab=VSS}
C {bitcell_6t.sym} 3600 8800 0 0 {name=Xr44c18}
N 3560 8840 3540 8840 {}
C {lab_pin.sym} 3540 8840 0 0 {name=l28251 lab=BL18}
N 3560 8800 3540 8800 {}
C {lab_pin.sym} 3540 8800 0 0 {name=l28252 lab=BLB18}
N 3560 8760 3540 8760 {}
C {lab_pin.sym} 3540 8760 0 0 {name=l28253 lab=WL44}
N 3640 8840 3660 8840 {}
C {lab_pin.sym} 3660 8840 0 0 {name=l28254 lab=VDD}
N 3640 8760 3660 8760 {}
C {lab_pin.sym} 3660 8760 0 0 {name=l28255 lab=VSS}
C {bitcell_6t.sym} 3800 8800 0 0 {name=Xr44c19}
N 3760 8840 3740 8840 {}
C {lab_pin.sym} 3740 8840 0 0 {name=l28256 lab=BL19}
N 3760 8800 3740 8800 {}
C {lab_pin.sym} 3740 8800 0 0 {name=l28257 lab=BLB19}
N 3760 8760 3740 8760 {}
C {lab_pin.sym} 3740 8760 0 0 {name=l28258 lab=WL44}
N 3840 8840 3860 8840 {}
C {lab_pin.sym} 3860 8840 0 0 {name=l28259 lab=VDD}
N 3840 8760 3860 8760 {}
C {lab_pin.sym} 3860 8760 0 0 {name=l28260 lab=VSS}
C {bitcell_6t.sym} 4000 8800 0 0 {name=Xr44c20}
N 3960 8840 3940 8840 {}
C {lab_pin.sym} 3940 8840 0 0 {name=l28261 lab=BL20}
N 3960 8800 3940 8800 {}
C {lab_pin.sym} 3940 8800 0 0 {name=l28262 lab=BLB20}
N 3960 8760 3940 8760 {}
C {lab_pin.sym} 3940 8760 0 0 {name=l28263 lab=WL44}
N 4040 8840 4060 8840 {}
C {lab_pin.sym} 4060 8840 0 0 {name=l28264 lab=VDD}
N 4040 8760 4060 8760 {}
C {lab_pin.sym} 4060 8760 0 0 {name=l28265 lab=VSS}
C {bitcell_6t.sym} 4200 8800 0 0 {name=Xr44c21}
N 4160 8840 4140 8840 {}
C {lab_pin.sym} 4140 8840 0 0 {name=l28266 lab=BL21}
N 4160 8800 4140 8800 {}
C {lab_pin.sym} 4140 8800 0 0 {name=l28267 lab=BLB21}
N 4160 8760 4140 8760 {}
C {lab_pin.sym} 4140 8760 0 0 {name=l28268 lab=WL44}
N 4240 8840 4260 8840 {}
C {lab_pin.sym} 4260 8840 0 0 {name=l28269 lab=VDD}
N 4240 8760 4260 8760 {}
C {lab_pin.sym} 4260 8760 0 0 {name=l28270 lab=VSS}
C {bitcell_6t.sym} 4400 8800 0 0 {name=Xr44c22}
N 4360 8840 4340 8840 {}
C {lab_pin.sym} 4340 8840 0 0 {name=l28271 lab=BL22}
N 4360 8800 4340 8800 {}
C {lab_pin.sym} 4340 8800 0 0 {name=l28272 lab=BLB22}
N 4360 8760 4340 8760 {}
C {lab_pin.sym} 4340 8760 0 0 {name=l28273 lab=WL44}
N 4440 8840 4460 8840 {}
C {lab_pin.sym} 4460 8840 0 0 {name=l28274 lab=VDD}
N 4440 8760 4460 8760 {}
C {lab_pin.sym} 4460 8760 0 0 {name=l28275 lab=VSS}
C {bitcell_6t.sym} 4600 8800 0 0 {name=Xr44c23}
N 4560 8840 4540 8840 {}
C {lab_pin.sym} 4540 8840 0 0 {name=l28276 lab=BL23}
N 4560 8800 4540 8800 {}
C {lab_pin.sym} 4540 8800 0 0 {name=l28277 lab=BLB23}
N 4560 8760 4540 8760 {}
C {lab_pin.sym} 4540 8760 0 0 {name=l28278 lab=WL44}
N 4640 8840 4660 8840 {}
C {lab_pin.sym} 4660 8840 0 0 {name=l28279 lab=VDD}
N 4640 8760 4660 8760 {}
C {lab_pin.sym} 4660 8760 0 0 {name=l28280 lab=VSS}
C {bitcell_6t.sym} 4800 8800 0 0 {name=Xr44c24}
N 4760 8840 4740 8840 {}
C {lab_pin.sym} 4740 8840 0 0 {name=l28281 lab=BL24}
N 4760 8800 4740 8800 {}
C {lab_pin.sym} 4740 8800 0 0 {name=l28282 lab=BLB24}
N 4760 8760 4740 8760 {}
C {lab_pin.sym} 4740 8760 0 0 {name=l28283 lab=WL44}
N 4840 8840 4860 8840 {}
C {lab_pin.sym} 4860 8840 0 0 {name=l28284 lab=VDD}
N 4840 8760 4860 8760 {}
C {lab_pin.sym} 4860 8760 0 0 {name=l28285 lab=VSS}
C {bitcell_6t.sym} 5000 8800 0 0 {name=Xr44c25}
N 4960 8840 4940 8840 {}
C {lab_pin.sym} 4940 8840 0 0 {name=l28286 lab=BL25}
N 4960 8800 4940 8800 {}
C {lab_pin.sym} 4940 8800 0 0 {name=l28287 lab=BLB25}
N 4960 8760 4940 8760 {}
C {lab_pin.sym} 4940 8760 0 0 {name=l28288 lab=WL44}
N 5040 8840 5060 8840 {}
C {lab_pin.sym} 5060 8840 0 0 {name=l28289 lab=VDD}
N 5040 8760 5060 8760 {}
C {lab_pin.sym} 5060 8760 0 0 {name=l28290 lab=VSS}
C {bitcell_6t.sym} 5200 8800 0 0 {name=Xr44c26}
N 5160 8840 5140 8840 {}
C {lab_pin.sym} 5140 8840 0 0 {name=l28291 lab=BL26}
N 5160 8800 5140 8800 {}
C {lab_pin.sym} 5140 8800 0 0 {name=l28292 lab=BLB26}
N 5160 8760 5140 8760 {}
C {lab_pin.sym} 5140 8760 0 0 {name=l28293 lab=WL44}
N 5240 8840 5260 8840 {}
C {lab_pin.sym} 5260 8840 0 0 {name=l28294 lab=VDD}
N 5240 8760 5260 8760 {}
C {lab_pin.sym} 5260 8760 0 0 {name=l28295 lab=VSS}
C {bitcell_6t.sym} 5400 8800 0 0 {name=Xr44c27}
N 5360 8840 5340 8840 {}
C {lab_pin.sym} 5340 8840 0 0 {name=l28296 lab=BL27}
N 5360 8800 5340 8800 {}
C {lab_pin.sym} 5340 8800 0 0 {name=l28297 lab=BLB27}
N 5360 8760 5340 8760 {}
C {lab_pin.sym} 5340 8760 0 0 {name=l28298 lab=WL44}
N 5440 8840 5460 8840 {}
C {lab_pin.sym} 5460 8840 0 0 {name=l28299 lab=VDD}
N 5440 8760 5460 8760 {}
C {lab_pin.sym} 5460 8760 0 0 {name=l28300 lab=VSS}
C {bitcell_6t.sym} 5600 8800 0 0 {name=Xr44c28}
N 5560 8840 5540 8840 {}
C {lab_pin.sym} 5540 8840 0 0 {name=l28301 lab=BL28}
N 5560 8800 5540 8800 {}
C {lab_pin.sym} 5540 8800 0 0 {name=l28302 lab=BLB28}
N 5560 8760 5540 8760 {}
C {lab_pin.sym} 5540 8760 0 0 {name=l28303 lab=WL44}
N 5640 8840 5660 8840 {}
C {lab_pin.sym} 5660 8840 0 0 {name=l28304 lab=VDD}
N 5640 8760 5660 8760 {}
C {lab_pin.sym} 5660 8760 0 0 {name=l28305 lab=VSS}
C {bitcell_6t.sym} 5800 8800 0 0 {name=Xr44c29}
N 5760 8840 5740 8840 {}
C {lab_pin.sym} 5740 8840 0 0 {name=l28306 lab=BL29}
N 5760 8800 5740 8800 {}
C {lab_pin.sym} 5740 8800 0 0 {name=l28307 lab=BLB29}
N 5760 8760 5740 8760 {}
C {lab_pin.sym} 5740 8760 0 0 {name=l28308 lab=WL44}
N 5840 8840 5860 8840 {}
C {lab_pin.sym} 5860 8840 0 0 {name=l28309 lab=VDD}
N 5840 8760 5860 8760 {}
C {lab_pin.sym} 5860 8760 0 0 {name=l28310 lab=VSS}
C {bitcell_6t.sym} 6000 8800 0 0 {name=Xr44c30}
N 5960 8840 5940 8840 {}
C {lab_pin.sym} 5940 8840 0 0 {name=l28311 lab=BL30}
N 5960 8800 5940 8800 {}
C {lab_pin.sym} 5940 8800 0 0 {name=l28312 lab=BLB30}
N 5960 8760 5940 8760 {}
C {lab_pin.sym} 5940 8760 0 0 {name=l28313 lab=WL44}
N 6040 8840 6060 8840 {}
C {lab_pin.sym} 6060 8840 0 0 {name=l28314 lab=VDD}
N 6040 8760 6060 8760 {}
C {lab_pin.sym} 6060 8760 0 0 {name=l28315 lab=VSS}
C {bitcell_6t.sym} 6200 8800 0 0 {name=Xr44c31}
N 6160 8840 6140 8840 {}
C {lab_pin.sym} 6140 8840 0 0 {name=l28316 lab=BL31}
N 6160 8800 6140 8800 {}
C {lab_pin.sym} 6140 8800 0 0 {name=l28317 lab=BLB31}
N 6160 8760 6140 8760 {}
C {lab_pin.sym} 6140 8760 0 0 {name=l28318 lab=WL44}
N 6240 8840 6260 8840 {}
C {lab_pin.sym} 6260 8840 0 0 {name=l28319 lab=VDD}
N 6240 8760 6260 8760 {}
C {lab_pin.sym} 6260 8760 0 0 {name=l28320 lab=VSS}
C {bitcell_6t.sym} 6400 8800 0 0 {name=Xr44c32}
N 6360 8840 6340 8840 {}
C {lab_pin.sym} 6340 8840 0 0 {name=l28321 lab=BL32}
N 6360 8800 6340 8800 {}
C {lab_pin.sym} 6340 8800 0 0 {name=l28322 lab=BLB32}
N 6360 8760 6340 8760 {}
C {lab_pin.sym} 6340 8760 0 0 {name=l28323 lab=WL44}
N 6440 8840 6460 8840 {}
C {lab_pin.sym} 6460 8840 0 0 {name=l28324 lab=VDD}
N 6440 8760 6460 8760 {}
C {lab_pin.sym} 6460 8760 0 0 {name=l28325 lab=VSS}
C {bitcell_6t.sym} 6600 8800 0 0 {name=Xr44c33}
N 6560 8840 6540 8840 {}
C {lab_pin.sym} 6540 8840 0 0 {name=l28326 lab=BL33}
N 6560 8800 6540 8800 {}
C {lab_pin.sym} 6540 8800 0 0 {name=l28327 lab=BLB33}
N 6560 8760 6540 8760 {}
C {lab_pin.sym} 6540 8760 0 0 {name=l28328 lab=WL44}
N 6640 8840 6660 8840 {}
C {lab_pin.sym} 6660 8840 0 0 {name=l28329 lab=VDD}
N 6640 8760 6660 8760 {}
C {lab_pin.sym} 6660 8760 0 0 {name=l28330 lab=VSS}
C {bitcell_6t.sym} 6800 8800 0 0 {name=Xr44c34}
N 6760 8840 6740 8840 {}
C {lab_pin.sym} 6740 8840 0 0 {name=l28331 lab=BL34}
N 6760 8800 6740 8800 {}
C {lab_pin.sym} 6740 8800 0 0 {name=l28332 lab=BLB34}
N 6760 8760 6740 8760 {}
C {lab_pin.sym} 6740 8760 0 0 {name=l28333 lab=WL44}
N 6840 8840 6860 8840 {}
C {lab_pin.sym} 6860 8840 0 0 {name=l28334 lab=VDD}
N 6840 8760 6860 8760 {}
C {lab_pin.sym} 6860 8760 0 0 {name=l28335 lab=VSS}
C {bitcell_6t.sym} 7000 8800 0 0 {name=Xr44c35}
N 6960 8840 6940 8840 {}
C {lab_pin.sym} 6940 8840 0 0 {name=l28336 lab=BL35}
N 6960 8800 6940 8800 {}
C {lab_pin.sym} 6940 8800 0 0 {name=l28337 lab=BLB35}
N 6960 8760 6940 8760 {}
C {lab_pin.sym} 6940 8760 0 0 {name=l28338 lab=WL44}
N 7040 8840 7060 8840 {}
C {lab_pin.sym} 7060 8840 0 0 {name=l28339 lab=VDD}
N 7040 8760 7060 8760 {}
C {lab_pin.sym} 7060 8760 0 0 {name=l28340 lab=VSS}
C {bitcell_6t.sym} 7200 8800 0 0 {name=Xr44c36}
N 7160 8840 7140 8840 {}
C {lab_pin.sym} 7140 8840 0 0 {name=l28341 lab=BL36}
N 7160 8800 7140 8800 {}
C {lab_pin.sym} 7140 8800 0 0 {name=l28342 lab=BLB36}
N 7160 8760 7140 8760 {}
C {lab_pin.sym} 7140 8760 0 0 {name=l28343 lab=WL44}
N 7240 8840 7260 8840 {}
C {lab_pin.sym} 7260 8840 0 0 {name=l28344 lab=VDD}
N 7240 8760 7260 8760 {}
C {lab_pin.sym} 7260 8760 0 0 {name=l28345 lab=VSS}
C {bitcell_6t.sym} 7400 8800 0 0 {name=Xr44c37}
N 7360 8840 7340 8840 {}
C {lab_pin.sym} 7340 8840 0 0 {name=l28346 lab=BL37}
N 7360 8800 7340 8800 {}
C {lab_pin.sym} 7340 8800 0 0 {name=l28347 lab=BLB37}
N 7360 8760 7340 8760 {}
C {lab_pin.sym} 7340 8760 0 0 {name=l28348 lab=WL44}
N 7440 8840 7460 8840 {}
C {lab_pin.sym} 7460 8840 0 0 {name=l28349 lab=VDD}
N 7440 8760 7460 8760 {}
C {lab_pin.sym} 7460 8760 0 0 {name=l28350 lab=VSS}
C {bitcell_6t.sym} 7600 8800 0 0 {name=Xr44c38}
N 7560 8840 7540 8840 {}
C {lab_pin.sym} 7540 8840 0 0 {name=l28351 lab=BL38}
N 7560 8800 7540 8800 {}
C {lab_pin.sym} 7540 8800 0 0 {name=l28352 lab=BLB38}
N 7560 8760 7540 8760 {}
C {lab_pin.sym} 7540 8760 0 0 {name=l28353 lab=WL44}
N 7640 8840 7660 8840 {}
C {lab_pin.sym} 7660 8840 0 0 {name=l28354 lab=VDD}
N 7640 8760 7660 8760 {}
C {lab_pin.sym} 7660 8760 0 0 {name=l28355 lab=VSS}
C {bitcell_6t.sym} 7800 8800 0 0 {name=Xr44c39}
N 7760 8840 7740 8840 {}
C {lab_pin.sym} 7740 8840 0 0 {name=l28356 lab=BL39}
N 7760 8800 7740 8800 {}
C {lab_pin.sym} 7740 8800 0 0 {name=l28357 lab=BLB39}
N 7760 8760 7740 8760 {}
C {lab_pin.sym} 7740 8760 0 0 {name=l28358 lab=WL44}
N 7840 8840 7860 8840 {}
C {lab_pin.sym} 7860 8840 0 0 {name=l28359 lab=VDD}
N 7840 8760 7860 8760 {}
C {lab_pin.sym} 7860 8760 0 0 {name=l28360 lab=VSS}
C {bitcell_6t.sym} 8000 8800 0 0 {name=Xr44c40}
N 7960 8840 7940 8840 {}
C {lab_pin.sym} 7940 8840 0 0 {name=l28361 lab=BL40}
N 7960 8800 7940 8800 {}
C {lab_pin.sym} 7940 8800 0 0 {name=l28362 lab=BLB40}
N 7960 8760 7940 8760 {}
C {lab_pin.sym} 7940 8760 0 0 {name=l28363 lab=WL44}
N 8040 8840 8060 8840 {}
C {lab_pin.sym} 8060 8840 0 0 {name=l28364 lab=VDD}
N 8040 8760 8060 8760 {}
C {lab_pin.sym} 8060 8760 0 0 {name=l28365 lab=VSS}
C {bitcell_6t.sym} 8200 8800 0 0 {name=Xr44c41}
N 8160 8840 8140 8840 {}
C {lab_pin.sym} 8140 8840 0 0 {name=l28366 lab=BL41}
N 8160 8800 8140 8800 {}
C {lab_pin.sym} 8140 8800 0 0 {name=l28367 lab=BLB41}
N 8160 8760 8140 8760 {}
C {lab_pin.sym} 8140 8760 0 0 {name=l28368 lab=WL44}
N 8240 8840 8260 8840 {}
C {lab_pin.sym} 8260 8840 0 0 {name=l28369 lab=VDD}
N 8240 8760 8260 8760 {}
C {lab_pin.sym} 8260 8760 0 0 {name=l28370 lab=VSS}
C {bitcell_6t.sym} 8400 8800 0 0 {name=Xr44c42}
N 8360 8840 8340 8840 {}
C {lab_pin.sym} 8340 8840 0 0 {name=l28371 lab=BL42}
N 8360 8800 8340 8800 {}
C {lab_pin.sym} 8340 8800 0 0 {name=l28372 lab=BLB42}
N 8360 8760 8340 8760 {}
C {lab_pin.sym} 8340 8760 0 0 {name=l28373 lab=WL44}
N 8440 8840 8460 8840 {}
C {lab_pin.sym} 8460 8840 0 0 {name=l28374 lab=VDD}
N 8440 8760 8460 8760 {}
C {lab_pin.sym} 8460 8760 0 0 {name=l28375 lab=VSS}
C {bitcell_6t.sym} 8600 8800 0 0 {name=Xr44c43}
N 8560 8840 8540 8840 {}
C {lab_pin.sym} 8540 8840 0 0 {name=l28376 lab=BL43}
N 8560 8800 8540 8800 {}
C {lab_pin.sym} 8540 8800 0 0 {name=l28377 lab=BLB43}
N 8560 8760 8540 8760 {}
C {lab_pin.sym} 8540 8760 0 0 {name=l28378 lab=WL44}
N 8640 8840 8660 8840 {}
C {lab_pin.sym} 8660 8840 0 0 {name=l28379 lab=VDD}
N 8640 8760 8660 8760 {}
C {lab_pin.sym} 8660 8760 0 0 {name=l28380 lab=VSS}
C {bitcell_6t.sym} 8800 8800 0 0 {name=Xr44c44}
N 8760 8840 8740 8840 {}
C {lab_pin.sym} 8740 8840 0 0 {name=l28381 lab=BL44}
N 8760 8800 8740 8800 {}
C {lab_pin.sym} 8740 8800 0 0 {name=l28382 lab=BLB44}
N 8760 8760 8740 8760 {}
C {lab_pin.sym} 8740 8760 0 0 {name=l28383 lab=WL44}
N 8840 8840 8860 8840 {}
C {lab_pin.sym} 8860 8840 0 0 {name=l28384 lab=VDD}
N 8840 8760 8860 8760 {}
C {lab_pin.sym} 8860 8760 0 0 {name=l28385 lab=VSS}
C {bitcell_6t.sym} 9000 8800 0 0 {name=Xr44c45}
N 8960 8840 8940 8840 {}
C {lab_pin.sym} 8940 8840 0 0 {name=l28386 lab=BL45}
N 8960 8800 8940 8800 {}
C {lab_pin.sym} 8940 8800 0 0 {name=l28387 lab=BLB45}
N 8960 8760 8940 8760 {}
C {lab_pin.sym} 8940 8760 0 0 {name=l28388 lab=WL44}
N 9040 8840 9060 8840 {}
C {lab_pin.sym} 9060 8840 0 0 {name=l28389 lab=VDD}
N 9040 8760 9060 8760 {}
C {lab_pin.sym} 9060 8760 0 0 {name=l28390 lab=VSS}
C {bitcell_6t.sym} 9200 8800 0 0 {name=Xr44c46}
N 9160 8840 9140 8840 {}
C {lab_pin.sym} 9140 8840 0 0 {name=l28391 lab=BL46}
N 9160 8800 9140 8800 {}
C {lab_pin.sym} 9140 8800 0 0 {name=l28392 lab=BLB46}
N 9160 8760 9140 8760 {}
C {lab_pin.sym} 9140 8760 0 0 {name=l28393 lab=WL44}
N 9240 8840 9260 8840 {}
C {lab_pin.sym} 9260 8840 0 0 {name=l28394 lab=VDD}
N 9240 8760 9260 8760 {}
C {lab_pin.sym} 9260 8760 0 0 {name=l28395 lab=VSS}
C {bitcell_6t.sym} 9400 8800 0 0 {name=Xr44c47}
N 9360 8840 9340 8840 {}
C {lab_pin.sym} 9340 8840 0 0 {name=l28396 lab=BL47}
N 9360 8800 9340 8800 {}
C {lab_pin.sym} 9340 8800 0 0 {name=l28397 lab=BLB47}
N 9360 8760 9340 8760 {}
C {lab_pin.sym} 9340 8760 0 0 {name=l28398 lab=WL44}
N 9440 8840 9460 8840 {}
C {lab_pin.sym} 9460 8840 0 0 {name=l28399 lab=VDD}
N 9440 8760 9460 8760 {}
C {lab_pin.sym} 9460 8760 0 0 {name=l28400 lab=VSS}
C {bitcell_6t.sym} 9600 8800 0 0 {name=Xr44c48}
N 9560 8840 9540 8840 {}
C {lab_pin.sym} 9540 8840 0 0 {name=l28401 lab=BL48}
N 9560 8800 9540 8800 {}
C {lab_pin.sym} 9540 8800 0 0 {name=l28402 lab=BLB48}
N 9560 8760 9540 8760 {}
C {lab_pin.sym} 9540 8760 0 0 {name=l28403 lab=WL44}
N 9640 8840 9660 8840 {}
C {lab_pin.sym} 9660 8840 0 0 {name=l28404 lab=VDD}
N 9640 8760 9660 8760 {}
C {lab_pin.sym} 9660 8760 0 0 {name=l28405 lab=VSS}
C {bitcell_6t.sym} 9800 8800 0 0 {name=Xr44c49}
N 9760 8840 9740 8840 {}
C {lab_pin.sym} 9740 8840 0 0 {name=l28406 lab=BL49}
N 9760 8800 9740 8800 {}
C {lab_pin.sym} 9740 8800 0 0 {name=l28407 lab=BLB49}
N 9760 8760 9740 8760 {}
C {lab_pin.sym} 9740 8760 0 0 {name=l28408 lab=WL44}
N 9840 8840 9860 8840 {}
C {lab_pin.sym} 9860 8840 0 0 {name=l28409 lab=VDD}
N 9840 8760 9860 8760 {}
C {lab_pin.sym} 9860 8760 0 0 {name=l28410 lab=VSS}
C {bitcell_6t.sym} 10000 8800 0 0 {name=Xr44c50}
N 9960 8840 9940 8840 {}
C {lab_pin.sym} 9940 8840 0 0 {name=l28411 lab=BL50}
N 9960 8800 9940 8800 {}
C {lab_pin.sym} 9940 8800 0 0 {name=l28412 lab=BLB50}
N 9960 8760 9940 8760 {}
C {lab_pin.sym} 9940 8760 0 0 {name=l28413 lab=WL44}
N 10040 8840 10060 8840 {}
C {lab_pin.sym} 10060 8840 0 0 {name=l28414 lab=VDD}
N 10040 8760 10060 8760 {}
C {lab_pin.sym} 10060 8760 0 0 {name=l28415 lab=VSS}
C {bitcell_6t.sym} 10200 8800 0 0 {name=Xr44c51}
N 10160 8840 10140 8840 {}
C {lab_pin.sym} 10140 8840 0 0 {name=l28416 lab=BL51}
N 10160 8800 10140 8800 {}
C {lab_pin.sym} 10140 8800 0 0 {name=l28417 lab=BLB51}
N 10160 8760 10140 8760 {}
C {lab_pin.sym} 10140 8760 0 0 {name=l28418 lab=WL44}
N 10240 8840 10260 8840 {}
C {lab_pin.sym} 10260 8840 0 0 {name=l28419 lab=VDD}
N 10240 8760 10260 8760 {}
C {lab_pin.sym} 10260 8760 0 0 {name=l28420 lab=VSS}
C {bitcell_6t.sym} 10400 8800 0 0 {name=Xr44c52}
N 10360 8840 10340 8840 {}
C {lab_pin.sym} 10340 8840 0 0 {name=l28421 lab=BL52}
N 10360 8800 10340 8800 {}
C {lab_pin.sym} 10340 8800 0 0 {name=l28422 lab=BLB52}
N 10360 8760 10340 8760 {}
C {lab_pin.sym} 10340 8760 0 0 {name=l28423 lab=WL44}
N 10440 8840 10460 8840 {}
C {lab_pin.sym} 10460 8840 0 0 {name=l28424 lab=VDD}
N 10440 8760 10460 8760 {}
C {lab_pin.sym} 10460 8760 0 0 {name=l28425 lab=VSS}
C {bitcell_6t.sym} 10600 8800 0 0 {name=Xr44c53}
N 10560 8840 10540 8840 {}
C {lab_pin.sym} 10540 8840 0 0 {name=l28426 lab=BL53}
N 10560 8800 10540 8800 {}
C {lab_pin.sym} 10540 8800 0 0 {name=l28427 lab=BLB53}
N 10560 8760 10540 8760 {}
C {lab_pin.sym} 10540 8760 0 0 {name=l28428 lab=WL44}
N 10640 8840 10660 8840 {}
C {lab_pin.sym} 10660 8840 0 0 {name=l28429 lab=VDD}
N 10640 8760 10660 8760 {}
C {lab_pin.sym} 10660 8760 0 0 {name=l28430 lab=VSS}
C {bitcell_6t.sym} 10800 8800 0 0 {name=Xr44c54}
N 10760 8840 10740 8840 {}
C {lab_pin.sym} 10740 8840 0 0 {name=l28431 lab=BL54}
N 10760 8800 10740 8800 {}
C {lab_pin.sym} 10740 8800 0 0 {name=l28432 lab=BLB54}
N 10760 8760 10740 8760 {}
C {lab_pin.sym} 10740 8760 0 0 {name=l28433 lab=WL44}
N 10840 8840 10860 8840 {}
C {lab_pin.sym} 10860 8840 0 0 {name=l28434 lab=VDD}
N 10840 8760 10860 8760 {}
C {lab_pin.sym} 10860 8760 0 0 {name=l28435 lab=VSS}
C {bitcell_6t.sym} 11000 8800 0 0 {name=Xr44c55}
N 10960 8840 10940 8840 {}
C {lab_pin.sym} 10940 8840 0 0 {name=l28436 lab=BL55}
N 10960 8800 10940 8800 {}
C {lab_pin.sym} 10940 8800 0 0 {name=l28437 lab=BLB55}
N 10960 8760 10940 8760 {}
C {lab_pin.sym} 10940 8760 0 0 {name=l28438 lab=WL44}
N 11040 8840 11060 8840 {}
C {lab_pin.sym} 11060 8840 0 0 {name=l28439 lab=VDD}
N 11040 8760 11060 8760 {}
C {lab_pin.sym} 11060 8760 0 0 {name=l28440 lab=VSS}
C {bitcell_6t.sym} 11200 8800 0 0 {name=Xr44c56}
N 11160 8840 11140 8840 {}
C {lab_pin.sym} 11140 8840 0 0 {name=l28441 lab=BL56}
N 11160 8800 11140 8800 {}
C {lab_pin.sym} 11140 8800 0 0 {name=l28442 lab=BLB56}
N 11160 8760 11140 8760 {}
C {lab_pin.sym} 11140 8760 0 0 {name=l28443 lab=WL44}
N 11240 8840 11260 8840 {}
C {lab_pin.sym} 11260 8840 0 0 {name=l28444 lab=VDD}
N 11240 8760 11260 8760 {}
C {lab_pin.sym} 11260 8760 0 0 {name=l28445 lab=VSS}
C {bitcell_6t.sym} 11400 8800 0 0 {name=Xr44c57}
N 11360 8840 11340 8840 {}
C {lab_pin.sym} 11340 8840 0 0 {name=l28446 lab=BL57}
N 11360 8800 11340 8800 {}
C {lab_pin.sym} 11340 8800 0 0 {name=l28447 lab=BLB57}
N 11360 8760 11340 8760 {}
C {lab_pin.sym} 11340 8760 0 0 {name=l28448 lab=WL44}
N 11440 8840 11460 8840 {}
C {lab_pin.sym} 11460 8840 0 0 {name=l28449 lab=VDD}
N 11440 8760 11460 8760 {}
C {lab_pin.sym} 11460 8760 0 0 {name=l28450 lab=VSS}
C {bitcell_6t.sym} 11600 8800 0 0 {name=Xr44c58}
N 11560 8840 11540 8840 {}
C {lab_pin.sym} 11540 8840 0 0 {name=l28451 lab=BL58}
N 11560 8800 11540 8800 {}
C {lab_pin.sym} 11540 8800 0 0 {name=l28452 lab=BLB58}
N 11560 8760 11540 8760 {}
C {lab_pin.sym} 11540 8760 0 0 {name=l28453 lab=WL44}
N 11640 8840 11660 8840 {}
C {lab_pin.sym} 11660 8840 0 0 {name=l28454 lab=VDD}
N 11640 8760 11660 8760 {}
C {lab_pin.sym} 11660 8760 0 0 {name=l28455 lab=VSS}
C {bitcell_6t.sym} 11800 8800 0 0 {name=Xr44c59}
N 11760 8840 11740 8840 {}
C {lab_pin.sym} 11740 8840 0 0 {name=l28456 lab=BL59}
N 11760 8800 11740 8800 {}
C {lab_pin.sym} 11740 8800 0 0 {name=l28457 lab=BLB59}
N 11760 8760 11740 8760 {}
C {lab_pin.sym} 11740 8760 0 0 {name=l28458 lab=WL44}
N 11840 8840 11860 8840 {}
C {lab_pin.sym} 11860 8840 0 0 {name=l28459 lab=VDD}
N 11840 8760 11860 8760 {}
C {lab_pin.sym} 11860 8760 0 0 {name=l28460 lab=VSS}
C {bitcell_6t.sym} 12000 8800 0 0 {name=Xr44c60}
N 11960 8840 11940 8840 {}
C {lab_pin.sym} 11940 8840 0 0 {name=l28461 lab=BL60}
N 11960 8800 11940 8800 {}
C {lab_pin.sym} 11940 8800 0 0 {name=l28462 lab=BLB60}
N 11960 8760 11940 8760 {}
C {lab_pin.sym} 11940 8760 0 0 {name=l28463 lab=WL44}
N 12040 8840 12060 8840 {}
C {lab_pin.sym} 12060 8840 0 0 {name=l28464 lab=VDD}
N 12040 8760 12060 8760 {}
C {lab_pin.sym} 12060 8760 0 0 {name=l28465 lab=VSS}
C {bitcell_6t.sym} 12200 8800 0 0 {name=Xr44c61}
N 12160 8840 12140 8840 {}
C {lab_pin.sym} 12140 8840 0 0 {name=l28466 lab=BL61}
N 12160 8800 12140 8800 {}
C {lab_pin.sym} 12140 8800 0 0 {name=l28467 lab=BLB61}
N 12160 8760 12140 8760 {}
C {lab_pin.sym} 12140 8760 0 0 {name=l28468 lab=WL44}
N 12240 8840 12260 8840 {}
C {lab_pin.sym} 12260 8840 0 0 {name=l28469 lab=VDD}
N 12240 8760 12260 8760 {}
C {lab_pin.sym} 12260 8760 0 0 {name=l28470 lab=VSS}
C {bitcell_6t.sym} 12400 8800 0 0 {name=Xr44c62}
N 12360 8840 12340 8840 {}
C {lab_pin.sym} 12340 8840 0 0 {name=l28471 lab=BL62}
N 12360 8800 12340 8800 {}
C {lab_pin.sym} 12340 8800 0 0 {name=l28472 lab=BLB62}
N 12360 8760 12340 8760 {}
C {lab_pin.sym} 12340 8760 0 0 {name=l28473 lab=WL44}
N 12440 8840 12460 8840 {}
C {lab_pin.sym} 12460 8840 0 0 {name=l28474 lab=VDD}
N 12440 8760 12460 8760 {}
C {lab_pin.sym} 12460 8760 0 0 {name=l28475 lab=VSS}
C {bitcell_6t.sym} 12600 8800 0 0 {name=Xr44c63}
N 12560 8840 12540 8840 {}
C {lab_pin.sym} 12540 8840 0 0 {name=l28476 lab=BL63}
N 12560 8800 12540 8800 {}
C {lab_pin.sym} 12540 8800 0 0 {name=l28477 lab=BLB63}
N 12560 8760 12540 8760 {}
C {lab_pin.sym} 12540 8760 0 0 {name=l28478 lab=WL44}
N 12640 8840 12660 8840 {}
C {lab_pin.sym} 12660 8840 0 0 {name=l28479 lab=VDD}
N 12640 8760 12660 8760 {}
C {lab_pin.sym} 12660 8760 0 0 {name=l28480 lab=VSS}
C {bitcell_6t.sym} 12800 8800 0 0 {name=Xr44c64}
N 12760 8840 12740 8840 {}
C {lab_pin.sym} 12740 8840 0 0 {name=l28481 lab=BL64}
N 12760 8800 12740 8800 {}
C {lab_pin.sym} 12740 8800 0 0 {name=l28482 lab=BLB64}
N 12760 8760 12740 8760 {}
C {lab_pin.sym} 12740 8760 0 0 {name=l28483 lab=WL44}
N 12840 8840 12860 8840 {}
C {lab_pin.sym} 12860 8840 0 0 {name=l28484 lab=VDD}
N 12840 8760 12860 8760 {}
C {lab_pin.sym} 12860 8760 0 0 {name=l28485 lab=VSS}
C {bitcell_6t.sym} 13000 8800 0 0 {name=Xr44c65}
N 12960 8840 12940 8840 {}
C {lab_pin.sym} 12940 8840 0 0 {name=l28486 lab=BL65}
N 12960 8800 12940 8800 {}
C {lab_pin.sym} 12940 8800 0 0 {name=l28487 lab=BLB65}
N 12960 8760 12940 8760 {}
C {lab_pin.sym} 12940 8760 0 0 {name=l28488 lab=WL44}
N 13040 8840 13060 8840 {}
C {lab_pin.sym} 13060 8840 0 0 {name=l28489 lab=VDD}
N 13040 8760 13060 8760 {}
C {lab_pin.sym} 13060 8760 0 0 {name=l28490 lab=VSS}
C {bitcell_6t.sym} 13200 8800 0 0 {name=Xr44c66}
N 13160 8840 13140 8840 {}
C {lab_pin.sym} 13140 8840 0 0 {name=l28491 lab=BL66}
N 13160 8800 13140 8800 {}
C {lab_pin.sym} 13140 8800 0 0 {name=l28492 lab=BLB66}
N 13160 8760 13140 8760 {}
C {lab_pin.sym} 13140 8760 0 0 {name=l28493 lab=WL44}
N 13240 8840 13260 8840 {}
C {lab_pin.sym} 13260 8840 0 0 {name=l28494 lab=VDD}
N 13240 8760 13260 8760 {}
C {lab_pin.sym} 13260 8760 0 0 {name=l28495 lab=VSS}
C {bitcell_6t.sym} 13400 8800 0 0 {name=Xr44c67}
N 13360 8840 13340 8840 {}
C {lab_pin.sym} 13340 8840 0 0 {name=l28496 lab=BL67}
N 13360 8800 13340 8800 {}
C {lab_pin.sym} 13340 8800 0 0 {name=l28497 lab=BLB67}
N 13360 8760 13340 8760 {}
C {lab_pin.sym} 13340 8760 0 0 {name=l28498 lab=WL44}
N 13440 8840 13460 8840 {}
C {lab_pin.sym} 13460 8840 0 0 {name=l28499 lab=VDD}
N 13440 8760 13460 8760 {}
C {lab_pin.sym} 13460 8760 0 0 {name=l28500 lab=VSS}
C {bitcell_6t.sym} 13600 8800 0 0 {name=Xr44c68}
N 13560 8840 13540 8840 {}
C {lab_pin.sym} 13540 8840 0 0 {name=l28501 lab=BL68}
N 13560 8800 13540 8800 {}
C {lab_pin.sym} 13540 8800 0 0 {name=l28502 lab=BLB68}
N 13560 8760 13540 8760 {}
C {lab_pin.sym} 13540 8760 0 0 {name=l28503 lab=WL44}
N 13640 8840 13660 8840 {}
C {lab_pin.sym} 13660 8840 0 0 {name=l28504 lab=VDD}
N 13640 8760 13660 8760 {}
C {lab_pin.sym} 13660 8760 0 0 {name=l28505 lab=VSS}
C {bitcell_6t.sym} 13800 8800 0 0 {name=Xr44c69}
N 13760 8840 13740 8840 {}
C {lab_pin.sym} 13740 8840 0 0 {name=l28506 lab=BL69}
N 13760 8800 13740 8800 {}
C {lab_pin.sym} 13740 8800 0 0 {name=l28507 lab=BLB69}
N 13760 8760 13740 8760 {}
C {lab_pin.sym} 13740 8760 0 0 {name=l28508 lab=WL44}
N 13840 8840 13860 8840 {}
C {lab_pin.sym} 13860 8840 0 0 {name=l28509 lab=VDD}
N 13840 8760 13860 8760 {}
C {lab_pin.sym} 13860 8760 0 0 {name=l28510 lab=VSS}
C {bitcell_6t.sym} 14000 8800 0 0 {name=Xr44c70}
N 13960 8840 13940 8840 {}
C {lab_pin.sym} 13940 8840 0 0 {name=l28511 lab=BL70}
N 13960 8800 13940 8800 {}
C {lab_pin.sym} 13940 8800 0 0 {name=l28512 lab=BLB70}
N 13960 8760 13940 8760 {}
C {lab_pin.sym} 13940 8760 0 0 {name=l28513 lab=WL44}
N 14040 8840 14060 8840 {}
C {lab_pin.sym} 14060 8840 0 0 {name=l28514 lab=VDD}
N 14040 8760 14060 8760 {}
C {lab_pin.sym} 14060 8760 0 0 {name=l28515 lab=VSS}
C {bitcell_6t.sym} 14200 8800 0 0 {name=Xr44c71}
N 14160 8840 14140 8840 {}
C {lab_pin.sym} 14140 8840 0 0 {name=l28516 lab=BL71}
N 14160 8800 14140 8800 {}
C {lab_pin.sym} 14140 8800 0 0 {name=l28517 lab=BLB71}
N 14160 8760 14140 8760 {}
C {lab_pin.sym} 14140 8760 0 0 {name=l28518 lab=WL44}
N 14240 8840 14260 8840 {}
C {lab_pin.sym} 14260 8840 0 0 {name=l28519 lab=VDD}
N 14240 8760 14260 8760 {}
C {lab_pin.sym} 14260 8760 0 0 {name=l28520 lab=VSS}
C {bitcell_6t.sym} 14400 8800 0 0 {name=Xr44c72}
N 14360 8840 14340 8840 {}
C {lab_pin.sym} 14340 8840 0 0 {name=l28521 lab=BL72}
N 14360 8800 14340 8800 {}
C {lab_pin.sym} 14340 8800 0 0 {name=l28522 lab=BLB72}
N 14360 8760 14340 8760 {}
C {lab_pin.sym} 14340 8760 0 0 {name=l28523 lab=WL44}
N 14440 8840 14460 8840 {}
C {lab_pin.sym} 14460 8840 0 0 {name=l28524 lab=VDD}
N 14440 8760 14460 8760 {}
C {lab_pin.sym} 14460 8760 0 0 {name=l28525 lab=VSS}
C {bitcell_6t.sym} 14600 8800 0 0 {name=Xr44c73}
N 14560 8840 14540 8840 {}
C {lab_pin.sym} 14540 8840 0 0 {name=l28526 lab=BL73}
N 14560 8800 14540 8800 {}
C {lab_pin.sym} 14540 8800 0 0 {name=l28527 lab=BLB73}
N 14560 8760 14540 8760 {}
C {lab_pin.sym} 14540 8760 0 0 {name=l28528 lab=WL44}
N 14640 8840 14660 8840 {}
C {lab_pin.sym} 14660 8840 0 0 {name=l28529 lab=VDD}
N 14640 8760 14660 8760 {}
C {lab_pin.sym} 14660 8760 0 0 {name=l28530 lab=VSS}
C {bitcell_6t.sym} 14800 8800 0 0 {name=Xr44c74}
N 14760 8840 14740 8840 {}
C {lab_pin.sym} 14740 8840 0 0 {name=l28531 lab=BL74}
N 14760 8800 14740 8800 {}
C {lab_pin.sym} 14740 8800 0 0 {name=l28532 lab=BLB74}
N 14760 8760 14740 8760 {}
C {lab_pin.sym} 14740 8760 0 0 {name=l28533 lab=WL44}
N 14840 8840 14860 8840 {}
C {lab_pin.sym} 14860 8840 0 0 {name=l28534 lab=VDD}
N 14840 8760 14860 8760 {}
C {lab_pin.sym} 14860 8760 0 0 {name=l28535 lab=VSS}
C {bitcell_6t.sym} 15000 8800 0 0 {name=Xr44c75}
N 14960 8840 14940 8840 {}
C {lab_pin.sym} 14940 8840 0 0 {name=l28536 lab=BL75}
N 14960 8800 14940 8800 {}
C {lab_pin.sym} 14940 8800 0 0 {name=l28537 lab=BLB75}
N 14960 8760 14940 8760 {}
C {lab_pin.sym} 14940 8760 0 0 {name=l28538 lab=WL44}
N 15040 8840 15060 8840 {}
C {lab_pin.sym} 15060 8840 0 0 {name=l28539 lab=VDD}
N 15040 8760 15060 8760 {}
C {lab_pin.sym} 15060 8760 0 0 {name=l28540 lab=VSS}
C {bitcell_6t.sym} 15200 8800 0 0 {name=Xr44c76}
N 15160 8840 15140 8840 {}
C {lab_pin.sym} 15140 8840 0 0 {name=l28541 lab=BL76}
N 15160 8800 15140 8800 {}
C {lab_pin.sym} 15140 8800 0 0 {name=l28542 lab=BLB76}
N 15160 8760 15140 8760 {}
C {lab_pin.sym} 15140 8760 0 0 {name=l28543 lab=WL44}
N 15240 8840 15260 8840 {}
C {lab_pin.sym} 15260 8840 0 0 {name=l28544 lab=VDD}
N 15240 8760 15260 8760 {}
C {lab_pin.sym} 15260 8760 0 0 {name=l28545 lab=VSS}
C {bitcell_6t.sym} 15400 8800 0 0 {name=Xr44c77}
N 15360 8840 15340 8840 {}
C {lab_pin.sym} 15340 8840 0 0 {name=l28546 lab=BL77}
N 15360 8800 15340 8800 {}
C {lab_pin.sym} 15340 8800 0 0 {name=l28547 lab=BLB77}
N 15360 8760 15340 8760 {}
C {lab_pin.sym} 15340 8760 0 0 {name=l28548 lab=WL44}
N 15440 8840 15460 8840 {}
C {lab_pin.sym} 15460 8840 0 0 {name=l28549 lab=VDD}
N 15440 8760 15460 8760 {}
C {lab_pin.sym} 15460 8760 0 0 {name=l28550 lab=VSS}
C {bitcell_6t.sym} 15600 8800 0 0 {name=Xr44c78}
N 15560 8840 15540 8840 {}
C {lab_pin.sym} 15540 8840 0 0 {name=l28551 lab=BL78}
N 15560 8800 15540 8800 {}
C {lab_pin.sym} 15540 8800 0 0 {name=l28552 lab=BLB78}
N 15560 8760 15540 8760 {}
C {lab_pin.sym} 15540 8760 0 0 {name=l28553 lab=WL44}
N 15640 8840 15660 8840 {}
C {lab_pin.sym} 15660 8840 0 0 {name=l28554 lab=VDD}
N 15640 8760 15660 8760 {}
C {lab_pin.sym} 15660 8760 0 0 {name=l28555 lab=VSS}
C {bitcell_6t.sym} 15800 8800 0 0 {name=Xr44c79}
N 15760 8840 15740 8840 {}
C {lab_pin.sym} 15740 8840 0 0 {name=l28556 lab=BL79}
N 15760 8800 15740 8800 {}
C {lab_pin.sym} 15740 8800 0 0 {name=l28557 lab=BLB79}
N 15760 8760 15740 8760 {}
C {lab_pin.sym} 15740 8760 0 0 {name=l28558 lab=WL44}
N 15840 8840 15860 8840 {}
C {lab_pin.sym} 15860 8840 0 0 {name=l28559 lab=VDD}
N 15840 8760 15860 8760 {}
C {lab_pin.sym} 15860 8760 0 0 {name=l28560 lab=VSS}
C {bitcell_6t.sym} 16000 8800 0 0 {name=Xr44c80}
N 15960 8840 15940 8840 {}
C {lab_pin.sym} 15940 8840 0 0 {name=l28561 lab=BL80}
N 15960 8800 15940 8800 {}
C {lab_pin.sym} 15940 8800 0 0 {name=l28562 lab=BLB80}
N 15960 8760 15940 8760 {}
C {lab_pin.sym} 15940 8760 0 0 {name=l28563 lab=WL44}
N 16040 8840 16060 8840 {}
C {lab_pin.sym} 16060 8840 0 0 {name=l28564 lab=VDD}
N 16040 8760 16060 8760 {}
C {lab_pin.sym} 16060 8760 0 0 {name=l28565 lab=VSS}
C {bitcell_6t.sym} 16200 8800 0 0 {name=Xr44c81}
N 16160 8840 16140 8840 {}
C {lab_pin.sym} 16140 8840 0 0 {name=l28566 lab=BL81}
N 16160 8800 16140 8800 {}
C {lab_pin.sym} 16140 8800 0 0 {name=l28567 lab=BLB81}
N 16160 8760 16140 8760 {}
C {lab_pin.sym} 16140 8760 0 0 {name=l28568 lab=WL44}
N 16240 8840 16260 8840 {}
C {lab_pin.sym} 16260 8840 0 0 {name=l28569 lab=VDD}
N 16240 8760 16260 8760 {}
C {lab_pin.sym} 16260 8760 0 0 {name=l28570 lab=VSS}
C {bitcell_6t.sym} 16400 8800 0 0 {name=Xr44c82}
N 16360 8840 16340 8840 {}
C {lab_pin.sym} 16340 8840 0 0 {name=l28571 lab=BL82}
N 16360 8800 16340 8800 {}
C {lab_pin.sym} 16340 8800 0 0 {name=l28572 lab=BLB82}
N 16360 8760 16340 8760 {}
C {lab_pin.sym} 16340 8760 0 0 {name=l28573 lab=WL44}
N 16440 8840 16460 8840 {}
C {lab_pin.sym} 16460 8840 0 0 {name=l28574 lab=VDD}
N 16440 8760 16460 8760 {}
C {lab_pin.sym} 16460 8760 0 0 {name=l28575 lab=VSS}
C {bitcell_6t.sym} 16600 8800 0 0 {name=Xr44c83}
N 16560 8840 16540 8840 {}
C {lab_pin.sym} 16540 8840 0 0 {name=l28576 lab=BL83}
N 16560 8800 16540 8800 {}
C {lab_pin.sym} 16540 8800 0 0 {name=l28577 lab=BLB83}
N 16560 8760 16540 8760 {}
C {lab_pin.sym} 16540 8760 0 0 {name=l28578 lab=WL44}
N 16640 8840 16660 8840 {}
C {lab_pin.sym} 16660 8840 0 0 {name=l28579 lab=VDD}
N 16640 8760 16660 8760 {}
C {lab_pin.sym} 16660 8760 0 0 {name=l28580 lab=VSS}
C {bitcell_6t.sym} 16800 8800 0 0 {name=Xr44c84}
N 16760 8840 16740 8840 {}
C {lab_pin.sym} 16740 8840 0 0 {name=l28581 lab=BL84}
N 16760 8800 16740 8800 {}
C {lab_pin.sym} 16740 8800 0 0 {name=l28582 lab=BLB84}
N 16760 8760 16740 8760 {}
C {lab_pin.sym} 16740 8760 0 0 {name=l28583 lab=WL44}
N 16840 8840 16860 8840 {}
C {lab_pin.sym} 16860 8840 0 0 {name=l28584 lab=VDD}
N 16840 8760 16860 8760 {}
C {lab_pin.sym} 16860 8760 0 0 {name=l28585 lab=VSS}
C {bitcell_6t.sym} 17000 8800 0 0 {name=Xr44c85}
N 16960 8840 16940 8840 {}
C {lab_pin.sym} 16940 8840 0 0 {name=l28586 lab=BL85}
N 16960 8800 16940 8800 {}
C {lab_pin.sym} 16940 8800 0 0 {name=l28587 lab=BLB85}
N 16960 8760 16940 8760 {}
C {lab_pin.sym} 16940 8760 0 0 {name=l28588 lab=WL44}
N 17040 8840 17060 8840 {}
C {lab_pin.sym} 17060 8840 0 0 {name=l28589 lab=VDD}
N 17040 8760 17060 8760 {}
C {lab_pin.sym} 17060 8760 0 0 {name=l28590 lab=VSS}
C {bitcell_6t.sym} 17200 8800 0 0 {name=Xr44c86}
N 17160 8840 17140 8840 {}
C {lab_pin.sym} 17140 8840 0 0 {name=l28591 lab=BL86}
N 17160 8800 17140 8800 {}
C {lab_pin.sym} 17140 8800 0 0 {name=l28592 lab=BLB86}
N 17160 8760 17140 8760 {}
C {lab_pin.sym} 17140 8760 0 0 {name=l28593 lab=WL44}
N 17240 8840 17260 8840 {}
C {lab_pin.sym} 17260 8840 0 0 {name=l28594 lab=VDD}
N 17240 8760 17260 8760 {}
C {lab_pin.sym} 17260 8760 0 0 {name=l28595 lab=VSS}
C {bitcell_6t.sym} 17400 8800 0 0 {name=Xr44c87}
N 17360 8840 17340 8840 {}
C {lab_pin.sym} 17340 8840 0 0 {name=l28596 lab=BL87}
N 17360 8800 17340 8800 {}
C {lab_pin.sym} 17340 8800 0 0 {name=l28597 lab=BLB87}
N 17360 8760 17340 8760 {}
C {lab_pin.sym} 17340 8760 0 0 {name=l28598 lab=WL44}
N 17440 8840 17460 8840 {}
C {lab_pin.sym} 17460 8840 0 0 {name=l28599 lab=VDD}
N 17440 8760 17460 8760 {}
C {lab_pin.sym} 17460 8760 0 0 {name=l28600 lab=VSS}
C {bitcell_6t.sym} 17600 8800 0 0 {name=Xr44c88}
N 17560 8840 17540 8840 {}
C {lab_pin.sym} 17540 8840 0 0 {name=l28601 lab=BL88}
N 17560 8800 17540 8800 {}
C {lab_pin.sym} 17540 8800 0 0 {name=l28602 lab=BLB88}
N 17560 8760 17540 8760 {}
C {lab_pin.sym} 17540 8760 0 0 {name=l28603 lab=WL44}
N 17640 8840 17660 8840 {}
C {lab_pin.sym} 17660 8840 0 0 {name=l28604 lab=VDD}
N 17640 8760 17660 8760 {}
C {lab_pin.sym} 17660 8760 0 0 {name=l28605 lab=VSS}
C {bitcell_6t.sym} 17800 8800 0 0 {name=Xr44c89}
N 17760 8840 17740 8840 {}
C {lab_pin.sym} 17740 8840 0 0 {name=l28606 lab=BL89}
N 17760 8800 17740 8800 {}
C {lab_pin.sym} 17740 8800 0 0 {name=l28607 lab=BLB89}
N 17760 8760 17740 8760 {}
C {lab_pin.sym} 17740 8760 0 0 {name=l28608 lab=WL44}
N 17840 8840 17860 8840 {}
C {lab_pin.sym} 17860 8840 0 0 {name=l28609 lab=VDD}
N 17840 8760 17860 8760 {}
C {lab_pin.sym} 17860 8760 0 0 {name=l28610 lab=VSS}
C {bitcell_6t.sym} 18000 8800 0 0 {name=Xr44c90}
N 17960 8840 17940 8840 {}
C {lab_pin.sym} 17940 8840 0 0 {name=l28611 lab=BL90}
N 17960 8800 17940 8800 {}
C {lab_pin.sym} 17940 8800 0 0 {name=l28612 lab=BLB90}
N 17960 8760 17940 8760 {}
C {lab_pin.sym} 17940 8760 0 0 {name=l28613 lab=WL44}
N 18040 8840 18060 8840 {}
C {lab_pin.sym} 18060 8840 0 0 {name=l28614 lab=VDD}
N 18040 8760 18060 8760 {}
C {lab_pin.sym} 18060 8760 0 0 {name=l28615 lab=VSS}
C {bitcell_6t.sym} 18200 8800 0 0 {name=Xr44c91}
N 18160 8840 18140 8840 {}
C {lab_pin.sym} 18140 8840 0 0 {name=l28616 lab=BL91}
N 18160 8800 18140 8800 {}
C {lab_pin.sym} 18140 8800 0 0 {name=l28617 lab=BLB91}
N 18160 8760 18140 8760 {}
C {lab_pin.sym} 18140 8760 0 0 {name=l28618 lab=WL44}
N 18240 8840 18260 8840 {}
C {lab_pin.sym} 18260 8840 0 0 {name=l28619 lab=VDD}
N 18240 8760 18260 8760 {}
C {lab_pin.sym} 18260 8760 0 0 {name=l28620 lab=VSS}
C {bitcell_6t.sym} 18400 8800 0 0 {name=Xr44c92}
N 18360 8840 18340 8840 {}
C {lab_pin.sym} 18340 8840 0 0 {name=l28621 lab=BL92}
N 18360 8800 18340 8800 {}
C {lab_pin.sym} 18340 8800 0 0 {name=l28622 lab=BLB92}
N 18360 8760 18340 8760 {}
C {lab_pin.sym} 18340 8760 0 0 {name=l28623 lab=WL44}
N 18440 8840 18460 8840 {}
C {lab_pin.sym} 18460 8840 0 0 {name=l28624 lab=VDD}
N 18440 8760 18460 8760 {}
C {lab_pin.sym} 18460 8760 0 0 {name=l28625 lab=VSS}
C {bitcell_6t.sym} 18600 8800 0 0 {name=Xr44c93}
N 18560 8840 18540 8840 {}
C {lab_pin.sym} 18540 8840 0 0 {name=l28626 lab=BL93}
N 18560 8800 18540 8800 {}
C {lab_pin.sym} 18540 8800 0 0 {name=l28627 lab=BLB93}
N 18560 8760 18540 8760 {}
C {lab_pin.sym} 18540 8760 0 0 {name=l28628 lab=WL44}
N 18640 8840 18660 8840 {}
C {lab_pin.sym} 18660 8840 0 0 {name=l28629 lab=VDD}
N 18640 8760 18660 8760 {}
C {lab_pin.sym} 18660 8760 0 0 {name=l28630 lab=VSS}
C {bitcell_6t.sym} 18800 8800 0 0 {name=Xr44c94}
N 18760 8840 18740 8840 {}
C {lab_pin.sym} 18740 8840 0 0 {name=l28631 lab=BL94}
N 18760 8800 18740 8800 {}
C {lab_pin.sym} 18740 8800 0 0 {name=l28632 lab=BLB94}
N 18760 8760 18740 8760 {}
C {lab_pin.sym} 18740 8760 0 0 {name=l28633 lab=WL44}
N 18840 8840 18860 8840 {}
C {lab_pin.sym} 18860 8840 0 0 {name=l28634 lab=VDD}
N 18840 8760 18860 8760 {}
C {lab_pin.sym} 18860 8760 0 0 {name=l28635 lab=VSS}
C {bitcell_6t.sym} 19000 8800 0 0 {name=Xr44c95}
N 18960 8840 18940 8840 {}
C {lab_pin.sym} 18940 8840 0 0 {name=l28636 lab=BL95}
N 18960 8800 18940 8800 {}
C {lab_pin.sym} 18940 8800 0 0 {name=l28637 lab=BLB95}
N 18960 8760 18940 8760 {}
C {lab_pin.sym} 18940 8760 0 0 {name=l28638 lab=WL44}
N 19040 8840 19060 8840 {}
C {lab_pin.sym} 19060 8840 0 0 {name=l28639 lab=VDD}
N 19040 8760 19060 8760 {}
C {lab_pin.sym} 19060 8760 0 0 {name=l28640 lab=VSS}
C {bitcell_6t.sym} 19200 8800 0 0 {name=Xr44c96}
N 19160 8840 19140 8840 {}
C {lab_pin.sym} 19140 8840 0 0 {name=l28641 lab=BL96}
N 19160 8800 19140 8800 {}
C {lab_pin.sym} 19140 8800 0 0 {name=l28642 lab=BLB96}
N 19160 8760 19140 8760 {}
C {lab_pin.sym} 19140 8760 0 0 {name=l28643 lab=WL44}
N 19240 8840 19260 8840 {}
C {lab_pin.sym} 19260 8840 0 0 {name=l28644 lab=VDD}
N 19240 8760 19260 8760 {}
C {lab_pin.sym} 19260 8760 0 0 {name=l28645 lab=VSS}
C {bitcell_6t.sym} 19400 8800 0 0 {name=Xr44c97}
N 19360 8840 19340 8840 {}
C {lab_pin.sym} 19340 8840 0 0 {name=l28646 lab=BL97}
N 19360 8800 19340 8800 {}
C {lab_pin.sym} 19340 8800 0 0 {name=l28647 lab=BLB97}
N 19360 8760 19340 8760 {}
C {lab_pin.sym} 19340 8760 0 0 {name=l28648 lab=WL44}
N 19440 8840 19460 8840 {}
C {lab_pin.sym} 19460 8840 0 0 {name=l28649 lab=VDD}
N 19440 8760 19460 8760 {}
C {lab_pin.sym} 19460 8760 0 0 {name=l28650 lab=VSS}
C {bitcell_6t.sym} 19600 8800 0 0 {name=Xr44c98}
N 19560 8840 19540 8840 {}
C {lab_pin.sym} 19540 8840 0 0 {name=l28651 lab=BL98}
N 19560 8800 19540 8800 {}
C {lab_pin.sym} 19540 8800 0 0 {name=l28652 lab=BLB98}
N 19560 8760 19540 8760 {}
C {lab_pin.sym} 19540 8760 0 0 {name=l28653 lab=WL44}
N 19640 8840 19660 8840 {}
C {lab_pin.sym} 19660 8840 0 0 {name=l28654 lab=VDD}
N 19640 8760 19660 8760 {}
C {lab_pin.sym} 19660 8760 0 0 {name=l28655 lab=VSS}
C {bitcell_6t.sym} 19800 8800 0 0 {name=Xr44c99}
N 19760 8840 19740 8840 {}
C {lab_pin.sym} 19740 8840 0 0 {name=l28656 lab=BL99}
N 19760 8800 19740 8800 {}
C {lab_pin.sym} 19740 8800 0 0 {name=l28657 lab=BLB99}
N 19760 8760 19740 8760 {}
C {lab_pin.sym} 19740 8760 0 0 {name=l28658 lab=WL44}
N 19840 8840 19860 8840 {}
C {lab_pin.sym} 19860 8840 0 0 {name=l28659 lab=VDD}
N 19840 8760 19860 8760 {}
C {lab_pin.sym} 19860 8760 0 0 {name=l28660 lab=VSS}
C {bitcell_6t.sym} 20000 8800 0 0 {name=Xr44c100}
N 19960 8840 19940 8840 {}
C {lab_pin.sym} 19940 8840 0 0 {name=l28661 lab=BL100}
N 19960 8800 19940 8800 {}
C {lab_pin.sym} 19940 8800 0 0 {name=l28662 lab=BLB100}
N 19960 8760 19940 8760 {}
C {lab_pin.sym} 19940 8760 0 0 {name=l28663 lab=WL44}
N 20040 8840 20060 8840 {}
C {lab_pin.sym} 20060 8840 0 0 {name=l28664 lab=VDD}
N 20040 8760 20060 8760 {}
C {lab_pin.sym} 20060 8760 0 0 {name=l28665 lab=VSS}
C {bitcell_6t.sym} 20200 8800 0 0 {name=Xr44c101}
N 20160 8840 20140 8840 {}
C {lab_pin.sym} 20140 8840 0 0 {name=l28666 lab=BL101}
N 20160 8800 20140 8800 {}
C {lab_pin.sym} 20140 8800 0 0 {name=l28667 lab=BLB101}
N 20160 8760 20140 8760 {}
C {lab_pin.sym} 20140 8760 0 0 {name=l28668 lab=WL44}
N 20240 8840 20260 8840 {}
C {lab_pin.sym} 20260 8840 0 0 {name=l28669 lab=VDD}
N 20240 8760 20260 8760 {}
C {lab_pin.sym} 20260 8760 0 0 {name=l28670 lab=VSS}
C {bitcell_6t.sym} 20400 8800 0 0 {name=Xr44c102}
N 20360 8840 20340 8840 {}
C {lab_pin.sym} 20340 8840 0 0 {name=l28671 lab=BL102}
N 20360 8800 20340 8800 {}
C {lab_pin.sym} 20340 8800 0 0 {name=l28672 lab=BLB102}
N 20360 8760 20340 8760 {}
C {lab_pin.sym} 20340 8760 0 0 {name=l28673 lab=WL44}
N 20440 8840 20460 8840 {}
C {lab_pin.sym} 20460 8840 0 0 {name=l28674 lab=VDD}
N 20440 8760 20460 8760 {}
C {lab_pin.sym} 20460 8760 0 0 {name=l28675 lab=VSS}
C {bitcell_6t.sym} 20600 8800 0 0 {name=Xr44c103}
N 20560 8840 20540 8840 {}
C {lab_pin.sym} 20540 8840 0 0 {name=l28676 lab=BL103}
N 20560 8800 20540 8800 {}
C {lab_pin.sym} 20540 8800 0 0 {name=l28677 lab=BLB103}
N 20560 8760 20540 8760 {}
C {lab_pin.sym} 20540 8760 0 0 {name=l28678 lab=WL44}
N 20640 8840 20660 8840 {}
C {lab_pin.sym} 20660 8840 0 0 {name=l28679 lab=VDD}
N 20640 8760 20660 8760 {}
C {lab_pin.sym} 20660 8760 0 0 {name=l28680 lab=VSS}
C {bitcell_6t.sym} 20800 8800 0 0 {name=Xr44c104}
N 20760 8840 20740 8840 {}
C {lab_pin.sym} 20740 8840 0 0 {name=l28681 lab=BL104}
N 20760 8800 20740 8800 {}
C {lab_pin.sym} 20740 8800 0 0 {name=l28682 lab=BLB104}
N 20760 8760 20740 8760 {}
C {lab_pin.sym} 20740 8760 0 0 {name=l28683 lab=WL44}
N 20840 8840 20860 8840 {}
C {lab_pin.sym} 20860 8840 0 0 {name=l28684 lab=VDD}
N 20840 8760 20860 8760 {}
C {lab_pin.sym} 20860 8760 0 0 {name=l28685 lab=VSS}
C {bitcell_6t.sym} 21000 8800 0 0 {name=Xr44c105}
N 20960 8840 20940 8840 {}
C {lab_pin.sym} 20940 8840 0 0 {name=l28686 lab=BL105}
N 20960 8800 20940 8800 {}
C {lab_pin.sym} 20940 8800 0 0 {name=l28687 lab=BLB105}
N 20960 8760 20940 8760 {}
C {lab_pin.sym} 20940 8760 0 0 {name=l28688 lab=WL44}
N 21040 8840 21060 8840 {}
C {lab_pin.sym} 21060 8840 0 0 {name=l28689 lab=VDD}
N 21040 8760 21060 8760 {}
C {lab_pin.sym} 21060 8760 0 0 {name=l28690 lab=VSS}
C {bitcell_6t.sym} 21200 8800 0 0 {name=Xr44c106}
N 21160 8840 21140 8840 {}
C {lab_pin.sym} 21140 8840 0 0 {name=l28691 lab=BL106}
N 21160 8800 21140 8800 {}
C {lab_pin.sym} 21140 8800 0 0 {name=l28692 lab=BLB106}
N 21160 8760 21140 8760 {}
C {lab_pin.sym} 21140 8760 0 0 {name=l28693 lab=WL44}
N 21240 8840 21260 8840 {}
C {lab_pin.sym} 21260 8840 0 0 {name=l28694 lab=VDD}
N 21240 8760 21260 8760 {}
C {lab_pin.sym} 21260 8760 0 0 {name=l28695 lab=VSS}
C {bitcell_6t.sym} 21400 8800 0 0 {name=Xr44c107}
N 21360 8840 21340 8840 {}
C {lab_pin.sym} 21340 8840 0 0 {name=l28696 lab=BL107}
N 21360 8800 21340 8800 {}
C {lab_pin.sym} 21340 8800 0 0 {name=l28697 lab=BLB107}
N 21360 8760 21340 8760 {}
C {lab_pin.sym} 21340 8760 0 0 {name=l28698 lab=WL44}
N 21440 8840 21460 8840 {}
C {lab_pin.sym} 21460 8840 0 0 {name=l28699 lab=VDD}
N 21440 8760 21460 8760 {}
C {lab_pin.sym} 21460 8760 0 0 {name=l28700 lab=VSS}
C {bitcell_6t.sym} 21600 8800 0 0 {name=Xr44c108}
N 21560 8840 21540 8840 {}
C {lab_pin.sym} 21540 8840 0 0 {name=l28701 lab=BL108}
N 21560 8800 21540 8800 {}
C {lab_pin.sym} 21540 8800 0 0 {name=l28702 lab=BLB108}
N 21560 8760 21540 8760 {}
C {lab_pin.sym} 21540 8760 0 0 {name=l28703 lab=WL44}
N 21640 8840 21660 8840 {}
C {lab_pin.sym} 21660 8840 0 0 {name=l28704 lab=VDD}
N 21640 8760 21660 8760 {}
C {lab_pin.sym} 21660 8760 0 0 {name=l28705 lab=VSS}
C {bitcell_6t.sym} 21800 8800 0 0 {name=Xr44c109}
N 21760 8840 21740 8840 {}
C {lab_pin.sym} 21740 8840 0 0 {name=l28706 lab=BL109}
N 21760 8800 21740 8800 {}
C {lab_pin.sym} 21740 8800 0 0 {name=l28707 lab=BLB109}
N 21760 8760 21740 8760 {}
C {lab_pin.sym} 21740 8760 0 0 {name=l28708 lab=WL44}
N 21840 8840 21860 8840 {}
C {lab_pin.sym} 21860 8840 0 0 {name=l28709 lab=VDD}
N 21840 8760 21860 8760 {}
C {lab_pin.sym} 21860 8760 0 0 {name=l28710 lab=VSS}
C {bitcell_6t.sym} 22000 8800 0 0 {name=Xr44c110}
N 21960 8840 21940 8840 {}
C {lab_pin.sym} 21940 8840 0 0 {name=l28711 lab=BL110}
N 21960 8800 21940 8800 {}
C {lab_pin.sym} 21940 8800 0 0 {name=l28712 lab=BLB110}
N 21960 8760 21940 8760 {}
C {lab_pin.sym} 21940 8760 0 0 {name=l28713 lab=WL44}
N 22040 8840 22060 8840 {}
C {lab_pin.sym} 22060 8840 0 0 {name=l28714 lab=VDD}
N 22040 8760 22060 8760 {}
C {lab_pin.sym} 22060 8760 0 0 {name=l28715 lab=VSS}
C {bitcell_6t.sym} 22200 8800 0 0 {name=Xr44c111}
N 22160 8840 22140 8840 {}
C {lab_pin.sym} 22140 8840 0 0 {name=l28716 lab=BL111}
N 22160 8800 22140 8800 {}
C {lab_pin.sym} 22140 8800 0 0 {name=l28717 lab=BLB111}
N 22160 8760 22140 8760 {}
C {lab_pin.sym} 22140 8760 0 0 {name=l28718 lab=WL44}
N 22240 8840 22260 8840 {}
C {lab_pin.sym} 22260 8840 0 0 {name=l28719 lab=VDD}
N 22240 8760 22260 8760 {}
C {lab_pin.sym} 22260 8760 0 0 {name=l28720 lab=VSS}
C {bitcell_6t.sym} 22400 8800 0 0 {name=Xr44c112}
N 22360 8840 22340 8840 {}
C {lab_pin.sym} 22340 8840 0 0 {name=l28721 lab=BL112}
N 22360 8800 22340 8800 {}
C {lab_pin.sym} 22340 8800 0 0 {name=l28722 lab=BLB112}
N 22360 8760 22340 8760 {}
C {lab_pin.sym} 22340 8760 0 0 {name=l28723 lab=WL44}
N 22440 8840 22460 8840 {}
C {lab_pin.sym} 22460 8840 0 0 {name=l28724 lab=VDD}
N 22440 8760 22460 8760 {}
C {lab_pin.sym} 22460 8760 0 0 {name=l28725 lab=VSS}
C {bitcell_6t.sym} 22600 8800 0 0 {name=Xr44c113}
N 22560 8840 22540 8840 {}
C {lab_pin.sym} 22540 8840 0 0 {name=l28726 lab=BL113}
N 22560 8800 22540 8800 {}
C {lab_pin.sym} 22540 8800 0 0 {name=l28727 lab=BLB113}
N 22560 8760 22540 8760 {}
C {lab_pin.sym} 22540 8760 0 0 {name=l28728 lab=WL44}
N 22640 8840 22660 8840 {}
C {lab_pin.sym} 22660 8840 0 0 {name=l28729 lab=VDD}
N 22640 8760 22660 8760 {}
C {lab_pin.sym} 22660 8760 0 0 {name=l28730 lab=VSS}
C {bitcell_6t.sym} 22800 8800 0 0 {name=Xr44c114}
N 22760 8840 22740 8840 {}
C {lab_pin.sym} 22740 8840 0 0 {name=l28731 lab=BL114}
N 22760 8800 22740 8800 {}
C {lab_pin.sym} 22740 8800 0 0 {name=l28732 lab=BLB114}
N 22760 8760 22740 8760 {}
C {lab_pin.sym} 22740 8760 0 0 {name=l28733 lab=WL44}
N 22840 8840 22860 8840 {}
C {lab_pin.sym} 22860 8840 0 0 {name=l28734 lab=VDD}
N 22840 8760 22860 8760 {}
C {lab_pin.sym} 22860 8760 0 0 {name=l28735 lab=VSS}
C {bitcell_6t.sym} 23000 8800 0 0 {name=Xr44c115}
N 22960 8840 22940 8840 {}
C {lab_pin.sym} 22940 8840 0 0 {name=l28736 lab=BL115}
N 22960 8800 22940 8800 {}
C {lab_pin.sym} 22940 8800 0 0 {name=l28737 lab=BLB115}
N 22960 8760 22940 8760 {}
C {lab_pin.sym} 22940 8760 0 0 {name=l28738 lab=WL44}
N 23040 8840 23060 8840 {}
C {lab_pin.sym} 23060 8840 0 0 {name=l28739 lab=VDD}
N 23040 8760 23060 8760 {}
C {lab_pin.sym} 23060 8760 0 0 {name=l28740 lab=VSS}
C {bitcell_6t.sym} 23200 8800 0 0 {name=Xr44c116}
N 23160 8840 23140 8840 {}
C {lab_pin.sym} 23140 8840 0 0 {name=l28741 lab=BL116}
N 23160 8800 23140 8800 {}
C {lab_pin.sym} 23140 8800 0 0 {name=l28742 lab=BLB116}
N 23160 8760 23140 8760 {}
C {lab_pin.sym} 23140 8760 0 0 {name=l28743 lab=WL44}
N 23240 8840 23260 8840 {}
C {lab_pin.sym} 23260 8840 0 0 {name=l28744 lab=VDD}
N 23240 8760 23260 8760 {}
C {lab_pin.sym} 23260 8760 0 0 {name=l28745 lab=VSS}
C {bitcell_6t.sym} 23400 8800 0 0 {name=Xr44c117}
N 23360 8840 23340 8840 {}
C {lab_pin.sym} 23340 8840 0 0 {name=l28746 lab=BL117}
N 23360 8800 23340 8800 {}
C {lab_pin.sym} 23340 8800 0 0 {name=l28747 lab=BLB117}
N 23360 8760 23340 8760 {}
C {lab_pin.sym} 23340 8760 0 0 {name=l28748 lab=WL44}
N 23440 8840 23460 8840 {}
C {lab_pin.sym} 23460 8840 0 0 {name=l28749 lab=VDD}
N 23440 8760 23460 8760 {}
C {lab_pin.sym} 23460 8760 0 0 {name=l28750 lab=VSS}
C {bitcell_6t.sym} 23600 8800 0 0 {name=Xr44c118}
N 23560 8840 23540 8840 {}
C {lab_pin.sym} 23540 8840 0 0 {name=l28751 lab=BL118}
N 23560 8800 23540 8800 {}
C {lab_pin.sym} 23540 8800 0 0 {name=l28752 lab=BLB118}
N 23560 8760 23540 8760 {}
C {lab_pin.sym} 23540 8760 0 0 {name=l28753 lab=WL44}
N 23640 8840 23660 8840 {}
C {lab_pin.sym} 23660 8840 0 0 {name=l28754 lab=VDD}
N 23640 8760 23660 8760 {}
C {lab_pin.sym} 23660 8760 0 0 {name=l28755 lab=VSS}
C {bitcell_6t.sym} 23800 8800 0 0 {name=Xr44c119}
N 23760 8840 23740 8840 {}
C {lab_pin.sym} 23740 8840 0 0 {name=l28756 lab=BL119}
N 23760 8800 23740 8800 {}
C {lab_pin.sym} 23740 8800 0 0 {name=l28757 lab=BLB119}
N 23760 8760 23740 8760 {}
C {lab_pin.sym} 23740 8760 0 0 {name=l28758 lab=WL44}
N 23840 8840 23860 8840 {}
C {lab_pin.sym} 23860 8840 0 0 {name=l28759 lab=VDD}
N 23840 8760 23860 8760 {}
C {lab_pin.sym} 23860 8760 0 0 {name=l28760 lab=VSS}
C {bitcell_6t.sym} 24000 8800 0 0 {name=Xr44c120}
N 23960 8840 23940 8840 {}
C {lab_pin.sym} 23940 8840 0 0 {name=l28761 lab=BL120}
N 23960 8800 23940 8800 {}
C {lab_pin.sym} 23940 8800 0 0 {name=l28762 lab=BLB120}
N 23960 8760 23940 8760 {}
C {lab_pin.sym} 23940 8760 0 0 {name=l28763 lab=WL44}
N 24040 8840 24060 8840 {}
C {lab_pin.sym} 24060 8840 0 0 {name=l28764 lab=VDD}
N 24040 8760 24060 8760 {}
C {lab_pin.sym} 24060 8760 0 0 {name=l28765 lab=VSS}
C {bitcell_6t.sym} 24200 8800 0 0 {name=Xr44c121}
N 24160 8840 24140 8840 {}
C {lab_pin.sym} 24140 8840 0 0 {name=l28766 lab=BL121}
N 24160 8800 24140 8800 {}
C {lab_pin.sym} 24140 8800 0 0 {name=l28767 lab=BLB121}
N 24160 8760 24140 8760 {}
C {lab_pin.sym} 24140 8760 0 0 {name=l28768 lab=WL44}
N 24240 8840 24260 8840 {}
C {lab_pin.sym} 24260 8840 0 0 {name=l28769 lab=VDD}
N 24240 8760 24260 8760 {}
C {lab_pin.sym} 24260 8760 0 0 {name=l28770 lab=VSS}
C {bitcell_6t.sym} 24400 8800 0 0 {name=Xr44c122}
N 24360 8840 24340 8840 {}
C {lab_pin.sym} 24340 8840 0 0 {name=l28771 lab=BL122}
N 24360 8800 24340 8800 {}
C {lab_pin.sym} 24340 8800 0 0 {name=l28772 lab=BLB122}
N 24360 8760 24340 8760 {}
C {lab_pin.sym} 24340 8760 0 0 {name=l28773 lab=WL44}
N 24440 8840 24460 8840 {}
C {lab_pin.sym} 24460 8840 0 0 {name=l28774 lab=VDD}
N 24440 8760 24460 8760 {}
C {lab_pin.sym} 24460 8760 0 0 {name=l28775 lab=VSS}
C {bitcell_6t.sym} 24600 8800 0 0 {name=Xr44c123}
N 24560 8840 24540 8840 {}
C {lab_pin.sym} 24540 8840 0 0 {name=l28776 lab=BL123}
N 24560 8800 24540 8800 {}
C {lab_pin.sym} 24540 8800 0 0 {name=l28777 lab=BLB123}
N 24560 8760 24540 8760 {}
C {lab_pin.sym} 24540 8760 0 0 {name=l28778 lab=WL44}
N 24640 8840 24660 8840 {}
C {lab_pin.sym} 24660 8840 0 0 {name=l28779 lab=VDD}
N 24640 8760 24660 8760 {}
C {lab_pin.sym} 24660 8760 0 0 {name=l28780 lab=VSS}
C {bitcell_6t.sym} 24800 8800 0 0 {name=Xr44c124}
N 24760 8840 24740 8840 {}
C {lab_pin.sym} 24740 8840 0 0 {name=l28781 lab=BL124}
N 24760 8800 24740 8800 {}
C {lab_pin.sym} 24740 8800 0 0 {name=l28782 lab=BLB124}
N 24760 8760 24740 8760 {}
C {lab_pin.sym} 24740 8760 0 0 {name=l28783 lab=WL44}
N 24840 8840 24860 8840 {}
C {lab_pin.sym} 24860 8840 0 0 {name=l28784 lab=VDD}
N 24840 8760 24860 8760 {}
C {lab_pin.sym} 24860 8760 0 0 {name=l28785 lab=VSS}
C {bitcell_6t.sym} 25000 8800 0 0 {name=Xr44c125}
N 24960 8840 24940 8840 {}
C {lab_pin.sym} 24940 8840 0 0 {name=l28786 lab=BL125}
N 24960 8800 24940 8800 {}
C {lab_pin.sym} 24940 8800 0 0 {name=l28787 lab=BLB125}
N 24960 8760 24940 8760 {}
C {lab_pin.sym} 24940 8760 0 0 {name=l28788 lab=WL44}
N 25040 8840 25060 8840 {}
C {lab_pin.sym} 25060 8840 0 0 {name=l28789 lab=VDD}
N 25040 8760 25060 8760 {}
C {lab_pin.sym} 25060 8760 0 0 {name=l28790 lab=VSS}
C {bitcell_6t.sym} 25200 8800 0 0 {name=Xr44c126}
N 25160 8840 25140 8840 {}
C {lab_pin.sym} 25140 8840 0 0 {name=l28791 lab=BL126}
N 25160 8800 25140 8800 {}
C {lab_pin.sym} 25140 8800 0 0 {name=l28792 lab=BLB126}
N 25160 8760 25140 8760 {}
C {lab_pin.sym} 25140 8760 0 0 {name=l28793 lab=WL44}
N 25240 8840 25260 8840 {}
C {lab_pin.sym} 25260 8840 0 0 {name=l28794 lab=VDD}
N 25240 8760 25260 8760 {}
C {lab_pin.sym} 25260 8760 0 0 {name=l28795 lab=VSS}
C {bitcell_6t.sym} 25400 8800 0 0 {name=Xr44c127}
N 25360 8840 25340 8840 {}
C {lab_pin.sym} 25340 8840 0 0 {name=l28796 lab=BL127}
N 25360 8800 25340 8800 {}
C {lab_pin.sym} 25340 8800 0 0 {name=l28797 lab=BLB127}
N 25360 8760 25340 8760 {}
C {lab_pin.sym} 25340 8760 0 0 {name=l28798 lab=WL44}
N 25440 8840 25460 8840 {}
C {lab_pin.sym} 25460 8840 0 0 {name=l28799 lab=VDD}
N 25440 8760 25460 8760 {}
C {lab_pin.sym} 25460 8760 0 0 {name=l28800 lab=VSS}
C {bitcell_6t.sym} 0 9000 0 0 {name=Xr45c0}
N -40 9040 -60 9040 {}
C {lab_pin.sym} -60 9040 0 0 {name=l28801 lab=BL0}
N -40 9000 -60 9000 {}
C {lab_pin.sym} -60 9000 0 0 {name=l28802 lab=BLB0}
N -40 8960 -60 8960 {}
C {lab_pin.sym} -60 8960 0 0 {name=l28803 lab=WL45}
N 40 9040 60 9040 {}
C {lab_pin.sym} 60 9040 0 0 {name=l28804 lab=VDD}
N 40 8960 60 8960 {}
C {lab_pin.sym} 60 8960 0 0 {name=l28805 lab=VSS}
C {bitcell_6t.sym} 200 9000 0 0 {name=Xr45c1}
N 160 9040 140 9040 {}
C {lab_pin.sym} 140 9040 0 0 {name=l28806 lab=BL1}
N 160 9000 140 9000 {}
C {lab_pin.sym} 140 9000 0 0 {name=l28807 lab=BLB1}
N 160 8960 140 8960 {}
C {lab_pin.sym} 140 8960 0 0 {name=l28808 lab=WL45}
N 240 9040 260 9040 {}
C {lab_pin.sym} 260 9040 0 0 {name=l28809 lab=VDD}
N 240 8960 260 8960 {}
C {lab_pin.sym} 260 8960 0 0 {name=l28810 lab=VSS}
C {bitcell_6t.sym} 400 9000 0 0 {name=Xr45c2}
N 360 9040 340 9040 {}
C {lab_pin.sym} 340 9040 0 0 {name=l28811 lab=BL2}
N 360 9000 340 9000 {}
C {lab_pin.sym} 340 9000 0 0 {name=l28812 lab=BLB2}
N 360 8960 340 8960 {}
C {lab_pin.sym} 340 8960 0 0 {name=l28813 lab=WL45}
N 440 9040 460 9040 {}
C {lab_pin.sym} 460 9040 0 0 {name=l28814 lab=VDD}
N 440 8960 460 8960 {}
C {lab_pin.sym} 460 8960 0 0 {name=l28815 lab=VSS}
C {bitcell_6t.sym} 600 9000 0 0 {name=Xr45c3}
N 560 9040 540 9040 {}
C {lab_pin.sym} 540 9040 0 0 {name=l28816 lab=BL3}
N 560 9000 540 9000 {}
C {lab_pin.sym} 540 9000 0 0 {name=l28817 lab=BLB3}
N 560 8960 540 8960 {}
C {lab_pin.sym} 540 8960 0 0 {name=l28818 lab=WL45}
N 640 9040 660 9040 {}
C {lab_pin.sym} 660 9040 0 0 {name=l28819 lab=VDD}
N 640 8960 660 8960 {}
C {lab_pin.sym} 660 8960 0 0 {name=l28820 lab=VSS}
C {bitcell_6t.sym} 800 9000 0 0 {name=Xr45c4}
N 760 9040 740 9040 {}
C {lab_pin.sym} 740 9040 0 0 {name=l28821 lab=BL4}
N 760 9000 740 9000 {}
C {lab_pin.sym} 740 9000 0 0 {name=l28822 lab=BLB4}
N 760 8960 740 8960 {}
C {lab_pin.sym} 740 8960 0 0 {name=l28823 lab=WL45}
N 840 9040 860 9040 {}
C {lab_pin.sym} 860 9040 0 0 {name=l28824 lab=VDD}
N 840 8960 860 8960 {}
C {lab_pin.sym} 860 8960 0 0 {name=l28825 lab=VSS}
C {bitcell_6t.sym} 1000 9000 0 0 {name=Xr45c5}
N 960 9040 940 9040 {}
C {lab_pin.sym} 940 9040 0 0 {name=l28826 lab=BL5}
N 960 9000 940 9000 {}
C {lab_pin.sym} 940 9000 0 0 {name=l28827 lab=BLB5}
N 960 8960 940 8960 {}
C {lab_pin.sym} 940 8960 0 0 {name=l28828 lab=WL45}
N 1040 9040 1060 9040 {}
C {lab_pin.sym} 1060 9040 0 0 {name=l28829 lab=VDD}
N 1040 8960 1060 8960 {}
C {lab_pin.sym} 1060 8960 0 0 {name=l28830 lab=VSS}
C {bitcell_6t.sym} 1200 9000 0 0 {name=Xr45c6}
N 1160 9040 1140 9040 {}
C {lab_pin.sym} 1140 9040 0 0 {name=l28831 lab=BL6}
N 1160 9000 1140 9000 {}
C {lab_pin.sym} 1140 9000 0 0 {name=l28832 lab=BLB6}
N 1160 8960 1140 8960 {}
C {lab_pin.sym} 1140 8960 0 0 {name=l28833 lab=WL45}
N 1240 9040 1260 9040 {}
C {lab_pin.sym} 1260 9040 0 0 {name=l28834 lab=VDD}
N 1240 8960 1260 8960 {}
C {lab_pin.sym} 1260 8960 0 0 {name=l28835 lab=VSS}
C {bitcell_6t.sym} 1400 9000 0 0 {name=Xr45c7}
N 1360 9040 1340 9040 {}
C {lab_pin.sym} 1340 9040 0 0 {name=l28836 lab=BL7}
N 1360 9000 1340 9000 {}
C {lab_pin.sym} 1340 9000 0 0 {name=l28837 lab=BLB7}
N 1360 8960 1340 8960 {}
C {lab_pin.sym} 1340 8960 0 0 {name=l28838 lab=WL45}
N 1440 9040 1460 9040 {}
C {lab_pin.sym} 1460 9040 0 0 {name=l28839 lab=VDD}
N 1440 8960 1460 8960 {}
C {lab_pin.sym} 1460 8960 0 0 {name=l28840 lab=VSS}
C {bitcell_6t.sym} 1600 9000 0 0 {name=Xr45c8}
N 1560 9040 1540 9040 {}
C {lab_pin.sym} 1540 9040 0 0 {name=l28841 lab=BL8}
N 1560 9000 1540 9000 {}
C {lab_pin.sym} 1540 9000 0 0 {name=l28842 lab=BLB8}
N 1560 8960 1540 8960 {}
C {lab_pin.sym} 1540 8960 0 0 {name=l28843 lab=WL45}
N 1640 9040 1660 9040 {}
C {lab_pin.sym} 1660 9040 0 0 {name=l28844 lab=VDD}
N 1640 8960 1660 8960 {}
C {lab_pin.sym} 1660 8960 0 0 {name=l28845 lab=VSS}
C {bitcell_6t.sym} 1800 9000 0 0 {name=Xr45c9}
N 1760 9040 1740 9040 {}
C {lab_pin.sym} 1740 9040 0 0 {name=l28846 lab=BL9}
N 1760 9000 1740 9000 {}
C {lab_pin.sym} 1740 9000 0 0 {name=l28847 lab=BLB9}
N 1760 8960 1740 8960 {}
C {lab_pin.sym} 1740 8960 0 0 {name=l28848 lab=WL45}
N 1840 9040 1860 9040 {}
C {lab_pin.sym} 1860 9040 0 0 {name=l28849 lab=VDD}
N 1840 8960 1860 8960 {}
C {lab_pin.sym} 1860 8960 0 0 {name=l28850 lab=VSS}
C {bitcell_6t.sym} 2000 9000 0 0 {name=Xr45c10}
N 1960 9040 1940 9040 {}
C {lab_pin.sym} 1940 9040 0 0 {name=l28851 lab=BL10}
N 1960 9000 1940 9000 {}
C {lab_pin.sym} 1940 9000 0 0 {name=l28852 lab=BLB10}
N 1960 8960 1940 8960 {}
C {lab_pin.sym} 1940 8960 0 0 {name=l28853 lab=WL45}
N 2040 9040 2060 9040 {}
C {lab_pin.sym} 2060 9040 0 0 {name=l28854 lab=VDD}
N 2040 8960 2060 8960 {}
C {lab_pin.sym} 2060 8960 0 0 {name=l28855 lab=VSS}
C {bitcell_6t.sym} 2200 9000 0 0 {name=Xr45c11}
N 2160 9040 2140 9040 {}
C {lab_pin.sym} 2140 9040 0 0 {name=l28856 lab=BL11}
N 2160 9000 2140 9000 {}
C {lab_pin.sym} 2140 9000 0 0 {name=l28857 lab=BLB11}
N 2160 8960 2140 8960 {}
C {lab_pin.sym} 2140 8960 0 0 {name=l28858 lab=WL45}
N 2240 9040 2260 9040 {}
C {lab_pin.sym} 2260 9040 0 0 {name=l28859 lab=VDD}
N 2240 8960 2260 8960 {}
C {lab_pin.sym} 2260 8960 0 0 {name=l28860 lab=VSS}
C {bitcell_6t.sym} 2400 9000 0 0 {name=Xr45c12}
N 2360 9040 2340 9040 {}
C {lab_pin.sym} 2340 9040 0 0 {name=l28861 lab=BL12}
N 2360 9000 2340 9000 {}
C {lab_pin.sym} 2340 9000 0 0 {name=l28862 lab=BLB12}
N 2360 8960 2340 8960 {}
C {lab_pin.sym} 2340 8960 0 0 {name=l28863 lab=WL45}
N 2440 9040 2460 9040 {}
C {lab_pin.sym} 2460 9040 0 0 {name=l28864 lab=VDD}
N 2440 8960 2460 8960 {}
C {lab_pin.sym} 2460 8960 0 0 {name=l28865 lab=VSS}
C {bitcell_6t.sym} 2600 9000 0 0 {name=Xr45c13}
N 2560 9040 2540 9040 {}
C {lab_pin.sym} 2540 9040 0 0 {name=l28866 lab=BL13}
N 2560 9000 2540 9000 {}
C {lab_pin.sym} 2540 9000 0 0 {name=l28867 lab=BLB13}
N 2560 8960 2540 8960 {}
C {lab_pin.sym} 2540 8960 0 0 {name=l28868 lab=WL45}
N 2640 9040 2660 9040 {}
C {lab_pin.sym} 2660 9040 0 0 {name=l28869 lab=VDD}
N 2640 8960 2660 8960 {}
C {lab_pin.sym} 2660 8960 0 0 {name=l28870 lab=VSS}
C {bitcell_6t.sym} 2800 9000 0 0 {name=Xr45c14}
N 2760 9040 2740 9040 {}
C {lab_pin.sym} 2740 9040 0 0 {name=l28871 lab=BL14}
N 2760 9000 2740 9000 {}
C {lab_pin.sym} 2740 9000 0 0 {name=l28872 lab=BLB14}
N 2760 8960 2740 8960 {}
C {lab_pin.sym} 2740 8960 0 0 {name=l28873 lab=WL45}
N 2840 9040 2860 9040 {}
C {lab_pin.sym} 2860 9040 0 0 {name=l28874 lab=VDD}
N 2840 8960 2860 8960 {}
C {lab_pin.sym} 2860 8960 0 0 {name=l28875 lab=VSS}
C {bitcell_6t.sym} 3000 9000 0 0 {name=Xr45c15}
N 2960 9040 2940 9040 {}
C {lab_pin.sym} 2940 9040 0 0 {name=l28876 lab=BL15}
N 2960 9000 2940 9000 {}
C {lab_pin.sym} 2940 9000 0 0 {name=l28877 lab=BLB15}
N 2960 8960 2940 8960 {}
C {lab_pin.sym} 2940 8960 0 0 {name=l28878 lab=WL45}
N 3040 9040 3060 9040 {}
C {lab_pin.sym} 3060 9040 0 0 {name=l28879 lab=VDD}
N 3040 8960 3060 8960 {}
C {lab_pin.sym} 3060 8960 0 0 {name=l28880 lab=VSS}
C {bitcell_6t.sym} 3200 9000 0 0 {name=Xr45c16}
N 3160 9040 3140 9040 {}
C {lab_pin.sym} 3140 9040 0 0 {name=l28881 lab=BL16}
N 3160 9000 3140 9000 {}
C {lab_pin.sym} 3140 9000 0 0 {name=l28882 lab=BLB16}
N 3160 8960 3140 8960 {}
C {lab_pin.sym} 3140 8960 0 0 {name=l28883 lab=WL45}
N 3240 9040 3260 9040 {}
C {lab_pin.sym} 3260 9040 0 0 {name=l28884 lab=VDD}
N 3240 8960 3260 8960 {}
C {lab_pin.sym} 3260 8960 0 0 {name=l28885 lab=VSS}
C {bitcell_6t.sym} 3400 9000 0 0 {name=Xr45c17}
N 3360 9040 3340 9040 {}
C {lab_pin.sym} 3340 9040 0 0 {name=l28886 lab=BL17}
N 3360 9000 3340 9000 {}
C {lab_pin.sym} 3340 9000 0 0 {name=l28887 lab=BLB17}
N 3360 8960 3340 8960 {}
C {lab_pin.sym} 3340 8960 0 0 {name=l28888 lab=WL45}
N 3440 9040 3460 9040 {}
C {lab_pin.sym} 3460 9040 0 0 {name=l28889 lab=VDD}
N 3440 8960 3460 8960 {}
C {lab_pin.sym} 3460 8960 0 0 {name=l28890 lab=VSS}
C {bitcell_6t.sym} 3600 9000 0 0 {name=Xr45c18}
N 3560 9040 3540 9040 {}
C {lab_pin.sym} 3540 9040 0 0 {name=l28891 lab=BL18}
N 3560 9000 3540 9000 {}
C {lab_pin.sym} 3540 9000 0 0 {name=l28892 lab=BLB18}
N 3560 8960 3540 8960 {}
C {lab_pin.sym} 3540 8960 0 0 {name=l28893 lab=WL45}
N 3640 9040 3660 9040 {}
C {lab_pin.sym} 3660 9040 0 0 {name=l28894 lab=VDD}
N 3640 8960 3660 8960 {}
C {lab_pin.sym} 3660 8960 0 0 {name=l28895 lab=VSS}
C {bitcell_6t.sym} 3800 9000 0 0 {name=Xr45c19}
N 3760 9040 3740 9040 {}
C {lab_pin.sym} 3740 9040 0 0 {name=l28896 lab=BL19}
N 3760 9000 3740 9000 {}
C {lab_pin.sym} 3740 9000 0 0 {name=l28897 lab=BLB19}
N 3760 8960 3740 8960 {}
C {lab_pin.sym} 3740 8960 0 0 {name=l28898 lab=WL45}
N 3840 9040 3860 9040 {}
C {lab_pin.sym} 3860 9040 0 0 {name=l28899 lab=VDD}
N 3840 8960 3860 8960 {}
C {lab_pin.sym} 3860 8960 0 0 {name=l28900 lab=VSS}
C {bitcell_6t.sym} 4000 9000 0 0 {name=Xr45c20}
N 3960 9040 3940 9040 {}
C {lab_pin.sym} 3940 9040 0 0 {name=l28901 lab=BL20}
N 3960 9000 3940 9000 {}
C {lab_pin.sym} 3940 9000 0 0 {name=l28902 lab=BLB20}
N 3960 8960 3940 8960 {}
C {lab_pin.sym} 3940 8960 0 0 {name=l28903 lab=WL45}
N 4040 9040 4060 9040 {}
C {lab_pin.sym} 4060 9040 0 0 {name=l28904 lab=VDD}
N 4040 8960 4060 8960 {}
C {lab_pin.sym} 4060 8960 0 0 {name=l28905 lab=VSS}
C {bitcell_6t.sym} 4200 9000 0 0 {name=Xr45c21}
N 4160 9040 4140 9040 {}
C {lab_pin.sym} 4140 9040 0 0 {name=l28906 lab=BL21}
N 4160 9000 4140 9000 {}
C {lab_pin.sym} 4140 9000 0 0 {name=l28907 lab=BLB21}
N 4160 8960 4140 8960 {}
C {lab_pin.sym} 4140 8960 0 0 {name=l28908 lab=WL45}
N 4240 9040 4260 9040 {}
C {lab_pin.sym} 4260 9040 0 0 {name=l28909 lab=VDD}
N 4240 8960 4260 8960 {}
C {lab_pin.sym} 4260 8960 0 0 {name=l28910 lab=VSS}
C {bitcell_6t.sym} 4400 9000 0 0 {name=Xr45c22}
N 4360 9040 4340 9040 {}
C {lab_pin.sym} 4340 9040 0 0 {name=l28911 lab=BL22}
N 4360 9000 4340 9000 {}
C {lab_pin.sym} 4340 9000 0 0 {name=l28912 lab=BLB22}
N 4360 8960 4340 8960 {}
C {lab_pin.sym} 4340 8960 0 0 {name=l28913 lab=WL45}
N 4440 9040 4460 9040 {}
C {lab_pin.sym} 4460 9040 0 0 {name=l28914 lab=VDD}
N 4440 8960 4460 8960 {}
C {lab_pin.sym} 4460 8960 0 0 {name=l28915 lab=VSS}
C {bitcell_6t.sym} 4600 9000 0 0 {name=Xr45c23}
N 4560 9040 4540 9040 {}
C {lab_pin.sym} 4540 9040 0 0 {name=l28916 lab=BL23}
N 4560 9000 4540 9000 {}
C {lab_pin.sym} 4540 9000 0 0 {name=l28917 lab=BLB23}
N 4560 8960 4540 8960 {}
C {lab_pin.sym} 4540 8960 0 0 {name=l28918 lab=WL45}
N 4640 9040 4660 9040 {}
C {lab_pin.sym} 4660 9040 0 0 {name=l28919 lab=VDD}
N 4640 8960 4660 8960 {}
C {lab_pin.sym} 4660 8960 0 0 {name=l28920 lab=VSS}
C {bitcell_6t.sym} 4800 9000 0 0 {name=Xr45c24}
N 4760 9040 4740 9040 {}
C {lab_pin.sym} 4740 9040 0 0 {name=l28921 lab=BL24}
N 4760 9000 4740 9000 {}
C {lab_pin.sym} 4740 9000 0 0 {name=l28922 lab=BLB24}
N 4760 8960 4740 8960 {}
C {lab_pin.sym} 4740 8960 0 0 {name=l28923 lab=WL45}
N 4840 9040 4860 9040 {}
C {lab_pin.sym} 4860 9040 0 0 {name=l28924 lab=VDD}
N 4840 8960 4860 8960 {}
C {lab_pin.sym} 4860 8960 0 0 {name=l28925 lab=VSS}
C {bitcell_6t.sym} 5000 9000 0 0 {name=Xr45c25}
N 4960 9040 4940 9040 {}
C {lab_pin.sym} 4940 9040 0 0 {name=l28926 lab=BL25}
N 4960 9000 4940 9000 {}
C {lab_pin.sym} 4940 9000 0 0 {name=l28927 lab=BLB25}
N 4960 8960 4940 8960 {}
C {lab_pin.sym} 4940 8960 0 0 {name=l28928 lab=WL45}
N 5040 9040 5060 9040 {}
C {lab_pin.sym} 5060 9040 0 0 {name=l28929 lab=VDD}
N 5040 8960 5060 8960 {}
C {lab_pin.sym} 5060 8960 0 0 {name=l28930 lab=VSS}
C {bitcell_6t.sym} 5200 9000 0 0 {name=Xr45c26}
N 5160 9040 5140 9040 {}
C {lab_pin.sym} 5140 9040 0 0 {name=l28931 lab=BL26}
N 5160 9000 5140 9000 {}
C {lab_pin.sym} 5140 9000 0 0 {name=l28932 lab=BLB26}
N 5160 8960 5140 8960 {}
C {lab_pin.sym} 5140 8960 0 0 {name=l28933 lab=WL45}
N 5240 9040 5260 9040 {}
C {lab_pin.sym} 5260 9040 0 0 {name=l28934 lab=VDD}
N 5240 8960 5260 8960 {}
C {lab_pin.sym} 5260 8960 0 0 {name=l28935 lab=VSS}
C {bitcell_6t.sym} 5400 9000 0 0 {name=Xr45c27}
N 5360 9040 5340 9040 {}
C {lab_pin.sym} 5340 9040 0 0 {name=l28936 lab=BL27}
N 5360 9000 5340 9000 {}
C {lab_pin.sym} 5340 9000 0 0 {name=l28937 lab=BLB27}
N 5360 8960 5340 8960 {}
C {lab_pin.sym} 5340 8960 0 0 {name=l28938 lab=WL45}
N 5440 9040 5460 9040 {}
C {lab_pin.sym} 5460 9040 0 0 {name=l28939 lab=VDD}
N 5440 8960 5460 8960 {}
C {lab_pin.sym} 5460 8960 0 0 {name=l28940 lab=VSS}
C {bitcell_6t.sym} 5600 9000 0 0 {name=Xr45c28}
N 5560 9040 5540 9040 {}
C {lab_pin.sym} 5540 9040 0 0 {name=l28941 lab=BL28}
N 5560 9000 5540 9000 {}
C {lab_pin.sym} 5540 9000 0 0 {name=l28942 lab=BLB28}
N 5560 8960 5540 8960 {}
C {lab_pin.sym} 5540 8960 0 0 {name=l28943 lab=WL45}
N 5640 9040 5660 9040 {}
C {lab_pin.sym} 5660 9040 0 0 {name=l28944 lab=VDD}
N 5640 8960 5660 8960 {}
C {lab_pin.sym} 5660 8960 0 0 {name=l28945 lab=VSS}
C {bitcell_6t.sym} 5800 9000 0 0 {name=Xr45c29}
N 5760 9040 5740 9040 {}
C {lab_pin.sym} 5740 9040 0 0 {name=l28946 lab=BL29}
N 5760 9000 5740 9000 {}
C {lab_pin.sym} 5740 9000 0 0 {name=l28947 lab=BLB29}
N 5760 8960 5740 8960 {}
C {lab_pin.sym} 5740 8960 0 0 {name=l28948 lab=WL45}
N 5840 9040 5860 9040 {}
C {lab_pin.sym} 5860 9040 0 0 {name=l28949 lab=VDD}
N 5840 8960 5860 8960 {}
C {lab_pin.sym} 5860 8960 0 0 {name=l28950 lab=VSS}
C {bitcell_6t.sym} 6000 9000 0 0 {name=Xr45c30}
N 5960 9040 5940 9040 {}
C {lab_pin.sym} 5940 9040 0 0 {name=l28951 lab=BL30}
N 5960 9000 5940 9000 {}
C {lab_pin.sym} 5940 9000 0 0 {name=l28952 lab=BLB30}
N 5960 8960 5940 8960 {}
C {lab_pin.sym} 5940 8960 0 0 {name=l28953 lab=WL45}
N 6040 9040 6060 9040 {}
C {lab_pin.sym} 6060 9040 0 0 {name=l28954 lab=VDD}
N 6040 8960 6060 8960 {}
C {lab_pin.sym} 6060 8960 0 0 {name=l28955 lab=VSS}
C {bitcell_6t.sym} 6200 9000 0 0 {name=Xr45c31}
N 6160 9040 6140 9040 {}
C {lab_pin.sym} 6140 9040 0 0 {name=l28956 lab=BL31}
N 6160 9000 6140 9000 {}
C {lab_pin.sym} 6140 9000 0 0 {name=l28957 lab=BLB31}
N 6160 8960 6140 8960 {}
C {lab_pin.sym} 6140 8960 0 0 {name=l28958 lab=WL45}
N 6240 9040 6260 9040 {}
C {lab_pin.sym} 6260 9040 0 0 {name=l28959 lab=VDD}
N 6240 8960 6260 8960 {}
C {lab_pin.sym} 6260 8960 0 0 {name=l28960 lab=VSS}
C {bitcell_6t.sym} 6400 9000 0 0 {name=Xr45c32}
N 6360 9040 6340 9040 {}
C {lab_pin.sym} 6340 9040 0 0 {name=l28961 lab=BL32}
N 6360 9000 6340 9000 {}
C {lab_pin.sym} 6340 9000 0 0 {name=l28962 lab=BLB32}
N 6360 8960 6340 8960 {}
C {lab_pin.sym} 6340 8960 0 0 {name=l28963 lab=WL45}
N 6440 9040 6460 9040 {}
C {lab_pin.sym} 6460 9040 0 0 {name=l28964 lab=VDD}
N 6440 8960 6460 8960 {}
C {lab_pin.sym} 6460 8960 0 0 {name=l28965 lab=VSS}
C {bitcell_6t.sym} 6600 9000 0 0 {name=Xr45c33}
N 6560 9040 6540 9040 {}
C {lab_pin.sym} 6540 9040 0 0 {name=l28966 lab=BL33}
N 6560 9000 6540 9000 {}
C {lab_pin.sym} 6540 9000 0 0 {name=l28967 lab=BLB33}
N 6560 8960 6540 8960 {}
C {lab_pin.sym} 6540 8960 0 0 {name=l28968 lab=WL45}
N 6640 9040 6660 9040 {}
C {lab_pin.sym} 6660 9040 0 0 {name=l28969 lab=VDD}
N 6640 8960 6660 8960 {}
C {lab_pin.sym} 6660 8960 0 0 {name=l28970 lab=VSS}
C {bitcell_6t.sym} 6800 9000 0 0 {name=Xr45c34}
N 6760 9040 6740 9040 {}
C {lab_pin.sym} 6740 9040 0 0 {name=l28971 lab=BL34}
N 6760 9000 6740 9000 {}
C {lab_pin.sym} 6740 9000 0 0 {name=l28972 lab=BLB34}
N 6760 8960 6740 8960 {}
C {lab_pin.sym} 6740 8960 0 0 {name=l28973 lab=WL45}
N 6840 9040 6860 9040 {}
C {lab_pin.sym} 6860 9040 0 0 {name=l28974 lab=VDD}
N 6840 8960 6860 8960 {}
C {lab_pin.sym} 6860 8960 0 0 {name=l28975 lab=VSS}
C {bitcell_6t.sym} 7000 9000 0 0 {name=Xr45c35}
N 6960 9040 6940 9040 {}
C {lab_pin.sym} 6940 9040 0 0 {name=l28976 lab=BL35}
N 6960 9000 6940 9000 {}
C {lab_pin.sym} 6940 9000 0 0 {name=l28977 lab=BLB35}
N 6960 8960 6940 8960 {}
C {lab_pin.sym} 6940 8960 0 0 {name=l28978 lab=WL45}
N 7040 9040 7060 9040 {}
C {lab_pin.sym} 7060 9040 0 0 {name=l28979 lab=VDD}
N 7040 8960 7060 8960 {}
C {lab_pin.sym} 7060 8960 0 0 {name=l28980 lab=VSS}
C {bitcell_6t.sym} 7200 9000 0 0 {name=Xr45c36}
N 7160 9040 7140 9040 {}
C {lab_pin.sym} 7140 9040 0 0 {name=l28981 lab=BL36}
N 7160 9000 7140 9000 {}
C {lab_pin.sym} 7140 9000 0 0 {name=l28982 lab=BLB36}
N 7160 8960 7140 8960 {}
C {lab_pin.sym} 7140 8960 0 0 {name=l28983 lab=WL45}
N 7240 9040 7260 9040 {}
C {lab_pin.sym} 7260 9040 0 0 {name=l28984 lab=VDD}
N 7240 8960 7260 8960 {}
C {lab_pin.sym} 7260 8960 0 0 {name=l28985 lab=VSS}
C {bitcell_6t.sym} 7400 9000 0 0 {name=Xr45c37}
N 7360 9040 7340 9040 {}
C {lab_pin.sym} 7340 9040 0 0 {name=l28986 lab=BL37}
N 7360 9000 7340 9000 {}
C {lab_pin.sym} 7340 9000 0 0 {name=l28987 lab=BLB37}
N 7360 8960 7340 8960 {}
C {lab_pin.sym} 7340 8960 0 0 {name=l28988 lab=WL45}
N 7440 9040 7460 9040 {}
C {lab_pin.sym} 7460 9040 0 0 {name=l28989 lab=VDD}
N 7440 8960 7460 8960 {}
C {lab_pin.sym} 7460 8960 0 0 {name=l28990 lab=VSS}
C {bitcell_6t.sym} 7600 9000 0 0 {name=Xr45c38}
N 7560 9040 7540 9040 {}
C {lab_pin.sym} 7540 9040 0 0 {name=l28991 lab=BL38}
N 7560 9000 7540 9000 {}
C {lab_pin.sym} 7540 9000 0 0 {name=l28992 lab=BLB38}
N 7560 8960 7540 8960 {}
C {lab_pin.sym} 7540 8960 0 0 {name=l28993 lab=WL45}
N 7640 9040 7660 9040 {}
C {lab_pin.sym} 7660 9040 0 0 {name=l28994 lab=VDD}
N 7640 8960 7660 8960 {}
C {lab_pin.sym} 7660 8960 0 0 {name=l28995 lab=VSS}
C {bitcell_6t.sym} 7800 9000 0 0 {name=Xr45c39}
N 7760 9040 7740 9040 {}
C {lab_pin.sym} 7740 9040 0 0 {name=l28996 lab=BL39}
N 7760 9000 7740 9000 {}
C {lab_pin.sym} 7740 9000 0 0 {name=l28997 lab=BLB39}
N 7760 8960 7740 8960 {}
C {lab_pin.sym} 7740 8960 0 0 {name=l28998 lab=WL45}
N 7840 9040 7860 9040 {}
C {lab_pin.sym} 7860 9040 0 0 {name=l28999 lab=VDD}
N 7840 8960 7860 8960 {}
C {lab_pin.sym} 7860 8960 0 0 {name=l29000 lab=VSS}
C {bitcell_6t.sym} 8000 9000 0 0 {name=Xr45c40}
N 7960 9040 7940 9040 {}
C {lab_pin.sym} 7940 9040 0 0 {name=l29001 lab=BL40}
N 7960 9000 7940 9000 {}
C {lab_pin.sym} 7940 9000 0 0 {name=l29002 lab=BLB40}
N 7960 8960 7940 8960 {}
C {lab_pin.sym} 7940 8960 0 0 {name=l29003 lab=WL45}
N 8040 9040 8060 9040 {}
C {lab_pin.sym} 8060 9040 0 0 {name=l29004 lab=VDD}
N 8040 8960 8060 8960 {}
C {lab_pin.sym} 8060 8960 0 0 {name=l29005 lab=VSS}
C {bitcell_6t.sym} 8200 9000 0 0 {name=Xr45c41}
N 8160 9040 8140 9040 {}
C {lab_pin.sym} 8140 9040 0 0 {name=l29006 lab=BL41}
N 8160 9000 8140 9000 {}
C {lab_pin.sym} 8140 9000 0 0 {name=l29007 lab=BLB41}
N 8160 8960 8140 8960 {}
C {lab_pin.sym} 8140 8960 0 0 {name=l29008 lab=WL45}
N 8240 9040 8260 9040 {}
C {lab_pin.sym} 8260 9040 0 0 {name=l29009 lab=VDD}
N 8240 8960 8260 8960 {}
C {lab_pin.sym} 8260 8960 0 0 {name=l29010 lab=VSS}
C {bitcell_6t.sym} 8400 9000 0 0 {name=Xr45c42}
N 8360 9040 8340 9040 {}
C {lab_pin.sym} 8340 9040 0 0 {name=l29011 lab=BL42}
N 8360 9000 8340 9000 {}
C {lab_pin.sym} 8340 9000 0 0 {name=l29012 lab=BLB42}
N 8360 8960 8340 8960 {}
C {lab_pin.sym} 8340 8960 0 0 {name=l29013 lab=WL45}
N 8440 9040 8460 9040 {}
C {lab_pin.sym} 8460 9040 0 0 {name=l29014 lab=VDD}
N 8440 8960 8460 8960 {}
C {lab_pin.sym} 8460 8960 0 0 {name=l29015 lab=VSS}
C {bitcell_6t.sym} 8600 9000 0 0 {name=Xr45c43}
N 8560 9040 8540 9040 {}
C {lab_pin.sym} 8540 9040 0 0 {name=l29016 lab=BL43}
N 8560 9000 8540 9000 {}
C {lab_pin.sym} 8540 9000 0 0 {name=l29017 lab=BLB43}
N 8560 8960 8540 8960 {}
C {lab_pin.sym} 8540 8960 0 0 {name=l29018 lab=WL45}
N 8640 9040 8660 9040 {}
C {lab_pin.sym} 8660 9040 0 0 {name=l29019 lab=VDD}
N 8640 8960 8660 8960 {}
C {lab_pin.sym} 8660 8960 0 0 {name=l29020 lab=VSS}
C {bitcell_6t.sym} 8800 9000 0 0 {name=Xr45c44}
N 8760 9040 8740 9040 {}
C {lab_pin.sym} 8740 9040 0 0 {name=l29021 lab=BL44}
N 8760 9000 8740 9000 {}
C {lab_pin.sym} 8740 9000 0 0 {name=l29022 lab=BLB44}
N 8760 8960 8740 8960 {}
C {lab_pin.sym} 8740 8960 0 0 {name=l29023 lab=WL45}
N 8840 9040 8860 9040 {}
C {lab_pin.sym} 8860 9040 0 0 {name=l29024 lab=VDD}
N 8840 8960 8860 8960 {}
C {lab_pin.sym} 8860 8960 0 0 {name=l29025 lab=VSS}
C {bitcell_6t.sym} 9000 9000 0 0 {name=Xr45c45}
N 8960 9040 8940 9040 {}
C {lab_pin.sym} 8940 9040 0 0 {name=l29026 lab=BL45}
N 8960 9000 8940 9000 {}
C {lab_pin.sym} 8940 9000 0 0 {name=l29027 lab=BLB45}
N 8960 8960 8940 8960 {}
C {lab_pin.sym} 8940 8960 0 0 {name=l29028 lab=WL45}
N 9040 9040 9060 9040 {}
C {lab_pin.sym} 9060 9040 0 0 {name=l29029 lab=VDD}
N 9040 8960 9060 8960 {}
C {lab_pin.sym} 9060 8960 0 0 {name=l29030 lab=VSS}
C {bitcell_6t.sym} 9200 9000 0 0 {name=Xr45c46}
N 9160 9040 9140 9040 {}
C {lab_pin.sym} 9140 9040 0 0 {name=l29031 lab=BL46}
N 9160 9000 9140 9000 {}
C {lab_pin.sym} 9140 9000 0 0 {name=l29032 lab=BLB46}
N 9160 8960 9140 8960 {}
C {lab_pin.sym} 9140 8960 0 0 {name=l29033 lab=WL45}
N 9240 9040 9260 9040 {}
C {lab_pin.sym} 9260 9040 0 0 {name=l29034 lab=VDD}
N 9240 8960 9260 8960 {}
C {lab_pin.sym} 9260 8960 0 0 {name=l29035 lab=VSS}
C {bitcell_6t.sym} 9400 9000 0 0 {name=Xr45c47}
N 9360 9040 9340 9040 {}
C {lab_pin.sym} 9340 9040 0 0 {name=l29036 lab=BL47}
N 9360 9000 9340 9000 {}
C {lab_pin.sym} 9340 9000 0 0 {name=l29037 lab=BLB47}
N 9360 8960 9340 8960 {}
C {lab_pin.sym} 9340 8960 0 0 {name=l29038 lab=WL45}
N 9440 9040 9460 9040 {}
C {lab_pin.sym} 9460 9040 0 0 {name=l29039 lab=VDD}
N 9440 8960 9460 8960 {}
C {lab_pin.sym} 9460 8960 0 0 {name=l29040 lab=VSS}
C {bitcell_6t.sym} 9600 9000 0 0 {name=Xr45c48}
N 9560 9040 9540 9040 {}
C {lab_pin.sym} 9540 9040 0 0 {name=l29041 lab=BL48}
N 9560 9000 9540 9000 {}
C {lab_pin.sym} 9540 9000 0 0 {name=l29042 lab=BLB48}
N 9560 8960 9540 8960 {}
C {lab_pin.sym} 9540 8960 0 0 {name=l29043 lab=WL45}
N 9640 9040 9660 9040 {}
C {lab_pin.sym} 9660 9040 0 0 {name=l29044 lab=VDD}
N 9640 8960 9660 8960 {}
C {lab_pin.sym} 9660 8960 0 0 {name=l29045 lab=VSS}
C {bitcell_6t.sym} 9800 9000 0 0 {name=Xr45c49}
N 9760 9040 9740 9040 {}
C {lab_pin.sym} 9740 9040 0 0 {name=l29046 lab=BL49}
N 9760 9000 9740 9000 {}
C {lab_pin.sym} 9740 9000 0 0 {name=l29047 lab=BLB49}
N 9760 8960 9740 8960 {}
C {lab_pin.sym} 9740 8960 0 0 {name=l29048 lab=WL45}
N 9840 9040 9860 9040 {}
C {lab_pin.sym} 9860 9040 0 0 {name=l29049 lab=VDD}
N 9840 8960 9860 8960 {}
C {lab_pin.sym} 9860 8960 0 0 {name=l29050 lab=VSS}
C {bitcell_6t.sym} 10000 9000 0 0 {name=Xr45c50}
N 9960 9040 9940 9040 {}
C {lab_pin.sym} 9940 9040 0 0 {name=l29051 lab=BL50}
N 9960 9000 9940 9000 {}
C {lab_pin.sym} 9940 9000 0 0 {name=l29052 lab=BLB50}
N 9960 8960 9940 8960 {}
C {lab_pin.sym} 9940 8960 0 0 {name=l29053 lab=WL45}
N 10040 9040 10060 9040 {}
C {lab_pin.sym} 10060 9040 0 0 {name=l29054 lab=VDD}
N 10040 8960 10060 8960 {}
C {lab_pin.sym} 10060 8960 0 0 {name=l29055 lab=VSS}
C {bitcell_6t.sym} 10200 9000 0 0 {name=Xr45c51}
N 10160 9040 10140 9040 {}
C {lab_pin.sym} 10140 9040 0 0 {name=l29056 lab=BL51}
N 10160 9000 10140 9000 {}
C {lab_pin.sym} 10140 9000 0 0 {name=l29057 lab=BLB51}
N 10160 8960 10140 8960 {}
C {lab_pin.sym} 10140 8960 0 0 {name=l29058 lab=WL45}
N 10240 9040 10260 9040 {}
C {lab_pin.sym} 10260 9040 0 0 {name=l29059 lab=VDD}
N 10240 8960 10260 8960 {}
C {lab_pin.sym} 10260 8960 0 0 {name=l29060 lab=VSS}
C {bitcell_6t.sym} 10400 9000 0 0 {name=Xr45c52}
N 10360 9040 10340 9040 {}
C {lab_pin.sym} 10340 9040 0 0 {name=l29061 lab=BL52}
N 10360 9000 10340 9000 {}
C {lab_pin.sym} 10340 9000 0 0 {name=l29062 lab=BLB52}
N 10360 8960 10340 8960 {}
C {lab_pin.sym} 10340 8960 0 0 {name=l29063 lab=WL45}
N 10440 9040 10460 9040 {}
C {lab_pin.sym} 10460 9040 0 0 {name=l29064 lab=VDD}
N 10440 8960 10460 8960 {}
C {lab_pin.sym} 10460 8960 0 0 {name=l29065 lab=VSS}
C {bitcell_6t.sym} 10600 9000 0 0 {name=Xr45c53}
N 10560 9040 10540 9040 {}
C {lab_pin.sym} 10540 9040 0 0 {name=l29066 lab=BL53}
N 10560 9000 10540 9000 {}
C {lab_pin.sym} 10540 9000 0 0 {name=l29067 lab=BLB53}
N 10560 8960 10540 8960 {}
C {lab_pin.sym} 10540 8960 0 0 {name=l29068 lab=WL45}
N 10640 9040 10660 9040 {}
C {lab_pin.sym} 10660 9040 0 0 {name=l29069 lab=VDD}
N 10640 8960 10660 8960 {}
C {lab_pin.sym} 10660 8960 0 0 {name=l29070 lab=VSS}
C {bitcell_6t.sym} 10800 9000 0 0 {name=Xr45c54}
N 10760 9040 10740 9040 {}
C {lab_pin.sym} 10740 9040 0 0 {name=l29071 lab=BL54}
N 10760 9000 10740 9000 {}
C {lab_pin.sym} 10740 9000 0 0 {name=l29072 lab=BLB54}
N 10760 8960 10740 8960 {}
C {lab_pin.sym} 10740 8960 0 0 {name=l29073 lab=WL45}
N 10840 9040 10860 9040 {}
C {lab_pin.sym} 10860 9040 0 0 {name=l29074 lab=VDD}
N 10840 8960 10860 8960 {}
C {lab_pin.sym} 10860 8960 0 0 {name=l29075 lab=VSS}
C {bitcell_6t.sym} 11000 9000 0 0 {name=Xr45c55}
N 10960 9040 10940 9040 {}
C {lab_pin.sym} 10940 9040 0 0 {name=l29076 lab=BL55}
N 10960 9000 10940 9000 {}
C {lab_pin.sym} 10940 9000 0 0 {name=l29077 lab=BLB55}
N 10960 8960 10940 8960 {}
C {lab_pin.sym} 10940 8960 0 0 {name=l29078 lab=WL45}
N 11040 9040 11060 9040 {}
C {lab_pin.sym} 11060 9040 0 0 {name=l29079 lab=VDD}
N 11040 8960 11060 8960 {}
C {lab_pin.sym} 11060 8960 0 0 {name=l29080 lab=VSS}
C {bitcell_6t.sym} 11200 9000 0 0 {name=Xr45c56}
N 11160 9040 11140 9040 {}
C {lab_pin.sym} 11140 9040 0 0 {name=l29081 lab=BL56}
N 11160 9000 11140 9000 {}
C {lab_pin.sym} 11140 9000 0 0 {name=l29082 lab=BLB56}
N 11160 8960 11140 8960 {}
C {lab_pin.sym} 11140 8960 0 0 {name=l29083 lab=WL45}
N 11240 9040 11260 9040 {}
C {lab_pin.sym} 11260 9040 0 0 {name=l29084 lab=VDD}
N 11240 8960 11260 8960 {}
C {lab_pin.sym} 11260 8960 0 0 {name=l29085 lab=VSS}
C {bitcell_6t.sym} 11400 9000 0 0 {name=Xr45c57}
N 11360 9040 11340 9040 {}
C {lab_pin.sym} 11340 9040 0 0 {name=l29086 lab=BL57}
N 11360 9000 11340 9000 {}
C {lab_pin.sym} 11340 9000 0 0 {name=l29087 lab=BLB57}
N 11360 8960 11340 8960 {}
C {lab_pin.sym} 11340 8960 0 0 {name=l29088 lab=WL45}
N 11440 9040 11460 9040 {}
C {lab_pin.sym} 11460 9040 0 0 {name=l29089 lab=VDD}
N 11440 8960 11460 8960 {}
C {lab_pin.sym} 11460 8960 0 0 {name=l29090 lab=VSS}
C {bitcell_6t.sym} 11600 9000 0 0 {name=Xr45c58}
N 11560 9040 11540 9040 {}
C {lab_pin.sym} 11540 9040 0 0 {name=l29091 lab=BL58}
N 11560 9000 11540 9000 {}
C {lab_pin.sym} 11540 9000 0 0 {name=l29092 lab=BLB58}
N 11560 8960 11540 8960 {}
C {lab_pin.sym} 11540 8960 0 0 {name=l29093 lab=WL45}
N 11640 9040 11660 9040 {}
C {lab_pin.sym} 11660 9040 0 0 {name=l29094 lab=VDD}
N 11640 8960 11660 8960 {}
C {lab_pin.sym} 11660 8960 0 0 {name=l29095 lab=VSS}
C {bitcell_6t.sym} 11800 9000 0 0 {name=Xr45c59}
N 11760 9040 11740 9040 {}
C {lab_pin.sym} 11740 9040 0 0 {name=l29096 lab=BL59}
N 11760 9000 11740 9000 {}
C {lab_pin.sym} 11740 9000 0 0 {name=l29097 lab=BLB59}
N 11760 8960 11740 8960 {}
C {lab_pin.sym} 11740 8960 0 0 {name=l29098 lab=WL45}
N 11840 9040 11860 9040 {}
C {lab_pin.sym} 11860 9040 0 0 {name=l29099 lab=VDD}
N 11840 8960 11860 8960 {}
C {lab_pin.sym} 11860 8960 0 0 {name=l29100 lab=VSS}
C {bitcell_6t.sym} 12000 9000 0 0 {name=Xr45c60}
N 11960 9040 11940 9040 {}
C {lab_pin.sym} 11940 9040 0 0 {name=l29101 lab=BL60}
N 11960 9000 11940 9000 {}
C {lab_pin.sym} 11940 9000 0 0 {name=l29102 lab=BLB60}
N 11960 8960 11940 8960 {}
C {lab_pin.sym} 11940 8960 0 0 {name=l29103 lab=WL45}
N 12040 9040 12060 9040 {}
C {lab_pin.sym} 12060 9040 0 0 {name=l29104 lab=VDD}
N 12040 8960 12060 8960 {}
C {lab_pin.sym} 12060 8960 0 0 {name=l29105 lab=VSS}
C {bitcell_6t.sym} 12200 9000 0 0 {name=Xr45c61}
N 12160 9040 12140 9040 {}
C {lab_pin.sym} 12140 9040 0 0 {name=l29106 lab=BL61}
N 12160 9000 12140 9000 {}
C {lab_pin.sym} 12140 9000 0 0 {name=l29107 lab=BLB61}
N 12160 8960 12140 8960 {}
C {lab_pin.sym} 12140 8960 0 0 {name=l29108 lab=WL45}
N 12240 9040 12260 9040 {}
C {lab_pin.sym} 12260 9040 0 0 {name=l29109 lab=VDD}
N 12240 8960 12260 8960 {}
C {lab_pin.sym} 12260 8960 0 0 {name=l29110 lab=VSS}
C {bitcell_6t.sym} 12400 9000 0 0 {name=Xr45c62}
N 12360 9040 12340 9040 {}
C {lab_pin.sym} 12340 9040 0 0 {name=l29111 lab=BL62}
N 12360 9000 12340 9000 {}
C {lab_pin.sym} 12340 9000 0 0 {name=l29112 lab=BLB62}
N 12360 8960 12340 8960 {}
C {lab_pin.sym} 12340 8960 0 0 {name=l29113 lab=WL45}
N 12440 9040 12460 9040 {}
C {lab_pin.sym} 12460 9040 0 0 {name=l29114 lab=VDD}
N 12440 8960 12460 8960 {}
C {lab_pin.sym} 12460 8960 0 0 {name=l29115 lab=VSS}
C {bitcell_6t.sym} 12600 9000 0 0 {name=Xr45c63}
N 12560 9040 12540 9040 {}
C {lab_pin.sym} 12540 9040 0 0 {name=l29116 lab=BL63}
N 12560 9000 12540 9000 {}
C {lab_pin.sym} 12540 9000 0 0 {name=l29117 lab=BLB63}
N 12560 8960 12540 8960 {}
C {lab_pin.sym} 12540 8960 0 0 {name=l29118 lab=WL45}
N 12640 9040 12660 9040 {}
C {lab_pin.sym} 12660 9040 0 0 {name=l29119 lab=VDD}
N 12640 8960 12660 8960 {}
C {lab_pin.sym} 12660 8960 0 0 {name=l29120 lab=VSS}
C {bitcell_6t.sym} 12800 9000 0 0 {name=Xr45c64}
N 12760 9040 12740 9040 {}
C {lab_pin.sym} 12740 9040 0 0 {name=l29121 lab=BL64}
N 12760 9000 12740 9000 {}
C {lab_pin.sym} 12740 9000 0 0 {name=l29122 lab=BLB64}
N 12760 8960 12740 8960 {}
C {lab_pin.sym} 12740 8960 0 0 {name=l29123 lab=WL45}
N 12840 9040 12860 9040 {}
C {lab_pin.sym} 12860 9040 0 0 {name=l29124 lab=VDD}
N 12840 8960 12860 8960 {}
C {lab_pin.sym} 12860 8960 0 0 {name=l29125 lab=VSS}
C {bitcell_6t.sym} 13000 9000 0 0 {name=Xr45c65}
N 12960 9040 12940 9040 {}
C {lab_pin.sym} 12940 9040 0 0 {name=l29126 lab=BL65}
N 12960 9000 12940 9000 {}
C {lab_pin.sym} 12940 9000 0 0 {name=l29127 lab=BLB65}
N 12960 8960 12940 8960 {}
C {lab_pin.sym} 12940 8960 0 0 {name=l29128 lab=WL45}
N 13040 9040 13060 9040 {}
C {lab_pin.sym} 13060 9040 0 0 {name=l29129 lab=VDD}
N 13040 8960 13060 8960 {}
C {lab_pin.sym} 13060 8960 0 0 {name=l29130 lab=VSS}
C {bitcell_6t.sym} 13200 9000 0 0 {name=Xr45c66}
N 13160 9040 13140 9040 {}
C {lab_pin.sym} 13140 9040 0 0 {name=l29131 lab=BL66}
N 13160 9000 13140 9000 {}
C {lab_pin.sym} 13140 9000 0 0 {name=l29132 lab=BLB66}
N 13160 8960 13140 8960 {}
C {lab_pin.sym} 13140 8960 0 0 {name=l29133 lab=WL45}
N 13240 9040 13260 9040 {}
C {lab_pin.sym} 13260 9040 0 0 {name=l29134 lab=VDD}
N 13240 8960 13260 8960 {}
C {lab_pin.sym} 13260 8960 0 0 {name=l29135 lab=VSS}
C {bitcell_6t.sym} 13400 9000 0 0 {name=Xr45c67}
N 13360 9040 13340 9040 {}
C {lab_pin.sym} 13340 9040 0 0 {name=l29136 lab=BL67}
N 13360 9000 13340 9000 {}
C {lab_pin.sym} 13340 9000 0 0 {name=l29137 lab=BLB67}
N 13360 8960 13340 8960 {}
C {lab_pin.sym} 13340 8960 0 0 {name=l29138 lab=WL45}
N 13440 9040 13460 9040 {}
C {lab_pin.sym} 13460 9040 0 0 {name=l29139 lab=VDD}
N 13440 8960 13460 8960 {}
C {lab_pin.sym} 13460 8960 0 0 {name=l29140 lab=VSS}
C {bitcell_6t.sym} 13600 9000 0 0 {name=Xr45c68}
N 13560 9040 13540 9040 {}
C {lab_pin.sym} 13540 9040 0 0 {name=l29141 lab=BL68}
N 13560 9000 13540 9000 {}
C {lab_pin.sym} 13540 9000 0 0 {name=l29142 lab=BLB68}
N 13560 8960 13540 8960 {}
C {lab_pin.sym} 13540 8960 0 0 {name=l29143 lab=WL45}
N 13640 9040 13660 9040 {}
C {lab_pin.sym} 13660 9040 0 0 {name=l29144 lab=VDD}
N 13640 8960 13660 8960 {}
C {lab_pin.sym} 13660 8960 0 0 {name=l29145 lab=VSS}
C {bitcell_6t.sym} 13800 9000 0 0 {name=Xr45c69}
N 13760 9040 13740 9040 {}
C {lab_pin.sym} 13740 9040 0 0 {name=l29146 lab=BL69}
N 13760 9000 13740 9000 {}
C {lab_pin.sym} 13740 9000 0 0 {name=l29147 lab=BLB69}
N 13760 8960 13740 8960 {}
C {lab_pin.sym} 13740 8960 0 0 {name=l29148 lab=WL45}
N 13840 9040 13860 9040 {}
C {lab_pin.sym} 13860 9040 0 0 {name=l29149 lab=VDD}
N 13840 8960 13860 8960 {}
C {lab_pin.sym} 13860 8960 0 0 {name=l29150 lab=VSS}
C {bitcell_6t.sym} 14000 9000 0 0 {name=Xr45c70}
N 13960 9040 13940 9040 {}
C {lab_pin.sym} 13940 9040 0 0 {name=l29151 lab=BL70}
N 13960 9000 13940 9000 {}
C {lab_pin.sym} 13940 9000 0 0 {name=l29152 lab=BLB70}
N 13960 8960 13940 8960 {}
C {lab_pin.sym} 13940 8960 0 0 {name=l29153 lab=WL45}
N 14040 9040 14060 9040 {}
C {lab_pin.sym} 14060 9040 0 0 {name=l29154 lab=VDD}
N 14040 8960 14060 8960 {}
C {lab_pin.sym} 14060 8960 0 0 {name=l29155 lab=VSS}
C {bitcell_6t.sym} 14200 9000 0 0 {name=Xr45c71}
N 14160 9040 14140 9040 {}
C {lab_pin.sym} 14140 9040 0 0 {name=l29156 lab=BL71}
N 14160 9000 14140 9000 {}
C {lab_pin.sym} 14140 9000 0 0 {name=l29157 lab=BLB71}
N 14160 8960 14140 8960 {}
C {lab_pin.sym} 14140 8960 0 0 {name=l29158 lab=WL45}
N 14240 9040 14260 9040 {}
C {lab_pin.sym} 14260 9040 0 0 {name=l29159 lab=VDD}
N 14240 8960 14260 8960 {}
C {lab_pin.sym} 14260 8960 0 0 {name=l29160 lab=VSS}
C {bitcell_6t.sym} 14400 9000 0 0 {name=Xr45c72}
N 14360 9040 14340 9040 {}
C {lab_pin.sym} 14340 9040 0 0 {name=l29161 lab=BL72}
N 14360 9000 14340 9000 {}
C {lab_pin.sym} 14340 9000 0 0 {name=l29162 lab=BLB72}
N 14360 8960 14340 8960 {}
C {lab_pin.sym} 14340 8960 0 0 {name=l29163 lab=WL45}
N 14440 9040 14460 9040 {}
C {lab_pin.sym} 14460 9040 0 0 {name=l29164 lab=VDD}
N 14440 8960 14460 8960 {}
C {lab_pin.sym} 14460 8960 0 0 {name=l29165 lab=VSS}
C {bitcell_6t.sym} 14600 9000 0 0 {name=Xr45c73}
N 14560 9040 14540 9040 {}
C {lab_pin.sym} 14540 9040 0 0 {name=l29166 lab=BL73}
N 14560 9000 14540 9000 {}
C {lab_pin.sym} 14540 9000 0 0 {name=l29167 lab=BLB73}
N 14560 8960 14540 8960 {}
C {lab_pin.sym} 14540 8960 0 0 {name=l29168 lab=WL45}
N 14640 9040 14660 9040 {}
C {lab_pin.sym} 14660 9040 0 0 {name=l29169 lab=VDD}
N 14640 8960 14660 8960 {}
C {lab_pin.sym} 14660 8960 0 0 {name=l29170 lab=VSS}
C {bitcell_6t.sym} 14800 9000 0 0 {name=Xr45c74}
N 14760 9040 14740 9040 {}
C {lab_pin.sym} 14740 9040 0 0 {name=l29171 lab=BL74}
N 14760 9000 14740 9000 {}
C {lab_pin.sym} 14740 9000 0 0 {name=l29172 lab=BLB74}
N 14760 8960 14740 8960 {}
C {lab_pin.sym} 14740 8960 0 0 {name=l29173 lab=WL45}
N 14840 9040 14860 9040 {}
C {lab_pin.sym} 14860 9040 0 0 {name=l29174 lab=VDD}
N 14840 8960 14860 8960 {}
C {lab_pin.sym} 14860 8960 0 0 {name=l29175 lab=VSS}
C {bitcell_6t.sym} 15000 9000 0 0 {name=Xr45c75}
N 14960 9040 14940 9040 {}
C {lab_pin.sym} 14940 9040 0 0 {name=l29176 lab=BL75}
N 14960 9000 14940 9000 {}
C {lab_pin.sym} 14940 9000 0 0 {name=l29177 lab=BLB75}
N 14960 8960 14940 8960 {}
C {lab_pin.sym} 14940 8960 0 0 {name=l29178 lab=WL45}
N 15040 9040 15060 9040 {}
C {lab_pin.sym} 15060 9040 0 0 {name=l29179 lab=VDD}
N 15040 8960 15060 8960 {}
C {lab_pin.sym} 15060 8960 0 0 {name=l29180 lab=VSS}
C {bitcell_6t.sym} 15200 9000 0 0 {name=Xr45c76}
N 15160 9040 15140 9040 {}
C {lab_pin.sym} 15140 9040 0 0 {name=l29181 lab=BL76}
N 15160 9000 15140 9000 {}
C {lab_pin.sym} 15140 9000 0 0 {name=l29182 lab=BLB76}
N 15160 8960 15140 8960 {}
C {lab_pin.sym} 15140 8960 0 0 {name=l29183 lab=WL45}
N 15240 9040 15260 9040 {}
C {lab_pin.sym} 15260 9040 0 0 {name=l29184 lab=VDD}
N 15240 8960 15260 8960 {}
C {lab_pin.sym} 15260 8960 0 0 {name=l29185 lab=VSS}
C {bitcell_6t.sym} 15400 9000 0 0 {name=Xr45c77}
N 15360 9040 15340 9040 {}
C {lab_pin.sym} 15340 9040 0 0 {name=l29186 lab=BL77}
N 15360 9000 15340 9000 {}
C {lab_pin.sym} 15340 9000 0 0 {name=l29187 lab=BLB77}
N 15360 8960 15340 8960 {}
C {lab_pin.sym} 15340 8960 0 0 {name=l29188 lab=WL45}
N 15440 9040 15460 9040 {}
C {lab_pin.sym} 15460 9040 0 0 {name=l29189 lab=VDD}
N 15440 8960 15460 8960 {}
C {lab_pin.sym} 15460 8960 0 0 {name=l29190 lab=VSS}
C {bitcell_6t.sym} 15600 9000 0 0 {name=Xr45c78}
N 15560 9040 15540 9040 {}
C {lab_pin.sym} 15540 9040 0 0 {name=l29191 lab=BL78}
N 15560 9000 15540 9000 {}
C {lab_pin.sym} 15540 9000 0 0 {name=l29192 lab=BLB78}
N 15560 8960 15540 8960 {}
C {lab_pin.sym} 15540 8960 0 0 {name=l29193 lab=WL45}
N 15640 9040 15660 9040 {}
C {lab_pin.sym} 15660 9040 0 0 {name=l29194 lab=VDD}
N 15640 8960 15660 8960 {}
C {lab_pin.sym} 15660 8960 0 0 {name=l29195 lab=VSS}
C {bitcell_6t.sym} 15800 9000 0 0 {name=Xr45c79}
N 15760 9040 15740 9040 {}
C {lab_pin.sym} 15740 9040 0 0 {name=l29196 lab=BL79}
N 15760 9000 15740 9000 {}
C {lab_pin.sym} 15740 9000 0 0 {name=l29197 lab=BLB79}
N 15760 8960 15740 8960 {}
C {lab_pin.sym} 15740 8960 0 0 {name=l29198 lab=WL45}
N 15840 9040 15860 9040 {}
C {lab_pin.sym} 15860 9040 0 0 {name=l29199 lab=VDD}
N 15840 8960 15860 8960 {}
C {lab_pin.sym} 15860 8960 0 0 {name=l29200 lab=VSS}
C {bitcell_6t.sym} 16000 9000 0 0 {name=Xr45c80}
N 15960 9040 15940 9040 {}
C {lab_pin.sym} 15940 9040 0 0 {name=l29201 lab=BL80}
N 15960 9000 15940 9000 {}
C {lab_pin.sym} 15940 9000 0 0 {name=l29202 lab=BLB80}
N 15960 8960 15940 8960 {}
C {lab_pin.sym} 15940 8960 0 0 {name=l29203 lab=WL45}
N 16040 9040 16060 9040 {}
C {lab_pin.sym} 16060 9040 0 0 {name=l29204 lab=VDD}
N 16040 8960 16060 8960 {}
C {lab_pin.sym} 16060 8960 0 0 {name=l29205 lab=VSS}
C {bitcell_6t.sym} 16200 9000 0 0 {name=Xr45c81}
N 16160 9040 16140 9040 {}
C {lab_pin.sym} 16140 9040 0 0 {name=l29206 lab=BL81}
N 16160 9000 16140 9000 {}
C {lab_pin.sym} 16140 9000 0 0 {name=l29207 lab=BLB81}
N 16160 8960 16140 8960 {}
C {lab_pin.sym} 16140 8960 0 0 {name=l29208 lab=WL45}
N 16240 9040 16260 9040 {}
C {lab_pin.sym} 16260 9040 0 0 {name=l29209 lab=VDD}
N 16240 8960 16260 8960 {}
C {lab_pin.sym} 16260 8960 0 0 {name=l29210 lab=VSS}
C {bitcell_6t.sym} 16400 9000 0 0 {name=Xr45c82}
N 16360 9040 16340 9040 {}
C {lab_pin.sym} 16340 9040 0 0 {name=l29211 lab=BL82}
N 16360 9000 16340 9000 {}
C {lab_pin.sym} 16340 9000 0 0 {name=l29212 lab=BLB82}
N 16360 8960 16340 8960 {}
C {lab_pin.sym} 16340 8960 0 0 {name=l29213 lab=WL45}
N 16440 9040 16460 9040 {}
C {lab_pin.sym} 16460 9040 0 0 {name=l29214 lab=VDD}
N 16440 8960 16460 8960 {}
C {lab_pin.sym} 16460 8960 0 0 {name=l29215 lab=VSS}
C {bitcell_6t.sym} 16600 9000 0 0 {name=Xr45c83}
N 16560 9040 16540 9040 {}
C {lab_pin.sym} 16540 9040 0 0 {name=l29216 lab=BL83}
N 16560 9000 16540 9000 {}
C {lab_pin.sym} 16540 9000 0 0 {name=l29217 lab=BLB83}
N 16560 8960 16540 8960 {}
C {lab_pin.sym} 16540 8960 0 0 {name=l29218 lab=WL45}
N 16640 9040 16660 9040 {}
C {lab_pin.sym} 16660 9040 0 0 {name=l29219 lab=VDD}
N 16640 8960 16660 8960 {}
C {lab_pin.sym} 16660 8960 0 0 {name=l29220 lab=VSS}
C {bitcell_6t.sym} 16800 9000 0 0 {name=Xr45c84}
N 16760 9040 16740 9040 {}
C {lab_pin.sym} 16740 9040 0 0 {name=l29221 lab=BL84}
N 16760 9000 16740 9000 {}
C {lab_pin.sym} 16740 9000 0 0 {name=l29222 lab=BLB84}
N 16760 8960 16740 8960 {}
C {lab_pin.sym} 16740 8960 0 0 {name=l29223 lab=WL45}
N 16840 9040 16860 9040 {}
C {lab_pin.sym} 16860 9040 0 0 {name=l29224 lab=VDD}
N 16840 8960 16860 8960 {}
C {lab_pin.sym} 16860 8960 0 0 {name=l29225 lab=VSS}
C {bitcell_6t.sym} 17000 9000 0 0 {name=Xr45c85}
N 16960 9040 16940 9040 {}
C {lab_pin.sym} 16940 9040 0 0 {name=l29226 lab=BL85}
N 16960 9000 16940 9000 {}
C {lab_pin.sym} 16940 9000 0 0 {name=l29227 lab=BLB85}
N 16960 8960 16940 8960 {}
C {lab_pin.sym} 16940 8960 0 0 {name=l29228 lab=WL45}
N 17040 9040 17060 9040 {}
C {lab_pin.sym} 17060 9040 0 0 {name=l29229 lab=VDD}
N 17040 8960 17060 8960 {}
C {lab_pin.sym} 17060 8960 0 0 {name=l29230 lab=VSS}
C {bitcell_6t.sym} 17200 9000 0 0 {name=Xr45c86}
N 17160 9040 17140 9040 {}
C {lab_pin.sym} 17140 9040 0 0 {name=l29231 lab=BL86}
N 17160 9000 17140 9000 {}
C {lab_pin.sym} 17140 9000 0 0 {name=l29232 lab=BLB86}
N 17160 8960 17140 8960 {}
C {lab_pin.sym} 17140 8960 0 0 {name=l29233 lab=WL45}
N 17240 9040 17260 9040 {}
C {lab_pin.sym} 17260 9040 0 0 {name=l29234 lab=VDD}
N 17240 8960 17260 8960 {}
C {lab_pin.sym} 17260 8960 0 0 {name=l29235 lab=VSS}
C {bitcell_6t.sym} 17400 9000 0 0 {name=Xr45c87}
N 17360 9040 17340 9040 {}
C {lab_pin.sym} 17340 9040 0 0 {name=l29236 lab=BL87}
N 17360 9000 17340 9000 {}
C {lab_pin.sym} 17340 9000 0 0 {name=l29237 lab=BLB87}
N 17360 8960 17340 8960 {}
C {lab_pin.sym} 17340 8960 0 0 {name=l29238 lab=WL45}
N 17440 9040 17460 9040 {}
C {lab_pin.sym} 17460 9040 0 0 {name=l29239 lab=VDD}
N 17440 8960 17460 8960 {}
C {lab_pin.sym} 17460 8960 0 0 {name=l29240 lab=VSS}
C {bitcell_6t.sym} 17600 9000 0 0 {name=Xr45c88}
N 17560 9040 17540 9040 {}
C {lab_pin.sym} 17540 9040 0 0 {name=l29241 lab=BL88}
N 17560 9000 17540 9000 {}
C {lab_pin.sym} 17540 9000 0 0 {name=l29242 lab=BLB88}
N 17560 8960 17540 8960 {}
C {lab_pin.sym} 17540 8960 0 0 {name=l29243 lab=WL45}
N 17640 9040 17660 9040 {}
C {lab_pin.sym} 17660 9040 0 0 {name=l29244 lab=VDD}
N 17640 8960 17660 8960 {}
C {lab_pin.sym} 17660 8960 0 0 {name=l29245 lab=VSS}
C {bitcell_6t.sym} 17800 9000 0 0 {name=Xr45c89}
N 17760 9040 17740 9040 {}
C {lab_pin.sym} 17740 9040 0 0 {name=l29246 lab=BL89}
N 17760 9000 17740 9000 {}
C {lab_pin.sym} 17740 9000 0 0 {name=l29247 lab=BLB89}
N 17760 8960 17740 8960 {}
C {lab_pin.sym} 17740 8960 0 0 {name=l29248 lab=WL45}
N 17840 9040 17860 9040 {}
C {lab_pin.sym} 17860 9040 0 0 {name=l29249 lab=VDD}
N 17840 8960 17860 8960 {}
C {lab_pin.sym} 17860 8960 0 0 {name=l29250 lab=VSS}
C {bitcell_6t.sym} 18000 9000 0 0 {name=Xr45c90}
N 17960 9040 17940 9040 {}
C {lab_pin.sym} 17940 9040 0 0 {name=l29251 lab=BL90}
N 17960 9000 17940 9000 {}
C {lab_pin.sym} 17940 9000 0 0 {name=l29252 lab=BLB90}
N 17960 8960 17940 8960 {}
C {lab_pin.sym} 17940 8960 0 0 {name=l29253 lab=WL45}
N 18040 9040 18060 9040 {}
C {lab_pin.sym} 18060 9040 0 0 {name=l29254 lab=VDD}
N 18040 8960 18060 8960 {}
C {lab_pin.sym} 18060 8960 0 0 {name=l29255 lab=VSS}
C {bitcell_6t.sym} 18200 9000 0 0 {name=Xr45c91}
N 18160 9040 18140 9040 {}
C {lab_pin.sym} 18140 9040 0 0 {name=l29256 lab=BL91}
N 18160 9000 18140 9000 {}
C {lab_pin.sym} 18140 9000 0 0 {name=l29257 lab=BLB91}
N 18160 8960 18140 8960 {}
C {lab_pin.sym} 18140 8960 0 0 {name=l29258 lab=WL45}
N 18240 9040 18260 9040 {}
C {lab_pin.sym} 18260 9040 0 0 {name=l29259 lab=VDD}
N 18240 8960 18260 8960 {}
C {lab_pin.sym} 18260 8960 0 0 {name=l29260 lab=VSS}
C {bitcell_6t.sym} 18400 9000 0 0 {name=Xr45c92}
N 18360 9040 18340 9040 {}
C {lab_pin.sym} 18340 9040 0 0 {name=l29261 lab=BL92}
N 18360 9000 18340 9000 {}
C {lab_pin.sym} 18340 9000 0 0 {name=l29262 lab=BLB92}
N 18360 8960 18340 8960 {}
C {lab_pin.sym} 18340 8960 0 0 {name=l29263 lab=WL45}
N 18440 9040 18460 9040 {}
C {lab_pin.sym} 18460 9040 0 0 {name=l29264 lab=VDD}
N 18440 8960 18460 8960 {}
C {lab_pin.sym} 18460 8960 0 0 {name=l29265 lab=VSS}
C {bitcell_6t.sym} 18600 9000 0 0 {name=Xr45c93}
N 18560 9040 18540 9040 {}
C {lab_pin.sym} 18540 9040 0 0 {name=l29266 lab=BL93}
N 18560 9000 18540 9000 {}
C {lab_pin.sym} 18540 9000 0 0 {name=l29267 lab=BLB93}
N 18560 8960 18540 8960 {}
C {lab_pin.sym} 18540 8960 0 0 {name=l29268 lab=WL45}
N 18640 9040 18660 9040 {}
C {lab_pin.sym} 18660 9040 0 0 {name=l29269 lab=VDD}
N 18640 8960 18660 8960 {}
C {lab_pin.sym} 18660 8960 0 0 {name=l29270 lab=VSS}
C {bitcell_6t.sym} 18800 9000 0 0 {name=Xr45c94}
N 18760 9040 18740 9040 {}
C {lab_pin.sym} 18740 9040 0 0 {name=l29271 lab=BL94}
N 18760 9000 18740 9000 {}
C {lab_pin.sym} 18740 9000 0 0 {name=l29272 lab=BLB94}
N 18760 8960 18740 8960 {}
C {lab_pin.sym} 18740 8960 0 0 {name=l29273 lab=WL45}
N 18840 9040 18860 9040 {}
C {lab_pin.sym} 18860 9040 0 0 {name=l29274 lab=VDD}
N 18840 8960 18860 8960 {}
C {lab_pin.sym} 18860 8960 0 0 {name=l29275 lab=VSS}
C {bitcell_6t.sym} 19000 9000 0 0 {name=Xr45c95}
N 18960 9040 18940 9040 {}
C {lab_pin.sym} 18940 9040 0 0 {name=l29276 lab=BL95}
N 18960 9000 18940 9000 {}
C {lab_pin.sym} 18940 9000 0 0 {name=l29277 lab=BLB95}
N 18960 8960 18940 8960 {}
C {lab_pin.sym} 18940 8960 0 0 {name=l29278 lab=WL45}
N 19040 9040 19060 9040 {}
C {lab_pin.sym} 19060 9040 0 0 {name=l29279 lab=VDD}
N 19040 8960 19060 8960 {}
C {lab_pin.sym} 19060 8960 0 0 {name=l29280 lab=VSS}
C {bitcell_6t.sym} 19200 9000 0 0 {name=Xr45c96}
N 19160 9040 19140 9040 {}
C {lab_pin.sym} 19140 9040 0 0 {name=l29281 lab=BL96}
N 19160 9000 19140 9000 {}
C {lab_pin.sym} 19140 9000 0 0 {name=l29282 lab=BLB96}
N 19160 8960 19140 8960 {}
C {lab_pin.sym} 19140 8960 0 0 {name=l29283 lab=WL45}
N 19240 9040 19260 9040 {}
C {lab_pin.sym} 19260 9040 0 0 {name=l29284 lab=VDD}
N 19240 8960 19260 8960 {}
C {lab_pin.sym} 19260 8960 0 0 {name=l29285 lab=VSS}
C {bitcell_6t.sym} 19400 9000 0 0 {name=Xr45c97}
N 19360 9040 19340 9040 {}
C {lab_pin.sym} 19340 9040 0 0 {name=l29286 lab=BL97}
N 19360 9000 19340 9000 {}
C {lab_pin.sym} 19340 9000 0 0 {name=l29287 lab=BLB97}
N 19360 8960 19340 8960 {}
C {lab_pin.sym} 19340 8960 0 0 {name=l29288 lab=WL45}
N 19440 9040 19460 9040 {}
C {lab_pin.sym} 19460 9040 0 0 {name=l29289 lab=VDD}
N 19440 8960 19460 8960 {}
C {lab_pin.sym} 19460 8960 0 0 {name=l29290 lab=VSS}
C {bitcell_6t.sym} 19600 9000 0 0 {name=Xr45c98}
N 19560 9040 19540 9040 {}
C {lab_pin.sym} 19540 9040 0 0 {name=l29291 lab=BL98}
N 19560 9000 19540 9000 {}
C {lab_pin.sym} 19540 9000 0 0 {name=l29292 lab=BLB98}
N 19560 8960 19540 8960 {}
C {lab_pin.sym} 19540 8960 0 0 {name=l29293 lab=WL45}
N 19640 9040 19660 9040 {}
C {lab_pin.sym} 19660 9040 0 0 {name=l29294 lab=VDD}
N 19640 8960 19660 8960 {}
C {lab_pin.sym} 19660 8960 0 0 {name=l29295 lab=VSS}
C {bitcell_6t.sym} 19800 9000 0 0 {name=Xr45c99}
N 19760 9040 19740 9040 {}
C {lab_pin.sym} 19740 9040 0 0 {name=l29296 lab=BL99}
N 19760 9000 19740 9000 {}
C {lab_pin.sym} 19740 9000 0 0 {name=l29297 lab=BLB99}
N 19760 8960 19740 8960 {}
C {lab_pin.sym} 19740 8960 0 0 {name=l29298 lab=WL45}
N 19840 9040 19860 9040 {}
C {lab_pin.sym} 19860 9040 0 0 {name=l29299 lab=VDD}
N 19840 8960 19860 8960 {}
C {lab_pin.sym} 19860 8960 0 0 {name=l29300 lab=VSS}
C {bitcell_6t.sym} 20000 9000 0 0 {name=Xr45c100}
N 19960 9040 19940 9040 {}
C {lab_pin.sym} 19940 9040 0 0 {name=l29301 lab=BL100}
N 19960 9000 19940 9000 {}
C {lab_pin.sym} 19940 9000 0 0 {name=l29302 lab=BLB100}
N 19960 8960 19940 8960 {}
C {lab_pin.sym} 19940 8960 0 0 {name=l29303 lab=WL45}
N 20040 9040 20060 9040 {}
C {lab_pin.sym} 20060 9040 0 0 {name=l29304 lab=VDD}
N 20040 8960 20060 8960 {}
C {lab_pin.sym} 20060 8960 0 0 {name=l29305 lab=VSS}
C {bitcell_6t.sym} 20200 9000 0 0 {name=Xr45c101}
N 20160 9040 20140 9040 {}
C {lab_pin.sym} 20140 9040 0 0 {name=l29306 lab=BL101}
N 20160 9000 20140 9000 {}
C {lab_pin.sym} 20140 9000 0 0 {name=l29307 lab=BLB101}
N 20160 8960 20140 8960 {}
C {lab_pin.sym} 20140 8960 0 0 {name=l29308 lab=WL45}
N 20240 9040 20260 9040 {}
C {lab_pin.sym} 20260 9040 0 0 {name=l29309 lab=VDD}
N 20240 8960 20260 8960 {}
C {lab_pin.sym} 20260 8960 0 0 {name=l29310 lab=VSS}
C {bitcell_6t.sym} 20400 9000 0 0 {name=Xr45c102}
N 20360 9040 20340 9040 {}
C {lab_pin.sym} 20340 9040 0 0 {name=l29311 lab=BL102}
N 20360 9000 20340 9000 {}
C {lab_pin.sym} 20340 9000 0 0 {name=l29312 lab=BLB102}
N 20360 8960 20340 8960 {}
C {lab_pin.sym} 20340 8960 0 0 {name=l29313 lab=WL45}
N 20440 9040 20460 9040 {}
C {lab_pin.sym} 20460 9040 0 0 {name=l29314 lab=VDD}
N 20440 8960 20460 8960 {}
C {lab_pin.sym} 20460 8960 0 0 {name=l29315 lab=VSS}
C {bitcell_6t.sym} 20600 9000 0 0 {name=Xr45c103}
N 20560 9040 20540 9040 {}
C {lab_pin.sym} 20540 9040 0 0 {name=l29316 lab=BL103}
N 20560 9000 20540 9000 {}
C {lab_pin.sym} 20540 9000 0 0 {name=l29317 lab=BLB103}
N 20560 8960 20540 8960 {}
C {lab_pin.sym} 20540 8960 0 0 {name=l29318 lab=WL45}
N 20640 9040 20660 9040 {}
C {lab_pin.sym} 20660 9040 0 0 {name=l29319 lab=VDD}
N 20640 8960 20660 8960 {}
C {lab_pin.sym} 20660 8960 0 0 {name=l29320 lab=VSS}
C {bitcell_6t.sym} 20800 9000 0 0 {name=Xr45c104}
N 20760 9040 20740 9040 {}
C {lab_pin.sym} 20740 9040 0 0 {name=l29321 lab=BL104}
N 20760 9000 20740 9000 {}
C {lab_pin.sym} 20740 9000 0 0 {name=l29322 lab=BLB104}
N 20760 8960 20740 8960 {}
C {lab_pin.sym} 20740 8960 0 0 {name=l29323 lab=WL45}
N 20840 9040 20860 9040 {}
C {lab_pin.sym} 20860 9040 0 0 {name=l29324 lab=VDD}
N 20840 8960 20860 8960 {}
C {lab_pin.sym} 20860 8960 0 0 {name=l29325 lab=VSS}
C {bitcell_6t.sym} 21000 9000 0 0 {name=Xr45c105}
N 20960 9040 20940 9040 {}
C {lab_pin.sym} 20940 9040 0 0 {name=l29326 lab=BL105}
N 20960 9000 20940 9000 {}
C {lab_pin.sym} 20940 9000 0 0 {name=l29327 lab=BLB105}
N 20960 8960 20940 8960 {}
C {lab_pin.sym} 20940 8960 0 0 {name=l29328 lab=WL45}
N 21040 9040 21060 9040 {}
C {lab_pin.sym} 21060 9040 0 0 {name=l29329 lab=VDD}
N 21040 8960 21060 8960 {}
C {lab_pin.sym} 21060 8960 0 0 {name=l29330 lab=VSS}
C {bitcell_6t.sym} 21200 9000 0 0 {name=Xr45c106}
N 21160 9040 21140 9040 {}
C {lab_pin.sym} 21140 9040 0 0 {name=l29331 lab=BL106}
N 21160 9000 21140 9000 {}
C {lab_pin.sym} 21140 9000 0 0 {name=l29332 lab=BLB106}
N 21160 8960 21140 8960 {}
C {lab_pin.sym} 21140 8960 0 0 {name=l29333 lab=WL45}
N 21240 9040 21260 9040 {}
C {lab_pin.sym} 21260 9040 0 0 {name=l29334 lab=VDD}
N 21240 8960 21260 8960 {}
C {lab_pin.sym} 21260 8960 0 0 {name=l29335 lab=VSS}
C {bitcell_6t.sym} 21400 9000 0 0 {name=Xr45c107}
N 21360 9040 21340 9040 {}
C {lab_pin.sym} 21340 9040 0 0 {name=l29336 lab=BL107}
N 21360 9000 21340 9000 {}
C {lab_pin.sym} 21340 9000 0 0 {name=l29337 lab=BLB107}
N 21360 8960 21340 8960 {}
C {lab_pin.sym} 21340 8960 0 0 {name=l29338 lab=WL45}
N 21440 9040 21460 9040 {}
C {lab_pin.sym} 21460 9040 0 0 {name=l29339 lab=VDD}
N 21440 8960 21460 8960 {}
C {lab_pin.sym} 21460 8960 0 0 {name=l29340 lab=VSS}
C {bitcell_6t.sym} 21600 9000 0 0 {name=Xr45c108}
N 21560 9040 21540 9040 {}
C {lab_pin.sym} 21540 9040 0 0 {name=l29341 lab=BL108}
N 21560 9000 21540 9000 {}
C {lab_pin.sym} 21540 9000 0 0 {name=l29342 lab=BLB108}
N 21560 8960 21540 8960 {}
C {lab_pin.sym} 21540 8960 0 0 {name=l29343 lab=WL45}
N 21640 9040 21660 9040 {}
C {lab_pin.sym} 21660 9040 0 0 {name=l29344 lab=VDD}
N 21640 8960 21660 8960 {}
C {lab_pin.sym} 21660 8960 0 0 {name=l29345 lab=VSS}
C {bitcell_6t.sym} 21800 9000 0 0 {name=Xr45c109}
N 21760 9040 21740 9040 {}
C {lab_pin.sym} 21740 9040 0 0 {name=l29346 lab=BL109}
N 21760 9000 21740 9000 {}
C {lab_pin.sym} 21740 9000 0 0 {name=l29347 lab=BLB109}
N 21760 8960 21740 8960 {}
C {lab_pin.sym} 21740 8960 0 0 {name=l29348 lab=WL45}
N 21840 9040 21860 9040 {}
C {lab_pin.sym} 21860 9040 0 0 {name=l29349 lab=VDD}
N 21840 8960 21860 8960 {}
C {lab_pin.sym} 21860 8960 0 0 {name=l29350 lab=VSS}
C {bitcell_6t.sym} 22000 9000 0 0 {name=Xr45c110}
N 21960 9040 21940 9040 {}
C {lab_pin.sym} 21940 9040 0 0 {name=l29351 lab=BL110}
N 21960 9000 21940 9000 {}
C {lab_pin.sym} 21940 9000 0 0 {name=l29352 lab=BLB110}
N 21960 8960 21940 8960 {}
C {lab_pin.sym} 21940 8960 0 0 {name=l29353 lab=WL45}
N 22040 9040 22060 9040 {}
C {lab_pin.sym} 22060 9040 0 0 {name=l29354 lab=VDD}
N 22040 8960 22060 8960 {}
C {lab_pin.sym} 22060 8960 0 0 {name=l29355 lab=VSS}
C {bitcell_6t.sym} 22200 9000 0 0 {name=Xr45c111}
N 22160 9040 22140 9040 {}
C {lab_pin.sym} 22140 9040 0 0 {name=l29356 lab=BL111}
N 22160 9000 22140 9000 {}
C {lab_pin.sym} 22140 9000 0 0 {name=l29357 lab=BLB111}
N 22160 8960 22140 8960 {}
C {lab_pin.sym} 22140 8960 0 0 {name=l29358 lab=WL45}
N 22240 9040 22260 9040 {}
C {lab_pin.sym} 22260 9040 0 0 {name=l29359 lab=VDD}
N 22240 8960 22260 8960 {}
C {lab_pin.sym} 22260 8960 0 0 {name=l29360 lab=VSS}
C {bitcell_6t.sym} 22400 9000 0 0 {name=Xr45c112}
N 22360 9040 22340 9040 {}
C {lab_pin.sym} 22340 9040 0 0 {name=l29361 lab=BL112}
N 22360 9000 22340 9000 {}
C {lab_pin.sym} 22340 9000 0 0 {name=l29362 lab=BLB112}
N 22360 8960 22340 8960 {}
C {lab_pin.sym} 22340 8960 0 0 {name=l29363 lab=WL45}
N 22440 9040 22460 9040 {}
C {lab_pin.sym} 22460 9040 0 0 {name=l29364 lab=VDD}
N 22440 8960 22460 8960 {}
C {lab_pin.sym} 22460 8960 0 0 {name=l29365 lab=VSS}
C {bitcell_6t.sym} 22600 9000 0 0 {name=Xr45c113}
N 22560 9040 22540 9040 {}
C {lab_pin.sym} 22540 9040 0 0 {name=l29366 lab=BL113}
N 22560 9000 22540 9000 {}
C {lab_pin.sym} 22540 9000 0 0 {name=l29367 lab=BLB113}
N 22560 8960 22540 8960 {}
C {lab_pin.sym} 22540 8960 0 0 {name=l29368 lab=WL45}
N 22640 9040 22660 9040 {}
C {lab_pin.sym} 22660 9040 0 0 {name=l29369 lab=VDD}
N 22640 8960 22660 8960 {}
C {lab_pin.sym} 22660 8960 0 0 {name=l29370 lab=VSS}
C {bitcell_6t.sym} 22800 9000 0 0 {name=Xr45c114}
N 22760 9040 22740 9040 {}
C {lab_pin.sym} 22740 9040 0 0 {name=l29371 lab=BL114}
N 22760 9000 22740 9000 {}
C {lab_pin.sym} 22740 9000 0 0 {name=l29372 lab=BLB114}
N 22760 8960 22740 8960 {}
C {lab_pin.sym} 22740 8960 0 0 {name=l29373 lab=WL45}
N 22840 9040 22860 9040 {}
C {lab_pin.sym} 22860 9040 0 0 {name=l29374 lab=VDD}
N 22840 8960 22860 8960 {}
C {lab_pin.sym} 22860 8960 0 0 {name=l29375 lab=VSS}
C {bitcell_6t.sym} 23000 9000 0 0 {name=Xr45c115}
N 22960 9040 22940 9040 {}
C {lab_pin.sym} 22940 9040 0 0 {name=l29376 lab=BL115}
N 22960 9000 22940 9000 {}
C {lab_pin.sym} 22940 9000 0 0 {name=l29377 lab=BLB115}
N 22960 8960 22940 8960 {}
C {lab_pin.sym} 22940 8960 0 0 {name=l29378 lab=WL45}
N 23040 9040 23060 9040 {}
C {lab_pin.sym} 23060 9040 0 0 {name=l29379 lab=VDD}
N 23040 8960 23060 8960 {}
C {lab_pin.sym} 23060 8960 0 0 {name=l29380 lab=VSS}
C {bitcell_6t.sym} 23200 9000 0 0 {name=Xr45c116}
N 23160 9040 23140 9040 {}
C {lab_pin.sym} 23140 9040 0 0 {name=l29381 lab=BL116}
N 23160 9000 23140 9000 {}
C {lab_pin.sym} 23140 9000 0 0 {name=l29382 lab=BLB116}
N 23160 8960 23140 8960 {}
C {lab_pin.sym} 23140 8960 0 0 {name=l29383 lab=WL45}
N 23240 9040 23260 9040 {}
C {lab_pin.sym} 23260 9040 0 0 {name=l29384 lab=VDD}
N 23240 8960 23260 8960 {}
C {lab_pin.sym} 23260 8960 0 0 {name=l29385 lab=VSS}
C {bitcell_6t.sym} 23400 9000 0 0 {name=Xr45c117}
N 23360 9040 23340 9040 {}
C {lab_pin.sym} 23340 9040 0 0 {name=l29386 lab=BL117}
N 23360 9000 23340 9000 {}
C {lab_pin.sym} 23340 9000 0 0 {name=l29387 lab=BLB117}
N 23360 8960 23340 8960 {}
C {lab_pin.sym} 23340 8960 0 0 {name=l29388 lab=WL45}
N 23440 9040 23460 9040 {}
C {lab_pin.sym} 23460 9040 0 0 {name=l29389 lab=VDD}
N 23440 8960 23460 8960 {}
C {lab_pin.sym} 23460 8960 0 0 {name=l29390 lab=VSS}
C {bitcell_6t.sym} 23600 9000 0 0 {name=Xr45c118}
N 23560 9040 23540 9040 {}
C {lab_pin.sym} 23540 9040 0 0 {name=l29391 lab=BL118}
N 23560 9000 23540 9000 {}
C {lab_pin.sym} 23540 9000 0 0 {name=l29392 lab=BLB118}
N 23560 8960 23540 8960 {}
C {lab_pin.sym} 23540 8960 0 0 {name=l29393 lab=WL45}
N 23640 9040 23660 9040 {}
C {lab_pin.sym} 23660 9040 0 0 {name=l29394 lab=VDD}
N 23640 8960 23660 8960 {}
C {lab_pin.sym} 23660 8960 0 0 {name=l29395 lab=VSS}
C {bitcell_6t.sym} 23800 9000 0 0 {name=Xr45c119}
N 23760 9040 23740 9040 {}
C {lab_pin.sym} 23740 9040 0 0 {name=l29396 lab=BL119}
N 23760 9000 23740 9000 {}
C {lab_pin.sym} 23740 9000 0 0 {name=l29397 lab=BLB119}
N 23760 8960 23740 8960 {}
C {lab_pin.sym} 23740 8960 0 0 {name=l29398 lab=WL45}
N 23840 9040 23860 9040 {}
C {lab_pin.sym} 23860 9040 0 0 {name=l29399 lab=VDD}
N 23840 8960 23860 8960 {}
C {lab_pin.sym} 23860 8960 0 0 {name=l29400 lab=VSS}
C {bitcell_6t.sym} 24000 9000 0 0 {name=Xr45c120}
N 23960 9040 23940 9040 {}
C {lab_pin.sym} 23940 9040 0 0 {name=l29401 lab=BL120}
N 23960 9000 23940 9000 {}
C {lab_pin.sym} 23940 9000 0 0 {name=l29402 lab=BLB120}
N 23960 8960 23940 8960 {}
C {lab_pin.sym} 23940 8960 0 0 {name=l29403 lab=WL45}
N 24040 9040 24060 9040 {}
C {lab_pin.sym} 24060 9040 0 0 {name=l29404 lab=VDD}
N 24040 8960 24060 8960 {}
C {lab_pin.sym} 24060 8960 0 0 {name=l29405 lab=VSS}
C {bitcell_6t.sym} 24200 9000 0 0 {name=Xr45c121}
N 24160 9040 24140 9040 {}
C {lab_pin.sym} 24140 9040 0 0 {name=l29406 lab=BL121}
N 24160 9000 24140 9000 {}
C {lab_pin.sym} 24140 9000 0 0 {name=l29407 lab=BLB121}
N 24160 8960 24140 8960 {}
C {lab_pin.sym} 24140 8960 0 0 {name=l29408 lab=WL45}
N 24240 9040 24260 9040 {}
C {lab_pin.sym} 24260 9040 0 0 {name=l29409 lab=VDD}
N 24240 8960 24260 8960 {}
C {lab_pin.sym} 24260 8960 0 0 {name=l29410 lab=VSS}
C {bitcell_6t.sym} 24400 9000 0 0 {name=Xr45c122}
N 24360 9040 24340 9040 {}
C {lab_pin.sym} 24340 9040 0 0 {name=l29411 lab=BL122}
N 24360 9000 24340 9000 {}
C {lab_pin.sym} 24340 9000 0 0 {name=l29412 lab=BLB122}
N 24360 8960 24340 8960 {}
C {lab_pin.sym} 24340 8960 0 0 {name=l29413 lab=WL45}
N 24440 9040 24460 9040 {}
C {lab_pin.sym} 24460 9040 0 0 {name=l29414 lab=VDD}
N 24440 8960 24460 8960 {}
C {lab_pin.sym} 24460 8960 0 0 {name=l29415 lab=VSS}
C {bitcell_6t.sym} 24600 9000 0 0 {name=Xr45c123}
N 24560 9040 24540 9040 {}
C {lab_pin.sym} 24540 9040 0 0 {name=l29416 lab=BL123}
N 24560 9000 24540 9000 {}
C {lab_pin.sym} 24540 9000 0 0 {name=l29417 lab=BLB123}
N 24560 8960 24540 8960 {}
C {lab_pin.sym} 24540 8960 0 0 {name=l29418 lab=WL45}
N 24640 9040 24660 9040 {}
C {lab_pin.sym} 24660 9040 0 0 {name=l29419 lab=VDD}
N 24640 8960 24660 8960 {}
C {lab_pin.sym} 24660 8960 0 0 {name=l29420 lab=VSS}
C {bitcell_6t.sym} 24800 9000 0 0 {name=Xr45c124}
N 24760 9040 24740 9040 {}
C {lab_pin.sym} 24740 9040 0 0 {name=l29421 lab=BL124}
N 24760 9000 24740 9000 {}
C {lab_pin.sym} 24740 9000 0 0 {name=l29422 lab=BLB124}
N 24760 8960 24740 8960 {}
C {lab_pin.sym} 24740 8960 0 0 {name=l29423 lab=WL45}
N 24840 9040 24860 9040 {}
C {lab_pin.sym} 24860 9040 0 0 {name=l29424 lab=VDD}
N 24840 8960 24860 8960 {}
C {lab_pin.sym} 24860 8960 0 0 {name=l29425 lab=VSS}
C {bitcell_6t.sym} 25000 9000 0 0 {name=Xr45c125}
N 24960 9040 24940 9040 {}
C {lab_pin.sym} 24940 9040 0 0 {name=l29426 lab=BL125}
N 24960 9000 24940 9000 {}
C {lab_pin.sym} 24940 9000 0 0 {name=l29427 lab=BLB125}
N 24960 8960 24940 8960 {}
C {lab_pin.sym} 24940 8960 0 0 {name=l29428 lab=WL45}
N 25040 9040 25060 9040 {}
C {lab_pin.sym} 25060 9040 0 0 {name=l29429 lab=VDD}
N 25040 8960 25060 8960 {}
C {lab_pin.sym} 25060 8960 0 0 {name=l29430 lab=VSS}
C {bitcell_6t.sym} 25200 9000 0 0 {name=Xr45c126}
N 25160 9040 25140 9040 {}
C {lab_pin.sym} 25140 9040 0 0 {name=l29431 lab=BL126}
N 25160 9000 25140 9000 {}
C {lab_pin.sym} 25140 9000 0 0 {name=l29432 lab=BLB126}
N 25160 8960 25140 8960 {}
C {lab_pin.sym} 25140 8960 0 0 {name=l29433 lab=WL45}
N 25240 9040 25260 9040 {}
C {lab_pin.sym} 25260 9040 0 0 {name=l29434 lab=VDD}
N 25240 8960 25260 8960 {}
C {lab_pin.sym} 25260 8960 0 0 {name=l29435 lab=VSS}
C {bitcell_6t.sym} 25400 9000 0 0 {name=Xr45c127}
N 25360 9040 25340 9040 {}
C {lab_pin.sym} 25340 9040 0 0 {name=l29436 lab=BL127}
N 25360 9000 25340 9000 {}
C {lab_pin.sym} 25340 9000 0 0 {name=l29437 lab=BLB127}
N 25360 8960 25340 8960 {}
C {lab_pin.sym} 25340 8960 0 0 {name=l29438 lab=WL45}
N 25440 9040 25460 9040 {}
C {lab_pin.sym} 25460 9040 0 0 {name=l29439 lab=VDD}
N 25440 8960 25460 8960 {}
C {lab_pin.sym} 25460 8960 0 0 {name=l29440 lab=VSS}
C {bitcell_6t.sym} 0 9200 0 0 {name=Xr46c0}
N -40 9240 -60 9240 {}
C {lab_pin.sym} -60 9240 0 0 {name=l29441 lab=BL0}
N -40 9200 -60 9200 {}
C {lab_pin.sym} -60 9200 0 0 {name=l29442 lab=BLB0}
N -40 9160 -60 9160 {}
C {lab_pin.sym} -60 9160 0 0 {name=l29443 lab=WL46}
N 40 9240 60 9240 {}
C {lab_pin.sym} 60 9240 0 0 {name=l29444 lab=VDD}
N 40 9160 60 9160 {}
C {lab_pin.sym} 60 9160 0 0 {name=l29445 lab=VSS}
C {bitcell_6t.sym} 200 9200 0 0 {name=Xr46c1}
N 160 9240 140 9240 {}
C {lab_pin.sym} 140 9240 0 0 {name=l29446 lab=BL1}
N 160 9200 140 9200 {}
C {lab_pin.sym} 140 9200 0 0 {name=l29447 lab=BLB1}
N 160 9160 140 9160 {}
C {lab_pin.sym} 140 9160 0 0 {name=l29448 lab=WL46}
N 240 9240 260 9240 {}
C {lab_pin.sym} 260 9240 0 0 {name=l29449 lab=VDD}
N 240 9160 260 9160 {}
C {lab_pin.sym} 260 9160 0 0 {name=l29450 lab=VSS}
C {bitcell_6t.sym} 400 9200 0 0 {name=Xr46c2}
N 360 9240 340 9240 {}
C {lab_pin.sym} 340 9240 0 0 {name=l29451 lab=BL2}
N 360 9200 340 9200 {}
C {lab_pin.sym} 340 9200 0 0 {name=l29452 lab=BLB2}
N 360 9160 340 9160 {}
C {lab_pin.sym} 340 9160 0 0 {name=l29453 lab=WL46}
N 440 9240 460 9240 {}
C {lab_pin.sym} 460 9240 0 0 {name=l29454 lab=VDD}
N 440 9160 460 9160 {}
C {lab_pin.sym} 460 9160 0 0 {name=l29455 lab=VSS}
C {bitcell_6t.sym} 600 9200 0 0 {name=Xr46c3}
N 560 9240 540 9240 {}
C {lab_pin.sym} 540 9240 0 0 {name=l29456 lab=BL3}
N 560 9200 540 9200 {}
C {lab_pin.sym} 540 9200 0 0 {name=l29457 lab=BLB3}
N 560 9160 540 9160 {}
C {lab_pin.sym} 540 9160 0 0 {name=l29458 lab=WL46}
N 640 9240 660 9240 {}
C {lab_pin.sym} 660 9240 0 0 {name=l29459 lab=VDD}
N 640 9160 660 9160 {}
C {lab_pin.sym} 660 9160 0 0 {name=l29460 lab=VSS}
C {bitcell_6t.sym} 800 9200 0 0 {name=Xr46c4}
N 760 9240 740 9240 {}
C {lab_pin.sym} 740 9240 0 0 {name=l29461 lab=BL4}
N 760 9200 740 9200 {}
C {lab_pin.sym} 740 9200 0 0 {name=l29462 lab=BLB4}
N 760 9160 740 9160 {}
C {lab_pin.sym} 740 9160 0 0 {name=l29463 lab=WL46}
N 840 9240 860 9240 {}
C {lab_pin.sym} 860 9240 0 0 {name=l29464 lab=VDD}
N 840 9160 860 9160 {}
C {lab_pin.sym} 860 9160 0 0 {name=l29465 lab=VSS}
C {bitcell_6t.sym} 1000 9200 0 0 {name=Xr46c5}
N 960 9240 940 9240 {}
C {lab_pin.sym} 940 9240 0 0 {name=l29466 lab=BL5}
N 960 9200 940 9200 {}
C {lab_pin.sym} 940 9200 0 0 {name=l29467 lab=BLB5}
N 960 9160 940 9160 {}
C {lab_pin.sym} 940 9160 0 0 {name=l29468 lab=WL46}
N 1040 9240 1060 9240 {}
C {lab_pin.sym} 1060 9240 0 0 {name=l29469 lab=VDD}
N 1040 9160 1060 9160 {}
C {lab_pin.sym} 1060 9160 0 0 {name=l29470 lab=VSS}
C {bitcell_6t.sym} 1200 9200 0 0 {name=Xr46c6}
N 1160 9240 1140 9240 {}
C {lab_pin.sym} 1140 9240 0 0 {name=l29471 lab=BL6}
N 1160 9200 1140 9200 {}
C {lab_pin.sym} 1140 9200 0 0 {name=l29472 lab=BLB6}
N 1160 9160 1140 9160 {}
C {lab_pin.sym} 1140 9160 0 0 {name=l29473 lab=WL46}
N 1240 9240 1260 9240 {}
C {lab_pin.sym} 1260 9240 0 0 {name=l29474 lab=VDD}
N 1240 9160 1260 9160 {}
C {lab_pin.sym} 1260 9160 0 0 {name=l29475 lab=VSS}
C {bitcell_6t.sym} 1400 9200 0 0 {name=Xr46c7}
N 1360 9240 1340 9240 {}
C {lab_pin.sym} 1340 9240 0 0 {name=l29476 lab=BL7}
N 1360 9200 1340 9200 {}
C {lab_pin.sym} 1340 9200 0 0 {name=l29477 lab=BLB7}
N 1360 9160 1340 9160 {}
C {lab_pin.sym} 1340 9160 0 0 {name=l29478 lab=WL46}
N 1440 9240 1460 9240 {}
C {lab_pin.sym} 1460 9240 0 0 {name=l29479 lab=VDD}
N 1440 9160 1460 9160 {}
C {lab_pin.sym} 1460 9160 0 0 {name=l29480 lab=VSS}
C {bitcell_6t.sym} 1600 9200 0 0 {name=Xr46c8}
N 1560 9240 1540 9240 {}
C {lab_pin.sym} 1540 9240 0 0 {name=l29481 lab=BL8}
N 1560 9200 1540 9200 {}
C {lab_pin.sym} 1540 9200 0 0 {name=l29482 lab=BLB8}
N 1560 9160 1540 9160 {}
C {lab_pin.sym} 1540 9160 0 0 {name=l29483 lab=WL46}
N 1640 9240 1660 9240 {}
C {lab_pin.sym} 1660 9240 0 0 {name=l29484 lab=VDD}
N 1640 9160 1660 9160 {}
C {lab_pin.sym} 1660 9160 0 0 {name=l29485 lab=VSS}
C {bitcell_6t.sym} 1800 9200 0 0 {name=Xr46c9}
N 1760 9240 1740 9240 {}
C {lab_pin.sym} 1740 9240 0 0 {name=l29486 lab=BL9}
N 1760 9200 1740 9200 {}
C {lab_pin.sym} 1740 9200 0 0 {name=l29487 lab=BLB9}
N 1760 9160 1740 9160 {}
C {lab_pin.sym} 1740 9160 0 0 {name=l29488 lab=WL46}
N 1840 9240 1860 9240 {}
C {lab_pin.sym} 1860 9240 0 0 {name=l29489 lab=VDD}
N 1840 9160 1860 9160 {}
C {lab_pin.sym} 1860 9160 0 0 {name=l29490 lab=VSS}
C {bitcell_6t.sym} 2000 9200 0 0 {name=Xr46c10}
N 1960 9240 1940 9240 {}
C {lab_pin.sym} 1940 9240 0 0 {name=l29491 lab=BL10}
N 1960 9200 1940 9200 {}
C {lab_pin.sym} 1940 9200 0 0 {name=l29492 lab=BLB10}
N 1960 9160 1940 9160 {}
C {lab_pin.sym} 1940 9160 0 0 {name=l29493 lab=WL46}
N 2040 9240 2060 9240 {}
C {lab_pin.sym} 2060 9240 0 0 {name=l29494 lab=VDD}
N 2040 9160 2060 9160 {}
C {lab_pin.sym} 2060 9160 0 0 {name=l29495 lab=VSS}
C {bitcell_6t.sym} 2200 9200 0 0 {name=Xr46c11}
N 2160 9240 2140 9240 {}
C {lab_pin.sym} 2140 9240 0 0 {name=l29496 lab=BL11}
N 2160 9200 2140 9200 {}
C {lab_pin.sym} 2140 9200 0 0 {name=l29497 lab=BLB11}
N 2160 9160 2140 9160 {}
C {lab_pin.sym} 2140 9160 0 0 {name=l29498 lab=WL46}
N 2240 9240 2260 9240 {}
C {lab_pin.sym} 2260 9240 0 0 {name=l29499 lab=VDD}
N 2240 9160 2260 9160 {}
C {lab_pin.sym} 2260 9160 0 0 {name=l29500 lab=VSS}
C {bitcell_6t.sym} 2400 9200 0 0 {name=Xr46c12}
N 2360 9240 2340 9240 {}
C {lab_pin.sym} 2340 9240 0 0 {name=l29501 lab=BL12}
N 2360 9200 2340 9200 {}
C {lab_pin.sym} 2340 9200 0 0 {name=l29502 lab=BLB12}
N 2360 9160 2340 9160 {}
C {lab_pin.sym} 2340 9160 0 0 {name=l29503 lab=WL46}
N 2440 9240 2460 9240 {}
C {lab_pin.sym} 2460 9240 0 0 {name=l29504 lab=VDD}
N 2440 9160 2460 9160 {}
C {lab_pin.sym} 2460 9160 0 0 {name=l29505 lab=VSS}
C {bitcell_6t.sym} 2600 9200 0 0 {name=Xr46c13}
N 2560 9240 2540 9240 {}
C {lab_pin.sym} 2540 9240 0 0 {name=l29506 lab=BL13}
N 2560 9200 2540 9200 {}
C {lab_pin.sym} 2540 9200 0 0 {name=l29507 lab=BLB13}
N 2560 9160 2540 9160 {}
C {lab_pin.sym} 2540 9160 0 0 {name=l29508 lab=WL46}
N 2640 9240 2660 9240 {}
C {lab_pin.sym} 2660 9240 0 0 {name=l29509 lab=VDD}
N 2640 9160 2660 9160 {}
C {lab_pin.sym} 2660 9160 0 0 {name=l29510 lab=VSS}
C {bitcell_6t.sym} 2800 9200 0 0 {name=Xr46c14}
N 2760 9240 2740 9240 {}
C {lab_pin.sym} 2740 9240 0 0 {name=l29511 lab=BL14}
N 2760 9200 2740 9200 {}
C {lab_pin.sym} 2740 9200 0 0 {name=l29512 lab=BLB14}
N 2760 9160 2740 9160 {}
C {lab_pin.sym} 2740 9160 0 0 {name=l29513 lab=WL46}
N 2840 9240 2860 9240 {}
C {lab_pin.sym} 2860 9240 0 0 {name=l29514 lab=VDD}
N 2840 9160 2860 9160 {}
C {lab_pin.sym} 2860 9160 0 0 {name=l29515 lab=VSS}
C {bitcell_6t.sym} 3000 9200 0 0 {name=Xr46c15}
N 2960 9240 2940 9240 {}
C {lab_pin.sym} 2940 9240 0 0 {name=l29516 lab=BL15}
N 2960 9200 2940 9200 {}
C {lab_pin.sym} 2940 9200 0 0 {name=l29517 lab=BLB15}
N 2960 9160 2940 9160 {}
C {lab_pin.sym} 2940 9160 0 0 {name=l29518 lab=WL46}
N 3040 9240 3060 9240 {}
C {lab_pin.sym} 3060 9240 0 0 {name=l29519 lab=VDD}
N 3040 9160 3060 9160 {}
C {lab_pin.sym} 3060 9160 0 0 {name=l29520 lab=VSS}
C {bitcell_6t.sym} 3200 9200 0 0 {name=Xr46c16}
N 3160 9240 3140 9240 {}
C {lab_pin.sym} 3140 9240 0 0 {name=l29521 lab=BL16}
N 3160 9200 3140 9200 {}
C {lab_pin.sym} 3140 9200 0 0 {name=l29522 lab=BLB16}
N 3160 9160 3140 9160 {}
C {lab_pin.sym} 3140 9160 0 0 {name=l29523 lab=WL46}
N 3240 9240 3260 9240 {}
C {lab_pin.sym} 3260 9240 0 0 {name=l29524 lab=VDD}
N 3240 9160 3260 9160 {}
C {lab_pin.sym} 3260 9160 0 0 {name=l29525 lab=VSS}
C {bitcell_6t.sym} 3400 9200 0 0 {name=Xr46c17}
N 3360 9240 3340 9240 {}
C {lab_pin.sym} 3340 9240 0 0 {name=l29526 lab=BL17}
N 3360 9200 3340 9200 {}
C {lab_pin.sym} 3340 9200 0 0 {name=l29527 lab=BLB17}
N 3360 9160 3340 9160 {}
C {lab_pin.sym} 3340 9160 0 0 {name=l29528 lab=WL46}
N 3440 9240 3460 9240 {}
C {lab_pin.sym} 3460 9240 0 0 {name=l29529 lab=VDD}
N 3440 9160 3460 9160 {}
C {lab_pin.sym} 3460 9160 0 0 {name=l29530 lab=VSS}
C {bitcell_6t.sym} 3600 9200 0 0 {name=Xr46c18}
N 3560 9240 3540 9240 {}
C {lab_pin.sym} 3540 9240 0 0 {name=l29531 lab=BL18}
N 3560 9200 3540 9200 {}
C {lab_pin.sym} 3540 9200 0 0 {name=l29532 lab=BLB18}
N 3560 9160 3540 9160 {}
C {lab_pin.sym} 3540 9160 0 0 {name=l29533 lab=WL46}
N 3640 9240 3660 9240 {}
C {lab_pin.sym} 3660 9240 0 0 {name=l29534 lab=VDD}
N 3640 9160 3660 9160 {}
C {lab_pin.sym} 3660 9160 0 0 {name=l29535 lab=VSS}
C {bitcell_6t.sym} 3800 9200 0 0 {name=Xr46c19}
N 3760 9240 3740 9240 {}
C {lab_pin.sym} 3740 9240 0 0 {name=l29536 lab=BL19}
N 3760 9200 3740 9200 {}
C {lab_pin.sym} 3740 9200 0 0 {name=l29537 lab=BLB19}
N 3760 9160 3740 9160 {}
C {lab_pin.sym} 3740 9160 0 0 {name=l29538 lab=WL46}
N 3840 9240 3860 9240 {}
C {lab_pin.sym} 3860 9240 0 0 {name=l29539 lab=VDD}
N 3840 9160 3860 9160 {}
C {lab_pin.sym} 3860 9160 0 0 {name=l29540 lab=VSS}
C {bitcell_6t.sym} 4000 9200 0 0 {name=Xr46c20}
N 3960 9240 3940 9240 {}
C {lab_pin.sym} 3940 9240 0 0 {name=l29541 lab=BL20}
N 3960 9200 3940 9200 {}
C {lab_pin.sym} 3940 9200 0 0 {name=l29542 lab=BLB20}
N 3960 9160 3940 9160 {}
C {lab_pin.sym} 3940 9160 0 0 {name=l29543 lab=WL46}
N 4040 9240 4060 9240 {}
C {lab_pin.sym} 4060 9240 0 0 {name=l29544 lab=VDD}
N 4040 9160 4060 9160 {}
C {lab_pin.sym} 4060 9160 0 0 {name=l29545 lab=VSS}
C {bitcell_6t.sym} 4200 9200 0 0 {name=Xr46c21}
N 4160 9240 4140 9240 {}
C {lab_pin.sym} 4140 9240 0 0 {name=l29546 lab=BL21}
N 4160 9200 4140 9200 {}
C {lab_pin.sym} 4140 9200 0 0 {name=l29547 lab=BLB21}
N 4160 9160 4140 9160 {}
C {lab_pin.sym} 4140 9160 0 0 {name=l29548 lab=WL46}
N 4240 9240 4260 9240 {}
C {lab_pin.sym} 4260 9240 0 0 {name=l29549 lab=VDD}
N 4240 9160 4260 9160 {}
C {lab_pin.sym} 4260 9160 0 0 {name=l29550 lab=VSS}
C {bitcell_6t.sym} 4400 9200 0 0 {name=Xr46c22}
N 4360 9240 4340 9240 {}
C {lab_pin.sym} 4340 9240 0 0 {name=l29551 lab=BL22}
N 4360 9200 4340 9200 {}
C {lab_pin.sym} 4340 9200 0 0 {name=l29552 lab=BLB22}
N 4360 9160 4340 9160 {}
C {lab_pin.sym} 4340 9160 0 0 {name=l29553 lab=WL46}
N 4440 9240 4460 9240 {}
C {lab_pin.sym} 4460 9240 0 0 {name=l29554 lab=VDD}
N 4440 9160 4460 9160 {}
C {lab_pin.sym} 4460 9160 0 0 {name=l29555 lab=VSS}
C {bitcell_6t.sym} 4600 9200 0 0 {name=Xr46c23}
N 4560 9240 4540 9240 {}
C {lab_pin.sym} 4540 9240 0 0 {name=l29556 lab=BL23}
N 4560 9200 4540 9200 {}
C {lab_pin.sym} 4540 9200 0 0 {name=l29557 lab=BLB23}
N 4560 9160 4540 9160 {}
C {lab_pin.sym} 4540 9160 0 0 {name=l29558 lab=WL46}
N 4640 9240 4660 9240 {}
C {lab_pin.sym} 4660 9240 0 0 {name=l29559 lab=VDD}
N 4640 9160 4660 9160 {}
C {lab_pin.sym} 4660 9160 0 0 {name=l29560 lab=VSS}
C {bitcell_6t.sym} 4800 9200 0 0 {name=Xr46c24}
N 4760 9240 4740 9240 {}
C {lab_pin.sym} 4740 9240 0 0 {name=l29561 lab=BL24}
N 4760 9200 4740 9200 {}
C {lab_pin.sym} 4740 9200 0 0 {name=l29562 lab=BLB24}
N 4760 9160 4740 9160 {}
C {lab_pin.sym} 4740 9160 0 0 {name=l29563 lab=WL46}
N 4840 9240 4860 9240 {}
C {lab_pin.sym} 4860 9240 0 0 {name=l29564 lab=VDD}
N 4840 9160 4860 9160 {}
C {lab_pin.sym} 4860 9160 0 0 {name=l29565 lab=VSS}
C {bitcell_6t.sym} 5000 9200 0 0 {name=Xr46c25}
N 4960 9240 4940 9240 {}
C {lab_pin.sym} 4940 9240 0 0 {name=l29566 lab=BL25}
N 4960 9200 4940 9200 {}
C {lab_pin.sym} 4940 9200 0 0 {name=l29567 lab=BLB25}
N 4960 9160 4940 9160 {}
C {lab_pin.sym} 4940 9160 0 0 {name=l29568 lab=WL46}
N 5040 9240 5060 9240 {}
C {lab_pin.sym} 5060 9240 0 0 {name=l29569 lab=VDD}
N 5040 9160 5060 9160 {}
C {lab_pin.sym} 5060 9160 0 0 {name=l29570 lab=VSS}
C {bitcell_6t.sym} 5200 9200 0 0 {name=Xr46c26}
N 5160 9240 5140 9240 {}
C {lab_pin.sym} 5140 9240 0 0 {name=l29571 lab=BL26}
N 5160 9200 5140 9200 {}
C {lab_pin.sym} 5140 9200 0 0 {name=l29572 lab=BLB26}
N 5160 9160 5140 9160 {}
C {lab_pin.sym} 5140 9160 0 0 {name=l29573 lab=WL46}
N 5240 9240 5260 9240 {}
C {lab_pin.sym} 5260 9240 0 0 {name=l29574 lab=VDD}
N 5240 9160 5260 9160 {}
C {lab_pin.sym} 5260 9160 0 0 {name=l29575 lab=VSS}
C {bitcell_6t.sym} 5400 9200 0 0 {name=Xr46c27}
N 5360 9240 5340 9240 {}
C {lab_pin.sym} 5340 9240 0 0 {name=l29576 lab=BL27}
N 5360 9200 5340 9200 {}
C {lab_pin.sym} 5340 9200 0 0 {name=l29577 lab=BLB27}
N 5360 9160 5340 9160 {}
C {lab_pin.sym} 5340 9160 0 0 {name=l29578 lab=WL46}
N 5440 9240 5460 9240 {}
C {lab_pin.sym} 5460 9240 0 0 {name=l29579 lab=VDD}
N 5440 9160 5460 9160 {}
C {lab_pin.sym} 5460 9160 0 0 {name=l29580 lab=VSS}
C {bitcell_6t.sym} 5600 9200 0 0 {name=Xr46c28}
N 5560 9240 5540 9240 {}
C {lab_pin.sym} 5540 9240 0 0 {name=l29581 lab=BL28}
N 5560 9200 5540 9200 {}
C {lab_pin.sym} 5540 9200 0 0 {name=l29582 lab=BLB28}
N 5560 9160 5540 9160 {}
C {lab_pin.sym} 5540 9160 0 0 {name=l29583 lab=WL46}
N 5640 9240 5660 9240 {}
C {lab_pin.sym} 5660 9240 0 0 {name=l29584 lab=VDD}
N 5640 9160 5660 9160 {}
C {lab_pin.sym} 5660 9160 0 0 {name=l29585 lab=VSS}
C {bitcell_6t.sym} 5800 9200 0 0 {name=Xr46c29}
N 5760 9240 5740 9240 {}
C {lab_pin.sym} 5740 9240 0 0 {name=l29586 lab=BL29}
N 5760 9200 5740 9200 {}
C {lab_pin.sym} 5740 9200 0 0 {name=l29587 lab=BLB29}
N 5760 9160 5740 9160 {}
C {lab_pin.sym} 5740 9160 0 0 {name=l29588 lab=WL46}
N 5840 9240 5860 9240 {}
C {lab_pin.sym} 5860 9240 0 0 {name=l29589 lab=VDD}
N 5840 9160 5860 9160 {}
C {lab_pin.sym} 5860 9160 0 0 {name=l29590 lab=VSS}
C {bitcell_6t.sym} 6000 9200 0 0 {name=Xr46c30}
N 5960 9240 5940 9240 {}
C {lab_pin.sym} 5940 9240 0 0 {name=l29591 lab=BL30}
N 5960 9200 5940 9200 {}
C {lab_pin.sym} 5940 9200 0 0 {name=l29592 lab=BLB30}
N 5960 9160 5940 9160 {}
C {lab_pin.sym} 5940 9160 0 0 {name=l29593 lab=WL46}
N 6040 9240 6060 9240 {}
C {lab_pin.sym} 6060 9240 0 0 {name=l29594 lab=VDD}
N 6040 9160 6060 9160 {}
C {lab_pin.sym} 6060 9160 0 0 {name=l29595 lab=VSS}
C {bitcell_6t.sym} 6200 9200 0 0 {name=Xr46c31}
N 6160 9240 6140 9240 {}
C {lab_pin.sym} 6140 9240 0 0 {name=l29596 lab=BL31}
N 6160 9200 6140 9200 {}
C {lab_pin.sym} 6140 9200 0 0 {name=l29597 lab=BLB31}
N 6160 9160 6140 9160 {}
C {lab_pin.sym} 6140 9160 0 0 {name=l29598 lab=WL46}
N 6240 9240 6260 9240 {}
C {lab_pin.sym} 6260 9240 0 0 {name=l29599 lab=VDD}
N 6240 9160 6260 9160 {}
C {lab_pin.sym} 6260 9160 0 0 {name=l29600 lab=VSS}
C {bitcell_6t.sym} 6400 9200 0 0 {name=Xr46c32}
N 6360 9240 6340 9240 {}
C {lab_pin.sym} 6340 9240 0 0 {name=l29601 lab=BL32}
N 6360 9200 6340 9200 {}
C {lab_pin.sym} 6340 9200 0 0 {name=l29602 lab=BLB32}
N 6360 9160 6340 9160 {}
C {lab_pin.sym} 6340 9160 0 0 {name=l29603 lab=WL46}
N 6440 9240 6460 9240 {}
C {lab_pin.sym} 6460 9240 0 0 {name=l29604 lab=VDD}
N 6440 9160 6460 9160 {}
C {lab_pin.sym} 6460 9160 0 0 {name=l29605 lab=VSS}
C {bitcell_6t.sym} 6600 9200 0 0 {name=Xr46c33}
N 6560 9240 6540 9240 {}
C {lab_pin.sym} 6540 9240 0 0 {name=l29606 lab=BL33}
N 6560 9200 6540 9200 {}
C {lab_pin.sym} 6540 9200 0 0 {name=l29607 lab=BLB33}
N 6560 9160 6540 9160 {}
C {lab_pin.sym} 6540 9160 0 0 {name=l29608 lab=WL46}
N 6640 9240 6660 9240 {}
C {lab_pin.sym} 6660 9240 0 0 {name=l29609 lab=VDD}
N 6640 9160 6660 9160 {}
C {lab_pin.sym} 6660 9160 0 0 {name=l29610 lab=VSS}
C {bitcell_6t.sym} 6800 9200 0 0 {name=Xr46c34}
N 6760 9240 6740 9240 {}
C {lab_pin.sym} 6740 9240 0 0 {name=l29611 lab=BL34}
N 6760 9200 6740 9200 {}
C {lab_pin.sym} 6740 9200 0 0 {name=l29612 lab=BLB34}
N 6760 9160 6740 9160 {}
C {lab_pin.sym} 6740 9160 0 0 {name=l29613 lab=WL46}
N 6840 9240 6860 9240 {}
C {lab_pin.sym} 6860 9240 0 0 {name=l29614 lab=VDD}
N 6840 9160 6860 9160 {}
C {lab_pin.sym} 6860 9160 0 0 {name=l29615 lab=VSS}
C {bitcell_6t.sym} 7000 9200 0 0 {name=Xr46c35}
N 6960 9240 6940 9240 {}
C {lab_pin.sym} 6940 9240 0 0 {name=l29616 lab=BL35}
N 6960 9200 6940 9200 {}
C {lab_pin.sym} 6940 9200 0 0 {name=l29617 lab=BLB35}
N 6960 9160 6940 9160 {}
C {lab_pin.sym} 6940 9160 0 0 {name=l29618 lab=WL46}
N 7040 9240 7060 9240 {}
C {lab_pin.sym} 7060 9240 0 0 {name=l29619 lab=VDD}
N 7040 9160 7060 9160 {}
C {lab_pin.sym} 7060 9160 0 0 {name=l29620 lab=VSS}
C {bitcell_6t.sym} 7200 9200 0 0 {name=Xr46c36}
N 7160 9240 7140 9240 {}
C {lab_pin.sym} 7140 9240 0 0 {name=l29621 lab=BL36}
N 7160 9200 7140 9200 {}
C {lab_pin.sym} 7140 9200 0 0 {name=l29622 lab=BLB36}
N 7160 9160 7140 9160 {}
C {lab_pin.sym} 7140 9160 0 0 {name=l29623 lab=WL46}
N 7240 9240 7260 9240 {}
C {lab_pin.sym} 7260 9240 0 0 {name=l29624 lab=VDD}
N 7240 9160 7260 9160 {}
C {lab_pin.sym} 7260 9160 0 0 {name=l29625 lab=VSS}
C {bitcell_6t.sym} 7400 9200 0 0 {name=Xr46c37}
N 7360 9240 7340 9240 {}
C {lab_pin.sym} 7340 9240 0 0 {name=l29626 lab=BL37}
N 7360 9200 7340 9200 {}
C {lab_pin.sym} 7340 9200 0 0 {name=l29627 lab=BLB37}
N 7360 9160 7340 9160 {}
C {lab_pin.sym} 7340 9160 0 0 {name=l29628 lab=WL46}
N 7440 9240 7460 9240 {}
C {lab_pin.sym} 7460 9240 0 0 {name=l29629 lab=VDD}
N 7440 9160 7460 9160 {}
C {lab_pin.sym} 7460 9160 0 0 {name=l29630 lab=VSS}
C {bitcell_6t.sym} 7600 9200 0 0 {name=Xr46c38}
N 7560 9240 7540 9240 {}
C {lab_pin.sym} 7540 9240 0 0 {name=l29631 lab=BL38}
N 7560 9200 7540 9200 {}
C {lab_pin.sym} 7540 9200 0 0 {name=l29632 lab=BLB38}
N 7560 9160 7540 9160 {}
C {lab_pin.sym} 7540 9160 0 0 {name=l29633 lab=WL46}
N 7640 9240 7660 9240 {}
C {lab_pin.sym} 7660 9240 0 0 {name=l29634 lab=VDD}
N 7640 9160 7660 9160 {}
C {lab_pin.sym} 7660 9160 0 0 {name=l29635 lab=VSS}
C {bitcell_6t.sym} 7800 9200 0 0 {name=Xr46c39}
N 7760 9240 7740 9240 {}
C {lab_pin.sym} 7740 9240 0 0 {name=l29636 lab=BL39}
N 7760 9200 7740 9200 {}
C {lab_pin.sym} 7740 9200 0 0 {name=l29637 lab=BLB39}
N 7760 9160 7740 9160 {}
C {lab_pin.sym} 7740 9160 0 0 {name=l29638 lab=WL46}
N 7840 9240 7860 9240 {}
C {lab_pin.sym} 7860 9240 0 0 {name=l29639 lab=VDD}
N 7840 9160 7860 9160 {}
C {lab_pin.sym} 7860 9160 0 0 {name=l29640 lab=VSS}
C {bitcell_6t.sym} 8000 9200 0 0 {name=Xr46c40}
N 7960 9240 7940 9240 {}
C {lab_pin.sym} 7940 9240 0 0 {name=l29641 lab=BL40}
N 7960 9200 7940 9200 {}
C {lab_pin.sym} 7940 9200 0 0 {name=l29642 lab=BLB40}
N 7960 9160 7940 9160 {}
C {lab_pin.sym} 7940 9160 0 0 {name=l29643 lab=WL46}
N 8040 9240 8060 9240 {}
C {lab_pin.sym} 8060 9240 0 0 {name=l29644 lab=VDD}
N 8040 9160 8060 9160 {}
C {lab_pin.sym} 8060 9160 0 0 {name=l29645 lab=VSS}
C {bitcell_6t.sym} 8200 9200 0 0 {name=Xr46c41}
N 8160 9240 8140 9240 {}
C {lab_pin.sym} 8140 9240 0 0 {name=l29646 lab=BL41}
N 8160 9200 8140 9200 {}
C {lab_pin.sym} 8140 9200 0 0 {name=l29647 lab=BLB41}
N 8160 9160 8140 9160 {}
C {lab_pin.sym} 8140 9160 0 0 {name=l29648 lab=WL46}
N 8240 9240 8260 9240 {}
C {lab_pin.sym} 8260 9240 0 0 {name=l29649 lab=VDD}
N 8240 9160 8260 9160 {}
C {lab_pin.sym} 8260 9160 0 0 {name=l29650 lab=VSS}
C {bitcell_6t.sym} 8400 9200 0 0 {name=Xr46c42}
N 8360 9240 8340 9240 {}
C {lab_pin.sym} 8340 9240 0 0 {name=l29651 lab=BL42}
N 8360 9200 8340 9200 {}
C {lab_pin.sym} 8340 9200 0 0 {name=l29652 lab=BLB42}
N 8360 9160 8340 9160 {}
C {lab_pin.sym} 8340 9160 0 0 {name=l29653 lab=WL46}
N 8440 9240 8460 9240 {}
C {lab_pin.sym} 8460 9240 0 0 {name=l29654 lab=VDD}
N 8440 9160 8460 9160 {}
C {lab_pin.sym} 8460 9160 0 0 {name=l29655 lab=VSS}
C {bitcell_6t.sym} 8600 9200 0 0 {name=Xr46c43}
N 8560 9240 8540 9240 {}
C {lab_pin.sym} 8540 9240 0 0 {name=l29656 lab=BL43}
N 8560 9200 8540 9200 {}
C {lab_pin.sym} 8540 9200 0 0 {name=l29657 lab=BLB43}
N 8560 9160 8540 9160 {}
C {lab_pin.sym} 8540 9160 0 0 {name=l29658 lab=WL46}
N 8640 9240 8660 9240 {}
C {lab_pin.sym} 8660 9240 0 0 {name=l29659 lab=VDD}
N 8640 9160 8660 9160 {}
C {lab_pin.sym} 8660 9160 0 0 {name=l29660 lab=VSS}
C {bitcell_6t.sym} 8800 9200 0 0 {name=Xr46c44}
N 8760 9240 8740 9240 {}
C {lab_pin.sym} 8740 9240 0 0 {name=l29661 lab=BL44}
N 8760 9200 8740 9200 {}
C {lab_pin.sym} 8740 9200 0 0 {name=l29662 lab=BLB44}
N 8760 9160 8740 9160 {}
C {lab_pin.sym} 8740 9160 0 0 {name=l29663 lab=WL46}
N 8840 9240 8860 9240 {}
C {lab_pin.sym} 8860 9240 0 0 {name=l29664 lab=VDD}
N 8840 9160 8860 9160 {}
C {lab_pin.sym} 8860 9160 0 0 {name=l29665 lab=VSS}
C {bitcell_6t.sym} 9000 9200 0 0 {name=Xr46c45}
N 8960 9240 8940 9240 {}
C {lab_pin.sym} 8940 9240 0 0 {name=l29666 lab=BL45}
N 8960 9200 8940 9200 {}
C {lab_pin.sym} 8940 9200 0 0 {name=l29667 lab=BLB45}
N 8960 9160 8940 9160 {}
C {lab_pin.sym} 8940 9160 0 0 {name=l29668 lab=WL46}
N 9040 9240 9060 9240 {}
C {lab_pin.sym} 9060 9240 0 0 {name=l29669 lab=VDD}
N 9040 9160 9060 9160 {}
C {lab_pin.sym} 9060 9160 0 0 {name=l29670 lab=VSS}
C {bitcell_6t.sym} 9200 9200 0 0 {name=Xr46c46}
N 9160 9240 9140 9240 {}
C {lab_pin.sym} 9140 9240 0 0 {name=l29671 lab=BL46}
N 9160 9200 9140 9200 {}
C {lab_pin.sym} 9140 9200 0 0 {name=l29672 lab=BLB46}
N 9160 9160 9140 9160 {}
C {lab_pin.sym} 9140 9160 0 0 {name=l29673 lab=WL46}
N 9240 9240 9260 9240 {}
C {lab_pin.sym} 9260 9240 0 0 {name=l29674 lab=VDD}
N 9240 9160 9260 9160 {}
C {lab_pin.sym} 9260 9160 0 0 {name=l29675 lab=VSS}
C {bitcell_6t.sym} 9400 9200 0 0 {name=Xr46c47}
N 9360 9240 9340 9240 {}
C {lab_pin.sym} 9340 9240 0 0 {name=l29676 lab=BL47}
N 9360 9200 9340 9200 {}
C {lab_pin.sym} 9340 9200 0 0 {name=l29677 lab=BLB47}
N 9360 9160 9340 9160 {}
C {lab_pin.sym} 9340 9160 0 0 {name=l29678 lab=WL46}
N 9440 9240 9460 9240 {}
C {lab_pin.sym} 9460 9240 0 0 {name=l29679 lab=VDD}
N 9440 9160 9460 9160 {}
C {lab_pin.sym} 9460 9160 0 0 {name=l29680 lab=VSS}
C {bitcell_6t.sym} 9600 9200 0 0 {name=Xr46c48}
N 9560 9240 9540 9240 {}
C {lab_pin.sym} 9540 9240 0 0 {name=l29681 lab=BL48}
N 9560 9200 9540 9200 {}
C {lab_pin.sym} 9540 9200 0 0 {name=l29682 lab=BLB48}
N 9560 9160 9540 9160 {}
C {lab_pin.sym} 9540 9160 0 0 {name=l29683 lab=WL46}
N 9640 9240 9660 9240 {}
C {lab_pin.sym} 9660 9240 0 0 {name=l29684 lab=VDD}
N 9640 9160 9660 9160 {}
C {lab_pin.sym} 9660 9160 0 0 {name=l29685 lab=VSS}
C {bitcell_6t.sym} 9800 9200 0 0 {name=Xr46c49}
N 9760 9240 9740 9240 {}
C {lab_pin.sym} 9740 9240 0 0 {name=l29686 lab=BL49}
N 9760 9200 9740 9200 {}
C {lab_pin.sym} 9740 9200 0 0 {name=l29687 lab=BLB49}
N 9760 9160 9740 9160 {}
C {lab_pin.sym} 9740 9160 0 0 {name=l29688 lab=WL46}
N 9840 9240 9860 9240 {}
C {lab_pin.sym} 9860 9240 0 0 {name=l29689 lab=VDD}
N 9840 9160 9860 9160 {}
C {lab_pin.sym} 9860 9160 0 0 {name=l29690 lab=VSS}
C {bitcell_6t.sym} 10000 9200 0 0 {name=Xr46c50}
N 9960 9240 9940 9240 {}
C {lab_pin.sym} 9940 9240 0 0 {name=l29691 lab=BL50}
N 9960 9200 9940 9200 {}
C {lab_pin.sym} 9940 9200 0 0 {name=l29692 lab=BLB50}
N 9960 9160 9940 9160 {}
C {lab_pin.sym} 9940 9160 0 0 {name=l29693 lab=WL46}
N 10040 9240 10060 9240 {}
C {lab_pin.sym} 10060 9240 0 0 {name=l29694 lab=VDD}
N 10040 9160 10060 9160 {}
C {lab_pin.sym} 10060 9160 0 0 {name=l29695 lab=VSS}
C {bitcell_6t.sym} 10200 9200 0 0 {name=Xr46c51}
N 10160 9240 10140 9240 {}
C {lab_pin.sym} 10140 9240 0 0 {name=l29696 lab=BL51}
N 10160 9200 10140 9200 {}
C {lab_pin.sym} 10140 9200 0 0 {name=l29697 lab=BLB51}
N 10160 9160 10140 9160 {}
C {lab_pin.sym} 10140 9160 0 0 {name=l29698 lab=WL46}
N 10240 9240 10260 9240 {}
C {lab_pin.sym} 10260 9240 0 0 {name=l29699 lab=VDD}
N 10240 9160 10260 9160 {}
C {lab_pin.sym} 10260 9160 0 0 {name=l29700 lab=VSS}
C {bitcell_6t.sym} 10400 9200 0 0 {name=Xr46c52}
N 10360 9240 10340 9240 {}
C {lab_pin.sym} 10340 9240 0 0 {name=l29701 lab=BL52}
N 10360 9200 10340 9200 {}
C {lab_pin.sym} 10340 9200 0 0 {name=l29702 lab=BLB52}
N 10360 9160 10340 9160 {}
C {lab_pin.sym} 10340 9160 0 0 {name=l29703 lab=WL46}
N 10440 9240 10460 9240 {}
C {lab_pin.sym} 10460 9240 0 0 {name=l29704 lab=VDD}
N 10440 9160 10460 9160 {}
C {lab_pin.sym} 10460 9160 0 0 {name=l29705 lab=VSS}
C {bitcell_6t.sym} 10600 9200 0 0 {name=Xr46c53}
N 10560 9240 10540 9240 {}
C {lab_pin.sym} 10540 9240 0 0 {name=l29706 lab=BL53}
N 10560 9200 10540 9200 {}
C {lab_pin.sym} 10540 9200 0 0 {name=l29707 lab=BLB53}
N 10560 9160 10540 9160 {}
C {lab_pin.sym} 10540 9160 0 0 {name=l29708 lab=WL46}
N 10640 9240 10660 9240 {}
C {lab_pin.sym} 10660 9240 0 0 {name=l29709 lab=VDD}
N 10640 9160 10660 9160 {}
C {lab_pin.sym} 10660 9160 0 0 {name=l29710 lab=VSS}
C {bitcell_6t.sym} 10800 9200 0 0 {name=Xr46c54}
N 10760 9240 10740 9240 {}
C {lab_pin.sym} 10740 9240 0 0 {name=l29711 lab=BL54}
N 10760 9200 10740 9200 {}
C {lab_pin.sym} 10740 9200 0 0 {name=l29712 lab=BLB54}
N 10760 9160 10740 9160 {}
C {lab_pin.sym} 10740 9160 0 0 {name=l29713 lab=WL46}
N 10840 9240 10860 9240 {}
C {lab_pin.sym} 10860 9240 0 0 {name=l29714 lab=VDD}
N 10840 9160 10860 9160 {}
C {lab_pin.sym} 10860 9160 0 0 {name=l29715 lab=VSS}
C {bitcell_6t.sym} 11000 9200 0 0 {name=Xr46c55}
N 10960 9240 10940 9240 {}
C {lab_pin.sym} 10940 9240 0 0 {name=l29716 lab=BL55}
N 10960 9200 10940 9200 {}
C {lab_pin.sym} 10940 9200 0 0 {name=l29717 lab=BLB55}
N 10960 9160 10940 9160 {}
C {lab_pin.sym} 10940 9160 0 0 {name=l29718 lab=WL46}
N 11040 9240 11060 9240 {}
C {lab_pin.sym} 11060 9240 0 0 {name=l29719 lab=VDD}
N 11040 9160 11060 9160 {}
C {lab_pin.sym} 11060 9160 0 0 {name=l29720 lab=VSS}
C {bitcell_6t.sym} 11200 9200 0 0 {name=Xr46c56}
N 11160 9240 11140 9240 {}
C {lab_pin.sym} 11140 9240 0 0 {name=l29721 lab=BL56}
N 11160 9200 11140 9200 {}
C {lab_pin.sym} 11140 9200 0 0 {name=l29722 lab=BLB56}
N 11160 9160 11140 9160 {}
C {lab_pin.sym} 11140 9160 0 0 {name=l29723 lab=WL46}
N 11240 9240 11260 9240 {}
C {lab_pin.sym} 11260 9240 0 0 {name=l29724 lab=VDD}
N 11240 9160 11260 9160 {}
C {lab_pin.sym} 11260 9160 0 0 {name=l29725 lab=VSS}
C {bitcell_6t.sym} 11400 9200 0 0 {name=Xr46c57}
N 11360 9240 11340 9240 {}
C {lab_pin.sym} 11340 9240 0 0 {name=l29726 lab=BL57}
N 11360 9200 11340 9200 {}
C {lab_pin.sym} 11340 9200 0 0 {name=l29727 lab=BLB57}
N 11360 9160 11340 9160 {}
C {lab_pin.sym} 11340 9160 0 0 {name=l29728 lab=WL46}
N 11440 9240 11460 9240 {}
C {lab_pin.sym} 11460 9240 0 0 {name=l29729 lab=VDD}
N 11440 9160 11460 9160 {}
C {lab_pin.sym} 11460 9160 0 0 {name=l29730 lab=VSS}
C {bitcell_6t.sym} 11600 9200 0 0 {name=Xr46c58}
N 11560 9240 11540 9240 {}
C {lab_pin.sym} 11540 9240 0 0 {name=l29731 lab=BL58}
N 11560 9200 11540 9200 {}
C {lab_pin.sym} 11540 9200 0 0 {name=l29732 lab=BLB58}
N 11560 9160 11540 9160 {}
C {lab_pin.sym} 11540 9160 0 0 {name=l29733 lab=WL46}
N 11640 9240 11660 9240 {}
C {lab_pin.sym} 11660 9240 0 0 {name=l29734 lab=VDD}
N 11640 9160 11660 9160 {}
C {lab_pin.sym} 11660 9160 0 0 {name=l29735 lab=VSS}
C {bitcell_6t.sym} 11800 9200 0 0 {name=Xr46c59}
N 11760 9240 11740 9240 {}
C {lab_pin.sym} 11740 9240 0 0 {name=l29736 lab=BL59}
N 11760 9200 11740 9200 {}
C {lab_pin.sym} 11740 9200 0 0 {name=l29737 lab=BLB59}
N 11760 9160 11740 9160 {}
C {lab_pin.sym} 11740 9160 0 0 {name=l29738 lab=WL46}
N 11840 9240 11860 9240 {}
C {lab_pin.sym} 11860 9240 0 0 {name=l29739 lab=VDD}
N 11840 9160 11860 9160 {}
C {lab_pin.sym} 11860 9160 0 0 {name=l29740 lab=VSS}
C {bitcell_6t.sym} 12000 9200 0 0 {name=Xr46c60}
N 11960 9240 11940 9240 {}
C {lab_pin.sym} 11940 9240 0 0 {name=l29741 lab=BL60}
N 11960 9200 11940 9200 {}
C {lab_pin.sym} 11940 9200 0 0 {name=l29742 lab=BLB60}
N 11960 9160 11940 9160 {}
C {lab_pin.sym} 11940 9160 0 0 {name=l29743 lab=WL46}
N 12040 9240 12060 9240 {}
C {lab_pin.sym} 12060 9240 0 0 {name=l29744 lab=VDD}
N 12040 9160 12060 9160 {}
C {lab_pin.sym} 12060 9160 0 0 {name=l29745 lab=VSS}
C {bitcell_6t.sym} 12200 9200 0 0 {name=Xr46c61}
N 12160 9240 12140 9240 {}
C {lab_pin.sym} 12140 9240 0 0 {name=l29746 lab=BL61}
N 12160 9200 12140 9200 {}
C {lab_pin.sym} 12140 9200 0 0 {name=l29747 lab=BLB61}
N 12160 9160 12140 9160 {}
C {lab_pin.sym} 12140 9160 0 0 {name=l29748 lab=WL46}
N 12240 9240 12260 9240 {}
C {lab_pin.sym} 12260 9240 0 0 {name=l29749 lab=VDD}
N 12240 9160 12260 9160 {}
C {lab_pin.sym} 12260 9160 0 0 {name=l29750 lab=VSS}
C {bitcell_6t.sym} 12400 9200 0 0 {name=Xr46c62}
N 12360 9240 12340 9240 {}
C {lab_pin.sym} 12340 9240 0 0 {name=l29751 lab=BL62}
N 12360 9200 12340 9200 {}
C {lab_pin.sym} 12340 9200 0 0 {name=l29752 lab=BLB62}
N 12360 9160 12340 9160 {}
C {lab_pin.sym} 12340 9160 0 0 {name=l29753 lab=WL46}
N 12440 9240 12460 9240 {}
C {lab_pin.sym} 12460 9240 0 0 {name=l29754 lab=VDD}
N 12440 9160 12460 9160 {}
C {lab_pin.sym} 12460 9160 0 0 {name=l29755 lab=VSS}
C {bitcell_6t.sym} 12600 9200 0 0 {name=Xr46c63}
N 12560 9240 12540 9240 {}
C {lab_pin.sym} 12540 9240 0 0 {name=l29756 lab=BL63}
N 12560 9200 12540 9200 {}
C {lab_pin.sym} 12540 9200 0 0 {name=l29757 lab=BLB63}
N 12560 9160 12540 9160 {}
C {lab_pin.sym} 12540 9160 0 0 {name=l29758 lab=WL46}
N 12640 9240 12660 9240 {}
C {lab_pin.sym} 12660 9240 0 0 {name=l29759 lab=VDD}
N 12640 9160 12660 9160 {}
C {lab_pin.sym} 12660 9160 0 0 {name=l29760 lab=VSS}
C {bitcell_6t.sym} 12800 9200 0 0 {name=Xr46c64}
N 12760 9240 12740 9240 {}
C {lab_pin.sym} 12740 9240 0 0 {name=l29761 lab=BL64}
N 12760 9200 12740 9200 {}
C {lab_pin.sym} 12740 9200 0 0 {name=l29762 lab=BLB64}
N 12760 9160 12740 9160 {}
C {lab_pin.sym} 12740 9160 0 0 {name=l29763 lab=WL46}
N 12840 9240 12860 9240 {}
C {lab_pin.sym} 12860 9240 0 0 {name=l29764 lab=VDD}
N 12840 9160 12860 9160 {}
C {lab_pin.sym} 12860 9160 0 0 {name=l29765 lab=VSS}
C {bitcell_6t.sym} 13000 9200 0 0 {name=Xr46c65}
N 12960 9240 12940 9240 {}
C {lab_pin.sym} 12940 9240 0 0 {name=l29766 lab=BL65}
N 12960 9200 12940 9200 {}
C {lab_pin.sym} 12940 9200 0 0 {name=l29767 lab=BLB65}
N 12960 9160 12940 9160 {}
C {lab_pin.sym} 12940 9160 0 0 {name=l29768 lab=WL46}
N 13040 9240 13060 9240 {}
C {lab_pin.sym} 13060 9240 0 0 {name=l29769 lab=VDD}
N 13040 9160 13060 9160 {}
C {lab_pin.sym} 13060 9160 0 0 {name=l29770 lab=VSS}
C {bitcell_6t.sym} 13200 9200 0 0 {name=Xr46c66}
N 13160 9240 13140 9240 {}
C {lab_pin.sym} 13140 9240 0 0 {name=l29771 lab=BL66}
N 13160 9200 13140 9200 {}
C {lab_pin.sym} 13140 9200 0 0 {name=l29772 lab=BLB66}
N 13160 9160 13140 9160 {}
C {lab_pin.sym} 13140 9160 0 0 {name=l29773 lab=WL46}
N 13240 9240 13260 9240 {}
C {lab_pin.sym} 13260 9240 0 0 {name=l29774 lab=VDD}
N 13240 9160 13260 9160 {}
C {lab_pin.sym} 13260 9160 0 0 {name=l29775 lab=VSS}
C {bitcell_6t.sym} 13400 9200 0 0 {name=Xr46c67}
N 13360 9240 13340 9240 {}
C {lab_pin.sym} 13340 9240 0 0 {name=l29776 lab=BL67}
N 13360 9200 13340 9200 {}
C {lab_pin.sym} 13340 9200 0 0 {name=l29777 lab=BLB67}
N 13360 9160 13340 9160 {}
C {lab_pin.sym} 13340 9160 0 0 {name=l29778 lab=WL46}
N 13440 9240 13460 9240 {}
C {lab_pin.sym} 13460 9240 0 0 {name=l29779 lab=VDD}
N 13440 9160 13460 9160 {}
C {lab_pin.sym} 13460 9160 0 0 {name=l29780 lab=VSS}
C {bitcell_6t.sym} 13600 9200 0 0 {name=Xr46c68}
N 13560 9240 13540 9240 {}
C {lab_pin.sym} 13540 9240 0 0 {name=l29781 lab=BL68}
N 13560 9200 13540 9200 {}
C {lab_pin.sym} 13540 9200 0 0 {name=l29782 lab=BLB68}
N 13560 9160 13540 9160 {}
C {lab_pin.sym} 13540 9160 0 0 {name=l29783 lab=WL46}
N 13640 9240 13660 9240 {}
C {lab_pin.sym} 13660 9240 0 0 {name=l29784 lab=VDD}
N 13640 9160 13660 9160 {}
C {lab_pin.sym} 13660 9160 0 0 {name=l29785 lab=VSS}
C {bitcell_6t.sym} 13800 9200 0 0 {name=Xr46c69}
N 13760 9240 13740 9240 {}
C {lab_pin.sym} 13740 9240 0 0 {name=l29786 lab=BL69}
N 13760 9200 13740 9200 {}
C {lab_pin.sym} 13740 9200 0 0 {name=l29787 lab=BLB69}
N 13760 9160 13740 9160 {}
C {lab_pin.sym} 13740 9160 0 0 {name=l29788 lab=WL46}
N 13840 9240 13860 9240 {}
C {lab_pin.sym} 13860 9240 0 0 {name=l29789 lab=VDD}
N 13840 9160 13860 9160 {}
C {lab_pin.sym} 13860 9160 0 0 {name=l29790 lab=VSS}
C {bitcell_6t.sym} 14000 9200 0 0 {name=Xr46c70}
N 13960 9240 13940 9240 {}
C {lab_pin.sym} 13940 9240 0 0 {name=l29791 lab=BL70}
N 13960 9200 13940 9200 {}
C {lab_pin.sym} 13940 9200 0 0 {name=l29792 lab=BLB70}
N 13960 9160 13940 9160 {}
C {lab_pin.sym} 13940 9160 0 0 {name=l29793 lab=WL46}
N 14040 9240 14060 9240 {}
C {lab_pin.sym} 14060 9240 0 0 {name=l29794 lab=VDD}
N 14040 9160 14060 9160 {}
C {lab_pin.sym} 14060 9160 0 0 {name=l29795 lab=VSS}
C {bitcell_6t.sym} 14200 9200 0 0 {name=Xr46c71}
N 14160 9240 14140 9240 {}
C {lab_pin.sym} 14140 9240 0 0 {name=l29796 lab=BL71}
N 14160 9200 14140 9200 {}
C {lab_pin.sym} 14140 9200 0 0 {name=l29797 lab=BLB71}
N 14160 9160 14140 9160 {}
C {lab_pin.sym} 14140 9160 0 0 {name=l29798 lab=WL46}
N 14240 9240 14260 9240 {}
C {lab_pin.sym} 14260 9240 0 0 {name=l29799 lab=VDD}
N 14240 9160 14260 9160 {}
C {lab_pin.sym} 14260 9160 0 0 {name=l29800 lab=VSS}
C {bitcell_6t.sym} 14400 9200 0 0 {name=Xr46c72}
N 14360 9240 14340 9240 {}
C {lab_pin.sym} 14340 9240 0 0 {name=l29801 lab=BL72}
N 14360 9200 14340 9200 {}
C {lab_pin.sym} 14340 9200 0 0 {name=l29802 lab=BLB72}
N 14360 9160 14340 9160 {}
C {lab_pin.sym} 14340 9160 0 0 {name=l29803 lab=WL46}
N 14440 9240 14460 9240 {}
C {lab_pin.sym} 14460 9240 0 0 {name=l29804 lab=VDD}
N 14440 9160 14460 9160 {}
C {lab_pin.sym} 14460 9160 0 0 {name=l29805 lab=VSS}
C {bitcell_6t.sym} 14600 9200 0 0 {name=Xr46c73}
N 14560 9240 14540 9240 {}
C {lab_pin.sym} 14540 9240 0 0 {name=l29806 lab=BL73}
N 14560 9200 14540 9200 {}
C {lab_pin.sym} 14540 9200 0 0 {name=l29807 lab=BLB73}
N 14560 9160 14540 9160 {}
C {lab_pin.sym} 14540 9160 0 0 {name=l29808 lab=WL46}
N 14640 9240 14660 9240 {}
C {lab_pin.sym} 14660 9240 0 0 {name=l29809 lab=VDD}
N 14640 9160 14660 9160 {}
C {lab_pin.sym} 14660 9160 0 0 {name=l29810 lab=VSS}
C {bitcell_6t.sym} 14800 9200 0 0 {name=Xr46c74}
N 14760 9240 14740 9240 {}
C {lab_pin.sym} 14740 9240 0 0 {name=l29811 lab=BL74}
N 14760 9200 14740 9200 {}
C {lab_pin.sym} 14740 9200 0 0 {name=l29812 lab=BLB74}
N 14760 9160 14740 9160 {}
C {lab_pin.sym} 14740 9160 0 0 {name=l29813 lab=WL46}
N 14840 9240 14860 9240 {}
C {lab_pin.sym} 14860 9240 0 0 {name=l29814 lab=VDD}
N 14840 9160 14860 9160 {}
C {lab_pin.sym} 14860 9160 0 0 {name=l29815 lab=VSS}
C {bitcell_6t.sym} 15000 9200 0 0 {name=Xr46c75}
N 14960 9240 14940 9240 {}
C {lab_pin.sym} 14940 9240 0 0 {name=l29816 lab=BL75}
N 14960 9200 14940 9200 {}
C {lab_pin.sym} 14940 9200 0 0 {name=l29817 lab=BLB75}
N 14960 9160 14940 9160 {}
C {lab_pin.sym} 14940 9160 0 0 {name=l29818 lab=WL46}
N 15040 9240 15060 9240 {}
C {lab_pin.sym} 15060 9240 0 0 {name=l29819 lab=VDD}
N 15040 9160 15060 9160 {}
C {lab_pin.sym} 15060 9160 0 0 {name=l29820 lab=VSS}
C {bitcell_6t.sym} 15200 9200 0 0 {name=Xr46c76}
N 15160 9240 15140 9240 {}
C {lab_pin.sym} 15140 9240 0 0 {name=l29821 lab=BL76}
N 15160 9200 15140 9200 {}
C {lab_pin.sym} 15140 9200 0 0 {name=l29822 lab=BLB76}
N 15160 9160 15140 9160 {}
C {lab_pin.sym} 15140 9160 0 0 {name=l29823 lab=WL46}
N 15240 9240 15260 9240 {}
C {lab_pin.sym} 15260 9240 0 0 {name=l29824 lab=VDD}
N 15240 9160 15260 9160 {}
C {lab_pin.sym} 15260 9160 0 0 {name=l29825 lab=VSS}
C {bitcell_6t.sym} 15400 9200 0 0 {name=Xr46c77}
N 15360 9240 15340 9240 {}
C {lab_pin.sym} 15340 9240 0 0 {name=l29826 lab=BL77}
N 15360 9200 15340 9200 {}
C {lab_pin.sym} 15340 9200 0 0 {name=l29827 lab=BLB77}
N 15360 9160 15340 9160 {}
C {lab_pin.sym} 15340 9160 0 0 {name=l29828 lab=WL46}
N 15440 9240 15460 9240 {}
C {lab_pin.sym} 15460 9240 0 0 {name=l29829 lab=VDD}
N 15440 9160 15460 9160 {}
C {lab_pin.sym} 15460 9160 0 0 {name=l29830 lab=VSS}
C {bitcell_6t.sym} 15600 9200 0 0 {name=Xr46c78}
N 15560 9240 15540 9240 {}
C {lab_pin.sym} 15540 9240 0 0 {name=l29831 lab=BL78}
N 15560 9200 15540 9200 {}
C {lab_pin.sym} 15540 9200 0 0 {name=l29832 lab=BLB78}
N 15560 9160 15540 9160 {}
C {lab_pin.sym} 15540 9160 0 0 {name=l29833 lab=WL46}
N 15640 9240 15660 9240 {}
C {lab_pin.sym} 15660 9240 0 0 {name=l29834 lab=VDD}
N 15640 9160 15660 9160 {}
C {lab_pin.sym} 15660 9160 0 0 {name=l29835 lab=VSS}
C {bitcell_6t.sym} 15800 9200 0 0 {name=Xr46c79}
N 15760 9240 15740 9240 {}
C {lab_pin.sym} 15740 9240 0 0 {name=l29836 lab=BL79}
N 15760 9200 15740 9200 {}
C {lab_pin.sym} 15740 9200 0 0 {name=l29837 lab=BLB79}
N 15760 9160 15740 9160 {}
C {lab_pin.sym} 15740 9160 0 0 {name=l29838 lab=WL46}
N 15840 9240 15860 9240 {}
C {lab_pin.sym} 15860 9240 0 0 {name=l29839 lab=VDD}
N 15840 9160 15860 9160 {}
C {lab_pin.sym} 15860 9160 0 0 {name=l29840 lab=VSS}
C {bitcell_6t.sym} 16000 9200 0 0 {name=Xr46c80}
N 15960 9240 15940 9240 {}
C {lab_pin.sym} 15940 9240 0 0 {name=l29841 lab=BL80}
N 15960 9200 15940 9200 {}
C {lab_pin.sym} 15940 9200 0 0 {name=l29842 lab=BLB80}
N 15960 9160 15940 9160 {}
C {lab_pin.sym} 15940 9160 0 0 {name=l29843 lab=WL46}
N 16040 9240 16060 9240 {}
C {lab_pin.sym} 16060 9240 0 0 {name=l29844 lab=VDD}
N 16040 9160 16060 9160 {}
C {lab_pin.sym} 16060 9160 0 0 {name=l29845 lab=VSS}
C {bitcell_6t.sym} 16200 9200 0 0 {name=Xr46c81}
N 16160 9240 16140 9240 {}
C {lab_pin.sym} 16140 9240 0 0 {name=l29846 lab=BL81}
N 16160 9200 16140 9200 {}
C {lab_pin.sym} 16140 9200 0 0 {name=l29847 lab=BLB81}
N 16160 9160 16140 9160 {}
C {lab_pin.sym} 16140 9160 0 0 {name=l29848 lab=WL46}
N 16240 9240 16260 9240 {}
C {lab_pin.sym} 16260 9240 0 0 {name=l29849 lab=VDD}
N 16240 9160 16260 9160 {}
C {lab_pin.sym} 16260 9160 0 0 {name=l29850 lab=VSS}
C {bitcell_6t.sym} 16400 9200 0 0 {name=Xr46c82}
N 16360 9240 16340 9240 {}
C {lab_pin.sym} 16340 9240 0 0 {name=l29851 lab=BL82}
N 16360 9200 16340 9200 {}
C {lab_pin.sym} 16340 9200 0 0 {name=l29852 lab=BLB82}
N 16360 9160 16340 9160 {}
C {lab_pin.sym} 16340 9160 0 0 {name=l29853 lab=WL46}
N 16440 9240 16460 9240 {}
C {lab_pin.sym} 16460 9240 0 0 {name=l29854 lab=VDD}
N 16440 9160 16460 9160 {}
C {lab_pin.sym} 16460 9160 0 0 {name=l29855 lab=VSS}
C {bitcell_6t.sym} 16600 9200 0 0 {name=Xr46c83}
N 16560 9240 16540 9240 {}
C {lab_pin.sym} 16540 9240 0 0 {name=l29856 lab=BL83}
N 16560 9200 16540 9200 {}
C {lab_pin.sym} 16540 9200 0 0 {name=l29857 lab=BLB83}
N 16560 9160 16540 9160 {}
C {lab_pin.sym} 16540 9160 0 0 {name=l29858 lab=WL46}
N 16640 9240 16660 9240 {}
C {lab_pin.sym} 16660 9240 0 0 {name=l29859 lab=VDD}
N 16640 9160 16660 9160 {}
C {lab_pin.sym} 16660 9160 0 0 {name=l29860 lab=VSS}
C {bitcell_6t.sym} 16800 9200 0 0 {name=Xr46c84}
N 16760 9240 16740 9240 {}
C {lab_pin.sym} 16740 9240 0 0 {name=l29861 lab=BL84}
N 16760 9200 16740 9200 {}
C {lab_pin.sym} 16740 9200 0 0 {name=l29862 lab=BLB84}
N 16760 9160 16740 9160 {}
C {lab_pin.sym} 16740 9160 0 0 {name=l29863 lab=WL46}
N 16840 9240 16860 9240 {}
C {lab_pin.sym} 16860 9240 0 0 {name=l29864 lab=VDD}
N 16840 9160 16860 9160 {}
C {lab_pin.sym} 16860 9160 0 0 {name=l29865 lab=VSS}
C {bitcell_6t.sym} 17000 9200 0 0 {name=Xr46c85}
N 16960 9240 16940 9240 {}
C {lab_pin.sym} 16940 9240 0 0 {name=l29866 lab=BL85}
N 16960 9200 16940 9200 {}
C {lab_pin.sym} 16940 9200 0 0 {name=l29867 lab=BLB85}
N 16960 9160 16940 9160 {}
C {lab_pin.sym} 16940 9160 0 0 {name=l29868 lab=WL46}
N 17040 9240 17060 9240 {}
C {lab_pin.sym} 17060 9240 0 0 {name=l29869 lab=VDD}
N 17040 9160 17060 9160 {}
C {lab_pin.sym} 17060 9160 0 0 {name=l29870 lab=VSS}
C {bitcell_6t.sym} 17200 9200 0 0 {name=Xr46c86}
N 17160 9240 17140 9240 {}
C {lab_pin.sym} 17140 9240 0 0 {name=l29871 lab=BL86}
N 17160 9200 17140 9200 {}
C {lab_pin.sym} 17140 9200 0 0 {name=l29872 lab=BLB86}
N 17160 9160 17140 9160 {}
C {lab_pin.sym} 17140 9160 0 0 {name=l29873 lab=WL46}
N 17240 9240 17260 9240 {}
C {lab_pin.sym} 17260 9240 0 0 {name=l29874 lab=VDD}
N 17240 9160 17260 9160 {}
C {lab_pin.sym} 17260 9160 0 0 {name=l29875 lab=VSS}
C {bitcell_6t.sym} 17400 9200 0 0 {name=Xr46c87}
N 17360 9240 17340 9240 {}
C {lab_pin.sym} 17340 9240 0 0 {name=l29876 lab=BL87}
N 17360 9200 17340 9200 {}
C {lab_pin.sym} 17340 9200 0 0 {name=l29877 lab=BLB87}
N 17360 9160 17340 9160 {}
C {lab_pin.sym} 17340 9160 0 0 {name=l29878 lab=WL46}
N 17440 9240 17460 9240 {}
C {lab_pin.sym} 17460 9240 0 0 {name=l29879 lab=VDD}
N 17440 9160 17460 9160 {}
C {lab_pin.sym} 17460 9160 0 0 {name=l29880 lab=VSS}
C {bitcell_6t.sym} 17600 9200 0 0 {name=Xr46c88}
N 17560 9240 17540 9240 {}
C {lab_pin.sym} 17540 9240 0 0 {name=l29881 lab=BL88}
N 17560 9200 17540 9200 {}
C {lab_pin.sym} 17540 9200 0 0 {name=l29882 lab=BLB88}
N 17560 9160 17540 9160 {}
C {lab_pin.sym} 17540 9160 0 0 {name=l29883 lab=WL46}
N 17640 9240 17660 9240 {}
C {lab_pin.sym} 17660 9240 0 0 {name=l29884 lab=VDD}
N 17640 9160 17660 9160 {}
C {lab_pin.sym} 17660 9160 0 0 {name=l29885 lab=VSS}
C {bitcell_6t.sym} 17800 9200 0 0 {name=Xr46c89}
N 17760 9240 17740 9240 {}
C {lab_pin.sym} 17740 9240 0 0 {name=l29886 lab=BL89}
N 17760 9200 17740 9200 {}
C {lab_pin.sym} 17740 9200 0 0 {name=l29887 lab=BLB89}
N 17760 9160 17740 9160 {}
C {lab_pin.sym} 17740 9160 0 0 {name=l29888 lab=WL46}
N 17840 9240 17860 9240 {}
C {lab_pin.sym} 17860 9240 0 0 {name=l29889 lab=VDD}
N 17840 9160 17860 9160 {}
C {lab_pin.sym} 17860 9160 0 0 {name=l29890 lab=VSS}
C {bitcell_6t.sym} 18000 9200 0 0 {name=Xr46c90}
N 17960 9240 17940 9240 {}
C {lab_pin.sym} 17940 9240 0 0 {name=l29891 lab=BL90}
N 17960 9200 17940 9200 {}
C {lab_pin.sym} 17940 9200 0 0 {name=l29892 lab=BLB90}
N 17960 9160 17940 9160 {}
C {lab_pin.sym} 17940 9160 0 0 {name=l29893 lab=WL46}
N 18040 9240 18060 9240 {}
C {lab_pin.sym} 18060 9240 0 0 {name=l29894 lab=VDD}
N 18040 9160 18060 9160 {}
C {lab_pin.sym} 18060 9160 0 0 {name=l29895 lab=VSS}
C {bitcell_6t.sym} 18200 9200 0 0 {name=Xr46c91}
N 18160 9240 18140 9240 {}
C {lab_pin.sym} 18140 9240 0 0 {name=l29896 lab=BL91}
N 18160 9200 18140 9200 {}
C {lab_pin.sym} 18140 9200 0 0 {name=l29897 lab=BLB91}
N 18160 9160 18140 9160 {}
C {lab_pin.sym} 18140 9160 0 0 {name=l29898 lab=WL46}
N 18240 9240 18260 9240 {}
C {lab_pin.sym} 18260 9240 0 0 {name=l29899 lab=VDD}
N 18240 9160 18260 9160 {}
C {lab_pin.sym} 18260 9160 0 0 {name=l29900 lab=VSS}
C {bitcell_6t.sym} 18400 9200 0 0 {name=Xr46c92}
N 18360 9240 18340 9240 {}
C {lab_pin.sym} 18340 9240 0 0 {name=l29901 lab=BL92}
N 18360 9200 18340 9200 {}
C {lab_pin.sym} 18340 9200 0 0 {name=l29902 lab=BLB92}
N 18360 9160 18340 9160 {}
C {lab_pin.sym} 18340 9160 0 0 {name=l29903 lab=WL46}
N 18440 9240 18460 9240 {}
C {lab_pin.sym} 18460 9240 0 0 {name=l29904 lab=VDD}
N 18440 9160 18460 9160 {}
C {lab_pin.sym} 18460 9160 0 0 {name=l29905 lab=VSS}
C {bitcell_6t.sym} 18600 9200 0 0 {name=Xr46c93}
N 18560 9240 18540 9240 {}
C {lab_pin.sym} 18540 9240 0 0 {name=l29906 lab=BL93}
N 18560 9200 18540 9200 {}
C {lab_pin.sym} 18540 9200 0 0 {name=l29907 lab=BLB93}
N 18560 9160 18540 9160 {}
C {lab_pin.sym} 18540 9160 0 0 {name=l29908 lab=WL46}
N 18640 9240 18660 9240 {}
C {lab_pin.sym} 18660 9240 0 0 {name=l29909 lab=VDD}
N 18640 9160 18660 9160 {}
C {lab_pin.sym} 18660 9160 0 0 {name=l29910 lab=VSS}
C {bitcell_6t.sym} 18800 9200 0 0 {name=Xr46c94}
N 18760 9240 18740 9240 {}
C {lab_pin.sym} 18740 9240 0 0 {name=l29911 lab=BL94}
N 18760 9200 18740 9200 {}
C {lab_pin.sym} 18740 9200 0 0 {name=l29912 lab=BLB94}
N 18760 9160 18740 9160 {}
C {lab_pin.sym} 18740 9160 0 0 {name=l29913 lab=WL46}
N 18840 9240 18860 9240 {}
C {lab_pin.sym} 18860 9240 0 0 {name=l29914 lab=VDD}
N 18840 9160 18860 9160 {}
C {lab_pin.sym} 18860 9160 0 0 {name=l29915 lab=VSS}
C {bitcell_6t.sym} 19000 9200 0 0 {name=Xr46c95}
N 18960 9240 18940 9240 {}
C {lab_pin.sym} 18940 9240 0 0 {name=l29916 lab=BL95}
N 18960 9200 18940 9200 {}
C {lab_pin.sym} 18940 9200 0 0 {name=l29917 lab=BLB95}
N 18960 9160 18940 9160 {}
C {lab_pin.sym} 18940 9160 0 0 {name=l29918 lab=WL46}
N 19040 9240 19060 9240 {}
C {lab_pin.sym} 19060 9240 0 0 {name=l29919 lab=VDD}
N 19040 9160 19060 9160 {}
C {lab_pin.sym} 19060 9160 0 0 {name=l29920 lab=VSS}
C {bitcell_6t.sym} 19200 9200 0 0 {name=Xr46c96}
N 19160 9240 19140 9240 {}
C {lab_pin.sym} 19140 9240 0 0 {name=l29921 lab=BL96}
N 19160 9200 19140 9200 {}
C {lab_pin.sym} 19140 9200 0 0 {name=l29922 lab=BLB96}
N 19160 9160 19140 9160 {}
C {lab_pin.sym} 19140 9160 0 0 {name=l29923 lab=WL46}
N 19240 9240 19260 9240 {}
C {lab_pin.sym} 19260 9240 0 0 {name=l29924 lab=VDD}
N 19240 9160 19260 9160 {}
C {lab_pin.sym} 19260 9160 0 0 {name=l29925 lab=VSS}
C {bitcell_6t.sym} 19400 9200 0 0 {name=Xr46c97}
N 19360 9240 19340 9240 {}
C {lab_pin.sym} 19340 9240 0 0 {name=l29926 lab=BL97}
N 19360 9200 19340 9200 {}
C {lab_pin.sym} 19340 9200 0 0 {name=l29927 lab=BLB97}
N 19360 9160 19340 9160 {}
C {lab_pin.sym} 19340 9160 0 0 {name=l29928 lab=WL46}
N 19440 9240 19460 9240 {}
C {lab_pin.sym} 19460 9240 0 0 {name=l29929 lab=VDD}
N 19440 9160 19460 9160 {}
C {lab_pin.sym} 19460 9160 0 0 {name=l29930 lab=VSS}
C {bitcell_6t.sym} 19600 9200 0 0 {name=Xr46c98}
N 19560 9240 19540 9240 {}
C {lab_pin.sym} 19540 9240 0 0 {name=l29931 lab=BL98}
N 19560 9200 19540 9200 {}
C {lab_pin.sym} 19540 9200 0 0 {name=l29932 lab=BLB98}
N 19560 9160 19540 9160 {}
C {lab_pin.sym} 19540 9160 0 0 {name=l29933 lab=WL46}
N 19640 9240 19660 9240 {}
C {lab_pin.sym} 19660 9240 0 0 {name=l29934 lab=VDD}
N 19640 9160 19660 9160 {}
C {lab_pin.sym} 19660 9160 0 0 {name=l29935 lab=VSS}
C {bitcell_6t.sym} 19800 9200 0 0 {name=Xr46c99}
N 19760 9240 19740 9240 {}
C {lab_pin.sym} 19740 9240 0 0 {name=l29936 lab=BL99}
N 19760 9200 19740 9200 {}
C {lab_pin.sym} 19740 9200 0 0 {name=l29937 lab=BLB99}
N 19760 9160 19740 9160 {}
C {lab_pin.sym} 19740 9160 0 0 {name=l29938 lab=WL46}
N 19840 9240 19860 9240 {}
C {lab_pin.sym} 19860 9240 0 0 {name=l29939 lab=VDD}
N 19840 9160 19860 9160 {}
C {lab_pin.sym} 19860 9160 0 0 {name=l29940 lab=VSS}
C {bitcell_6t.sym} 20000 9200 0 0 {name=Xr46c100}
N 19960 9240 19940 9240 {}
C {lab_pin.sym} 19940 9240 0 0 {name=l29941 lab=BL100}
N 19960 9200 19940 9200 {}
C {lab_pin.sym} 19940 9200 0 0 {name=l29942 lab=BLB100}
N 19960 9160 19940 9160 {}
C {lab_pin.sym} 19940 9160 0 0 {name=l29943 lab=WL46}
N 20040 9240 20060 9240 {}
C {lab_pin.sym} 20060 9240 0 0 {name=l29944 lab=VDD}
N 20040 9160 20060 9160 {}
C {lab_pin.sym} 20060 9160 0 0 {name=l29945 lab=VSS}
C {bitcell_6t.sym} 20200 9200 0 0 {name=Xr46c101}
N 20160 9240 20140 9240 {}
C {lab_pin.sym} 20140 9240 0 0 {name=l29946 lab=BL101}
N 20160 9200 20140 9200 {}
C {lab_pin.sym} 20140 9200 0 0 {name=l29947 lab=BLB101}
N 20160 9160 20140 9160 {}
C {lab_pin.sym} 20140 9160 0 0 {name=l29948 lab=WL46}
N 20240 9240 20260 9240 {}
C {lab_pin.sym} 20260 9240 0 0 {name=l29949 lab=VDD}
N 20240 9160 20260 9160 {}
C {lab_pin.sym} 20260 9160 0 0 {name=l29950 lab=VSS}
C {bitcell_6t.sym} 20400 9200 0 0 {name=Xr46c102}
N 20360 9240 20340 9240 {}
C {lab_pin.sym} 20340 9240 0 0 {name=l29951 lab=BL102}
N 20360 9200 20340 9200 {}
C {lab_pin.sym} 20340 9200 0 0 {name=l29952 lab=BLB102}
N 20360 9160 20340 9160 {}
C {lab_pin.sym} 20340 9160 0 0 {name=l29953 lab=WL46}
N 20440 9240 20460 9240 {}
C {lab_pin.sym} 20460 9240 0 0 {name=l29954 lab=VDD}
N 20440 9160 20460 9160 {}
C {lab_pin.sym} 20460 9160 0 0 {name=l29955 lab=VSS}
C {bitcell_6t.sym} 20600 9200 0 0 {name=Xr46c103}
N 20560 9240 20540 9240 {}
C {lab_pin.sym} 20540 9240 0 0 {name=l29956 lab=BL103}
N 20560 9200 20540 9200 {}
C {lab_pin.sym} 20540 9200 0 0 {name=l29957 lab=BLB103}
N 20560 9160 20540 9160 {}
C {lab_pin.sym} 20540 9160 0 0 {name=l29958 lab=WL46}
N 20640 9240 20660 9240 {}
C {lab_pin.sym} 20660 9240 0 0 {name=l29959 lab=VDD}
N 20640 9160 20660 9160 {}
C {lab_pin.sym} 20660 9160 0 0 {name=l29960 lab=VSS}
C {bitcell_6t.sym} 20800 9200 0 0 {name=Xr46c104}
N 20760 9240 20740 9240 {}
C {lab_pin.sym} 20740 9240 0 0 {name=l29961 lab=BL104}
N 20760 9200 20740 9200 {}
C {lab_pin.sym} 20740 9200 0 0 {name=l29962 lab=BLB104}
N 20760 9160 20740 9160 {}
C {lab_pin.sym} 20740 9160 0 0 {name=l29963 lab=WL46}
N 20840 9240 20860 9240 {}
C {lab_pin.sym} 20860 9240 0 0 {name=l29964 lab=VDD}
N 20840 9160 20860 9160 {}
C {lab_pin.sym} 20860 9160 0 0 {name=l29965 lab=VSS}
C {bitcell_6t.sym} 21000 9200 0 0 {name=Xr46c105}
N 20960 9240 20940 9240 {}
C {lab_pin.sym} 20940 9240 0 0 {name=l29966 lab=BL105}
N 20960 9200 20940 9200 {}
C {lab_pin.sym} 20940 9200 0 0 {name=l29967 lab=BLB105}
N 20960 9160 20940 9160 {}
C {lab_pin.sym} 20940 9160 0 0 {name=l29968 lab=WL46}
N 21040 9240 21060 9240 {}
C {lab_pin.sym} 21060 9240 0 0 {name=l29969 lab=VDD}
N 21040 9160 21060 9160 {}
C {lab_pin.sym} 21060 9160 0 0 {name=l29970 lab=VSS}
C {bitcell_6t.sym} 21200 9200 0 0 {name=Xr46c106}
N 21160 9240 21140 9240 {}
C {lab_pin.sym} 21140 9240 0 0 {name=l29971 lab=BL106}
N 21160 9200 21140 9200 {}
C {lab_pin.sym} 21140 9200 0 0 {name=l29972 lab=BLB106}
N 21160 9160 21140 9160 {}
C {lab_pin.sym} 21140 9160 0 0 {name=l29973 lab=WL46}
N 21240 9240 21260 9240 {}
C {lab_pin.sym} 21260 9240 0 0 {name=l29974 lab=VDD}
N 21240 9160 21260 9160 {}
C {lab_pin.sym} 21260 9160 0 0 {name=l29975 lab=VSS}
C {bitcell_6t.sym} 21400 9200 0 0 {name=Xr46c107}
N 21360 9240 21340 9240 {}
C {lab_pin.sym} 21340 9240 0 0 {name=l29976 lab=BL107}
N 21360 9200 21340 9200 {}
C {lab_pin.sym} 21340 9200 0 0 {name=l29977 lab=BLB107}
N 21360 9160 21340 9160 {}
C {lab_pin.sym} 21340 9160 0 0 {name=l29978 lab=WL46}
N 21440 9240 21460 9240 {}
C {lab_pin.sym} 21460 9240 0 0 {name=l29979 lab=VDD}
N 21440 9160 21460 9160 {}
C {lab_pin.sym} 21460 9160 0 0 {name=l29980 lab=VSS}
C {bitcell_6t.sym} 21600 9200 0 0 {name=Xr46c108}
N 21560 9240 21540 9240 {}
C {lab_pin.sym} 21540 9240 0 0 {name=l29981 lab=BL108}
N 21560 9200 21540 9200 {}
C {lab_pin.sym} 21540 9200 0 0 {name=l29982 lab=BLB108}
N 21560 9160 21540 9160 {}
C {lab_pin.sym} 21540 9160 0 0 {name=l29983 lab=WL46}
N 21640 9240 21660 9240 {}
C {lab_pin.sym} 21660 9240 0 0 {name=l29984 lab=VDD}
N 21640 9160 21660 9160 {}
C {lab_pin.sym} 21660 9160 0 0 {name=l29985 lab=VSS}
C {bitcell_6t.sym} 21800 9200 0 0 {name=Xr46c109}
N 21760 9240 21740 9240 {}
C {lab_pin.sym} 21740 9240 0 0 {name=l29986 lab=BL109}
N 21760 9200 21740 9200 {}
C {lab_pin.sym} 21740 9200 0 0 {name=l29987 lab=BLB109}
N 21760 9160 21740 9160 {}
C {lab_pin.sym} 21740 9160 0 0 {name=l29988 lab=WL46}
N 21840 9240 21860 9240 {}
C {lab_pin.sym} 21860 9240 0 0 {name=l29989 lab=VDD}
N 21840 9160 21860 9160 {}
C {lab_pin.sym} 21860 9160 0 0 {name=l29990 lab=VSS}
C {bitcell_6t.sym} 22000 9200 0 0 {name=Xr46c110}
N 21960 9240 21940 9240 {}
C {lab_pin.sym} 21940 9240 0 0 {name=l29991 lab=BL110}
N 21960 9200 21940 9200 {}
C {lab_pin.sym} 21940 9200 0 0 {name=l29992 lab=BLB110}
N 21960 9160 21940 9160 {}
C {lab_pin.sym} 21940 9160 0 0 {name=l29993 lab=WL46}
N 22040 9240 22060 9240 {}
C {lab_pin.sym} 22060 9240 0 0 {name=l29994 lab=VDD}
N 22040 9160 22060 9160 {}
C {lab_pin.sym} 22060 9160 0 0 {name=l29995 lab=VSS}
C {bitcell_6t.sym} 22200 9200 0 0 {name=Xr46c111}
N 22160 9240 22140 9240 {}
C {lab_pin.sym} 22140 9240 0 0 {name=l29996 lab=BL111}
N 22160 9200 22140 9200 {}
C {lab_pin.sym} 22140 9200 0 0 {name=l29997 lab=BLB111}
N 22160 9160 22140 9160 {}
C {lab_pin.sym} 22140 9160 0 0 {name=l29998 lab=WL46}
N 22240 9240 22260 9240 {}
C {lab_pin.sym} 22260 9240 0 0 {name=l29999 lab=VDD}
N 22240 9160 22260 9160 {}
C {lab_pin.sym} 22260 9160 0 0 {name=l30000 lab=VSS}
C {bitcell_6t.sym} 22400 9200 0 0 {name=Xr46c112}
N 22360 9240 22340 9240 {}
C {lab_pin.sym} 22340 9240 0 0 {name=l30001 lab=BL112}
N 22360 9200 22340 9200 {}
C {lab_pin.sym} 22340 9200 0 0 {name=l30002 lab=BLB112}
N 22360 9160 22340 9160 {}
C {lab_pin.sym} 22340 9160 0 0 {name=l30003 lab=WL46}
N 22440 9240 22460 9240 {}
C {lab_pin.sym} 22460 9240 0 0 {name=l30004 lab=VDD}
N 22440 9160 22460 9160 {}
C {lab_pin.sym} 22460 9160 0 0 {name=l30005 lab=VSS}
C {bitcell_6t.sym} 22600 9200 0 0 {name=Xr46c113}
N 22560 9240 22540 9240 {}
C {lab_pin.sym} 22540 9240 0 0 {name=l30006 lab=BL113}
N 22560 9200 22540 9200 {}
C {lab_pin.sym} 22540 9200 0 0 {name=l30007 lab=BLB113}
N 22560 9160 22540 9160 {}
C {lab_pin.sym} 22540 9160 0 0 {name=l30008 lab=WL46}
N 22640 9240 22660 9240 {}
C {lab_pin.sym} 22660 9240 0 0 {name=l30009 lab=VDD}
N 22640 9160 22660 9160 {}
C {lab_pin.sym} 22660 9160 0 0 {name=l30010 lab=VSS}
C {bitcell_6t.sym} 22800 9200 0 0 {name=Xr46c114}
N 22760 9240 22740 9240 {}
C {lab_pin.sym} 22740 9240 0 0 {name=l30011 lab=BL114}
N 22760 9200 22740 9200 {}
C {lab_pin.sym} 22740 9200 0 0 {name=l30012 lab=BLB114}
N 22760 9160 22740 9160 {}
C {lab_pin.sym} 22740 9160 0 0 {name=l30013 lab=WL46}
N 22840 9240 22860 9240 {}
C {lab_pin.sym} 22860 9240 0 0 {name=l30014 lab=VDD}
N 22840 9160 22860 9160 {}
C {lab_pin.sym} 22860 9160 0 0 {name=l30015 lab=VSS}
C {bitcell_6t.sym} 23000 9200 0 0 {name=Xr46c115}
N 22960 9240 22940 9240 {}
C {lab_pin.sym} 22940 9240 0 0 {name=l30016 lab=BL115}
N 22960 9200 22940 9200 {}
C {lab_pin.sym} 22940 9200 0 0 {name=l30017 lab=BLB115}
N 22960 9160 22940 9160 {}
C {lab_pin.sym} 22940 9160 0 0 {name=l30018 lab=WL46}
N 23040 9240 23060 9240 {}
C {lab_pin.sym} 23060 9240 0 0 {name=l30019 lab=VDD}
N 23040 9160 23060 9160 {}
C {lab_pin.sym} 23060 9160 0 0 {name=l30020 lab=VSS}
C {bitcell_6t.sym} 23200 9200 0 0 {name=Xr46c116}
N 23160 9240 23140 9240 {}
C {lab_pin.sym} 23140 9240 0 0 {name=l30021 lab=BL116}
N 23160 9200 23140 9200 {}
C {lab_pin.sym} 23140 9200 0 0 {name=l30022 lab=BLB116}
N 23160 9160 23140 9160 {}
C {lab_pin.sym} 23140 9160 0 0 {name=l30023 lab=WL46}
N 23240 9240 23260 9240 {}
C {lab_pin.sym} 23260 9240 0 0 {name=l30024 lab=VDD}
N 23240 9160 23260 9160 {}
C {lab_pin.sym} 23260 9160 0 0 {name=l30025 lab=VSS}
C {bitcell_6t.sym} 23400 9200 0 0 {name=Xr46c117}
N 23360 9240 23340 9240 {}
C {lab_pin.sym} 23340 9240 0 0 {name=l30026 lab=BL117}
N 23360 9200 23340 9200 {}
C {lab_pin.sym} 23340 9200 0 0 {name=l30027 lab=BLB117}
N 23360 9160 23340 9160 {}
C {lab_pin.sym} 23340 9160 0 0 {name=l30028 lab=WL46}
N 23440 9240 23460 9240 {}
C {lab_pin.sym} 23460 9240 0 0 {name=l30029 lab=VDD}
N 23440 9160 23460 9160 {}
C {lab_pin.sym} 23460 9160 0 0 {name=l30030 lab=VSS}
C {bitcell_6t.sym} 23600 9200 0 0 {name=Xr46c118}
N 23560 9240 23540 9240 {}
C {lab_pin.sym} 23540 9240 0 0 {name=l30031 lab=BL118}
N 23560 9200 23540 9200 {}
C {lab_pin.sym} 23540 9200 0 0 {name=l30032 lab=BLB118}
N 23560 9160 23540 9160 {}
C {lab_pin.sym} 23540 9160 0 0 {name=l30033 lab=WL46}
N 23640 9240 23660 9240 {}
C {lab_pin.sym} 23660 9240 0 0 {name=l30034 lab=VDD}
N 23640 9160 23660 9160 {}
C {lab_pin.sym} 23660 9160 0 0 {name=l30035 lab=VSS}
C {bitcell_6t.sym} 23800 9200 0 0 {name=Xr46c119}
N 23760 9240 23740 9240 {}
C {lab_pin.sym} 23740 9240 0 0 {name=l30036 lab=BL119}
N 23760 9200 23740 9200 {}
C {lab_pin.sym} 23740 9200 0 0 {name=l30037 lab=BLB119}
N 23760 9160 23740 9160 {}
C {lab_pin.sym} 23740 9160 0 0 {name=l30038 lab=WL46}
N 23840 9240 23860 9240 {}
C {lab_pin.sym} 23860 9240 0 0 {name=l30039 lab=VDD}
N 23840 9160 23860 9160 {}
C {lab_pin.sym} 23860 9160 0 0 {name=l30040 lab=VSS}
C {bitcell_6t.sym} 24000 9200 0 0 {name=Xr46c120}
N 23960 9240 23940 9240 {}
C {lab_pin.sym} 23940 9240 0 0 {name=l30041 lab=BL120}
N 23960 9200 23940 9200 {}
C {lab_pin.sym} 23940 9200 0 0 {name=l30042 lab=BLB120}
N 23960 9160 23940 9160 {}
C {lab_pin.sym} 23940 9160 0 0 {name=l30043 lab=WL46}
N 24040 9240 24060 9240 {}
C {lab_pin.sym} 24060 9240 0 0 {name=l30044 lab=VDD}
N 24040 9160 24060 9160 {}
C {lab_pin.sym} 24060 9160 0 0 {name=l30045 lab=VSS}
C {bitcell_6t.sym} 24200 9200 0 0 {name=Xr46c121}
N 24160 9240 24140 9240 {}
C {lab_pin.sym} 24140 9240 0 0 {name=l30046 lab=BL121}
N 24160 9200 24140 9200 {}
C {lab_pin.sym} 24140 9200 0 0 {name=l30047 lab=BLB121}
N 24160 9160 24140 9160 {}
C {lab_pin.sym} 24140 9160 0 0 {name=l30048 lab=WL46}
N 24240 9240 24260 9240 {}
C {lab_pin.sym} 24260 9240 0 0 {name=l30049 lab=VDD}
N 24240 9160 24260 9160 {}
C {lab_pin.sym} 24260 9160 0 0 {name=l30050 lab=VSS}
C {bitcell_6t.sym} 24400 9200 0 0 {name=Xr46c122}
N 24360 9240 24340 9240 {}
C {lab_pin.sym} 24340 9240 0 0 {name=l30051 lab=BL122}
N 24360 9200 24340 9200 {}
C {lab_pin.sym} 24340 9200 0 0 {name=l30052 lab=BLB122}
N 24360 9160 24340 9160 {}
C {lab_pin.sym} 24340 9160 0 0 {name=l30053 lab=WL46}
N 24440 9240 24460 9240 {}
C {lab_pin.sym} 24460 9240 0 0 {name=l30054 lab=VDD}
N 24440 9160 24460 9160 {}
C {lab_pin.sym} 24460 9160 0 0 {name=l30055 lab=VSS}
C {bitcell_6t.sym} 24600 9200 0 0 {name=Xr46c123}
N 24560 9240 24540 9240 {}
C {lab_pin.sym} 24540 9240 0 0 {name=l30056 lab=BL123}
N 24560 9200 24540 9200 {}
C {lab_pin.sym} 24540 9200 0 0 {name=l30057 lab=BLB123}
N 24560 9160 24540 9160 {}
C {lab_pin.sym} 24540 9160 0 0 {name=l30058 lab=WL46}
N 24640 9240 24660 9240 {}
C {lab_pin.sym} 24660 9240 0 0 {name=l30059 lab=VDD}
N 24640 9160 24660 9160 {}
C {lab_pin.sym} 24660 9160 0 0 {name=l30060 lab=VSS}
C {bitcell_6t.sym} 24800 9200 0 0 {name=Xr46c124}
N 24760 9240 24740 9240 {}
C {lab_pin.sym} 24740 9240 0 0 {name=l30061 lab=BL124}
N 24760 9200 24740 9200 {}
C {lab_pin.sym} 24740 9200 0 0 {name=l30062 lab=BLB124}
N 24760 9160 24740 9160 {}
C {lab_pin.sym} 24740 9160 0 0 {name=l30063 lab=WL46}
N 24840 9240 24860 9240 {}
C {lab_pin.sym} 24860 9240 0 0 {name=l30064 lab=VDD}
N 24840 9160 24860 9160 {}
C {lab_pin.sym} 24860 9160 0 0 {name=l30065 lab=VSS}
C {bitcell_6t.sym} 25000 9200 0 0 {name=Xr46c125}
N 24960 9240 24940 9240 {}
C {lab_pin.sym} 24940 9240 0 0 {name=l30066 lab=BL125}
N 24960 9200 24940 9200 {}
C {lab_pin.sym} 24940 9200 0 0 {name=l30067 lab=BLB125}
N 24960 9160 24940 9160 {}
C {lab_pin.sym} 24940 9160 0 0 {name=l30068 lab=WL46}
N 25040 9240 25060 9240 {}
C {lab_pin.sym} 25060 9240 0 0 {name=l30069 lab=VDD}
N 25040 9160 25060 9160 {}
C {lab_pin.sym} 25060 9160 0 0 {name=l30070 lab=VSS}
C {bitcell_6t.sym} 25200 9200 0 0 {name=Xr46c126}
N 25160 9240 25140 9240 {}
C {lab_pin.sym} 25140 9240 0 0 {name=l30071 lab=BL126}
N 25160 9200 25140 9200 {}
C {lab_pin.sym} 25140 9200 0 0 {name=l30072 lab=BLB126}
N 25160 9160 25140 9160 {}
C {lab_pin.sym} 25140 9160 0 0 {name=l30073 lab=WL46}
N 25240 9240 25260 9240 {}
C {lab_pin.sym} 25260 9240 0 0 {name=l30074 lab=VDD}
N 25240 9160 25260 9160 {}
C {lab_pin.sym} 25260 9160 0 0 {name=l30075 lab=VSS}
C {bitcell_6t.sym} 25400 9200 0 0 {name=Xr46c127}
N 25360 9240 25340 9240 {}
C {lab_pin.sym} 25340 9240 0 0 {name=l30076 lab=BL127}
N 25360 9200 25340 9200 {}
C {lab_pin.sym} 25340 9200 0 0 {name=l30077 lab=BLB127}
N 25360 9160 25340 9160 {}
C {lab_pin.sym} 25340 9160 0 0 {name=l30078 lab=WL46}
N 25440 9240 25460 9240 {}
C {lab_pin.sym} 25460 9240 0 0 {name=l30079 lab=VDD}
N 25440 9160 25460 9160 {}
C {lab_pin.sym} 25460 9160 0 0 {name=l30080 lab=VSS}
C {bitcell_6t.sym} 0 9400 0 0 {name=Xr47c0}
N -40 9440 -60 9440 {}
C {lab_pin.sym} -60 9440 0 0 {name=l30081 lab=BL0}
N -40 9400 -60 9400 {}
C {lab_pin.sym} -60 9400 0 0 {name=l30082 lab=BLB0}
N -40 9360 -60 9360 {}
C {lab_pin.sym} -60 9360 0 0 {name=l30083 lab=WL47}
N 40 9440 60 9440 {}
C {lab_pin.sym} 60 9440 0 0 {name=l30084 lab=VDD}
N 40 9360 60 9360 {}
C {lab_pin.sym} 60 9360 0 0 {name=l30085 lab=VSS}
C {bitcell_6t.sym} 200 9400 0 0 {name=Xr47c1}
N 160 9440 140 9440 {}
C {lab_pin.sym} 140 9440 0 0 {name=l30086 lab=BL1}
N 160 9400 140 9400 {}
C {lab_pin.sym} 140 9400 0 0 {name=l30087 lab=BLB1}
N 160 9360 140 9360 {}
C {lab_pin.sym} 140 9360 0 0 {name=l30088 lab=WL47}
N 240 9440 260 9440 {}
C {lab_pin.sym} 260 9440 0 0 {name=l30089 lab=VDD}
N 240 9360 260 9360 {}
C {lab_pin.sym} 260 9360 0 0 {name=l30090 lab=VSS}
C {bitcell_6t.sym} 400 9400 0 0 {name=Xr47c2}
N 360 9440 340 9440 {}
C {lab_pin.sym} 340 9440 0 0 {name=l30091 lab=BL2}
N 360 9400 340 9400 {}
C {lab_pin.sym} 340 9400 0 0 {name=l30092 lab=BLB2}
N 360 9360 340 9360 {}
C {lab_pin.sym} 340 9360 0 0 {name=l30093 lab=WL47}
N 440 9440 460 9440 {}
C {lab_pin.sym} 460 9440 0 0 {name=l30094 lab=VDD}
N 440 9360 460 9360 {}
C {lab_pin.sym} 460 9360 0 0 {name=l30095 lab=VSS}
C {bitcell_6t.sym} 600 9400 0 0 {name=Xr47c3}
N 560 9440 540 9440 {}
C {lab_pin.sym} 540 9440 0 0 {name=l30096 lab=BL3}
N 560 9400 540 9400 {}
C {lab_pin.sym} 540 9400 0 0 {name=l30097 lab=BLB3}
N 560 9360 540 9360 {}
C {lab_pin.sym} 540 9360 0 0 {name=l30098 lab=WL47}
N 640 9440 660 9440 {}
C {lab_pin.sym} 660 9440 0 0 {name=l30099 lab=VDD}
N 640 9360 660 9360 {}
C {lab_pin.sym} 660 9360 0 0 {name=l30100 lab=VSS}
C {bitcell_6t.sym} 800 9400 0 0 {name=Xr47c4}
N 760 9440 740 9440 {}
C {lab_pin.sym} 740 9440 0 0 {name=l30101 lab=BL4}
N 760 9400 740 9400 {}
C {lab_pin.sym} 740 9400 0 0 {name=l30102 lab=BLB4}
N 760 9360 740 9360 {}
C {lab_pin.sym} 740 9360 0 0 {name=l30103 lab=WL47}
N 840 9440 860 9440 {}
C {lab_pin.sym} 860 9440 0 0 {name=l30104 lab=VDD}
N 840 9360 860 9360 {}
C {lab_pin.sym} 860 9360 0 0 {name=l30105 lab=VSS}
C {bitcell_6t.sym} 1000 9400 0 0 {name=Xr47c5}
N 960 9440 940 9440 {}
C {lab_pin.sym} 940 9440 0 0 {name=l30106 lab=BL5}
N 960 9400 940 9400 {}
C {lab_pin.sym} 940 9400 0 0 {name=l30107 lab=BLB5}
N 960 9360 940 9360 {}
C {lab_pin.sym} 940 9360 0 0 {name=l30108 lab=WL47}
N 1040 9440 1060 9440 {}
C {lab_pin.sym} 1060 9440 0 0 {name=l30109 lab=VDD}
N 1040 9360 1060 9360 {}
C {lab_pin.sym} 1060 9360 0 0 {name=l30110 lab=VSS}
C {bitcell_6t.sym} 1200 9400 0 0 {name=Xr47c6}
N 1160 9440 1140 9440 {}
C {lab_pin.sym} 1140 9440 0 0 {name=l30111 lab=BL6}
N 1160 9400 1140 9400 {}
C {lab_pin.sym} 1140 9400 0 0 {name=l30112 lab=BLB6}
N 1160 9360 1140 9360 {}
C {lab_pin.sym} 1140 9360 0 0 {name=l30113 lab=WL47}
N 1240 9440 1260 9440 {}
C {lab_pin.sym} 1260 9440 0 0 {name=l30114 lab=VDD}
N 1240 9360 1260 9360 {}
C {lab_pin.sym} 1260 9360 0 0 {name=l30115 lab=VSS}
C {bitcell_6t.sym} 1400 9400 0 0 {name=Xr47c7}
N 1360 9440 1340 9440 {}
C {lab_pin.sym} 1340 9440 0 0 {name=l30116 lab=BL7}
N 1360 9400 1340 9400 {}
C {lab_pin.sym} 1340 9400 0 0 {name=l30117 lab=BLB7}
N 1360 9360 1340 9360 {}
C {lab_pin.sym} 1340 9360 0 0 {name=l30118 lab=WL47}
N 1440 9440 1460 9440 {}
C {lab_pin.sym} 1460 9440 0 0 {name=l30119 lab=VDD}
N 1440 9360 1460 9360 {}
C {lab_pin.sym} 1460 9360 0 0 {name=l30120 lab=VSS}
C {bitcell_6t.sym} 1600 9400 0 0 {name=Xr47c8}
N 1560 9440 1540 9440 {}
C {lab_pin.sym} 1540 9440 0 0 {name=l30121 lab=BL8}
N 1560 9400 1540 9400 {}
C {lab_pin.sym} 1540 9400 0 0 {name=l30122 lab=BLB8}
N 1560 9360 1540 9360 {}
C {lab_pin.sym} 1540 9360 0 0 {name=l30123 lab=WL47}
N 1640 9440 1660 9440 {}
C {lab_pin.sym} 1660 9440 0 0 {name=l30124 lab=VDD}
N 1640 9360 1660 9360 {}
C {lab_pin.sym} 1660 9360 0 0 {name=l30125 lab=VSS}
C {bitcell_6t.sym} 1800 9400 0 0 {name=Xr47c9}
N 1760 9440 1740 9440 {}
C {lab_pin.sym} 1740 9440 0 0 {name=l30126 lab=BL9}
N 1760 9400 1740 9400 {}
C {lab_pin.sym} 1740 9400 0 0 {name=l30127 lab=BLB9}
N 1760 9360 1740 9360 {}
C {lab_pin.sym} 1740 9360 0 0 {name=l30128 lab=WL47}
N 1840 9440 1860 9440 {}
C {lab_pin.sym} 1860 9440 0 0 {name=l30129 lab=VDD}
N 1840 9360 1860 9360 {}
C {lab_pin.sym} 1860 9360 0 0 {name=l30130 lab=VSS}
C {bitcell_6t.sym} 2000 9400 0 0 {name=Xr47c10}
N 1960 9440 1940 9440 {}
C {lab_pin.sym} 1940 9440 0 0 {name=l30131 lab=BL10}
N 1960 9400 1940 9400 {}
C {lab_pin.sym} 1940 9400 0 0 {name=l30132 lab=BLB10}
N 1960 9360 1940 9360 {}
C {lab_pin.sym} 1940 9360 0 0 {name=l30133 lab=WL47}
N 2040 9440 2060 9440 {}
C {lab_pin.sym} 2060 9440 0 0 {name=l30134 lab=VDD}
N 2040 9360 2060 9360 {}
C {lab_pin.sym} 2060 9360 0 0 {name=l30135 lab=VSS}
C {bitcell_6t.sym} 2200 9400 0 0 {name=Xr47c11}
N 2160 9440 2140 9440 {}
C {lab_pin.sym} 2140 9440 0 0 {name=l30136 lab=BL11}
N 2160 9400 2140 9400 {}
C {lab_pin.sym} 2140 9400 0 0 {name=l30137 lab=BLB11}
N 2160 9360 2140 9360 {}
C {lab_pin.sym} 2140 9360 0 0 {name=l30138 lab=WL47}
N 2240 9440 2260 9440 {}
C {lab_pin.sym} 2260 9440 0 0 {name=l30139 lab=VDD}
N 2240 9360 2260 9360 {}
C {lab_pin.sym} 2260 9360 0 0 {name=l30140 lab=VSS}
C {bitcell_6t.sym} 2400 9400 0 0 {name=Xr47c12}
N 2360 9440 2340 9440 {}
C {lab_pin.sym} 2340 9440 0 0 {name=l30141 lab=BL12}
N 2360 9400 2340 9400 {}
C {lab_pin.sym} 2340 9400 0 0 {name=l30142 lab=BLB12}
N 2360 9360 2340 9360 {}
C {lab_pin.sym} 2340 9360 0 0 {name=l30143 lab=WL47}
N 2440 9440 2460 9440 {}
C {lab_pin.sym} 2460 9440 0 0 {name=l30144 lab=VDD}
N 2440 9360 2460 9360 {}
C {lab_pin.sym} 2460 9360 0 0 {name=l30145 lab=VSS}
C {bitcell_6t.sym} 2600 9400 0 0 {name=Xr47c13}
N 2560 9440 2540 9440 {}
C {lab_pin.sym} 2540 9440 0 0 {name=l30146 lab=BL13}
N 2560 9400 2540 9400 {}
C {lab_pin.sym} 2540 9400 0 0 {name=l30147 lab=BLB13}
N 2560 9360 2540 9360 {}
C {lab_pin.sym} 2540 9360 0 0 {name=l30148 lab=WL47}
N 2640 9440 2660 9440 {}
C {lab_pin.sym} 2660 9440 0 0 {name=l30149 lab=VDD}
N 2640 9360 2660 9360 {}
C {lab_pin.sym} 2660 9360 0 0 {name=l30150 lab=VSS}
C {bitcell_6t.sym} 2800 9400 0 0 {name=Xr47c14}
N 2760 9440 2740 9440 {}
C {lab_pin.sym} 2740 9440 0 0 {name=l30151 lab=BL14}
N 2760 9400 2740 9400 {}
C {lab_pin.sym} 2740 9400 0 0 {name=l30152 lab=BLB14}
N 2760 9360 2740 9360 {}
C {lab_pin.sym} 2740 9360 0 0 {name=l30153 lab=WL47}
N 2840 9440 2860 9440 {}
C {lab_pin.sym} 2860 9440 0 0 {name=l30154 lab=VDD}
N 2840 9360 2860 9360 {}
C {lab_pin.sym} 2860 9360 0 0 {name=l30155 lab=VSS}
C {bitcell_6t.sym} 3000 9400 0 0 {name=Xr47c15}
N 2960 9440 2940 9440 {}
C {lab_pin.sym} 2940 9440 0 0 {name=l30156 lab=BL15}
N 2960 9400 2940 9400 {}
C {lab_pin.sym} 2940 9400 0 0 {name=l30157 lab=BLB15}
N 2960 9360 2940 9360 {}
C {lab_pin.sym} 2940 9360 0 0 {name=l30158 lab=WL47}
N 3040 9440 3060 9440 {}
C {lab_pin.sym} 3060 9440 0 0 {name=l30159 lab=VDD}
N 3040 9360 3060 9360 {}
C {lab_pin.sym} 3060 9360 0 0 {name=l30160 lab=VSS}
C {bitcell_6t.sym} 3200 9400 0 0 {name=Xr47c16}
N 3160 9440 3140 9440 {}
C {lab_pin.sym} 3140 9440 0 0 {name=l30161 lab=BL16}
N 3160 9400 3140 9400 {}
C {lab_pin.sym} 3140 9400 0 0 {name=l30162 lab=BLB16}
N 3160 9360 3140 9360 {}
C {lab_pin.sym} 3140 9360 0 0 {name=l30163 lab=WL47}
N 3240 9440 3260 9440 {}
C {lab_pin.sym} 3260 9440 0 0 {name=l30164 lab=VDD}
N 3240 9360 3260 9360 {}
C {lab_pin.sym} 3260 9360 0 0 {name=l30165 lab=VSS}
C {bitcell_6t.sym} 3400 9400 0 0 {name=Xr47c17}
N 3360 9440 3340 9440 {}
C {lab_pin.sym} 3340 9440 0 0 {name=l30166 lab=BL17}
N 3360 9400 3340 9400 {}
C {lab_pin.sym} 3340 9400 0 0 {name=l30167 lab=BLB17}
N 3360 9360 3340 9360 {}
C {lab_pin.sym} 3340 9360 0 0 {name=l30168 lab=WL47}
N 3440 9440 3460 9440 {}
C {lab_pin.sym} 3460 9440 0 0 {name=l30169 lab=VDD}
N 3440 9360 3460 9360 {}
C {lab_pin.sym} 3460 9360 0 0 {name=l30170 lab=VSS}
C {bitcell_6t.sym} 3600 9400 0 0 {name=Xr47c18}
N 3560 9440 3540 9440 {}
C {lab_pin.sym} 3540 9440 0 0 {name=l30171 lab=BL18}
N 3560 9400 3540 9400 {}
C {lab_pin.sym} 3540 9400 0 0 {name=l30172 lab=BLB18}
N 3560 9360 3540 9360 {}
C {lab_pin.sym} 3540 9360 0 0 {name=l30173 lab=WL47}
N 3640 9440 3660 9440 {}
C {lab_pin.sym} 3660 9440 0 0 {name=l30174 lab=VDD}
N 3640 9360 3660 9360 {}
C {lab_pin.sym} 3660 9360 0 0 {name=l30175 lab=VSS}
C {bitcell_6t.sym} 3800 9400 0 0 {name=Xr47c19}
N 3760 9440 3740 9440 {}
C {lab_pin.sym} 3740 9440 0 0 {name=l30176 lab=BL19}
N 3760 9400 3740 9400 {}
C {lab_pin.sym} 3740 9400 0 0 {name=l30177 lab=BLB19}
N 3760 9360 3740 9360 {}
C {lab_pin.sym} 3740 9360 0 0 {name=l30178 lab=WL47}
N 3840 9440 3860 9440 {}
C {lab_pin.sym} 3860 9440 0 0 {name=l30179 lab=VDD}
N 3840 9360 3860 9360 {}
C {lab_pin.sym} 3860 9360 0 0 {name=l30180 lab=VSS}
C {bitcell_6t.sym} 4000 9400 0 0 {name=Xr47c20}
N 3960 9440 3940 9440 {}
C {lab_pin.sym} 3940 9440 0 0 {name=l30181 lab=BL20}
N 3960 9400 3940 9400 {}
C {lab_pin.sym} 3940 9400 0 0 {name=l30182 lab=BLB20}
N 3960 9360 3940 9360 {}
C {lab_pin.sym} 3940 9360 0 0 {name=l30183 lab=WL47}
N 4040 9440 4060 9440 {}
C {lab_pin.sym} 4060 9440 0 0 {name=l30184 lab=VDD}
N 4040 9360 4060 9360 {}
C {lab_pin.sym} 4060 9360 0 0 {name=l30185 lab=VSS}
C {bitcell_6t.sym} 4200 9400 0 0 {name=Xr47c21}
N 4160 9440 4140 9440 {}
C {lab_pin.sym} 4140 9440 0 0 {name=l30186 lab=BL21}
N 4160 9400 4140 9400 {}
C {lab_pin.sym} 4140 9400 0 0 {name=l30187 lab=BLB21}
N 4160 9360 4140 9360 {}
C {lab_pin.sym} 4140 9360 0 0 {name=l30188 lab=WL47}
N 4240 9440 4260 9440 {}
C {lab_pin.sym} 4260 9440 0 0 {name=l30189 lab=VDD}
N 4240 9360 4260 9360 {}
C {lab_pin.sym} 4260 9360 0 0 {name=l30190 lab=VSS}
C {bitcell_6t.sym} 4400 9400 0 0 {name=Xr47c22}
N 4360 9440 4340 9440 {}
C {lab_pin.sym} 4340 9440 0 0 {name=l30191 lab=BL22}
N 4360 9400 4340 9400 {}
C {lab_pin.sym} 4340 9400 0 0 {name=l30192 lab=BLB22}
N 4360 9360 4340 9360 {}
C {lab_pin.sym} 4340 9360 0 0 {name=l30193 lab=WL47}
N 4440 9440 4460 9440 {}
C {lab_pin.sym} 4460 9440 0 0 {name=l30194 lab=VDD}
N 4440 9360 4460 9360 {}
C {lab_pin.sym} 4460 9360 0 0 {name=l30195 lab=VSS}
C {bitcell_6t.sym} 4600 9400 0 0 {name=Xr47c23}
N 4560 9440 4540 9440 {}
C {lab_pin.sym} 4540 9440 0 0 {name=l30196 lab=BL23}
N 4560 9400 4540 9400 {}
C {lab_pin.sym} 4540 9400 0 0 {name=l30197 lab=BLB23}
N 4560 9360 4540 9360 {}
C {lab_pin.sym} 4540 9360 0 0 {name=l30198 lab=WL47}
N 4640 9440 4660 9440 {}
C {lab_pin.sym} 4660 9440 0 0 {name=l30199 lab=VDD}
N 4640 9360 4660 9360 {}
C {lab_pin.sym} 4660 9360 0 0 {name=l30200 lab=VSS}
C {bitcell_6t.sym} 4800 9400 0 0 {name=Xr47c24}
N 4760 9440 4740 9440 {}
C {lab_pin.sym} 4740 9440 0 0 {name=l30201 lab=BL24}
N 4760 9400 4740 9400 {}
C {lab_pin.sym} 4740 9400 0 0 {name=l30202 lab=BLB24}
N 4760 9360 4740 9360 {}
C {lab_pin.sym} 4740 9360 0 0 {name=l30203 lab=WL47}
N 4840 9440 4860 9440 {}
C {lab_pin.sym} 4860 9440 0 0 {name=l30204 lab=VDD}
N 4840 9360 4860 9360 {}
C {lab_pin.sym} 4860 9360 0 0 {name=l30205 lab=VSS}
C {bitcell_6t.sym} 5000 9400 0 0 {name=Xr47c25}
N 4960 9440 4940 9440 {}
C {lab_pin.sym} 4940 9440 0 0 {name=l30206 lab=BL25}
N 4960 9400 4940 9400 {}
C {lab_pin.sym} 4940 9400 0 0 {name=l30207 lab=BLB25}
N 4960 9360 4940 9360 {}
C {lab_pin.sym} 4940 9360 0 0 {name=l30208 lab=WL47}
N 5040 9440 5060 9440 {}
C {lab_pin.sym} 5060 9440 0 0 {name=l30209 lab=VDD}
N 5040 9360 5060 9360 {}
C {lab_pin.sym} 5060 9360 0 0 {name=l30210 lab=VSS}
C {bitcell_6t.sym} 5200 9400 0 0 {name=Xr47c26}
N 5160 9440 5140 9440 {}
C {lab_pin.sym} 5140 9440 0 0 {name=l30211 lab=BL26}
N 5160 9400 5140 9400 {}
C {lab_pin.sym} 5140 9400 0 0 {name=l30212 lab=BLB26}
N 5160 9360 5140 9360 {}
C {lab_pin.sym} 5140 9360 0 0 {name=l30213 lab=WL47}
N 5240 9440 5260 9440 {}
C {lab_pin.sym} 5260 9440 0 0 {name=l30214 lab=VDD}
N 5240 9360 5260 9360 {}
C {lab_pin.sym} 5260 9360 0 0 {name=l30215 lab=VSS}
C {bitcell_6t.sym} 5400 9400 0 0 {name=Xr47c27}
N 5360 9440 5340 9440 {}
C {lab_pin.sym} 5340 9440 0 0 {name=l30216 lab=BL27}
N 5360 9400 5340 9400 {}
C {lab_pin.sym} 5340 9400 0 0 {name=l30217 lab=BLB27}
N 5360 9360 5340 9360 {}
C {lab_pin.sym} 5340 9360 0 0 {name=l30218 lab=WL47}
N 5440 9440 5460 9440 {}
C {lab_pin.sym} 5460 9440 0 0 {name=l30219 lab=VDD}
N 5440 9360 5460 9360 {}
C {lab_pin.sym} 5460 9360 0 0 {name=l30220 lab=VSS}
C {bitcell_6t.sym} 5600 9400 0 0 {name=Xr47c28}
N 5560 9440 5540 9440 {}
C {lab_pin.sym} 5540 9440 0 0 {name=l30221 lab=BL28}
N 5560 9400 5540 9400 {}
C {lab_pin.sym} 5540 9400 0 0 {name=l30222 lab=BLB28}
N 5560 9360 5540 9360 {}
C {lab_pin.sym} 5540 9360 0 0 {name=l30223 lab=WL47}
N 5640 9440 5660 9440 {}
C {lab_pin.sym} 5660 9440 0 0 {name=l30224 lab=VDD}
N 5640 9360 5660 9360 {}
C {lab_pin.sym} 5660 9360 0 0 {name=l30225 lab=VSS}
C {bitcell_6t.sym} 5800 9400 0 0 {name=Xr47c29}
N 5760 9440 5740 9440 {}
C {lab_pin.sym} 5740 9440 0 0 {name=l30226 lab=BL29}
N 5760 9400 5740 9400 {}
C {lab_pin.sym} 5740 9400 0 0 {name=l30227 lab=BLB29}
N 5760 9360 5740 9360 {}
C {lab_pin.sym} 5740 9360 0 0 {name=l30228 lab=WL47}
N 5840 9440 5860 9440 {}
C {lab_pin.sym} 5860 9440 0 0 {name=l30229 lab=VDD}
N 5840 9360 5860 9360 {}
C {lab_pin.sym} 5860 9360 0 0 {name=l30230 lab=VSS}
C {bitcell_6t.sym} 6000 9400 0 0 {name=Xr47c30}
N 5960 9440 5940 9440 {}
C {lab_pin.sym} 5940 9440 0 0 {name=l30231 lab=BL30}
N 5960 9400 5940 9400 {}
C {lab_pin.sym} 5940 9400 0 0 {name=l30232 lab=BLB30}
N 5960 9360 5940 9360 {}
C {lab_pin.sym} 5940 9360 0 0 {name=l30233 lab=WL47}
N 6040 9440 6060 9440 {}
C {lab_pin.sym} 6060 9440 0 0 {name=l30234 lab=VDD}
N 6040 9360 6060 9360 {}
C {lab_pin.sym} 6060 9360 0 0 {name=l30235 lab=VSS}
C {bitcell_6t.sym} 6200 9400 0 0 {name=Xr47c31}
N 6160 9440 6140 9440 {}
C {lab_pin.sym} 6140 9440 0 0 {name=l30236 lab=BL31}
N 6160 9400 6140 9400 {}
C {lab_pin.sym} 6140 9400 0 0 {name=l30237 lab=BLB31}
N 6160 9360 6140 9360 {}
C {lab_pin.sym} 6140 9360 0 0 {name=l30238 lab=WL47}
N 6240 9440 6260 9440 {}
C {lab_pin.sym} 6260 9440 0 0 {name=l30239 lab=VDD}
N 6240 9360 6260 9360 {}
C {lab_pin.sym} 6260 9360 0 0 {name=l30240 lab=VSS}
C {bitcell_6t.sym} 6400 9400 0 0 {name=Xr47c32}
N 6360 9440 6340 9440 {}
C {lab_pin.sym} 6340 9440 0 0 {name=l30241 lab=BL32}
N 6360 9400 6340 9400 {}
C {lab_pin.sym} 6340 9400 0 0 {name=l30242 lab=BLB32}
N 6360 9360 6340 9360 {}
C {lab_pin.sym} 6340 9360 0 0 {name=l30243 lab=WL47}
N 6440 9440 6460 9440 {}
C {lab_pin.sym} 6460 9440 0 0 {name=l30244 lab=VDD}
N 6440 9360 6460 9360 {}
C {lab_pin.sym} 6460 9360 0 0 {name=l30245 lab=VSS}
C {bitcell_6t.sym} 6600 9400 0 0 {name=Xr47c33}
N 6560 9440 6540 9440 {}
C {lab_pin.sym} 6540 9440 0 0 {name=l30246 lab=BL33}
N 6560 9400 6540 9400 {}
C {lab_pin.sym} 6540 9400 0 0 {name=l30247 lab=BLB33}
N 6560 9360 6540 9360 {}
C {lab_pin.sym} 6540 9360 0 0 {name=l30248 lab=WL47}
N 6640 9440 6660 9440 {}
C {lab_pin.sym} 6660 9440 0 0 {name=l30249 lab=VDD}
N 6640 9360 6660 9360 {}
C {lab_pin.sym} 6660 9360 0 0 {name=l30250 lab=VSS}
C {bitcell_6t.sym} 6800 9400 0 0 {name=Xr47c34}
N 6760 9440 6740 9440 {}
C {lab_pin.sym} 6740 9440 0 0 {name=l30251 lab=BL34}
N 6760 9400 6740 9400 {}
C {lab_pin.sym} 6740 9400 0 0 {name=l30252 lab=BLB34}
N 6760 9360 6740 9360 {}
C {lab_pin.sym} 6740 9360 0 0 {name=l30253 lab=WL47}
N 6840 9440 6860 9440 {}
C {lab_pin.sym} 6860 9440 0 0 {name=l30254 lab=VDD}
N 6840 9360 6860 9360 {}
C {lab_pin.sym} 6860 9360 0 0 {name=l30255 lab=VSS}
C {bitcell_6t.sym} 7000 9400 0 0 {name=Xr47c35}
N 6960 9440 6940 9440 {}
C {lab_pin.sym} 6940 9440 0 0 {name=l30256 lab=BL35}
N 6960 9400 6940 9400 {}
C {lab_pin.sym} 6940 9400 0 0 {name=l30257 lab=BLB35}
N 6960 9360 6940 9360 {}
C {lab_pin.sym} 6940 9360 0 0 {name=l30258 lab=WL47}
N 7040 9440 7060 9440 {}
C {lab_pin.sym} 7060 9440 0 0 {name=l30259 lab=VDD}
N 7040 9360 7060 9360 {}
C {lab_pin.sym} 7060 9360 0 0 {name=l30260 lab=VSS}
C {bitcell_6t.sym} 7200 9400 0 0 {name=Xr47c36}
N 7160 9440 7140 9440 {}
C {lab_pin.sym} 7140 9440 0 0 {name=l30261 lab=BL36}
N 7160 9400 7140 9400 {}
C {lab_pin.sym} 7140 9400 0 0 {name=l30262 lab=BLB36}
N 7160 9360 7140 9360 {}
C {lab_pin.sym} 7140 9360 0 0 {name=l30263 lab=WL47}
N 7240 9440 7260 9440 {}
C {lab_pin.sym} 7260 9440 0 0 {name=l30264 lab=VDD}
N 7240 9360 7260 9360 {}
C {lab_pin.sym} 7260 9360 0 0 {name=l30265 lab=VSS}
C {bitcell_6t.sym} 7400 9400 0 0 {name=Xr47c37}
N 7360 9440 7340 9440 {}
C {lab_pin.sym} 7340 9440 0 0 {name=l30266 lab=BL37}
N 7360 9400 7340 9400 {}
C {lab_pin.sym} 7340 9400 0 0 {name=l30267 lab=BLB37}
N 7360 9360 7340 9360 {}
C {lab_pin.sym} 7340 9360 0 0 {name=l30268 lab=WL47}
N 7440 9440 7460 9440 {}
C {lab_pin.sym} 7460 9440 0 0 {name=l30269 lab=VDD}
N 7440 9360 7460 9360 {}
C {lab_pin.sym} 7460 9360 0 0 {name=l30270 lab=VSS}
C {bitcell_6t.sym} 7600 9400 0 0 {name=Xr47c38}
N 7560 9440 7540 9440 {}
C {lab_pin.sym} 7540 9440 0 0 {name=l30271 lab=BL38}
N 7560 9400 7540 9400 {}
C {lab_pin.sym} 7540 9400 0 0 {name=l30272 lab=BLB38}
N 7560 9360 7540 9360 {}
C {lab_pin.sym} 7540 9360 0 0 {name=l30273 lab=WL47}
N 7640 9440 7660 9440 {}
C {lab_pin.sym} 7660 9440 0 0 {name=l30274 lab=VDD}
N 7640 9360 7660 9360 {}
C {lab_pin.sym} 7660 9360 0 0 {name=l30275 lab=VSS}
C {bitcell_6t.sym} 7800 9400 0 0 {name=Xr47c39}
N 7760 9440 7740 9440 {}
C {lab_pin.sym} 7740 9440 0 0 {name=l30276 lab=BL39}
N 7760 9400 7740 9400 {}
C {lab_pin.sym} 7740 9400 0 0 {name=l30277 lab=BLB39}
N 7760 9360 7740 9360 {}
C {lab_pin.sym} 7740 9360 0 0 {name=l30278 lab=WL47}
N 7840 9440 7860 9440 {}
C {lab_pin.sym} 7860 9440 0 0 {name=l30279 lab=VDD}
N 7840 9360 7860 9360 {}
C {lab_pin.sym} 7860 9360 0 0 {name=l30280 lab=VSS}
C {bitcell_6t.sym} 8000 9400 0 0 {name=Xr47c40}
N 7960 9440 7940 9440 {}
C {lab_pin.sym} 7940 9440 0 0 {name=l30281 lab=BL40}
N 7960 9400 7940 9400 {}
C {lab_pin.sym} 7940 9400 0 0 {name=l30282 lab=BLB40}
N 7960 9360 7940 9360 {}
C {lab_pin.sym} 7940 9360 0 0 {name=l30283 lab=WL47}
N 8040 9440 8060 9440 {}
C {lab_pin.sym} 8060 9440 0 0 {name=l30284 lab=VDD}
N 8040 9360 8060 9360 {}
C {lab_pin.sym} 8060 9360 0 0 {name=l30285 lab=VSS}
C {bitcell_6t.sym} 8200 9400 0 0 {name=Xr47c41}
N 8160 9440 8140 9440 {}
C {lab_pin.sym} 8140 9440 0 0 {name=l30286 lab=BL41}
N 8160 9400 8140 9400 {}
C {lab_pin.sym} 8140 9400 0 0 {name=l30287 lab=BLB41}
N 8160 9360 8140 9360 {}
C {lab_pin.sym} 8140 9360 0 0 {name=l30288 lab=WL47}
N 8240 9440 8260 9440 {}
C {lab_pin.sym} 8260 9440 0 0 {name=l30289 lab=VDD}
N 8240 9360 8260 9360 {}
C {lab_pin.sym} 8260 9360 0 0 {name=l30290 lab=VSS}
C {bitcell_6t.sym} 8400 9400 0 0 {name=Xr47c42}
N 8360 9440 8340 9440 {}
C {lab_pin.sym} 8340 9440 0 0 {name=l30291 lab=BL42}
N 8360 9400 8340 9400 {}
C {lab_pin.sym} 8340 9400 0 0 {name=l30292 lab=BLB42}
N 8360 9360 8340 9360 {}
C {lab_pin.sym} 8340 9360 0 0 {name=l30293 lab=WL47}
N 8440 9440 8460 9440 {}
C {lab_pin.sym} 8460 9440 0 0 {name=l30294 lab=VDD}
N 8440 9360 8460 9360 {}
C {lab_pin.sym} 8460 9360 0 0 {name=l30295 lab=VSS}
C {bitcell_6t.sym} 8600 9400 0 0 {name=Xr47c43}
N 8560 9440 8540 9440 {}
C {lab_pin.sym} 8540 9440 0 0 {name=l30296 lab=BL43}
N 8560 9400 8540 9400 {}
C {lab_pin.sym} 8540 9400 0 0 {name=l30297 lab=BLB43}
N 8560 9360 8540 9360 {}
C {lab_pin.sym} 8540 9360 0 0 {name=l30298 lab=WL47}
N 8640 9440 8660 9440 {}
C {lab_pin.sym} 8660 9440 0 0 {name=l30299 lab=VDD}
N 8640 9360 8660 9360 {}
C {lab_pin.sym} 8660 9360 0 0 {name=l30300 lab=VSS}
C {bitcell_6t.sym} 8800 9400 0 0 {name=Xr47c44}
N 8760 9440 8740 9440 {}
C {lab_pin.sym} 8740 9440 0 0 {name=l30301 lab=BL44}
N 8760 9400 8740 9400 {}
C {lab_pin.sym} 8740 9400 0 0 {name=l30302 lab=BLB44}
N 8760 9360 8740 9360 {}
C {lab_pin.sym} 8740 9360 0 0 {name=l30303 lab=WL47}
N 8840 9440 8860 9440 {}
C {lab_pin.sym} 8860 9440 0 0 {name=l30304 lab=VDD}
N 8840 9360 8860 9360 {}
C {lab_pin.sym} 8860 9360 0 0 {name=l30305 lab=VSS}
C {bitcell_6t.sym} 9000 9400 0 0 {name=Xr47c45}
N 8960 9440 8940 9440 {}
C {lab_pin.sym} 8940 9440 0 0 {name=l30306 lab=BL45}
N 8960 9400 8940 9400 {}
C {lab_pin.sym} 8940 9400 0 0 {name=l30307 lab=BLB45}
N 8960 9360 8940 9360 {}
C {lab_pin.sym} 8940 9360 0 0 {name=l30308 lab=WL47}
N 9040 9440 9060 9440 {}
C {lab_pin.sym} 9060 9440 0 0 {name=l30309 lab=VDD}
N 9040 9360 9060 9360 {}
C {lab_pin.sym} 9060 9360 0 0 {name=l30310 lab=VSS}
C {bitcell_6t.sym} 9200 9400 0 0 {name=Xr47c46}
N 9160 9440 9140 9440 {}
C {lab_pin.sym} 9140 9440 0 0 {name=l30311 lab=BL46}
N 9160 9400 9140 9400 {}
C {lab_pin.sym} 9140 9400 0 0 {name=l30312 lab=BLB46}
N 9160 9360 9140 9360 {}
C {lab_pin.sym} 9140 9360 0 0 {name=l30313 lab=WL47}
N 9240 9440 9260 9440 {}
C {lab_pin.sym} 9260 9440 0 0 {name=l30314 lab=VDD}
N 9240 9360 9260 9360 {}
C {lab_pin.sym} 9260 9360 0 0 {name=l30315 lab=VSS}
C {bitcell_6t.sym} 9400 9400 0 0 {name=Xr47c47}
N 9360 9440 9340 9440 {}
C {lab_pin.sym} 9340 9440 0 0 {name=l30316 lab=BL47}
N 9360 9400 9340 9400 {}
C {lab_pin.sym} 9340 9400 0 0 {name=l30317 lab=BLB47}
N 9360 9360 9340 9360 {}
C {lab_pin.sym} 9340 9360 0 0 {name=l30318 lab=WL47}
N 9440 9440 9460 9440 {}
C {lab_pin.sym} 9460 9440 0 0 {name=l30319 lab=VDD}
N 9440 9360 9460 9360 {}
C {lab_pin.sym} 9460 9360 0 0 {name=l30320 lab=VSS}
C {bitcell_6t.sym} 9600 9400 0 0 {name=Xr47c48}
N 9560 9440 9540 9440 {}
C {lab_pin.sym} 9540 9440 0 0 {name=l30321 lab=BL48}
N 9560 9400 9540 9400 {}
C {lab_pin.sym} 9540 9400 0 0 {name=l30322 lab=BLB48}
N 9560 9360 9540 9360 {}
C {lab_pin.sym} 9540 9360 0 0 {name=l30323 lab=WL47}
N 9640 9440 9660 9440 {}
C {lab_pin.sym} 9660 9440 0 0 {name=l30324 lab=VDD}
N 9640 9360 9660 9360 {}
C {lab_pin.sym} 9660 9360 0 0 {name=l30325 lab=VSS}
C {bitcell_6t.sym} 9800 9400 0 0 {name=Xr47c49}
N 9760 9440 9740 9440 {}
C {lab_pin.sym} 9740 9440 0 0 {name=l30326 lab=BL49}
N 9760 9400 9740 9400 {}
C {lab_pin.sym} 9740 9400 0 0 {name=l30327 lab=BLB49}
N 9760 9360 9740 9360 {}
C {lab_pin.sym} 9740 9360 0 0 {name=l30328 lab=WL47}
N 9840 9440 9860 9440 {}
C {lab_pin.sym} 9860 9440 0 0 {name=l30329 lab=VDD}
N 9840 9360 9860 9360 {}
C {lab_pin.sym} 9860 9360 0 0 {name=l30330 lab=VSS}
C {bitcell_6t.sym} 10000 9400 0 0 {name=Xr47c50}
N 9960 9440 9940 9440 {}
C {lab_pin.sym} 9940 9440 0 0 {name=l30331 lab=BL50}
N 9960 9400 9940 9400 {}
C {lab_pin.sym} 9940 9400 0 0 {name=l30332 lab=BLB50}
N 9960 9360 9940 9360 {}
C {lab_pin.sym} 9940 9360 0 0 {name=l30333 lab=WL47}
N 10040 9440 10060 9440 {}
C {lab_pin.sym} 10060 9440 0 0 {name=l30334 lab=VDD}
N 10040 9360 10060 9360 {}
C {lab_pin.sym} 10060 9360 0 0 {name=l30335 lab=VSS}
C {bitcell_6t.sym} 10200 9400 0 0 {name=Xr47c51}
N 10160 9440 10140 9440 {}
C {lab_pin.sym} 10140 9440 0 0 {name=l30336 lab=BL51}
N 10160 9400 10140 9400 {}
C {lab_pin.sym} 10140 9400 0 0 {name=l30337 lab=BLB51}
N 10160 9360 10140 9360 {}
C {lab_pin.sym} 10140 9360 0 0 {name=l30338 lab=WL47}
N 10240 9440 10260 9440 {}
C {lab_pin.sym} 10260 9440 0 0 {name=l30339 lab=VDD}
N 10240 9360 10260 9360 {}
C {lab_pin.sym} 10260 9360 0 0 {name=l30340 lab=VSS}
C {bitcell_6t.sym} 10400 9400 0 0 {name=Xr47c52}
N 10360 9440 10340 9440 {}
C {lab_pin.sym} 10340 9440 0 0 {name=l30341 lab=BL52}
N 10360 9400 10340 9400 {}
C {lab_pin.sym} 10340 9400 0 0 {name=l30342 lab=BLB52}
N 10360 9360 10340 9360 {}
C {lab_pin.sym} 10340 9360 0 0 {name=l30343 lab=WL47}
N 10440 9440 10460 9440 {}
C {lab_pin.sym} 10460 9440 0 0 {name=l30344 lab=VDD}
N 10440 9360 10460 9360 {}
C {lab_pin.sym} 10460 9360 0 0 {name=l30345 lab=VSS}
C {bitcell_6t.sym} 10600 9400 0 0 {name=Xr47c53}
N 10560 9440 10540 9440 {}
C {lab_pin.sym} 10540 9440 0 0 {name=l30346 lab=BL53}
N 10560 9400 10540 9400 {}
C {lab_pin.sym} 10540 9400 0 0 {name=l30347 lab=BLB53}
N 10560 9360 10540 9360 {}
C {lab_pin.sym} 10540 9360 0 0 {name=l30348 lab=WL47}
N 10640 9440 10660 9440 {}
C {lab_pin.sym} 10660 9440 0 0 {name=l30349 lab=VDD}
N 10640 9360 10660 9360 {}
C {lab_pin.sym} 10660 9360 0 0 {name=l30350 lab=VSS}
C {bitcell_6t.sym} 10800 9400 0 0 {name=Xr47c54}
N 10760 9440 10740 9440 {}
C {lab_pin.sym} 10740 9440 0 0 {name=l30351 lab=BL54}
N 10760 9400 10740 9400 {}
C {lab_pin.sym} 10740 9400 0 0 {name=l30352 lab=BLB54}
N 10760 9360 10740 9360 {}
C {lab_pin.sym} 10740 9360 0 0 {name=l30353 lab=WL47}
N 10840 9440 10860 9440 {}
C {lab_pin.sym} 10860 9440 0 0 {name=l30354 lab=VDD}
N 10840 9360 10860 9360 {}
C {lab_pin.sym} 10860 9360 0 0 {name=l30355 lab=VSS}
C {bitcell_6t.sym} 11000 9400 0 0 {name=Xr47c55}
N 10960 9440 10940 9440 {}
C {lab_pin.sym} 10940 9440 0 0 {name=l30356 lab=BL55}
N 10960 9400 10940 9400 {}
C {lab_pin.sym} 10940 9400 0 0 {name=l30357 lab=BLB55}
N 10960 9360 10940 9360 {}
C {lab_pin.sym} 10940 9360 0 0 {name=l30358 lab=WL47}
N 11040 9440 11060 9440 {}
C {lab_pin.sym} 11060 9440 0 0 {name=l30359 lab=VDD}
N 11040 9360 11060 9360 {}
C {lab_pin.sym} 11060 9360 0 0 {name=l30360 lab=VSS}
C {bitcell_6t.sym} 11200 9400 0 0 {name=Xr47c56}
N 11160 9440 11140 9440 {}
C {lab_pin.sym} 11140 9440 0 0 {name=l30361 lab=BL56}
N 11160 9400 11140 9400 {}
C {lab_pin.sym} 11140 9400 0 0 {name=l30362 lab=BLB56}
N 11160 9360 11140 9360 {}
C {lab_pin.sym} 11140 9360 0 0 {name=l30363 lab=WL47}
N 11240 9440 11260 9440 {}
C {lab_pin.sym} 11260 9440 0 0 {name=l30364 lab=VDD}
N 11240 9360 11260 9360 {}
C {lab_pin.sym} 11260 9360 0 0 {name=l30365 lab=VSS}
C {bitcell_6t.sym} 11400 9400 0 0 {name=Xr47c57}
N 11360 9440 11340 9440 {}
C {lab_pin.sym} 11340 9440 0 0 {name=l30366 lab=BL57}
N 11360 9400 11340 9400 {}
C {lab_pin.sym} 11340 9400 0 0 {name=l30367 lab=BLB57}
N 11360 9360 11340 9360 {}
C {lab_pin.sym} 11340 9360 0 0 {name=l30368 lab=WL47}
N 11440 9440 11460 9440 {}
C {lab_pin.sym} 11460 9440 0 0 {name=l30369 lab=VDD}
N 11440 9360 11460 9360 {}
C {lab_pin.sym} 11460 9360 0 0 {name=l30370 lab=VSS}
C {bitcell_6t.sym} 11600 9400 0 0 {name=Xr47c58}
N 11560 9440 11540 9440 {}
C {lab_pin.sym} 11540 9440 0 0 {name=l30371 lab=BL58}
N 11560 9400 11540 9400 {}
C {lab_pin.sym} 11540 9400 0 0 {name=l30372 lab=BLB58}
N 11560 9360 11540 9360 {}
C {lab_pin.sym} 11540 9360 0 0 {name=l30373 lab=WL47}
N 11640 9440 11660 9440 {}
C {lab_pin.sym} 11660 9440 0 0 {name=l30374 lab=VDD}
N 11640 9360 11660 9360 {}
C {lab_pin.sym} 11660 9360 0 0 {name=l30375 lab=VSS}
C {bitcell_6t.sym} 11800 9400 0 0 {name=Xr47c59}
N 11760 9440 11740 9440 {}
C {lab_pin.sym} 11740 9440 0 0 {name=l30376 lab=BL59}
N 11760 9400 11740 9400 {}
C {lab_pin.sym} 11740 9400 0 0 {name=l30377 lab=BLB59}
N 11760 9360 11740 9360 {}
C {lab_pin.sym} 11740 9360 0 0 {name=l30378 lab=WL47}
N 11840 9440 11860 9440 {}
C {lab_pin.sym} 11860 9440 0 0 {name=l30379 lab=VDD}
N 11840 9360 11860 9360 {}
C {lab_pin.sym} 11860 9360 0 0 {name=l30380 lab=VSS}
C {bitcell_6t.sym} 12000 9400 0 0 {name=Xr47c60}
N 11960 9440 11940 9440 {}
C {lab_pin.sym} 11940 9440 0 0 {name=l30381 lab=BL60}
N 11960 9400 11940 9400 {}
C {lab_pin.sym} 11940 9400 0 0 {name=l30382 lab=BLB60}
N 11960 9360 11940 9360 {}
C {lab_pin.sym} 11940 9360 0 0 {name=l30383 lab=WL47}
N 12040 9440 12060 9440 {}
C {lab_pin.sym} 12060 9440 0 0 {name=l30384 lab=VDD}
N 12040 9360 12060 9360 {}
C {lab_pin.sym} 12060 9360 0 0 {name=l30385 lab=VSS}
C {bitcell_6t.sym} 12200 9400 0 0 {name=Xr47c61}
N 12160 9440 12140 9440 {}
C {lab_pin.sym} 12140 9440 0 0 {name=l30386 lab=BL61}
N 12160 9400 12140 9400 {}
C {lab_pin.sym} 12140 9400 0 0 {name=l30387 lab=BLB61}
N 12160 9360 12140 9360 {}
C {lab_pin.sym} 12140 9360 0 0 {name=l30388 lab=WL47}
N 12240 9440 12260 9440 {}
C {lab_pin.sym} 12260 9440 0 0 {name=l30389 lab=VDD}
N 12240 9360 12260 9360 {}
C {lab_pin.sym} 12260 9360 0 0 {name=l30390 lab=VSS}
C {bitcell_6t.sym} 12400 9400 0 0 {name=Xr47c62}
N 12360 9440 12340 9440 {}
C {lab_pin.sym} 12340 9440 0 0 {name=l30391 lab=BL62}
N 12360 9400 12340 9400 {}
C {lab_pin.sym} 12340 9400 0 0 {name=l30392 lab=BLB62}
N 12360 9360 12340 9360 {}
C {lab_pin.sym} 12340 9360 0 0 {name=l30393 lab=WL47}
N 12440 9440 12460 9440 {}
C {lab_pin.sym} 12460 9440 0 0 {name=l30394 lab=VDD}
N 12440 9360 12460 9360 {}
C {lab_pin.sym} 12460 9360 0 0 {name=l30395 lab=VSS}
C {bitcell_6t.sym} 12600 9400 0 0 {name=Xr47c63}
N 12560 9440 12540 9440 {}
C {lab_pin.sym} 12540 9440 0 0 {name=l30396 lab=BL63}
N 12560 9400 12540 9400 {}
C {lab_pin.sym} 12540 9400 0 0 {name=l30397 lab=BLB63}
N 12560 9360 12540 9360 {}
C {lab_pin.sym} 12540 9360 0 0 {name=l30398 lab=WL47}
N 12640 9440 12660 9440 {}
C {lab_pin.sym} 12660 9440 0 0 {name=l30399 lab=VDD}
N 12640 9360 12660 9360 {}
C {lab_pin.sym} 12660 9360 0 0 {name=l30400 lab=VSS}
C {bitcell_6t.sym} 12800 9400 0 0 {name=Xr47c64}
N 12760 9440 12740 9440 {}
C {lab_pin.sym} 12740 9440 0 0 {name=l30401 lab=BL64}
N 12760 9400 12740 9400 {}
C {lab_pin.sym} 12740 9400 0 0 {name=l30402 lab=BLB64}
N 12760 9360 12740 9360 {}
C {lab_pin.sym} 12740 9360 0 0 {name=l30403 lab=WL47}
N 12840 9440 12860 9440 {}
C {lab_pin.sym} 12860 9440 0 0 {name=l30404 lab=VDD}
N 12840 9360 12860 9360 {}
C {lab_pin.sym} 12860 9360 0 0 {name=l30405 lab=VSS}
C {bitcell_6t.sym} 13000 9400 0 0 {name=Xr47c65}
N 12960 9440 12940 9440 {}
C {lab_pin.sym} 12940 9440 0 0 {name=l30406 lab=BL65}
N 12960 9400 12940 9400 {}
C {lab_pin.sym} 12940 9400 0 0 {name=l30407 lab=BLB65}
N 12960 9360 12940 9360 {}
C {lab_pin.sym} 12940 9360 0 0 {name=l30408 lab=WL47}
N 13040 9440 13060 9440 {}
C {lab_pin.sym} 13060 9440 0 0 {name=l30409 lab=VDD}
N 13040 9360 13060 9360 {}
C {lab_pin.sym} 13060 9360 0 0 {name=l30410 lab=VSS}
C {bitcell_6t.sym} 13200 9400 0 0 {name=Xr47c66}
N 13160 9440 13140 9440 {}
C {lab_pin.sym} 13140 9440 0 0 {name=l30411 lab=BL66}
N 13160 9400 13140 9400 {}
C {lab_pin.sym} 13140 9400 0 0 {name=l30412 lab=BLB66}
N 13160 9360 13140 9360 {}
C {lab_pin.sym} 13140 9360 0 0 {name=l30413 lab=WL47}
N 13240 9440 13260 9440 {}
C {lab_pin.sym} 13260 9440 0 0 {name=l30414 lab=VDD}
N 13240 9360 13260 9360 {}
C {lab_pin.sym} 13260 9360 0 0 {name=l30415 lab=VSS}
C {bitcell_6t.sym} 13400 9400 0 0 {name=Xr47c67}
N 13360 9440 13340 9440 {}
C {lab_pin.sym} 13340 9440 0 0 {name=l30416 lab=BL67}
N 13360 9400 13340 9400 {}
C {lab_pin.sym} 13340 9400 0 0 {name=l30417 lab=BLB67}
N 13360 9360 13340 9360 {}
C {lab_pin.sym} 13340 9360 0 0 {name=l30418 lab=WL47}
N 13440 9440 13460 9440 {}
C {lab_pin.sym} 13460 9440 0 0 {name=l30419 lab=VDD}
N 13440 9360 13460 9360 {}
C {lab_pin.sym} 13460 9360 0 0 {name=l30420 lab=VSS}
C {bitcell_6t.sym} 13600 9400 0 0 {name=Xr47c68}
N 13560 9440 13540 9440 {}
C {lab_pin.sym} 13540 9440 0 0 {name=l30421 lab=BL68}
N 13560 9400 13540 9400 {}
C {lab_pin.sym} 13540 9400 0 0 {name=l30422 lab=BLB68}
N 13560 9360 13540 9360 {}
C {lab_pin.sym} 13540 9360 0 0 {name=l30423 lab=WL47}
N 13640 9440 13660 9440 {}
C {lab_pin.sym} 13660 9440 0 0 {name=l30424 lab=VDD}
N 13640 9360 13660 9360 {}
C {lab_pin.sym} 13660 9360 0 0 {name=l30425 lab=VSS}
C {bitcell_6t.sym} 13800 9400 0 0 {name=Xr47c69}
N 13760 9440 13740 9440 {}
C {lab_pin.sym} 13740 9440 0 0 {name=l30426 lab=BL69}
N 13760 9400 13740 9400 {}
C {lab_pin.sym} 13740 9400 0 0 {name=l30427 lab=BLB69}
N 13760 9360 13740 9360 {}
C {lab_pin.sym} 13740 9360 0 0 {name=l30428 lab=WL47}
N 13840 9440 13860 9440 {}
C {lab_pin.sym} 13860 9440 0 0 {name=l30429 lab=VDD}
N 13840 9360 13860 9360 {}
C {lab_pin.sym} 13860 9360 0 0 {name=l30430 lab=VSS}
C {bitcell_6t.sym} 14000 9400 0 0 {name=Xr47c70}
N 13960 9440 13940 9440 {}
C {lab_pin.sym} 13940 9440 0 0 {name=l30431 lab=BL70}
N 13960 9400 13940 9400 {}
C {lab_pin.sym} 13940 9400 0 0 {name=l30432 lab=BLB70}
N 13960 9360 13940 9360 {}
C {lab_pin.sym} 13940 9360 0 0 {name=l30433 lab=WL47}
N 14040 9440 14060 9440 {}
C {lab_pin.sym} 14060 9440 0 0 {name=l30434 lab=VDD}
N 14040 9360 14060 9360 {}
C {lab_pin.sym} 14060 9360 0 0 {name=l30435 lab=VSS}
C {bitcell_6t.sym} 14200 9400 0 0 {name=Xr47c71}
N 14160 9440 14140 9440 {}
C {lab_pin.sym} 14140 9440 0 0 {name=l30436 lab=BL71}
N 14160 9400 14140 9400 {}
C {lab_pin.sym} 14140 9400 0 0 {name=l30437 lab=BLB71}
N 14160 9360 14140 9360 {}
C {lab_pin.sym} 14140 9360 0 0 {name=l30438 lab=WL47}
N 14240 9440 14260 9440 {}
C {lab_pin.sym} 14260 9440 0 0 {name=l30439 lab=VDD}
N 14240 9360 14260 9360 {}
C {lab_pin.sym} 14260 9360 0 0 {name=l30440 lab=VSS}
C {bitcell_6t.sym} 14400 9400 0 0 {name=Xr47c72}
N 14360 9440 14340 9440 {}
C {lab_pin.sym} 14340 9440 0 0 {name=l30441 lab=BL72}
N 14360 9400 14340 9400 {}
C {lab_pin.sym} 14340 9400 0 0 {name=l30442 lab=BLB72}
N 14360 9360 14340 9360 {}
C {lab_pin.sym} 14340 9360 0 0 {name=l30443 lab=WL47}
N 14440 9440 14460 9440 {}
C {lab_pin.sym} 14460 9440 0 0 {name=l30444 lab=VDD}
N 14440 9360 14460 9360 {}
C {lab_pin.sym} 14460 9360 0 0 {name=l30445 lab=VSS}
C {bitcell_6t.sym} 14600 9400 0 0 {name=Xr47c73}
N 14560 9440 14540 9440 {}
C {lab_pin.sym} 14540 9440 0 0 {name=l30446 lab=BL73}
N 14560 9400 14540 9400 {}
C {lab_pin.sym} 14540 9400 0 0 {name=l30447 lab=BLB73}
N 14560 9360 14540 9360 {}
C {lab_pin.sym} 14540 9360 0 0 {name=l30448 lab=WL47}
N 14640 9440 14660 9440 {}
C {lab_pin.sym} 14660 9440 0 0 {name=l30449 lab=VDD}
N 14640 9360 14660 9360 {}
C {lab_pin.sym} 14660 9360 0 0 {name=l30450 lab=VSS}
C {bitcell_6t.sym} 14800 9400 0 0 {name=Xr47c74}
N 14760 9440 14740 9440 {}
C {lab_pin.sym} 14740 9440 0 0 {name=l30451 lab=BL74}
N 14760 9400 14740 9400 {}
C {lab_pin.sym} 14740 9400 0 0 {name=l30452 lab=BLB74}
N 14760 9360 14740 9360 {}
C {lab_pin.sym} 14740 9360 0 0 {name=l30453 lab=WL47}
N 14840 9440 14860 9440 {}
C {lab_pin.sym} 14860 9440 0 0 {name=l30454 lab=VDD}
N 14840 9360 14860 9360 {}
C {lab_pin.sym} 14860 9360 0 0 {name=l30455 lab=VSS}
C {bitcell_6t.sym} 15000 9400 0 0 {name=Xr47c75}
N 14960 9440 14940 9440 {}
C {lab_pin.sym} 14940 9440 0 0 {name=l30456 lab=BL75}
N 14960 9400 14940 9400 {}
C {lab_pin.sym} 14940 9400 0 0 {name=l30457 lab=BLB75}
N 14960 9360 14940 9360 {}
C {lab_pin.sym} 14940 9360 0 0 {name=l30458 lab=WL47}
N 15040 9440 15060 9440 {}
C {lab_pin.sym} 15060 9440 0 0 {name=l30459 lab=VDD}
N 15040 9360 15060 9360 {}
C {lab_pin.sym} 15060 9360 0 0 {name=l30460 lab=VSS}
C {bitcell_6t.sym} 15200 9400 0 0 {name=Xr47c76}
N 15160 9440 15140 9440 {}
C {lab_pin.sym} 15140 9440 0 0 {name=l30461 lab=BL76}
N 15160 9400 15140 9400 {}
C {lab_pin.sym} 15140 9400 0 0 {name=l30462 lab=BLB76}
N 15160 9360 15140 9360 {}
C {lab_pin.sym} 15140 9360 0 0 {name=l30463 lab=WL47}
N 15240 9440 15260 9440 {}
C {lab_pin.sym} 15260 9440 0 0 {name=l30464 lab=VDD}
N 15240 9360 15260 9360 {}
C {lab_pin.sym} 15260 9360 0 0 {name=l30465 lab=VSS}
C {bitcell_6t.sym} 15400 9400 0 0 {name=Xr47c77}
N 15360 9440 15340 9440 {}
C {lab_pin.sym} 15340 9440 0 0 {name=l30466 lab=BL77}
N 15360 9400 15340 9400 {}
C {lab_pin.sym} 15340 9400 0 0 {name=l30467 lab=BLB77}
N 15360 9360 15340 9360 {}
C {lab_pin.sym} 15340 9360 0 0 {name=l30468 lab=WL47}
N 15440 9440 15460 9440 {}
C {lab_pin.sym} 15460 9440 0 0 {name=l30469 lab=VDD}
N 15440 9360 15460 9360 {}
C {lab_pin.sym} 15460 9360 0 0 {name=l30470 lab=VSS}
C {bitcell_6t.sym} 15600 9400 0 0 {name=Xr47c78}
N 15560 9440 15540 9440 {}
C {lab_pin.sym} 15540 9440 0 0 {name=l30471 lab=BL78}
N 15560 9400 15540 9400 {}
C {lab_pin.sym} 15540 9400 0 0 {name=l30472 lab=BLB78}
N 15560 9360 15540 9360 {}
C {lab_pin.sym} 15540 9360 0 0 {name=l30473 lab=WL47}
N 15640 9440 15660 9440 {}
C {lab_pin.sym} 15660 9440 0 0 {name=l30474 lab=VDD}
N 15640 9360 15660 9360 {}
C {lab_pin.sym} 15660 9360 0 0 {name=l30475 lab=VSS}
C {bitcell_6t.sym} 15800 9400 0 0 {name=Xr47c79}
N 15760 9440 15740 9440 {}
C {lab_pin.sym} 15740 9440 0 0 {name=l30476 lab=BL79}
N 15760 9400 15740 9400 {}
C {lab_pin.sym} 15740 9400 0 0 {name=l30477 lab=BLB79}
N 15760 9360 15740 9360 {}
C {lab_pin.sym} 15740 9360 0 0 {name=l30478 lab=WL47}
N 15840 9440 15860 9440 {}
C {lab_pin.sym} 15860 9440 0 0 {name=l30479 lab=VDD}
N 15840 9360 15860 9360 {}
C {lab_pin.sym} 15860 9360 0 0 {name=l30480 lab=VSS}
C {bitcell_6t.sym} 16000 9400 0 0 {name=Xr47c80}
N 15960 9440 15940 9440 {}
C {lab_pin.sym} 15940 9440 0 0 {name=l30481 lab=BL80}
N 15960 9400 15940 9400 {}
C {lab_pin.sym} 15940 9400 0 0 {name=l30482 lab=BLB80}
N 15960 9360 15940 9360 {}
C {lab_pin.sym} 15940 9360 0 0 {name=l30483 lab=WL47}
N 16040 9440 16060 9440 {}
C {lab_pin.sym} 16060 9440 0 0 {name=l30484 lab=VDD}
N 16040 9360 16060 9360 {}
C {lab_pin.sym} 16060 9360 0 0 {name=l30485 lab=VSS}
C {bitcell_6t.sym} 16200 9400 0 0 {name=Xr47c81}
N 16160 9440 16140 9440 {}
C {lab_pin.sym} 16140 9440 0 0 {name=l30486 lab=BL81}
N 16160 9400 16140 9400 {}
C {lab_pin.sym} 16140 9400 0 0 {name=l30487 lab=BLB81}
N 16160 9360 16140 9360 {}
C {lab_pin.sym} 16140 9360 0 0 {name=l30488 lab=WL47}
N 16240 9440 16260 9440 {}
C {lab_pin.sym} 16260 9440 0 0 {name=l30489 lab=VDD}
N 16240 9360 16260 9360 {}
C {lab_pin.sym} 16260 9360 0 0 {name=l30490 lab=VSS}
C {bitcell_6t.sym} 16400 9400 0 0 {name=Xr47c82}
N 16360 9440 16340 9440 {}
C {lab_pin.sym} 16340 9440 0 0 {name=l30491 lab=BL82}
N 16360 9400 16340 9400 {}
C {lab_pin.sym} 16340 9400 0 0 {name=l30492 lab=BLB82}
N 16360 9360 16340 9360 {}
C {lab_pin.sym} 16340 9360 0 0 {name=l30493 lab=WL47}
N 16440 9440 16460 9440 {}
C {lab_pin.sym} 16460 9440 0 0 {name=l30494 lab=VDD}
N 16440 9360 16460 9360 {}
C {lab_pin.sym} 16460 9360 0 0 {name=l30495 lab=VSS}
C {bitcell_6t.sym} 16600 9400 0 0 {name=Xr47c83}
N 16560 9440 16540 9440 {}
C {lab_pin.sym} 16540 9440 0 0 {name=l30496 lab=BL83}
N 16560 9400 16540 9400 {}
C {lab_pin.sym} 16540 9400 0 0 {name=l30497 lab=BLB83}
N 16560 9360 16540 9360 {}
C {lab_pin.sym} 16540 9360 0 0 {name=l30498 lab=WL47}
N 16640 9440 16660 9440 {}
C {lab_pin.sym} 16660 9440 0 0 {name=l30499 lab=VDD}
N 16640 9360 16660 9360 {}
C {lab_pin.sym} 16660 9360 0 0 {name=l30500 lab=VSS}
C {bitcell_6t.sym} 16800 9400 0 0 {name=Xr47c84}
N 16760 9440 16740 9440 {}
C {lab_pin.sym} 16740 9440 0 0 {name=l30501 lab=BL84}
N 16760 9400 16740 9400 {}
C {lab_pin.sym} 16740 9400 0 0 {name=l30502 lab=BLB84}
N 16760 9360 16740 9360 {}
C {lab_pin.sym} 16740 9360 0 0 {name=l30503 lab=WL47}
N 16840 9440 16860 9440 {}
C {lab_pin.sym} 16860 9440 0 0 {name=l30504 lab=VDD}
N 16840 9360 16860 9360 {}
C {lab_pin.sym} 16860 9360 0 0 {name=l30505 lab=VSS}
C {bitcell_6t.sym} 17000 9400 0 0 {name=Xr47c85}
N 16960 9440 16940 9440 {}
C {lab_pin.sym} 16940 9440 0 0 {name=l30506 lab=BL85}
N 16960 9400 16940 9400 {}
C {lab_pin.sym} 16940 9400 0 0 {name=l30507 lab=BLB85}
N 16960 9360 16940 9360 {}
C {lab_pin.sym} 16940 9360 0 0 {name=l30508 lab=WL47}
N 17040 9440 17060 9440 {}
C {lab_pin.sym} 17060 9440 0 0 {name=l30509 lab=VDD}
N 17040 9360 17060 9360 {}
C {lab_pin.sym} 17060 9360 0 0 {name=l30510 lab=VSS}
C {bitcell_6t.sym} 17200 9400 0 0 {name=Xr47c86}
N 17160 9440 17140 9440 {}
C {lab_pin.sym} 17140 9440 0 0 {name=l30511 lab=BL86}
N 17160 9400 17140 9400 {}
C {lab_pin.sym} 17140 9400 0 0 {name=l30512 lab=BLB86}
N 17160 9360 17140 9360 {}
C {lab_pin.sym} 17140 9360 0 0 {name=l30513 lab=WL47}
N 17240 9440 17260 9440 {}
C {lab_pin.sym} 17260 9440 0 0 {name=l30514 lab=VDD}
N 17240 9360 17260 9360 {}
C {lab_pin.sym} 17260 9360 0 0 {name=l30515 lab=VSS}
C {bitcell_6t.sym} 17400 9400 0 0 {name=Xr47c87}
N 17360 9440 17340 9440 {}
C {lab_pin.sym} 17340 9440 0 0 {name=l30516 lab=BL87}
N 17360 9400 17340 9400 {}
C {lab_pin.sym} 17340 9400 0 0 {name=l30517 lab=BLB87}
N 17360 9360 17340 9360 {}
C {lab_pin.sym} 17340 9360 0 0 {name=l30518 lab=WL47}
N 17440 9440 17460 9440 {}
C {lab_pin.sym} 17460 9440 0 0 {name=l30519 lab=VDD}
N 17440 9360 17460 9360 {}
C {lab_pin.sym} 17460 9360 0 0 {name=l30520 lab=VSS}
C {bitcell_6t.sym} 17600 9400 0 0 {name=Xr47c88}
N 17560 9440 17540 9440 {}
C {lab_pin.sym} 17540 9440 0 0 {name=l30521 lab=BL88}
N 17560 9400 17540 9400 {}
C {lab_pin.sym} 17540 9400 0 0 {name=l30522 lab=BLB88}
N 17560 9360 17540 9360 {}
C {lab_pin.sym} 17540 9360 0 0 {name=l30523 lab=WL47}
N 17640 9440 17660 9440 {}
C {lab_pin.sym} 17660 9440 0 0 {name=l30524 lab=VDD}
N 17640 9360 17660 9360 {}
C {lab_pin.sym} 17660 9360 0 0 {name=l30525 lab=VSS}
C {bitcell_6t.sym} 17800 9400 0 0 {name=Xr47c89}
N 17760 9440 17740 9440 {}
C {lab_pin.sym} 17740 9440 0 0 {name=l30526 lab=BL89}
N 17760 9400 17740 9400 {}
C {lab_pin.sym} 17740 9400 0 0 {name=l30527 lab=BLB89}
N 17760 9360 17740 9360 {}
C {lab_pin.sym} 17740 9360 0 0 {name=l30528 lab=WL47}
N 17840 9440 17860 9440 {}
C {lab_pin.sym} 17860 9440 0 0 {name=l30529 lab=VDD}
N 17840 9360 17860 9360 {}
C {lab_pin.sym} 17860 9360 0 0 {name=l30530 lab=VSS}
C {bitcell_6t.sym} 18000 9400 0 0 {name=Xr47c90}
N 17960 9440 17940 9440 {}
C {lab_pin.sym} 17940 9440 0 0 {name=l30531 lab=BL90}
N 17960 9400 17940 9400 {}
C {lab_pin.sym} 17940 9400 0 0 {name=l30532 lab=BLB90}
N 17960 9360 17940 9360 {}
C {lab_pin.sym} 17940 9360 0 0 {name=l30533 lab=WL47}
N 18040 9440 18060 9440 {}
C {lab_pin.sym} 18060 9440 0 0 {name=l30534 lab=VDD}
N 18040 9360 18060 9360 {}
C {lab_pin.sym} 18060 9360 0 0 {name=l30535 lab=VSS}
C {bitcell_6t.sym} 18200 9400 0 0 {name=Xr47c91}
N 18160 9440 18140 9440 {}
C {lab_pin.sym} 18140 9440 0 0 {name=l30536 lab=BL91}
N 18160 9400 18140 9400 {}
C {lab_pin.sym} 18140 9400 0 0 {name=l30537 lab=BLB91}
N 18160 9360 18140 9360 {}
C {lab_pin.sym} 18140 9360 0 0 {name=l30538 lab=WL47}
N 18240 9440 18260 9440 {}
C {lab_pin.sym} 18260 9440 0 0 {name=l30539 lab=VDD}
N 18240 9360 18260 9360 {}
C {lab_pin.sym} 18260 9360 0 0 {name=l30540 lab=VSS}
C {bitcell_6t.sym} 18400 9400 0 0 {name=Xr47c92}
N 18360 9440 18340 9440 {}
C {lab_pin.sym} 18340 9440 0 0 {name=l30541 lab=BL92}
N 18360 9400 18340 9400 {}
C {lab_pin.sym} 18340 9400 0 0 {name=l30542 lab=BLB92}
N 18360 9360 18340 9360 {}
C {lab_pin.sym} 18340 9360 0 0 {name=l30543 lab=WL47}
N 18440 9440 18460 9440 {}
C {lab_pin.sym} 18460 9440 0 0 {name=l30544 lab=VDD}
N 18440 9360 18460 9360 {}
C {lab_pin.sym} 18460 9360 0 0 {name=l30545 lab=VSS}
C {bitcell_6t.sym} 18600 9400 0 0 {name=Xr47c93}
N 18560 9440 18540 9440 {}
C {lab_pin.sym} 18540 9440 0 0 {name=l30546 lab=BL93}
N 18560 9400 18540 9400 {}
C {lab_pin.sym} 18540 9400 0 0 {name=l30547 lab=BLB93}
N 18560 9360 18540 9360 {}
C {lab_pin.sym} 18540 9360 0 0 {name=l30548 lab=WL47}
N 18640 9440 18660 9440 {}
C {lab_pin.sym} 18660 9440 0 0 {name=l30549 lab=VDD}
N 18640 9360 18660 9360 {}
C {lab_pin.sym} 18660 9360 0 0 {name=l30550 lab=VSS}
C {bitcell_6t.sym} 18800 9400 0 0 {name=Xr47c94}
N 18760 9440 18740 9440 {}
C {lab_pin.sym} 18740 9440 0 0 {name=l30551 lab=BL94}
N 18760 9400 18740 9400 {}
C {lab_pin.sym} 18740 9400 0 0 {name=l30552 lab=BLB94}
N 18760 9360 18740 9360 {}
C {lab_pin.sym} 18740 9360 0 0 {name=l30553 lab=WL47}
N 18840 9440 18860 9440 {}
C {lab_pin.sym} 18860 9440 0 0 {name=l30554 lab=VDD}
N 18840 9360 18860 9360 {}
C {lab_pin.sym} 18860 9360 0 0 {name=l30555 lab=VSS}
C {bitcell_6t.sym} 19000 9400 0 0 {name=Xr47c95}
N 18960 9440 18940 9440 {}
C {lab_pin.sym} 18940 9440 0 0 {name=l30556 lab=BL95}
N 18960 9400 18940 9400 {}
C {lab_pin.sym} 18940 9400 0 0 {name=l30557 lab=BLB95}
N 18960 9360 18940 9360 {}
C {lab_pin.sym} 18940 9360 0 0 {name=l30558 lab=WL47}
N 19040 9440 19060 9440 {}
C {lab_pin.sym} 19060 9440 0 0 {name=l30559 lab=VDD}
N 19040 9360 19060 9360 {}
C {lab_pin.sym} 19060 9360 0 0 {name=l30560 lab=VSS}
C {bitcell_6t.sym} 19200 9400 0 0 {name=Xr47c96}
N 19160 9440 19140 9440 {}
C {lab_pin.sym} 19140 9440 0 0 {name=l30561 lab=BL96}
N 19160 9400 19140 9400 {}
C {lab_pin.sym} 19140 9400 0 0 {name=l30562 lab=BLB96}
N 19160 9360 19140 9360 {}
C {lab_pin.sym} 19140 9360 0 0 {name=l30563 lab=WL47}
N 19240 9440 19260 9440 {}
C {lab_pin.sym} 19260 9440 0 0 {name=l30564 lab=VDD}
N 19240 9360 19260 9360 {}
C {lab_pin.sym} 19260 9360 0 0 {name=l30565 lab=VSS}
C {bitcell_6t.sym} 19400 9400 0 0 {name=Xr47c97}
N 19360 9440 19340 9440 {}
C {lab_pin.sym} 19340 9440 0 0 {name=l30566 lab=BL97}
N 19360 9400 19340 9400 {}
C {lab_pin.sym} 19340 9400 0 0 {name=l30567 lab=BLB97}
N 19360 9360 19340 9360 {}
C {lab_pin.sym} 19340 9360 0 0 {name=l30568 lab=WL47}
N 19440 9440 19460 9440 {}
C {lab_pin.sym} 19460 9440 0 0 {name=l30569 lab=VDD}
N 19440 9360 19460 9360 {}
C {lab_pin.sym} 19460 9360 0 0 {name=l30570 lab=VSS}
C {bitcell_6t.sym} 19600 9400 0 0 {name=Xr47c98}
N 19560 9440 19540 9440 {}
C {lab_pin.sym} 19540 9440 0 0 {name=l30571 lab=BL98}
N 19560 9400 19540 9400 {}
C {lab_pin.sym} 19540 9400 0 0 {name=l30572 lab=BLB98}
N 19560 9360 19540 9360 {}
C {lab_pin.sym} 19540 9360 0 0 {name=l30573 lab=WL47}
N 19640 9440 19660 9440 {}
C {lab_pin.sym} 19660 9440 0 0 {name=l30574 lab=VDD}
N 19640 9360 19660 9360 {}
C {lab_pin.sym} 19660 9360 0 0 {name=l30575 lab=VSS}
C {bitcell_6t.sym} 19800 9400 0 0 {name=Xr47c99}
N 19760 9440 19740 9440 {}
C {lab_pin.sym} 19740 9440 0 0 {name=l30576 lab=BL99}
N 19760 9400 19740 9400 {}
C {lab_pin.sym} 19740 9400 0 0 {name=l30577 lab=BLB99}
N 19760 9360 19740 9360 {}
C {lab_pin.sym} 19740 9360 0 0 {name=l30578 lab=WL47}
N 19840 9440 19860 9440 {}
C {lab_pin.sym} 19860 9440 0 0 {name=l30579 lab=VDD}
N 19840 9360 19860 9360 {}
C {lab_pin.sym} 19860 9360 0 0 {name=l30580 lab=VSS}
C {bitcell_6t.sym} 20000 9400 0 0 {name=Xr47c100}
N 19960 9440 19940 9440 {}
C {lab_pin.sym} 19940 9440 0 0 {name=l30581 lab=BL100}
N 19960 9400 19940 9400 {}
C {lab_pin.sym} 19940 9400 0 0 {name=l30582 lab=BLB100}
N 19960 9360 19940 9360 {}
C {lab_pin.sym} 19940 9360 0 0 {name=l30583 lab=WL47}
N 20040 9440 20060 9440 {}
C {lab_pin.sym} 20060 9440 0 0 {name=l30584 lab=VDD}
N 20040 9360 20060 9360 {}
C {lab_pin.sym} 20060 9360 0 0 {name=l30585 lab=VSS}
C {bitcell_6t.sym} 20200 9400 0 0 {name=Xr47c101}
N 20160 9440 20140 9440 {}
C {lab_pin.sym} 20140 9440 0 0 {name=l30586 lab=BL101}
N 20160 9400 20140 9400 {}
C {lab_pin.sym} 20140 9400 0 0 {name=l30587 lab=BLB101}
N 20160 9360 20140 9360 {}
C {lab_pin.sym} 20140 9360 0 0 {name=l30588 lab=WL47}
N 20240 9440 20260 9440 {}
C {lab_pin.sym} 20260 9440 0 0 {name=l30589 lab=VDD}
N 20240 9360 20260 9360 {}
C {lab_pin.sym} 20260 9360 0 0 {name=l30590 lab=VSS}
C {bitcell_6t.sym} 20400 9400 0 0 {name=Xr47c102}
N 20360 9440 20340 9440 {}
C {lab_pin.sym} 20340 9440 0 0 {name=l30591 lab=BL102}
N 20360 9400 20340 9400 {}
C {lab_pin.sym} 20340 9400 0 0 {name=l30592 lab=BLB102}
N 20360 9360 20340 9360 {}
C {lab_pin.sym} 20340 9360 0 0 {name=l30593 lab=WL47}
N 20440 9440 20460 9440 {}
C {lab_pin.sym} 20460 9440 0 0 {name=l30594 lab=VDD}
N 20440 9360 20460 9360 {}
C {lab_pin.sym} 20460 9360 0 0 {name=l30595 lab=VSS}
C {bitcell_6t.sym} 20600 9400 0 0 {name=Xr47c103}
N 20560 9440 20540 9440 {}
C {lab_pin.sym} 20540 9440 0 0 {name=l30596 lab=BL103}
N 20560 9400 20540 9400 {}
C {lab_pin.sym} 20540 9400 0 0 {name=l30597 lab=BLB103}
N 20560 9360 20540 9360 {}
C {lab_pin.sym} 20540 9360 0 0 {name=l30598 lab=WL47}
N 20640 9440 20660 9440 {}
C {lab_pin.sym} 20660 9440 0 0 {name=l30599 lab=VDD}
N 20640 9360 20660 9360 {}
C {lab_pin.sym} 20660 9360 0 0 {name=l30600 lab=VSS}
C {bitcell_6t.sym} 20800 9400 0 0 {name=Xr47c104}
N 20760 9440 20740 9440 {}
C {lab_pin.sym} 20740 9440 0 0 {name=l30601 lab=BL104}
N 20760 9400 20740 9400 {}
C {lab_pin.sym} 20740 9400 0 0 {name=l30602 lab=BLB104}
N 20760 9360 20740 9360 {}
C {lab_pin.sym} 20740 9360 0 0 {name=l30603 lab=WL47}
N 20840 9440 20860 9440 {}
C {lab_pin.sym} 20860 9440 0 0 {name=l30604 lab=VDD}
N 20840 9360 20860 9360 {}
C {lab_pin.sym} 20860 9360 0 0 {name=l30605 lab=VSS}
C {bitcell_6t.sym} 21000 9400 0 0 {name=Xr47c105}
N 20960 9440 20940 9440 {}
C {lab_pin.sym} 20940 9440 0 0 {name=l30606 lab=BL105}
N 20960 9400 20940 9400 {}
C {lab_pin.sym} 20940 9400 0 0 {name=l30607 lab=BLB105}
N 20960 9360 20940 9360 {}
C {lab_pin.sym} 20940 9360 0 0 {name=l30608 lab=WL47}
N 21040 9440 21060 9440 {}
C {lab_pin.sym} 21060 9440 0 0 {name=l30609 lab=VDD}
N 21040 9360 21060 9360 {}
C {lab_pin.sym} 21060 9360 0 0 {name=l30610 lab=VSS}
C {bitcell_6t.sym} 21200 9400 0 0 {name=Xr47c106}
N 21160 9440 21140 9440 {}
C {lab_pin.sym} 21140 9440 0 0 {name=l30611 lab=BL106}
N 21160 9400 21140 9400 {}
C {lab_pin.sym} 21140 9400 0 0 {name=l30612 lab=BLB106}
N 21160 9360 21140 9360 {}
C {lab_pin.sym} 21140 9360 0 0 {name=l30613 lab=WL47}
N 21240 9440 21260 9440 {}
C {lab_pin.sym} 21260 9440 0 0 {name=l30614 lab=VDD}
N 21240 9360 21260 9360 {}
C {lab_pin.sym} 21260 9360 0 0 {name=l30615 lab=VSS}
C {bitcell_6t.sym} 21400 9400 0 0 {name=Xr47c107}
N 21360 9440 21340 9440 {}
C {lab_pin.sym} 21340 9440 0 0 {name=l30616 lab=BL107}
N 21360 9400 21340 9400 {}
C {lab_pin.sym} 21340 9400 0 0 {name=l30617 lab=BLB107}
N 21360 9360 21340 9360 {}
C {lab_pin.sym} 21340 9360 0 0 {name=l30618 lab=WL47}
N 21440 9440 21460 9440 {}
C {lab_pin.sym} 21460 9440 0 0 {name=l30619 lab=VDD}
N 21440 9360 21460 9360 {}
C {lab_pin.sym} 21460 9360 0 0 {name=l30620 lab=VSS}
C {bitcell_6t.sym} 21600 9400 0 0 {name=Xr47c108}
N 21560 9440 21540 9440 {}
C {lab_pin.sym} 21540 9440 0 0 {name=l30621 lab=BL108}
N 21560 9400 21540 9400 {}
C {lab_pin.sym} 21540 9400 0 0 {name=l30622 lab=BLB108}
N 21560 9360 21540 9360 {}
C {lab_pin.sym} 21540 9360 0 0 {name=l30623 lab=WL47}
N 21640 9440 21660 9440 {}
C {lab_pin.sym} 21660 9440 0 0 {name=l30624 lab=VDD}
N 21640 9360 21660 9360 {}
C {lab_pin.sym} 21660 9360 0 0 {name=l30625 lab=VSS}
C {bitcell_6t.sym} 21800 9400 0 0 {name=Xr47c109}
N 21760 9440 21740 9440 {}
C {lab_pin.sym} 21740 9440 0 0 {name=l30626 lab=BL109}
N 21760 9400 21740 9400 {}
C {lab_pin.sym} 21740 9400 0 0 {name=l30627 lab=BLB109}
N 21760 9360 21740 9360 {}
C {lab_pin.sym} 21740 9360 0 0 {name=l30628 lab=WL47}
N 21840 9440 21860 9440 {}
C {lab_pin.sym} 21860 9440 0 0 {name=l30629 lab=VDD}
N 21840 9360 21860 9360 {}
C {lab_pin.sym} 21860 9360 0 0 {name=l30630 lab=VSS}
C {bitcell_6t.sym} 22000 9400 0 0 {name=Xr47c110}
N 21960 9440 21940 9440 {}
C {lab_pin.sym} 21940 9440 0 0 {name=l30631 lab=BL110}
N 21960 9400 21940 9400 {}
C {lab_pin.sym} 21940 9400 0 0 {name=l30632 lab=BLB110}
N 21960 9360 21940 9360 {}
C {lab_pin.sym} 21940 9360 0 0 {name=l30633 lab=WL47}
N 22040 9440 22060 9440 {}
C {lab_pin.sym} 22060 9440 0 0 {name=l30634 lab=VDD}
N 22040 9360 22060 9360 {}
C {lab_pin.sym} 22060 9360 0 0 {name=l30635 lab=VSS}
C {bitcell_6t.sym} 22200 9400 0 0 {name=Xr47c111}
N 22160 9440 22140 9440 {}
C {lab_pin.sym} 22140 9440 0 0 {name=l30636 lab=BL111}
N 22160 9400 22140 9400 {}
C {lab_pin.sym} 22140 9400 0 0 {name=l30637 lab=BLB111}
N 22160 9360 22140 9360 {}
C {lab_pin.sym} 22140 9360 0 0 {name=l30638 lab=WL47}
N 22240 9440 22260 9440 {}
C {lab_pin.sym} 22260 9440 0 0 {name=l30639 lab=VDD}
N 22240 9360 22260 9360 {}
C {lab_pin.sym} 22260 9360 0 0 {name=l30640 lab=VSS}
C {bitcell_6t.sym} 22400 9400 0 0 {name=Xr47c112}
N 22360 9440 22340 9440 {}
C {lab_pin.sym} 22340 9440 0 0 {name=l30641 lab=BL112}
N 22360 9400 22340 9400 {}
C {lab_pin.sym} 22340 9400 0 0 {name=l30642 lab=BLB112}
N 22360 9360 22340 9360 {}
C {lab_pin.sym} 22340 9360 0 0 {name=l30643 lab=WL47}
N 22440 9440 22460 9440 {}
C {lab_pin.sym} 22460 9440 0 0 {name=l30644 lab=VDD}
N 22440 9360 22460 9360 {}
C {lab_pin.sym} 22460 9360 0 0 {name=l30645 lab=VSS}
C {bitcell_6t.sym} 22600 9400 0 0 {name=Xr47c113}
N 22560 9440 22540 9440 {}
C {lab_pin.sym} 22540 9440 0 0 {name=l30646 lab=BL113}
N 22560 9400 22540 9400 {}
C {lab_pin.sym} 22540 9400 0 0 {name=l30647 lab=BLB113}
N 22560 9360 22540 9360 {}
C {lab_pin.sym} 22540 9360 0 0 {name=l30648 lab=WL47}
N 22640 9440 22660 9440 {}
C {lab_pin.sym} 22660 9440 0 0 {name=l30649 lab=VDD}
N 22640 9360 22660 9360 {}
C {lab_pin.sym} 22660 9360 0 0 {name=l30650 lab=VSS}
C {bitcell_6t.sym} 22800 9400 0 0 {name=Xr47c114}
N 22760 9440 22740 9440 {}
C {lab_pin.sym} 22740 9440 0 0 {name=l30651 lab=BL114}
N 22760 9400 22740 9400 {}
C {lab_pin.sym} 22740 9400 0 0 {name=l30652 lab=BLB114}
N 22760 9360 22740 9360 {}
C {lab_pin.sym} 22740 9360 0 0 {name=l30653 lab=WL47}
N 22840 9440 22860 9440 {}
C {lab_pin.sym} 22860 9440 0 0 {name=l30654 lab=VDD}
N 22840 9360 22860 9360 {}
C {lab_pin.sym} 22860 9360 0 0 {name=l30655 lab=VSS}
C {bitcell_6t.sym} 23000 9400 0 0 {name=Xr47c115}
N 22960 9440 22940 9440 {}
C {lab_pin.sym} 22940 9440 0 0 {name=l30656 lab=BL115}
N 22960 9400 22940 9400 {}
C {lab_pin.sym} 22940 9400 0 0 {name=l30657 lab=BLB115}
N 22960 9360 22940 9360 {}
C {lab_pin.sym} 22940 9360 0 0 {name=l30658 lab=WL47}
N 23040 9440 23060 9440 {}
C {lab_pin.sym} 23060 9440 0 0 {name=l30659 lab=VDD}
N 23040 9360 23060 9360 {}
C {lab_pin.sym} 23060 9360 0 0 {name=l30660 lab=VSS}
C {bitcell_6t.sym} 23200 9400 0 0 {name=Xr47c116}
N 23160 9440 23140 9440 {}
C {lab_pin.sym} 23140 9440 0 0 {name=l30661 lab=BL116}
N 23160 9400 23140 9400 {}
C {lab_pin.sym} 23140 9400 0 0 {name=l30662 lab=BLB116}
N 23160 9360 23140 9360 {}
C {lab_pin.sym} 23140 9360 0 0 {name=l30663 lab=WL47}
N 23240 9440 23260 9440 {}
C {lab_pin.sym} 23260 9440 0 0 {name=l30664 lab=VDD}
N 23240 9360 23260 9360 {}
C {lab_pin.sym} 23260 9360 0 0 {name=l30665 lab=VSS}
C {bitcell_6t.sym} 23400 9400 0 0 {name=Xr47c117}
N 23360 9440 23340 9440 {}
C {lab_pin.sym} 23340 9440 0 0 {name=l30666 lab=BL117}
N 23360 9400 23340 9400 {}
C {lab_pin.sym} 23340 9400 0 0 {name=l30667 lab=BLB117}
N 23360 9360 23340 9360 {}
C {lab_pin.sym} 23340 9360 0 0 {name=l30668 lab=WL47}
N 23440 9440 23460 9440 {}
C {lab_pin.sym} 23460 9440 0 0 {name=l30669 lab=VDD}
N 23440 9360 23460 9360 {}
C {lab_pin.sym} 23460 9360 0 0 {name=l30670 lab=VSS}
C {bitcell_6t.sym} 23600 9400 0 0 {name=Xr47c118}
N 23560 9440 23540 9440 {}
C {lab_pin.sym} 23540 9440 0 0 {name=l30671 lab=BL118}
N 23560 9400 23540 9400 {}
C {lab_pin.sym} 23540 9400 0 0 {name=l30672 lab=BLB118}
N 23560 9360 23540 9360 {}
C {lab_pin.sym} 23540 9360 0 0 {name=l30673 lab=WL47}
N 23640 9440 23660 9440 {}
C {lab_pin.sym} 23660 9440 0 0 {name=l30674 lab=VDD}
N 23640 9360 23660 9360 {}
C {lab_pin.sym} 23660 9360 0 0 {name=l30675 lab=VSS}
C {bitcell_6t.sym} 23800 9400 0 0 {name=Xr47c119}
N 23760 9440 23740 9440 {}
C {lab_pin.sym} 23740 9440 0 0 {name=l30676 lab=BL119}
N 23760 9400 23740 9400 {}
C {lab_pin.sym} 23740 9400 0 0 {name=l30677 lab=BLB119}
N 23760 9360 23740 9360 {}
C {lab_pin.sym} 23740 9360 0 0 {name=l30678 lab=WL47}
N 23840 9440 23860 9440 {}
C {lab_pin.sym} 23860 9440 0 0 {name=l30679 lab=VDD}
N 23840 9360 23860 9360 {}
C {lab_pin.sym} 23860 9360 0 0 {name=l30680 lab=VSS}
C {bitcell_6t.sym} 24000 9400 0 0 {name=Xr47c120}
N 23960 9440 23940 9440 {}
C {lab_pin.sym} 23940 9440 0 0 {name=l30681 lab=BL120}
N 23960 9400 23940 9400 {}
C {lab_pin.sym} 23940 9400 0 0 {name=l30682 lab=BLB120}
N 23960 9360 23940 9360 {}
C {lab_pin.sym} 23940 9360 0 0 {name=l30683 lab=WL47}
N 24040 9440 24060 9440 {}
C {lab_pin.sym} 24060 9440 0 0 {name=l30684 lab=VDD}
N 24040 9360 24060 9360 {}
C {lab_pin.sym} 24060 9360 0 0 {name=l30685 lab=VSS}
C {bitcell_6t.sym} 24200 9400 0 0 {name=Xr47c121}
N 24160 9440 24140 9440 {}
C {lab_pin.sym} 24140 9440 0 0 {name=l30686 lab=BL121}
N 24160 9400 24140 9400 {}
C {lab_pin.sym} 24140 9400 0 0 {name=l30687 lab=BLB121}
N 24160 9360 24140 9360 {}
C {lab_pin.sym} 24140 9360 0 0 {name=l30688 lab=WL47}
N 24240 9440 24260 9440 {}
C {lab_pin.sym} 24260 9440 0 0 {name=l30689 lab=VDD}
N 24240 9360 24260 9360 {}
C {lab_pin.sym} 24260 9360 0 0 {name=l30690 lab=VSS}
C {bitcell_6t.sym} 24400 9400 0 0 {name=Xr47c122}
N 24360 9440 24340 9440 {}
C {lab_pin.sym} 24340 9440 0 0 {name=l30691 lab=BL122}
N 24360 9400 24340 9400 {}
C {lab_pin.sym} 24340 9400 0 0 {name=l30692 lab=BLB122}
N 24360 9360 24340 9360 {}
C {lab_pin.sym} 24340 9360 0 0 {name=l30693 lab=WL47}
N 24440 9440 24460 9440 {}
C {lab_pin.sym} 24460 9440 0 0 {name=l30694 lab=VDD}
N 24440 9360 24460 9360 {}
C {lab_pin.sym} 24460 9360 0 0 {name=l30695 lab=VSS}
C {bitcell_6t.sym} 24600 9400 0 0 {name=Xr47c123}
N 24560 9440 24540 9440 {}
C {lab_pin.sym} 24540 9440 0 0 {name=l30696 lab=BL123}
N 24560 9400 24540 9400 {}
C {lab_pin.sym} 24540 9400 0 0 {name=l30697 lab=BLB123}
N 24560 9360 24540 9360 {}
C {lab_pin.sym} 24540 9360 0 0 {name=l30698 lab=WL47}
N 24640 9440 24660 9440 {}
C {lab_pin.sym} 24660 9440 0 0 {name=l30699 lab=VDD}
N 24640 9360 24660 9360 {}
C {lab_pin.sym} 24660 9360 0 0 {name=l30700 lab=VSS}
C {bitcell_6t.sym} 24800 9400 0 0 {name=Xr47c124}
N 24760 9440 24740 9440 {}
C {lab_pin.sym} 24740 9440 0 0 {name=l30701 lab=BL124}
N 24760 9400 24740 9400 {}
C {lab_pin.sym} 24740 9400 0 0 {name=l30702 lab=BLB124}
N 24760 9360 24740 9360 {}
C {lab_pin.sym} 24740 9360 0 0 {name=l30703 lab=WL47}
N 24840 9440 24860 9440 {}
C {lab_pin.sym} 24860 9440 0 0 {name=l30704 lab=VDD}
N 24840 9360 24860 9360 {}
C {lab_pin.sym} 24860 9360 0 0 {name=l30705 lab=VSS}
C {bitcell_6t.sym} 25000 9400 0 0 {name=Xr47c125}
N 24960 9440 24940 9440 {}
C {lab_pin.sym} 24940 9440 0 0 {name=l30706 lab=BL125}
N 24960 9400 24940 9400 {}
C {lab_pin.sym} 24940 9400 0 0 {name=l30707 lab=BLB125}
N 24960 9360 24940 9360 {}
C {lab_pin.sym} 24940 9360 0 0 {name=l30708 lab=WL47}
N 25040 9440 25060 9440 {}
C {lab_pin.sym} 25060 9440 0 0 {name=l30709 lab=VDD}
N 25040 9360 25060 9360 {}
C {lab_pin.sym} 25060 9360 0 0 {name=l30710 lab=VSS}
C {bitcell_6t.sym} 25200 9400 0 0 {name=Xr47c126}
N 25160 9440 25140 9440 {}
C {lab_pin.sym} 25140 9440 0 0 {name=l30711 lab=BL126}
N 25160 9400 25140 9400 {}
C {lab_pin.sym} 25140 9400 0 0 {name=l30712 lab=BLB126}
N 25160 9360 25140 9360 {}
C {lab_pin.sym} 25140 9360 0 0 {name=l30713 lab=WL47}
N 25240 9440 25260 9440 {}
C {lab_pin.sym} 25260 9440 0 0 {name=l30714 lab=VDD}
N 25240 9360 25260 9360 {}
C {lab_pin.sym} 25260 9360 0 0 {name=l30715 lab=VSS}
C {bitcell_6t.sym} 25400 9400 0 0 {name=Xr47c127}
N 25360 9440 25340 9440 {}
C {lab_pin.sym} 25340 9440 0 0 {name=l30716 lab=BL127}
N 25360 9400 25340 9400 {}
C {lab_pin.sym} 25340 9400 0 0 {name=l30717 lab=BLB127}
N 25360 9360 25340 9360 {}
C {lab_pin.sym} 25340 9360 0 0 {name=l30718 lab=WL47}
N 25440 9440 25460 9440 {}
C {lab_pin.sym} 25460 9440 0 0 {name=l30719 lab=VDD}
N 25440 9360 25460 9360 {}
C {lab_pin.sym} 25460 9360 0 0 {name=l30720 lab=VSS}
C {bitcell_6t.sym} 0 9600 0 0 {name=Xr48c0}
N -40 9640 -60 9640 {}
C {lab_pin.sym} -60 9640 0 0 {name=l30721 lab=BL0}
N -40 9600 -60 9600 {}
C {lab_pin.sym} -60 9600 0 0 {name=l30722 lab=BLB0}
N -40 9560 -60 9560 {}
C {lab_pin.sym} -60 9560 0 0 {name=l30723 lab=WL48}
N 40 9640 60 9640 {}
C {lab_pin.sym} 60 9640 0 0 {name=l30724 lab=VDD}
N 40 9560 60 9560 {}
C {lab_pin.sym} 60 9560 0 0 {name=l30725 lab=VSS}
C {bitcell_6t.sym} 200 9600 0 0 {name=Xr48c1}
N 160 9640 140 9640 {}
C {lab_pin.sym} 140 9640 0 0 {name=l30726 lab=BL1}
N 160 9600 140 9600 {}
C {lab_pin.sym} 140 9600 0 0 {name=l30727 lab=BLB1}
N 160 9560 140 9560 {}
C {lab_pin.sym} 140 9560 0 0 {name=l30728 lab=WL48}
N 240 9640 260 9640 {}
C {lab_pin.sym} 260 9640 0 0 {name=l30729 lab=VDD}
N 240 9560 260 9560 {}
C {lab_pin.sym} 260 9560 0 0 {name=l30730 lab=VSS}
C {bitcell_6t.sym} 400 9600 0 0 {name=Xr48c2}
N 360 9640 340 9640 {}
C {lab_pin.sym} 340 9640 0 0 {name=l30731 lab=BL2}
N 360 9600 340 9600 {}
C {lab_pin.sym} 340 9600 0 0 {name=l30732 lab=BLB2}
N 360 9560 340 9560 {}
C {lab_pin.sym} 340 9560 0 0 {name=l30733 lab=WL48}
N 440 9640 460 9640 {}
C {lab_pin.sym} 460 9640 0 0 {name=l30734 lab=VDD}
N 440 9560 460 9560 {}
C {lab_pin.sym} 460 9560 0 0 {name=l30735 lab=VSS}
C {bitcell_6t.sym} 600 9600 0 0 {name=Xr48c3}
N 560 9640 540 9640 {}
C {lab_pin.sym} 540 9640 0 0 {name=l30736 lab=BL3}
N 560 9600 540 9600 {}
C {lab_pin.sym} 540 9600 0 0 {name=l30737 lab=BLB3}
N 560 9560 540 9560 {}
C {lab_pin.sym} 540 9560 0 0 {name=l30738 lab=WL48}
N 640 9640 660 9640 {}
C {lab_pin.sym} 660 9640 0 0 {name=l30739 lab=VDD}
N 640 9560 660 9560 {}
C {lab_pin.sym} 660 9560 0 0 {name=l30740 lab=VSS}
C {bitcell_6t.sym} 800 9600 0 0 {name=Xr48c4}
N 760 9640 740 9640 {}
C {lab_pin.sym} 740 9640 0 0 {name=l30741 lab=BL4}
N 760 9600 740 9600 {}
C {lab_pin.sym} 740 9600 0 0 {name=l30742 lab=BLB4}
N 760 9560 740 9560 {}
C {lab_pin.sym} 740 9560 0 0 {name=l30743 lab=WL48}
N 840 9640 860 9640 {}
C {lab_pin.sym} 860 9640 0 0 {name=l30744 lab=VDD}
N 840 9560 860 9560 {}
C {lab_pin.sym} 860 9560 0 0 {name=l30745 lab=VSS}
C {bitcell_6t.sym} 1000 9600 0 0 {name=Xr48c5}
N 960 9640 940 9640 {}
C {lab_pin.sym} 940 9640 0 0 {name=l30746 lab=BL5}
N 960 9600 940 9600 {}
C {lab_pin.sym} 940 9600 0 0 {name=l30747 lab=BLB5}
N 960 9560 940 9560 {}
C {lab_pin.sym} 940 9560 0 0 {name=l30748 lab=WL48}
N 1040 9640 1060 9640 {}
C {lab_pin.sym} 1060 9640 0 0 {name=l30749 lab=VDD}
N 1040 9560 1060 9560 {}
C {lab_pin.sym} 1060 9560 0 0 {name=l30750 lab=VSS}
C {bitcell_6t.sym} 1200 9600 0 0 {name=Xr48c6}
N 1160 9640 1140 9640 {}
C {lab_pin.sym} 1140 9640 0 0 {name=l30751 lab=BL6}
N 1160 9600 1140 9600 {}
C {lab_pin.sym} 1140 9600 0 0 {name=l30752 lab=BLB6}
N 1160 9560 1140 9560 {}
C {lab_pin.sym} 1140 9560 0 0 {name=l30753 lab=WL48}
N 1240 9640 1260 9640 {}
C {lab_pin.sym} 1260 9640 0 0 {name=l30754 lab=VDD}
N 1240 9560 1260 9560 {}
C {lab_pin.sym} 1260 9560 0 0 {name=l30755 lab=VSS}
C {bitcell_6t.sym} 1400 9600 0 0 {name=Xr48c7}
N 1360 9640 1340 9640 {}
C {lab_pin.sym} 1340 9640 0 0 {name=l30756 lab=BL7}
N 1360 9600 1340 9600 {}
C {lab_pin.sym} 1340 9600 0 0 {name=l30757 lab=BLB7}
N 1360 9560 1340 9560 {}
C {lab_pin.sym} 1340 9560 0 0 {name=l30758 lab=WL48}
N 1440 9640 1460 9640 {}
C {lab_pin.sym} 1460 9640 0 0 {name=l30759 lab=VDD}
N 1440 9560 1460 9560 {}
C {lab_pin.sym} 1460 9560 0 0 {name=l30760 lab=VSS}
C {bitcell_6t.sym} 1600 9600 0 0 {name=Xr48c8}
N 1560 9640 1540 9640 {}
C {lab_pin.sym} 1540 9640 0 0 {name=l30761 lab=BL8}
N 1560 9600 1540 9600 {}
C {lab_pin.sym} 1540 9600 0 0 {name=l30762 lab=BLB8}
N 1560 9560 1540 9560 {}
C {lab_pin.sym} 1540 9560 0 0 {name=l30763 lab=WL48}
N 1640 9640 1660 9640 {}
C {lab_pin.sym} 1660 9640 0 0 {name=l30764 lab=VDD}
N 1640 9560 1660 9560 {}
C {lab_pin.sym} 1660 9560 0 0 {name=l30765 lab=VSS}
C {bitcell_6t.sym} 1800 9600 0 0 {name=Xr48c9}
N 1760 9640 1740 9640 {}
C {lab_pin.sym} 1740 9640 0 0 {name=l30766 lab=BL9}
N 1760 9600 1740 9600 {}
C {lab_pin.sym} 1740 9600 0 0 {name=l30767 lab=BLB9}
N 1760 9560 1740 9560 {}
C {lab_pin.sym} 1740 9560 0 0 {name=l30768 lab=WL48}
N 1840 9640 1860 9640 {}
C {lab_pin.sym} 1860 9640 0 0 {name=l30769 lab=VDD}
N 1840 9560 1860 9560 {}
C {lab_pin.sym} 1860 9560 0 0 {name=l30770 lab=VSS}
C {bitcell_6t.sym} 2000 9600 0 0 {name=Xr48c10}
N 1960 9640 1940 9640 {}
C {lab_pin.sym} 1940 9640 0 0 {name=l30771 lab=BL10}
N 1960 9600 1940 9600 {}
C {lab_pin.sym} 1940 9600 0 0 {name=l30772 lab=BLB10}
N 1960 9560 1940 9560 {}
C {lab_pin.sym} 1940 9560 0 0 {name=l30773 lab=WL48}
N 2040 9640 2060 9640 {}
C {lab_pin.sym} 2060 9640 0 0 {name=l30774 lab=VDD}
N 2040 9560 2060 9560 {}
C {lab_pin.sym} 2060 9560 0 0 {name=l30775 lab=VSS}
C {bitcell_6t.sym} 2200 9600 0 0 {name=Xr48c11}
N 2160 9640 2140 9640 {}
C {lab_pin.sym} 2140 9640 0 0 {name=l30776 lab=BL11}
N 2160 9600 2140 9600 {}
C {lab_pin.sym} 2140 9600 0 0 {name=l30777 lab=BLB11}
N 2160 9560 2140 9560 {}
C {lab_pin.sym} 2140 9560 0 0 {name=l30778 lab=WL48}
N 2240 9640 2260 9640 {}
C {lab_pin.sym} 2260 9640 0 0 {name=l30779 lab=VDD}
N 2240 9560 2260 9560 {}
C {lab_pin.sym} 2260 9560 0 0 {name=l30780 lab=VSS}
C {bitcell_6t.sym} 2400 9600 0 0 {name=Xr48c12}
N 2360 9640 2340 9640 {}
C {lab_pin.sym} 2340 9640 0 0 {name=l30781 lab=BL12}
N 2360 9600 2340 9600 {}
C {lab_pin.sym} 2340 9600 0 0 {name=l30782 lab=BLB12}
N 2360 9560 2340 9560 {}
C {lab_pin.sym} 2340 9560 0 0 {name=l30783 lab=WL48}
N 2440 9640 2460 9640 {}
C {lab_pin.sym} 2460 9640 0 0 {name=l30784 lab=VDD}
N 2440 9560 2460 9560 {}
C {lab_pin.sym} 2460 9560 0 0 {name=l30785 lab=VSS}
C {bitcell_6t.sym} 2600 9600 0 0 {name=Xr48c13}
N 2560 9640 2540 9640 {}
C {lab_pin.sym} 2540 9640 0 0 {name=l30786 lab=BL13}
N 2560 9600 2540 9600 {}
C {lab_pin.sym} 2540 9600 0 0 {name=l30787 lab=BLB13}
N 2560 9560 2540 9560 {}
C {lab_pin.sym} 2540 9560 0 0 {name=l30788 lab=WL48}
N 2640 9640 2660 9640 {}
C {lab_pin.sym} 2660 9640 0 0 {name=l30789 lab=VDD}
N 2640 9560 2660 9560 {}
C {lab_pin.sym} 2660 9560 0 0 {name=l30790 lab=VSS}
C {bitcell_6t.sym} 2800 9600 0 0 {name=Xr48c14}
N 2760 9640 2740 9640 {}
C {lab_pin.sym} 2740 9640 0 0 {name=l30791 lab=BL14}
N 2760 9600 2740 9600 {}
C {lab_pin.sym} 2740 9600 0 0 {name=l30792 lab=BLB14}
N 2760 9560 2740 9560 {}
C {lab_pin.sym} 2740 9560 0 0 {name=l30793 lab=WL48}
N 2840 9640 2860 9640 {}
C {lab_pin.sym} 2860 9640 0 0 {name=l30794 lab=VDD}
N 2840 9560 2860 9560 {}
C {lab_pin.sym} 2860 9560 0 0 {name=l30795 lab=VSS}
C {bitcell_6t.sym} 3000 9600 0 0 {name=Xr48c15}
N 2960 9640 2940 9640 {}
C {lab_pin.sym} 2940 9640 0 0 {name=l30796 lab=BL15}
N 2960 9600 2940 9600 {}
C {lab_pin.sym} 2940 9600 0 0 {name=l30797 lab=BLB15}
N 2960 9560 2940 9560 {}
C {lab_pin.sym} 2940 9560 0 0 {name=l30798 lab=WL48}
N 3040 9640 3060 9640 {}
C {lab_pin.sym} 3060 9640 0 0 {name=l30799 lab=VDD}
N 3040 9560 3060 9560 {}
C {lab_pin.sym} 3060 9560 0 0 {name=l30800 lab=VSS}
C {bitcell_6t.sym} 3200 9600 0 0 {name=Xr48c16}
N 3160 9640 3140 9640 {}
C {lab_pin.sym} 3140 9640 0 0 {name=l30801 lab=BL16}
N 3160 9600 3140 9600 {}
C {lab_pin.sym} 3140 9600 0 0 {name=l30802 lab=BLB16}
N 3160 9560 3140 9560 {}
C {lab_pin.sym} 3140 9560 0 0 {name=l30803 lab=WL48}
N 3240 9640 3260 9640 {}
C {lab_pin.sym} 3260 9640 0 0 {name=l30804 lab=VDD}
N 3240 9560 3260 9560 {}
C {lab_pin.sym} 3260 9560 0 0 {name=l30805 lab=VSS}
C {bitcell_6t.sym} 3400 9600 0 0 {name=Xr48c17}
N 3360 9640 3340 9640 {}
C {lab_pin.sym} 3340 9640 0 0 {name=l30806 lab=BL17}
N 3360 9600 3340 9600 {}
C {lab_pin.sym} 3340 9600 0 0 {name=l30807 lab=BLB17}
N 3360 9560 3340 9560 {}
C {lab_pin.sym} 3340 9560 0 0 {name=l30808 lab=WL48}
N 3440 9640 3460 9640 {}
C {lab_pin.sym} 3460 9640 0 0 {name=l30809 lab=VDD}
N 3440 9560 3460 9560 {}
C {lab_pin.sym} 3460 9560 0 0 {name=l30810 lab=VSS}
C {bitcell_6t.sym} 3600 9600 0 0 {name=Xr48c18}
N 3560 9640 3540 9640 {}
C {lab_pin.sym} 3540 9640 0 0 {name=l30811 lab=BL18}
N 3560 9600 3540 9600 {}
C {lab_pin.sym} 3540 9600 0 0 {name=l30812 lab=BLB18}
N 3560 9560 3540 9560 {}
C {lab_pin.sym} 3540 9560 0 0 {name=l30813 lab=WL48}
N 3640 9640 3660 9640 {}
C {lab_pin.sym} 3660 9640 0 0 {name=l30814 lab=VDD}
N 3640 9560 3660 9560 {}
C {lab_pin.sym} 3660 9560 0 0 {name=l30815 lab=VSS}
C {bitcell_6t.sym} 3800 9600 0 0 {name=Xr48c19}
N 3760 9640 3740 9640 {}
C {lab_pin.sym} 3740 9640 0 0 {name=l30816 lab=BL19}
N 3760 9600 3740 9600 {}
C {lab_pin.sym} 3740 9600 0 0 {name=l30817 lab=BLB19}
N 3760 9560 3740 9560 {}
C {lab_pin.sym} 3740 9560 0 0 {name=l30818 lab=WL48}
N 3840 9640 3860 9640 {}
C {lab_pin.sym} 3860 9640 0 0 {name=l30819 lab=VDD}
N 3840 9560 3860 9560 {}
C {lab_pin.sym} 3860 9560 0 0 {name=l30820 lab=VSS}
C {bitcell_6t.sym} 4000 9600 0 0 {name=Xr48c20}
N 3960 9640 3940 9640 {}
C {lab_pin.sym} 3940 9640 0 0 {name=l30821 lab=BL20}
N 3960 9600 3940 9600 {}
C {lab_pin.sym} 3940 9600 0 0 {name=l30822 lab=BLB20}
N 3960 9560 3940 9560 {}
C {lab_pin.sym} 3940 9560 0 0 {name=l30823 lab=WL48}
N 4040 9640 4060 9640 {}
C {lab_pin.sym} 4060 9640 0 0 {name=l30824 lab=VDD}
N 4040 9560 4060 9560 {}
C {lab_pin.sym} 4060 9560 0 0 {name=l30825 lab=VSS}
C {bitcell_6t.sym} 4200 9600 0 0 {name=Xr48c21}
N 4160 9640 4140 9640 {}
C {lab_pin.sym} 4140 9640 0 0 {name=l30826 lab=BL21}
N 4160 9600 4140 9600 {}
C {lab_pin.sym} 4140 9600 0 0 {name=l30827 lab=BLB21}
N 4160 9560 4140 9560 {}
C {lab_pin.sym} 4140 9560 0 0 {name=l30828 lab=WL48}
N 4240 9640 4260 9640 {}
C {lab_pin.sym} 4260 9640 0 0 {name=l30829 lab=VDD}
N 4240 9560 4260 9560 {}
C {lab_pin.sym} 4260 9560 0 0 {name=l30830 lab=VSS}
C {bitcell_6t.sym} 4400 9600 0 0 {name=Xr48c22}
N 4360 9640 4340 9640 {}
C {lab_pin.sym} 4340 9640 0 0 {name=l30831 lab=BL22}
N 4360 9600 4340 9600 {}
C {lab_pin.sym} 4340 9600 0 0 {name=l30832 lab=BLB22}
N 4360 9560 4340 9560 {}
C {lab_pin.sym} 4340 9560 0 0 {name=l30833 lab=WL48}
N 4440 9640 4460 9640 {}
C {lab_pin.sym} 4460 9640 0 0 {name=l30834 lab=VDD}
N 4440 9560 4460 9560 {}
C {lab_pin.sym} 4460 9560 0 0 {name=l30835 lab=VSS}
C {bitcell_6t.sym} 4600 9600 0 0 {name=Xr48c23}
N 4560 9640 4540 9640 {}
C {lab_pin.sym} 4540 9640 0 0 {name=l30836 lab=BL23}
N 4560 9600 4540 9600 {}
C {lab_pin.sym} 4540 9600 0 0 {name=l30837 lab=BLB23}
N 4560 9560 4540 9560 {}
C {lab_pin.sym} 4540 9560 0 0 {name=l30838 lab=WL48}
N 4640 9640 4660 9640 {}
C {lab_pin.sym} 4660 9640 0 0 {name=l30839 lab=VDD}
N 4640 9560 4660 9560 {}
C {lab_pin.sym} 4660 9560 0 0 {name=l30840 lab=VSS}
C {bitcell_6t.sym} 4800 9600 0 0 {name=Xr48c24}
N 4760 9640 4740 9640 {}
C {lab_pin.sym} 4740 9640 0 0 {name=l30841 lab=BL24}
N 4760 9600 4740 9600 {}
C {lab_pin.sym} 4740 9600 0 0 {name=l30842 lab=BLB24}
N 4760 9560 4740 9560 {}
C {lab_pin.sym} 4740 9560 0 0 {name=l30843 lab=WL48}
N 4840 9640 4860 9640 {}
C {lab_pin.sym} 4860 9640 0 0 {name=l30844 lab=VDD}
N 4840 9560 4860 9560 {}
C {lab_pin.sym} 4860 9560 0 0 {name=l30845 lab=VSS}
C {bitcell_6t.sym} 5000 9600 0 0 {name=Xr48c25}
N 4960 9640 4940 9640 {}
C {lab_pin.sym} 4940 9640 0 0 {name=l30846 lab=BL25}
N 4960 9600 4940 9600 {}
C {lab_pin.sym} 4940 9600 0 0 {name=l30847 lab=BLB25}
N 4960 9560 4940 9560 {}
C {lab_pin.sym} 4940 9560 0 0 {name=l30848 lab=WL48}
N 5040 9640 5060 9640 {}
C {lab_pin.sym} 5060 9640 0 0 {name=l30849 lab=VDD}
N 5040 9560 5060 9560 {}
C {lab_pin.sym} 5060 9560 0 0 {name=l30850 lab=VSS}
C {bitcell_6t.sym} 5200 9600 0 0 {name=Xr48c26}
N 5160 9640 5140 9640 {}
C {lab_pin.sym} 5140 9640 0 0 {name=l30851 lab=BL26}
N 5160 9600 5140 9600 {}
C {lab_pin.sym} 5140 9600 0 0 {name=l30852 lab=BLB26}
N 5160 9560 5140 9560 {}
C {lab_pin.sym} 5140 9560 0 0 {name=l30853 lab=WL48}
N 5240 9640 5260 9640 {}
C {lab_pin.sym} 5260 9640 0 0 {name=l30854 lab=VDD}
N 5240 9560 5260 9560 {}
C {lab_pin.sym} 5260 9560 0 0 {name=l30855 lab=VSS}
C {bitcell_6t.sym} 5400 9600 0 0 {name=Xr48c27}
N 5360 9640 5340 9640 {}
C {lab_pin.sym} 5340 9640 0 0 {name=l30856 lab=BL27}
N 5360 9600 5340 9600 {}
C {lab_pin.sym} 5340 9600 0 0 {name=l30857 lab=BLB27}
N 5360 9560 5340 9560 {}
C {lab_pin.sym} 5340 9560 0 0 {name=l30858 lab=WL48}
N 5440 9640 5460 9640 {}
C {lab_pin.sym} 5460 9640 0 0 {name=l30859 lab=VDD}
N 5440 9560 5460 9560 {}
C {lab_pin.sym} 5460 9560 0 0 {name=l30860 lab=VSS}
C {bitcell_6t.sym} 5600 9600 0 0 {name=Xr48c28}
N 5560 9640 5540 9640 {}
C {lab_pin.sym} 5540 9640 0 0 {name=l30861 lab=BL28}
N 5560 9600 5540 9600 {}
C {lab_pin.sym} 5540 9600 0 0 {name=l30862 lab=BLB28}
N 5560 9560 5540 9560 {}
C {lab_pin.sym} 5540 9560 0 0 {name=l30863 lab=WL48}
N 5640 9640 5660 9640 {}
C {lab_pin.sym} 5660 9640 0 0 {name=l30864 lab=VDD}
N 5640 9560 5660 9560 {}
C {lab_pin.sym} 5660 9560 0 0 {name=l30865 lab=VSS}
C {bitcell_6t.sym} 5800 9600 0 0 {name=Xr48c29}
N 5760 9640 5740 9640 {}
C {lab_pin.sym} 5740 9640 0 0 {name=l30866 lab=BL29}
N 5760 9600 5740 9600 {}
C {lab_pin.sym} 5740 9600 0 0 {name=l30867 lab=BLB29}
N 5760 9560 5740 9560 {}
C {lab_pin.sym} 5740 9560 0 0 {name=l30868 lab=WL48}
N 5840 9640 5860 9640 {}
C {lab_pin.sym} 5860 9640 0 0 {name=l30869 lab=VDD}
N 5840 9560 5860 9560 {}
C {lab_pin.sym} 5860 9560 0 0 {name=l30870 lab=VSS}
C {bitcell_6t.sym} 6000 9600 0 0 {name=Xr48c30}
N 5960 9640 5940 9640 {}
C {lab_pin.sym} 5940 9640 0 0 {name=l30871 lab=BL30}
N 5960 9600 5940 9600 {}
C {lab_pin.sym} 5940 9600 0 0 {name=l30872 lab=BLB30}
N 5960 9560 5940 9560 {}
C {lab_pin.sym} 5940 9560 0 0 {name=l30873 lab=WL48}
N 6040 9640 6060 9640 {}
C {lab_pin.sym} 6060 9640 0 0 {name=l30874 lab=VDD}
N 6040 9560 6060 9560 {}
C {lab_pin.sym} 6060 9560 0 0 {name=l30875 lab=VSS}
C {bitcell_6t.sym} 6200 9600 0 0 {name=Xr48c31}
N 6160 9640 6140 9640 {}
C {lab_pin.sym} 6140 9640 0 0 {name=l30876 lab=BL31}
N 6160 9600 6140 9600 {}
C {lab_pin.sym} 6140 9600 0 0 {name=l30877 lab=BLB31}
N 6160 9560 6140 9560 {}
C {lab_pin.sym} 6140 9560 0 0 {name=l30878 lab=WL48}
N 6240 9640 6260 9640 {}
C {lab_pin.sym} 6260 9640 0 0 {name=l30879 lab=VDD}
N 6240 9560 6260 9560 {}
C {lab_pin.sym} 6260 9560 0 0 {name=l30880 lab=VSS}
C {bitcell_6t.sym} 6400 9600 0 0 {name=Xr48c32}
N 6360 9640 6340 9640 {}
C {lab_pin.sym} 6340 9640 0 0 {name=l30881 lab=BL32}
N 6360 9600 6340 9600 {}
C {lab_pin.sym} 6340 9600 0 0 {name=l30882 lab=BLB32}
N 6360 9560 6340 9560 {}
C {lab_pin.sym} 6340 9560 0 0 {name=l30883 lab=WL48}
N 6440 9640 6460 9640 {}
C {lab_pin.sym} 6460 9640 0 0 {name=l30884 lab=VDD}
N 6440 9560 6460 9560 {}
C {lab_pin.sym} 6460 9560 0 0 {name=l30885 lab=VSS}
C {bitcell_6t.sym} 6600 9600 0 0 {name=Xr48c33}
N 6560 9640 6540 9640 {}
C {lab_pin.sym} 6540 9640 0 0 {name=l30886 lab=BL33}
N 6560 9600 6540 9600 {}
C {lab_pin.sym} 6540 9600 0 0 {name=l30887 lab=BLB33}
N 6560 9560 6540 9560 {}
C {lab_pin.sym} 6540 9560 0 0 {name=l30888 lab=WL48}
N 6640 9640 6660 9640 {}
C {lab_pin.sym} 6660 9640 0 0 {name=l30889 lab=VDD}
N 6640 9560 6660 9560 {}
C {lab_pin.sym} 6660 9560 0 0 {name=l30890 lab=VSS}
C {bitcell_6t.sym} 6800 9600 0 0 {name=Xr48c34}
N 6760 9640 6740 9640 {}
C {lab_pin.sym} 6740 9640 0 0 {name=l30891 lab=BL34}
N 6760 9600 6740 9600 {}
C {lab_pin.sym} 6740 9600 0 0 {name=l30892 lab=BLB34}
N 6760 9560 6740 9560 {}
C {lab_pin.sym} 6740 9560 0 0 {name=l30893 lab=WL48}
N 6840 9640 6860 9640 {}
C {lab_pin.sym} 6860 9640 0 0 {name=l30894 lab=VDD}
N 6840 9560 6860 9560 {}
C {lab_pin.sym} 6860 9560 0 0 {name=l30895 lab=VSS}
C {bitcell_6t.sym} 7000 9600 0 0 {name=Xr48c35}
N 6960 9640 6940 9640 {}
C {lab_pin.sym} 6940 9640 0 0 {name=l30896 lab=BL35}
N 6960 9600 6940 9600 {}
C {lab_pin.sym} 6940 9600 0 0 {name=l30897 lab=BLB35}
N 6960 9560 6940 9560 {}
C {lab_pin.sym} 6940 9560 0 0 {name=l30898 lab=WL48}
N 7040 9640 7060 9640 {}
C {lab_pin.sym} 7060 9640 0 0 {name=l30899 lab=VDD}
N 7040 9560 7060 9560 {}
C {lab_pin.sym} 7060 9560 0 0 {name=l30900 lab=VSS}
C {bitcell_6t.sym} 7200 9600 0 0 {name=Xr48c36}
N 7160 9640 7140 9640 {}
C {lab_pin.sym} 7140 9640 0 0 {name=l30901 lab=BL36}
N 7160 9600 7140 9600 {}
C {lab_pin.sym} 7140 9600 0 0 {name=l30902 lab=BLB36}
N 7160 9560 7140 9560 {}
C {lab_pin.sym} 7140 9560 0 0 {name=l30903 lab=WL48}
N 7240 9640 7260 9640 {}
C {lab_pin.sym} 7260 9640 0 0 {name=l30904 lab=VDD}
N 7240 9560 7260 9560 {}
C {lab_pin.sym} 7260 9560 0 0 {name=l30905 lab=VSS}
C {bitcell_6t.sym} 7400 9600 0 0 {name=Xr48c37}
N 7360 9640 7340 9640 {}
C {lab_pin.sym} 7340 9640 0 0 {name=l30906 lab=BL37}
N 7360 9600 7340 9600 {}
C {lab_pin.sym} 7340 9600 0 0 {name=l30907 lab=BLB37}
N 7360 9560 7340 9560 {}
C {lab_pin.sym} 7340 9560 0 0 {name=l30908 lab=WL48}
N 7440 9640 7460 9640 {}
C {lab_pin.sym} 7460 9640 0 0 {name=l30909 lab=VDD}
N 7440 9560 7460 9560 {}
C {lab_pin.sym} 7460 9560 0 0 {name=l30910 lab=VSS}
C {bitcell_6t.sym} 7600 9600 0 0 {name=Xr48c38}
N 7560 9640 7540 9640 {}
C {lab_pin.sym} 7540 9640 0 0 {name=l30911 lab=BL38}
N 7560 9600 7540 9600 {}
C {lab_pin.sym} 7540 9600 0 0 {name=l30912 lab=BLB38}
N 7560 9560 7540 9560 {}
C {lab_pin.sym} 7540 9560 0 0 {name=l30913 lab=WL48}
N 7640 9640 7660 9640 {}
C {lab_pin.sym} 7660 9640 0 0 {name=l30914 lab=VDD}
N 7640 9560 7660 9560 {}
C {lab_pin.sym} 7660 9560 0 0 {name=l30915 lab=VSS}
C {bitcell_6t.sym} 7800 9600 0 0 {name=Xr48c39}
N 7760 9640 7740 9640 {}
C {lab_pin.sym} 7740 9640 0 0 {name=l30916 lab=BL39}
N 7760 9600 7740 9600 {}
C {lab_pin.sym} 7740 9600 0 0 {name=l30917 lab=BLB39}
N 7760 9560 7740 9560 {}
C {lab_pin.sym} 7740 9560 0 0 {name=l30918 lab=WL48}
N 7840 9640 7860 9640 {}
C {lab_pin.sym} 7860 9640 0 0 {name=l30919 lab=VDD}
N 7840 9560 7860 9560 {}
C {lab_pin.sym} 7860 9560 0 0 {name=l30920 lab=VSS}
C {bitcell_6t.sym} 8000 9600 0 0 {name=Xr48c40}
N 7960 9640 7940 9640 {}
C {lab_pin.sym} 7940 9640 0 0 {name=l30921 lab=BL40}
N 7960 9600 7940 9600 {}
C {lab_pin.sym} 7940 9600 0 0 {name=l30922 lab=BLB40}
N 7960 9560 7940 9560 {}
C {lab_pin.sym} 7940 9560 0 0 {name=l30923 lab=WL48}
N 8040 9640 8060 9640 {}
C {lab_pin.sym} 8060 9640 0 0 {name=l30924 lab=VDD}
N 8040 9560 8060 9560 {}
C {lab_pin.sym} 8060 9560 0 0 {name=l30925 lab=VSS}
C {bitcell_6t.sym} 8200 9600 0 0 {name=Xr48c41}
N 8160 9640 8140 9640 {}
C {lab_pin.sym} 8140 9640 0 0 {name=l30926 lab=BL41}
N 8160 9600 8140 9600 {}
C {lab_pin.sym} 8140 9600 0 0 {name=l30927 lab=BLB41}
N 8160 9560 8140 9560 {}
C {lab_pin.sym} 8140 9560 0 0 {name=l30928 lab=WL48}
N 8240 9640 8260 9640 {}
C {lab_pin.sym} 8260 9640 0 0 {name=l30929 lab=VDD}
N 8240 9560 8260 9560 {}
C {lab_pin.sym} 8260 9560 0 0 {name=l30930 lab=VSS}
C {bitcell_6t.sym} 8400 9600 0 0 {name=Xr48c42}
N 8360 9640 8340 9640 {}
C {lab_pin.sym} 8340 9640 0 0 {name=l30931 lab=BL42}
N 8360 9600 8340 9600 {}
C {lab_pin.sym} 8340 9600 0 0 {name=l30932 lab=BLB42}
N 8360 9560 8340 9560 {}
C {lab_pin.sym} 8340 9560 0 0 {name=l30933 lab=WL48}
N 8440 9640 8460 9640 {}
C {lab_pin.sym} 8460 9640 0 0 {name=l30934 lab=VDD}
N 8440 9560 8460 9560 {}
C {lab_pin.sym} 8460 9560 0 0 {name=l30935 lab=VSS}
C {bitcell_6t.sym} 8600 9600 0 0 {name=Xr48c43}
N 8560 9640 8540 9640 {}
C {lab_pin.sym} 8540 9640 0 0 {name=l30936 lab=BL43}
N 8560 9600 8540 9600 {}
C {lab_pin.sym} 8540 9600 0 0 {name=l30937 lab=BLB43}
N 8560 9560 8540 9560 {}
C {lab_pin.sym} 8540 9560 0 0 {name=l30938 lab=WL48}
N 8640 9640 8660 9640 {}
C {lab_pin.sym} 8660 9640 0 0 {name=l30939 lab=VDD}
N 8640 9560 8660 9560 {}
C {lab_pin.sym} 8660 9560 0 0 {name=l30940 lab=VSS}
C {bitcell_6t.sym} 8800 9600 0 0 {name=Xr48c44}
N 8760 9640 8740 9640 {}
C {lab_pin.sym} 8740 9640 0 0 {name=l30941 lab=BL44}
N 8760 9600 8740 9600 {}
C {lab_pin.sym} 8740 9600 0 0 {name=l30942 lab=BLB44}
N 8760 9560 8740 9560 {}
C {lab_pin.sym} 8740 9560 0 0 {name=l30943 lab=WL48}
N 8840 9640 8860 9640 {}
C {lab_pin.sym} 8860 9640 0 0 {name=l30944 lab=VDD}
N 8840 9560 8860 9560 {}
C {lab_pin.sym} 8860 9560 0 0 {name=l30945 lab=VSS}
C {bitcell_6t.sym} 9000 9600 0 0 {name=Xr48c45}
N 8960 9640 8940 9640 {}
C {lab_pin.sym} 8940 9640 0 0 {name=l30946 lab=BL45}
N 8960 9600 8940 9600 {}
C {lab_pin.sym} 8940 9600 0 0 {name=l30947 lab=BLB45}
N 8960 9560 8940 9560 {}
C {lab_pin.sym} 8940 9560 0 0 {name=l30948 lab=WL48}
N 9040 9640 9060 9640 {}
C {lab_pin.sym} 9060 9640 0 0 {name=l30949 lab=VDD}
N 9040 9560 9060 9560 {}
C {lab_pin.sym} 9060 9560 0 0 {name=l30950 lab=VSS}
C {bitcell_6t.sym} 9200 9600 0 0 {name=Xr48c46}
N 9160 9640 9140 9640 {}
C {lab_pin.sym} 9140 9640 0 0 {name=l30951 lab=BL46}
N 9160 9600 9140 9600 {}
C {lab_pin.sym} 9140 9600 0 0 {name=l30952 lab=BLB46}
N 9160 9560 9140 9560 {}
C {lab_pin.sym} 9140 9560 0 0 {name=l30953 lab=WL48}
N 9240 9640 9260 9640 {}
C {lab_pin.sym} 9260 9640 0 0 {name=l30954 lab=VDD}
N 9240 9560 9260 9560 {}
C {lab_pin.sym} 9260 9560 0 0 {name=l30955 lab=VSS}
C {bitcell_6t.sym} 9400 9600 0 0 {name=Xr48c47}
N 9360 9640 9340 9640 {}
C {lab_pin.sym} 9340 9640 0 0 {name=l30956 lab=BL47}
N 9360 9600 9340 9600 {}
C {lab_pin.sym} 9340 9600 0 0 {name=l30957 lab=BLB47}
N 9360 9560 9340 9560 {}
C {lab_pin.sym} 9340 9560 0 0 {name=l30958 lab=WL48}
N 9440 9640 9460 9640 {}
C {lab_pin.sym} 9460 9640 0 0 {name=l30959 lab=VDD}
N 9440 9560 9460 9560 {}
C {lab_pin.sym} 9460 9560 0 0 {name=l30960 lab=VSS}
C {bitcell_6t.sym} 9600 9600 0 0 {name=Xr48c48}
N 9560 9640 9540 9640 {}
C {lab_pin.sym} 9540 9640 0 0 {name=l30961 lab=BL48}
N 9560 9600 9540 9600 {}
C {lab_pin.sym} 9540 9600 0 0 {name=l30962 lab=BLB48}
N 9560 9560 9540 9560 {}
C {lab_pin.sym} 9540 9560 0 0 {name=l30963 lab=WL48}
N 9640 9640 9660 9640 {}
C {lab_pin.sym} 9660 9640 0 0 {name=l30964 lab=VDD}
N 9640 9560 9660 9560 {}
C {lab_pin.sym} 9660 9560 0 0 {name=l30965 lab=VSS}
C {bitcell_6t.sym} 9800 9600 0 0 {name=Xr48c49}
N 9760 9640 9740 9640 {}
C {lab_pin.sym} 9740 9640 0 0 {name=l30966 lab=BL49}
N 9760 9600 9740 9600 {}
C {lab_pin.sym} 9740 9600 0 0 {name=l30967 lab=BLB49}
N 9760 9560 9740 9560 {}
C {lab_pin.sym} 9740 9560 0 0 {name=l30968 lab=WL48}
N 9840 9640 9860 9640 {}
C {lab_pin.sym} 9860 9640 0 0 {name=l30969 lab=VDD}
N 9840 9560 9860 9560 {}
C {lab_pin.sym} 9860 9560 0 0 {name=l30970 lab=VSS}
C {bitcell_6t.sym} 10000 9600 0 0 {name=Xr48c50}
N 9960 9640 9940 9640 {}
C {lab_pin.sym} 9940 9640 0 0 {name=l30971 lab=BL50}
N 9960 9600 9940 9600 {}
C {lab_pin.sym} 9940 9600 0 0 {name=l30972 lab=BLB50}
N 9960 9560 9940 9560 {}
C {lab_pin.sym} 9940 9560 0 0 {name=l30973 lab=WL48}
N 10040 9640 10060 9640 {}
C {lab_pin.sym} 10060 9640 0 0 {name=l30974 lab=VDD}
N 10040 9560 10060 9560 {}
C {lab_pin.sym} 10060 9560 0 0 {name=l30975 lab=VSS}
C {bitcell_6t.sym} 10200 9600 0 0 {name=Xr48c51}
N 10160 9640 10140 9640 {}
C {lab_pin.sym} 10140 9640 0 0 {name=l30976 lab=BL51}
N 10160 9600 10140 9600 {}
C {lab_pin.sym} 10140 9600 0 0 {name=l30977 lab=BLB51}
N 10160 9560 10140 9560 {}
C {lab_pin.sym} 10140 9560 0 0 {name=l30978 lab=WL48}
N 10240 9640 10260 9640 {}
C {lab_pin.sym} 10260 9640 0 0 {name=l30979 lab=VDD}
N 10240 9560 10260 9560 {}
C {lab_pin.sym} 10260 9560 0 0 {name=l30980 lab=VSS}
C {bitcell_6t.sym} 10400 9600 0 0 {name=Xr48c52}
N 10360 9640 10340 9640 {}
C {lab_pin.sym} 10340 9640 0 0 {name=l30981 lab=BL52}
N 10360 9600 10340 9600 {}
C {lab_pin.sym} 10340 9600 0 0 {name=l30982 lab=BLB52}
N 10360 9560 10340 9560 {}
C {lab_pin.sym} 10340 9560 0 0 {name=l30983 lab=WL48}
N 10440 9640 10460 9640 {}
C {lab_pin.sym} 10460 9640 0 0 {name=l30984 lab=VDD}
N 10440 9560 10460 9560 {}
C {lab_pin.sym} 10460 9560 0 0 {name=l30985 lab=VSS}
C {bitcell_6t.sym} 10600 9600 0 0 {name=Xr48c53}
N 10560 9640 10540 9640 {}
C {lab_pin.sym} 10540 9640 0 0 {name=l30986 lab=BL53}
N 10560 9600 10540 9600 {}
C {lab_pin.sym} 10540 9600 0 0 {name=l30987 lab=BLB53}
N 10560 9560 10540 9560 {}
C {lab_pin.sym} 10540 9560 0 0 {name=l30988 lab=WL48}
N 10640 9640 10660 9640 {}
C {lab_pin.sym} 10660 9640 0 0 {name=l30989 lab=VDD}
N 10640 9560 10660 9560 {}
C {lab_pin.sym} 10660 9560 0 0 {name=l30990 lab=VSS}
C {bitcell_6t.sym} 10800 9600 0 0 {name=Xr48c54}
N 10760 9640 10740 9640 {}
C {lab_pin.sym} 10740 9640 0 0 {name=l30991 lab=BL54}
N 10760 9600 10740 9600 {}
C {lab_pin.sym} 10740 9600 0 0 {name=l30992 lab=BLB54}
N 10760 9560 10740 9560 {}
C {lab_pin.sym} 10740 9560 0 0 {name=l30993 lab=WL48}
N 10840 9640 10860 9640 {}
C {lab_pin.sym} 10860 9640 0 0 {name=l30994 lab=VDD}
N 10840 9560 10860 9560 {}
C {lab_pin.sym} 10860 9560 0 0 {name=l30995 lab=VSS}
C {bitcell_6t.sym} 11000 9600 0 0 {name=Xr48c55}
N 10960 9640 10940 9640 {}
C {lab_pin.sym} 10940 9640 0 0 {name=l30996 lab=BL55}
N 10960 9600 10940 9600 {}
C {lab_pin.sym} 10940 9600 0 0 {name=l30997 lab=BLB55}
N 10960 9560 10940 9560 {}
C {lab_pin.sym} 10940 9560 0 0 {name=l30998 lab=WL48}
N 11040 9640 11060 9640 {}
C {lab_pin.sym} 11060 9640 0 0 {name=l30999 lab=VDD}
N 11040 9560 11060 9560 {}
C {lab_pin.sym} 11060 9560 0 0 {name=l31000 lab=VSS}
C {bitcell_6t.sym} 11200 9600 0 0 {name=Xr48c56}
N 11160 9640 11140 9640 {}
C {lab_pin.sym} 11140 9640 0 0 {name=l31001 lab=BL56}
N 11160 9600 11140 9600 {}
C {lab_pin.sym} 11140 9600 0 0 {name=l31002 lab=BLB56}
N 11160 9560 11140 9560 {}
C {lab_pin.sym} 11140 9560 0 0 {name=l31003 lab=WL48}
N 11240 9640 11260 9640 {}
C {lab_pin.sym} 11260 9640 0 0 {name=l31004 lab=VDD}
N 11240 9560 11260 9560 {}
C {lab_pin.sym} 11260 9560 0 0 {name=l31005 lab=VSS}
C {bitcell_6t.sym} 11400 9600 0 0 {name=Xr48c57}
N 11360 9640 11340 9640 {}
C {lab_pin.sym} 11340 9640 0 0 {name=l31006 lab=BL57}
N 11360 9600 11340 9600 {}
C {lab_pin.sym} 11340 9600 0 0 {name=l31007 lab=BLB57}
N 11360 9560 11340 9560 {}
C {lab_pin.sym} 11340 9560 0 0 {name=l31008 lab=WL48}
N 11440 9640 11460 9640 {}
C {lab_pin.sym} 11460 9640 0 0 {name=l31009 lab=VDD}
N 11440 9560 11460 9560 {}
C {lab_pin.sym} 11460 9560 0 0 {name=l31010 lab=VSS}
C {bitcell_6t.sym} 11600 9600 0 0 {name=Xr48c58}
N 11560 9640 11540 9640 {}
C {lab_pin.sym} 11540 9640 0 0 {name=l31011 lab=BL58}
N 11560 9600 11540 9600 {}
C {lab_pin.sym} 11540 9600 0 0 {name=l31012 lab=BLB58}
N 11560 9560 11540 9560 {}
C {lab_pin.sym} 11540 9560 0 0 {name=l31013 lab=WL48}
N 11640 9640 11660 9640 {}
C {lab_pin.sym} 11660 9640 0 0 {name=l31014 lab=VDD}
N 11640 9560 11660 9560 {}
C {lab_pin.sym} 11660 9560 0 0 {name=l31015 lab=VSS}
C {bitcell_6t.sym} 11800 9600 0 0 {name=Xr48c59}
N 11760 9640 11740 9640 {}
C {lab_pin.sym} 11740 9640 0 0 {name=l31016 lab=BL59}
N 11760 9600 11740 9600 {}
C {lab_pin.sym} 11740 9600 0 0 {name=l31017 lab=BLB59}
N 11760 9560 11740 9560 {}
C {lab_pin.sym} 11740 9560 0 0 {name=l31018 lab=WL48}
N 11840 9640 11860 9640 {}
C {lab_pin.sym} 11860 9640 0 0 {name=l31019 lab=VDD}
N 11840 9560 11860 9560 {}
C {lab_pin.sym} 11860 9560 0 0 {name=l31020 lab=VSS}
C {bitcell_6t.sym} 12000 9600 0 0 {name=Xr48c60}
N 11960 9640 11940 9640 {}
C {lab_pin.sym} 11940 9640 0 0 {name=l31021 lab=BL60}
N 11960 9600 11940 9600 {}
C {lab_pin.sym} 11940 9600 0 0 {name=l31022 lab=BLB60}
N 11960 9560 11940 9560 {}
C {lab_pin.sym} 11940 9560 0 0 {name=l31023 lab=WL48}
N 12040 9640 12060 9640 {}
C {lab_pin.sym} 12060 9640 0 0 {name=l31024 lab=VDD}
N 12040 9560 12060 9560 {}
C {lab_pin.sym} 12060 9560 0 0 {name=l31025 lab=VSS}
C {bitcell_6t.sym} 12200 9600 0 0 {name=Xr48c61}
N 12160 9640 12140 9640 {}
C {lab_pin.sym} 12140 9640 0 0 {name=l31026 lab=BL61}
N 12160 9600 12140 9600 {}
C {lab_pin.sym} 12140 9600 0 0 {name=l31027 lab=BLB61}
N 12160 9560 12140 9560 {}
C {lab_pin.sym} 12140 9560 0 0 {name=l31028 lab=WL48}
N 12240 9640 12260 9640 {}
C {lab_pin.sym} 12260 9640 0 0 {name=l31029 lab=VDD}
N 12240 9560 12260 9560 {}
C {lab_pin.sym} 12260 9560 0 0 {name=l31030 lab=VSS}
C {bitcell_6t.sym} 12400 9600 0 0 {name=Xr48c62}
N 12360 9640 12340 9640 {}
C {lab_pin.sym} 12340 9640 0 0 {name=l31031 lab=BL62}
N 12360 9600 12340 9600 {}
C {lab_pin.sym} 12340 9600 0 0 {name=l31032 lab=BLB62}
N 12360 9560 12340 9560 {}
C {lab_pin.sym} 12340 9560 0 0 {name=l31033 lab=WL48}
N 12440 9640 12460 9640 {}
C {lab_pin.sym} 12460 9640 0 0 {name=l31034 lab=VDD}
N 12440 9560 12460 9560 {}
C {lab_pin.sym} 12460 9560 0 0 {name=l31035 lab=VSS}
C {bitcell_6t.sym} 12600 9600 0 0 {name=Xr48c63}
N 12560 9640 12540 9640 {}
C {lab_pin.sym} 12540 9640 0 0 {name=l31036 lab=BL63}
N 12560 9600 12540 9600 {}
C {lab_pin.sym} 12540 9600 0 0 {name=l31037 lab=BLB63}
N 12560 9560 12540 9560 {}
C {lab_pin.sym} 12540 9560 0 0 {name=l31038 lab=WL48}
N 12640 9640 12660 9640 {}
C {lab_pin.sym} 12660 9640 0 0 {name=l31039 lab=VDD}
N 12640 9560 12660 9560 {}
C {lab_pin.sym} 12660 9560 0 0 {name=l31040 lab=VSS}
C {bitcell_6t.sym} 12800 9600 0 0 {name=Xr48c64}
N 12760 9640 12740 9640 {}
C {lab_pin.sym} 12740 9640 0 0 {name=l31041 lab=BL64}
N 12760 9600 12740 9600 {}
C {lab_pin.sym} 12740 9600 0 0 {name=l31042 lab=BLB64}
N 12760 9560 12740 9560 {}
C {lab_pin.sym} 12740 9560 0 0 {name=l31043 lab=WL48}
N 12840 9640 12860 9640 {}
C {lab_pin.sym} 12860 9640 0 0 {name=l31044 lab=VDD}
N 12840 9560 12860 9560 {}
C {lab_pin.sym} 12860 9560 0 0 {name=l31045 lab=VSS}
C {bitcell_6t.sym} 13000 9600 0 0 {name=Xr48c65}
N 12960 9640 12940 9640 {}
C {lab_pin.sym} 12940 9640 0 0 {name=l31046 lab=BL65}
N 12960 9600 12940 9600 {}
C {lab_pin.sym} 12940 9600 0 0 {name=l31047 lab=BLB65}
N 12960 9560 12940 9560 {}
C {lab_pin.sym} 12940 9560 0 0 {name=l31048 lab=WL48}
N 13040 9640 13060 9640 {}
C {lab_pin.sym} 13060 9640 0 0 {name=l31049 lab=VDD}
N 13040 9560 13060 9560 {}
C {lab_pin.sym} 13060 9560 0 0 {name=l31050 lab=VSS}
C {bitcell_6t.sym} 13200 9600 0 0 {name=Xr48c66}
N 13160 9640 13140 9640 {}
C {lab_pin.sym} 13140 9640 0 0 {name=l31051 lab=BL66}
N 13160 9600 13140 9600 {}
C {lab_pin.sym} 13140 9600 0 0 {name=l31052 lab=BLB66}
N 13160 9560 13140 9560 {}
C {lab_pin.sym} 13140 9560 0 0 {name=l31053 lab=WL48}
N 13240 9640 13260 9640 {}
C {lab_pin.sym} 13260 9640 0 0 {name=l31054 lab=VDD}
N 13240 9560 13260 9560 {}
C {lab_pin.sym} 13260 9560 0 0 {name=l31055 lab=VSS}
C {bitcell_6t.sym} 13400 9600 0 0 {name=Xr48c67}
N 13360 9640 13340 9640 {}
C {lab_pin.sym} 13340 9640 0 0 {name=l31056 lab=BL67}
N 13360 9600 13340 9600 {}
C {lab_pin.sym} 13340 9600 0 0 {name=l31057 lab=BLB67}
N 13360 9560 13340 9560 {}
C {lab_pin.sym} 13340 9560 0 0 {name=l31058 lab=WL48}
N 13440 9640 13460 9640 {}
C {lab_pin.sym} 13460 9640 0 0 {name=l31059 lab=VDD}
N 13440 9560 13460 9560 {}
C {lab_pin.sym} 13460 9560 0 0 {name=l31060 lab=VSS}
C {bitcell_6t.sym} 13600 9600 0 0 {name=Xr48c68}
N 13560 9640 13540 9640 {}
C {lab_pin.sym} 13540 9640 0 0 {name=l31061 lab=BL68}
N 13560 9600 13540 9600 {}
C {lab_pin.sym} 13540 9600 0 0 {name=l31062 lab=BLB68}
N 13560 9560 13540 9560 {}
C {lab_pin.sym} 13540 9560 0 0 {name=l31063 lab=WL48}
N 13640 9640 13660 9640 {}
C {lab_pin.sym} 13660 9640 0 0 {name=l31064 lab=VDD}
N 13640 9560 13660 9560 {}
C {lab_pin.sym} 13660 9560 0 0 {name=l31065 lab=VSS}
C {bitcell_6t.sym} 13800 9600 0 0 {name=Xr48c69}
N 13760 9640 13740 9640 {}
C {lab_pin.sym} 13740 9640 0 0 {name=l31066 lab=BL69}
N 13760 9600 13740 9600 {}
C {lab_pin.sym} 13740 9600 0 0 {name=l31067 lab=BLB69}
N 13760 9560 13740 9560 {}
C {lab_pin.sym} 13740 9560 0 0 {name=l31068 lab=WL48}
N 13840 9640 13860 9640 {}
C {lab_pin.sym} 13860 9640 0 0 {name=l31069 lab=VDD}
N 13840 9560 13860 9560 {}
C {lab_pin.sym} 13860 9560 0 0 {name=l31070 lab=VSS}
C {bitcell_6t.sym} 14000 9600 0 0 {name=Xr48c70}
N 13960 9640 13940 9640 {}
C {lab_pin.sym} 13940 9640 0 0 {name=l31071 lab=BL70}
N 13960 9600 13940 9600 {}
C {lab_pin.sym} 13940 9600 0 0 {name=l31072 lab=BLB70}
N 13960 9560 13940 9560 {}
C {lab_pin.sym} 13940 9560 0 0 {name=l31073 lab=WL48}
N 14040 9640 14060 9640 {}
C {lab_pin.sym} 14060 9640 0 0 {name=l31074 lab=VDD}
N 14040 9560 14060 9560 {}
C {lab_pin.sym} 14060 9560 0 0 {name=l31075 lab=VSS}
C {bitcell_6t.sym} 14200 9600 0 0 {name=Xr48c71}
N 14160 9640 14140 9640 {}
C {lab_pin.sym} 14140 9640 0 0 {name=l31076 lab=BL71}
N 14160 9600 14140 9600 {}
C {lab_pin.sym} 14140 9600 0 0 {name=l31077 lab=BLB71}
N 14160 9560 14140 9560 {}
C {lab_pin.sym} 14140 9560 0 0 {name=l31078 lab=WL48}
N 14240 9640 14260 9640 {}
C {lab_pin.sym} 14260 9640 0 0 {name=l31079 lab=VDD}
N 14240 9560 14260 9560 {}
C {lab_pin.sym} 14260 9560 0 0 {name=l31080 lab=VSS}
C {bitcell_6t.sym} 14400 9600 0 0 {name=Xr48c72}
N 14360 9640 14340 9640 {}
C {lab_pin.sym} 14340 9640 0 0 {name=l31081 lab=BL72}
N 14360 9600 14340 9600 {}
C {lab_pin.sym} 14340 9600 0 0 {name=l31082 lab=BLB72}
N 14360 9560 14340 9560 {}
C {lab_pin.sym} 14340 9560 0 0 {name=l31083 lab=WL48}
N 14440 9640 14460 9640 {}
C {lab_pin.sym} 14460 9640 0 0 {name=l31084 lab=VDD}
N 14440 9560 14460 9560 {}
C {lab_pin.sym} 14460 9560 0 0 {name=l31085 lab=VSS}
C {bitcell_6t.sym} 14600 9600 0 0 {name=Xr48c73}
N 14560 9640 14540 9640 {}
C {lab_pin.sym} 14540 9640 0 0 {name=l31086 lab=BL73}
N 14560 9600 14540 9600 {}
C {lab_pin.sym} 14540 9600 0 0 {name=l31087 lab=BLB73}
N 14560 9560 14540 9560 {}
C {lab_pin.sym} 14540 9560 0 0 {name=l31088 lab=WL48}
N 14640 9640 14660 9640 {}
C {lab_pin.sym} 14660 9640 0 0 {name=l31089 lab=VDD}
N 14640 9560 14660 9560 {}
C {lab_pin.sym} 14660 9560 0 0 {name=l31090 lab=VSS}
C {bitcell_6t.sym} 14800 9600 0 0 {name=Xr48c74}
N 14760 9640 14740 9640 {}
C {lab_pin.sym} 14740 9640 0 0 {name=l31091 lab=BL74}
N 14760 9600 14740 9600 {}
C {lab_pin.sym} 14740 9600 0 0 {name=l31092 lab=BLB74}
N 14760 9560 14740 9560 {}
C {lab_pin.sym} 14740 9560 0 0 {name=l31093 lab=WL48}
N 14840 9640 14860 9640 {}
C {lab_pin.sym} 14860 9640 0 0 {name=l31094 lab=VDD}
N 14840 9560 14860 9560 {}
C {lab_pin.sym} 14860 9560 0 0 {name=l31095 lab=VSS}
C {bitcell_6t.sym} 15000 9600 0 0 {name=Xr48c75}
N 14960 9640 14940 9640 {}
C {lab_pin.sym} 14940 9640 0 0 {name=l31096 lab=BL75}
N 14960 9600 14940 9600 {}
C {lab_pin.sym} 14940 9600 0 0 {name=l31097 lab=BLB75}
N 14960 9560 14940 9560 {}
C {lab_pin.sym} 14940 9560 0 0 {name=l31098 lab=WL48}
N 15040 9640 15060 9640 {}
C {lab_pin.sym} 15060 9640 0 0 {name=l31099 lab=VDD}
N 15040 9560 15060 9560 {}
C {lab_pin.sym} 15060 9560 0 0 {name=l31100 lab=VSS}
C {bitcell_6t.sym} 15200 9600 0 0 {name=Xr48c76}
N 15160 9640 15140 9640 {}
C {lab_pin.sym} 15140 9640 0 0 {name=l31101 lab=BL76}
N 15160 9600 15140 9600 {}
C {lab_pin.sym} 15140 9600 0 0 {name=l31102 lab=BLB76}
N 15160 9560 15140 9560 {}
C {lab_pin.sym} 15140 9560 0 0 {name=l31103 lab=WL48}
N 15240 9640 15260 9640 {}
C {lab_pin.sym} 15260 9640 0 0 {name=l31104 lab=VDD}
N 15240 9560 15260 9560 {}
C {lab_pin.sym} 15260 9560 0 0 {name=l31105 lab=VSS}
C {bitcell_6t.sym} 15400 9600 0 0 {name=Xr48c77}
N 15360 9640 15340 9640 {}
C {lab_pin.sym} 15340 9640 0 0 {name=l31106 lab=BL77}
N 15360 9600 15340 9600 {}
C {lab_pin.sym} 15340 9600 0 0 {name=l31107 lab=BLB77}
N 15360 9560 15340 9560 {}
C {lab_pin.sym} 15340 9560 0 0 {name=l31108 lab=WL48}
N 15440 9640 15460 9640 {}
C {lab_pin.sym} 15460 9640 0 0 {name=l31109 lab=VDD}
N 15440 9560 15460 9560 {}
C {lab_pin.sym} 15460 9560 0 0 {name=l31110 lab=VSS}
C {bitcell_6t.sym} 15600 9600 0 0 {name=Xr48c78}
N 15560 9640 15540 9640 {}
C {lab_pin.sym} 15540 9640 0 0 {name=l31111 lab=BL78}
N 15560 9600 15540 9600 {}
C {lab_pin.sym} 15540 9600 0 0 {name=l31112 lab=BLB78}
N 15560 9560 15540 9560 {}
C {lab_pin.sym} 15540 9560 0 0 {name=l31113 lab=WL48}
N 15640 9640 15660 9640 {}
C {lab_pin.sym} 15660 9640 0 0 {name=l31114 lab=VDD}
N 15640 9560 15660 9560 {}
C {lab_pin.sym} 15660 9560 0 0 {name=l31115 lab=VSS}
C {bitcell_6t.sym} 15800 9600 0 0 {name=Xr48c79}
N 15760 9640 15740 9640 {}
C {lab_pin.sym} 15740 9640 0 0 {name=l31116 lab=BL79}
N 15760 9600 15740 9600 {}
C {lab_pin.sym} 15740 9600 0 0 {name=l31117 lab=BLB79}
N 15760 9560 15740 9560 {}
C {lab_pin.sym} 15740 9560 0 0 {name=l31118 lab=WL48}
N 15840 9640 15860 9640 {}
C {lab_pin.sym} 15860 9640 0 0 {name=l31119 lab=VDD}
N 15840 9560 15860 9560 {}
C {lab_pin.sym} 15860 9560 0 0 {name=l31120 lab=VSS}
C {bitcell_6t.sym} 16000 9600 0 0 {name=Xr48c80}
N 15960 9640 15940 9640 {}
C {lab_pin.sym} 15940 9640 0 0 {name=l31121 lab=BL80}
N 15960 9600 15940 9600 {}
C {lab_pin.sym} 15940 9600 0 0 {name=l31122 lab=BLB80}
N 15960 9560 15940 9560 {}
C {lab_pin.sym} 15940 9560 0 0 {name=l31123 lab=WL48}
N 16040 9640 16060 9640 {}
C {lab_pin.sym} 16060 9640 0 0 {name=l31124 lab=VDD}
N 16040 9560 16060 9560 {}
C {lab_pin.sym} 16060 9560 0 0 {name=l31125 lab=VSS}
C {bitcell_6t.sym} 16200 9600 0 0 {name=Xr48c81}
N 16160 9640 16140 9640 {}
C {lab_pin.sym} 16140 9640 0 0 {name=l31126 lab=BL81}
N 16160 9600 16140 9600 {}
C {lab_pin.sym} 16140 9600 0 0 {name=l31127 lab=BLB81}
N 16160 9560 16140 9560 {}
C {lab_pin.sym} 16140 9560 0 0 {name=l31128 lab=WL48}
N 16240 9640 16260 9640 {}
C {lab_pin.sym} 16260 9640 0 0 {name=l31129 lab=VDD}
N 16240 9560 16260 9560 {}
C {lab_pin.sym} 16260 9560 0 0 {name=l31130 lab=VSS}
C {bitcell_6t.sym} 16400 9600 0 0 {name=Xr48c82}
N 16360 9640 16340 9640 {}
C {lab_pin.sym} 16340 9640 0 0 {name=l31131 lab=BL82}
N 16360 9600 16340 9600 {}
C {lab_pin.sym} 16340 9600 0 0 {name=l31132 lab=BLB82}
N 16360 9560 16340 9560 {}
C {lab_pin.sym} 16340 9560 0 0 {name=l31133 lab=WL48}
N 16440 9640 16460 9640 {}
C {lab_pin.sym} 16460 9640 0 0 {name=l31134 lab=VDD}
N 16440 9560 16460 9560 {}
C {lab_pin.sym} 16460 9560 0 0 {name=l31135 lab=VSS}
C {bitcell_6t.sym} 16600 9600 0 0 {name=Xr48c83}
N 16560 9640 16540 9640 {}
C {lab_pin.sym} 16540 9640 0 0 {name=l31136 lab=BL83}
N 16560 9600 16540 9600 {}
C {lab_pin.sym} 16540 9600 0 0 {name=l31137 lab=BLB83}
N 16560 9560 16540 9560 {}
C {lab_pin.sym} 16540 9560 0 0 {name=l31138 lab=WL48}
N 16640 9640 16660 9640 {}
C {lab_pin.sym} 16660 9640 0 0 {name=l31139 lab=VDD}
N 16640 9560 16660 9560 {}
C {lab_pin.sym} 16660 9560 0 0 {name=l31140 lab=VSS}
C {bitcell_6t.sym} 16800 9600 0 0 {name=Xr48c84}
N 16760 9640 16740 9640 {}
C {lab_pin.sym} 16740 9640 0 0 {name=l31141 lab=BL84}
N 16760 9600 16740 9600 {}
C {lab_pin.sym} 16740 9600 0 0 {name=l31142 lab=BLB84}
N 16760 9560 16740 9560 {}
C {lab_pin.sym} 16740 9560 0 0 {name=l31143 lab=WL48}
N 16840 9640 16860 9640 {}
C {lab_pin.sym} 16860 9640 0 0 {name=l31144 lab=VDD}
N 16840 9560 16860 9560 {}
C {lab_pin.sym} 16860 9560 0 0 {name=l31145 lab=VSS}
C {bitcell_6t.sym} 17000 9600 0 0 {name=Xr48c85}
N 16960 9640 16940 9640 {}
C {lab_pin.sym} 16940 9640 0 0 {name=l31146 lab=BL85}
N 16960 9600 16940 9600 {}
C {lab_pin.sym} 16940 9600 0 0 {name=l31147 lab=BLB85}
N 16960 9560 16940 9560 {}
C {lab_pin.sym} 16940 9560 0 0 {name=l31148 lab=WL48}
N 17040 9640 17060 9640 {}
C {lab_pin.sym} 17060 9640 0 0 {name=l31149 lab=VDD}
N 17040 9560 17060 9560 {}
C {lab_pin.sym} 17060 9560 0 0 {name=l31150 lab=VSS}
C {bitcell_6t.sym} 17200 9600 0 0 {name=Xr48c86}
N 17160 9640 17140 9640 {}
C {lab_pin.sym} 17140 9640 0 0 {name=l31151 lab=BL86}
N 17160 9600 17140 9600 {}
C {lab_pin.sym} 17140 9600 0 0 {name=l31152 lab=BLB86}
N 17160 9560 17140 9560 {}
C {lab_pin.sym} 17140 9560 0 0 {name=l31153 lab=WL48}
N 17240 9640 17260 9640 {}
C {lab_pin.sym} 17260 9640 0 0 {name=l31154 lab=VDD}
N 17240 9560 17260 9560 {}
C {lab_pin.sym} 17260 9560 0 0 {name=l31155 lab=VSS}
C {bitcell_6t.sym} 17400 9600 0 0 {name=Xr48c87}
N 17360 9640 17340 9640 {}
C {lab_pin.sym} 17340 9640 0 0 {name=l31156 lab=BL87}
N 17360 9600 17340 9600 {}
C {lab_pin.sym} 17340 9600 0 0 {name=l31157 lab=BLB87}
N 17360 9560 17340 9560 {}
C {lab_pin.sym} 17340 9560 0 0 {name=l31158 lab=WL48}
N 17440 9640 17460 9640 {}
C {lab_pin.sym} 17460 9640 0 0 {name=l31159 lab=VDD}
N 17440 9560 17460 9560 {}
C {lab_pin.sym} 17460 9560 0 0 {name=l31160 lab=VSS}
C {bitcell_6t.sym} 17600 9600 0 0 {name=Xr48c88}
N 17560 9640 17540 9640 {}
C {lab_pin.sym} 17540 9640 0 0 {name=l31161 lab=BL88}
N 17560 9600 17540 9600 {}
C {lab_pin.sym} 17540 9600 0 0 {name=l31162 lab=BLB88}
N 17560 9560 17540 9560 {}
C {lab_pin.sym} 17540 9560 0 0 {name=l31163 lab=WL48}
N 17640 9640 17660 9640 {}
C {lab_pin.sym} 17660 9640 0 0 {name=l31164 lab=VDD}
N 17640 9560 17660 9560 {}
C {lab_pin.sym} 17660 9560 0 0 {name=l31165 lab=VSS}
C {bitcell_6t.sym} 17800 9600 0 0 {name=Xr48c89}
N 17760 9640 17740 9640 {}
C {lab_pin.sym} 17740 9640 0 0 {name=l31166 lab=BL89}
N 17760 9600 17740 9600 {}
C {lab_pin.sym} 17740 9600 0 0 {name=l31167 lab=BLB89}
N 17760 9560 17740 9560 {}
C {lab_pin.sym} 17740 9560 0 0 {name=l31168 lab=WL48}
N 17840 9640 17860 9640 {}
C {lab_pin.sym} 17860 9640 0 0 {name=l31169 lab=VDD}
N 17840 9560 17860 9560 {}
C {lab_pin.sym} 17860 9560 0 0 {name=l31170 lab=VSS}
C {bitcell_6t.sym} 18000 9600 0 0 {name=Xr48c90}
N 17960 9640 17940 9640 {}
C {lab_pin.sym} 17940 9640 0 0 {name=l31171 lab=BL90}
N 17960 9600 17940 9600 {}
C {lab_pin.sym} 17940 9600 0 0 {name=l31172 lab=BLB90}
N 17960 9560 17940 9560 {}
C {lab_pin.sym} 17940 9560 0 0 {name=l31173 lab=WL48}
N 18040 9640 18060 9640 {}
C {lab_pin.sym} 18060 9640 0 0 {name=l31174 lab=VDD}
N 18040 9560 18060 9560 {}
C {lab_pin.sym} 18060 9560 0 0 {name=l31175 lab=VSS}
C {bitcell_6t.sym} 18200 9600 0 0 {name=Xr48c91}
N 18160 9640 18140 9640 {}
C {lab_pin.sym} 18140 9640 0 0 {name=l31176 lab=BL91}
N 18160 9600 18140 9600 {}
C {lab_pin.sym} 18140 9600 0 0 {name=l31177 lab=BLB91}
N 18160 9560 18140 9560 {}
C {lab_pin.sym} 18140 9560 0 0 {name=l31178 lab=WL48}
N 18240 9640 18260 9640 {}
C {lab_pin.sym} 18260 9640 0 0 {name=l31179 lab=VDD}
N 18240 9560 18260 9560 {}
C {lab_pin.sym} 18260 9560 0 0 {name=l31180 lab=VSS}
C {bitcell_6t.sym} 18400 9600 0 0 {name=Xr48c92}
N 18360 9640 18340 9640 {}
C {lab_pin.sym} 18340 9640 0 0 {name=l31181 lab=BL92}
N 18360 9600 18340 9600 {}
C {lab_pin.sym} 18340 9600 0 0 {name=l31182 lab=BLB92}
N 18360 9560 18340 9560 {}
C {lab_pin.sym} 18340 9560 0 0 {name=l31183 lab=WL48}
N 18440 9640 18460 9640 {}
C {lab_pin.sym} 18460 9640 0 0 {name=l31184 lab=VDD}
N 18440 9560 18460 9560 {}
C {lab_pin.sym} 18460 9560 0 0 {name=l31185 lab=VSS}
C {bitcell_6t.sym} 18600 9600 0 0 {name=Xr48c93}
N 18560 9640 18540 9640 {}
C {lab_pin.sym} 18540 9640 0 0 {name=l31186 lab=BL93}
N 18560 9600 18540 9600 {}
C {lab_pin.sym} 18540 9600 0 0 {name=l31187 lab=BLB93}
N 18560 9560 18540 9560 {}
C {lab_pin.sym} 18540 9560 0 0 {name=l31188 lab=WL48}
N 18640 9640 18660 9640 {}
C {lab_pin.sym} 18660 9640 0 0 {name=l31189 lab=VDD}
N 18640 9560 18660 9560 {}
C {lab_pin.sym} 18660 9560 0 0 {name=l31190 lab=VSS}
C {bitcell_6t.sym} 18800 9600 0 0 {name=Xr48c94}
N 18760 9640 18740 9640 {}
C {lab_pin.sym} 18740 9640 0 0 {name=l31191 lab=BL94}
N 18760 9600 18740 9600 {}
C {lab_pin.sym} 18740 9600 0 0 {name=l31192 lab=BLB94}
N 18760 9560 18740 9560 {}
C {lab_pin.sym} 18740 9560 0 0 {name=l31193 lab=WL48}
N 18840 9640 18860 9640 {}
C {lab_pin.sym} 18860 9640 0 0 {name=l31194 lab=VDD}
N 18840 9560 18860 9560 {}
C {lab_pin.sym} 18860 9560 0 0 {name=l31195 lab=VSS}
C {bitcell_6t.sym} 19000 9600 0 0 {name=Xr48c95}
N 18960 9640 18940 9640 {}
C {lab_pin.sym} 18940 9640 0 0 {name=l31196 lab=BL95}
N 18960 9600 18940 9600 {}
C {lab_pin.sym} 18940 9600 0 0 {name=l31197 lab=BLB95}
N 18960 9560 18940 9560 {}
C {lab_pin.sym} 18940 9560 0 0 {name=l31198 lab=WL48}
N 19040 9640 19060 9640 {}
C {lab_pin.sym} 19060 9640 0 0 {name=l31199 lab=VDD}
N 19040 9560 19060 9560 {}
C {lab_pin.sym} 19060 9560 0 0 {name=l31200 lab=VSS}
C {bitcell_6t.sym} 19200 9600 0 0 {name=Xr48c96}
N 19160 9640 19140 9640 {}
C {lab_pin.sym} 19140 9640 0 0 {name=l31201 lab=BL96}
N 19160 9600 19140 9600 {}
C {lab_pin.sym} 19140 9600 0 0 {name=l31202 lab=BLB96}
N 19160 9560 19140 9560 {}
C {lab_pin.sym} 19140 9560 0 0 {name=l31203 lab=WL48}
N 19240 9640 19260 9640 {}
C {lab_pin.sym} 19260 9640 0 0 {name=l31204 lab=VDD}
N 19240 9560 19260 9560 {}
C {lab_pin.sym} 19260 9560 0 0 {name=l31205 lab=VSS}
C {bitcell_6t.sym} 19400 9600 0 0 {name=Xr48c97}
N 19360 9640 19340 9640 {}
C {lab_pin.sym} 19340 9640 0 0 {name=l31206 lab=BL97}
N 19360 9600 19340 9600 {}
C {lab_pin.sym} 19340 9600 0 0 {name=l31207 lab=BLB97}
N 19360 9560 19340 9560 {}
C {lab_pin.sym} 19340 9560 0 0 {name=l31208 lab=WL48}
N 19440 9640 19460 9640 {}
C {lab_pin.sym} 19460 9640 0 0 {name=l31209 lab=VDD}
N 19440 9560 19460 9560 {}
C {lab_pin.sym} 19460 9560 0 0 {name=l31210 lab=VSS}
C {bitcell_6t.sym} 19600 9600 0 0 {name=Xr48c98}
N 19560 9640 19540 9640 {}
C {lab_pin.sym} 19540 9640 0 0 {name=l31211 lab=BL98}
N 19560 9600 19540 9600 {}
C {lab_pin.sym} 19540 9600 0 0 {name=l31212 lab=BLB98}
N 19560 9560 19540 9560 {}
C {lab_pin.sym} 19540 9560 0 0 {name=l31213 lab=WL48}
N 19640 9640 19660 9640 {}
C {lab_pin.sym} 19660 9640 0 0 {name=l31214 lab=VDD}
N 19640 9560 19660 9560 {}
C {lab_pin.sym} 19660 9560 0 0 {name=l31215 lab=VSS}
C {bitcell_6t.sym} 19800 9600 0 0 {name=Xr48c99}
N 19760 9640 19740 9640 {}
C {lab_pin.sym} 19740 9640 0 0 {name=l31216 lab=BL99}
N 19760 9600 19740 9600 {}
C {lab_pin.sym} 19740 9600 0 0 {name=l31217 lab=BLB99}
N 19760 9560 19740 9560 {}
C {lab_pin.sym} 19740 9560 0 0 {name=l31218 lab=WL48}
N 19840 9640 19860 9640 {}
C {lab_pin.sym} 19860 9640 0 0 {name=l31219 lab=VDD}
N 19840 9560 19860 9560 {}
C {lab_pin.sym} 19860 9560 0 0 {name=l31220 lab=VSS}
C {bitcell_6t.sym} 20000 9600 0 0 {name=Xr48c100}
N 19960 9640 19940 9640 {}
C {lab_pin.sym} 19940 9640 0 0 {name=l31221 lab=BL100}
N 19960 9600 19940 9600 {}
C {lab_pin.sym} 19940 9600 0 0 {name=l31222 lab=BLB100}
N 19960 9560 19940 9560 {}
C {lab_pin.sym} 19940 9560 0 0 {name=l31223 lab=WL48}
N 20040 9640 20060 9640 {}
C {lab_pin.sym} 20060 9640 0 0 {name=l31224 lab=VDD}
N 20040 9560 20060 9560 {}
C {lab_pin.sym} 20060 9560 0 0 {name=l31225 lab=VSS}
C {bitcell_6t.sym} 20200 9600 0 0 {name=Xr48c101}
N 20160 9640 20140 9640 {}
C {lab_pin.sym} 20140 9640 0 0 {name=l31226 lab=BL101}
N 20160 9600 20140 9600 {}
C {lab_pin.sym} 20140 9600 0 0 {name=l31227 lab=BLB101}
N 20160 9560 20140 9560 {}
C {lab_pin.sym} 20140 9560 0 0 {name=l31228 lab=WL48}
N 20240 9640 20260 9640 {}
C {lab_pin.sym} 20260 9640 0 0 {name=l31229 lab=VDD}
N 20240 9560 20260 9560 {}
C {lab_pin.sym} 20260 9560 0 0 {name=l31230 lab=VSS}
C {bitcell_6t.sym} 20400 9600 0 0 {name=Xr48c102}
N 20360 9640 20340 9640 {}
C {lab_pin.sym} 20340 9640 0 0 {name=l31231 lab=BL102}
N 20360 9600 20340 9600 {}
C {lab_pin.sym} 20340 9600 0 0 {name=l31232 lab=BLB102}
N 20360 9560 20340 9560 {}
C {lab_pin.sym} 20340 9560 0 0 {name=l31233 lab=WL48}
N 20440 9640 20460 9640 {}
C {lab_pin.sym} 20460 9640 0 0 {name=l31234 lab=VDD}
N 20440 9560 20460 9560 {}
C {lab_pin.sym} 20460 9560 0 0 {name=l31235 lab=VSS}
C {bitcell_6t.sym} 20600 9600 0 0 {name=Xr48c103}
N 20560 9640 20540 9640 {}
C {lab_pin.sym} 20540 9640 0 0 {name=l31236 lab=BL103}
N 20560 9600 20540 9600 {}
C {lab_pin.sym} 20540 9600 0 0 {name=l31237 lab=BLB103}
N 20560 9560 20540 9560 {}
C {lab_pin.sym} 20540 9560 0 0 {name=l31238 lab=WL48}
N 20640 9640 20660 9640 {}
C {lab_pin.sym} 20660 9640 0 0 {name=l31239 lab=VDD}
N 20640 9560 20660 9560 {}
C {lab_pin.sym} 20660 9560 0 0 {name=l31240 lab=VSS}
C {bitcell_6t.sym} 20800 9600 0 0 {name=Xr48c104}
N 20760 9640 20740 9640 {}
C {lab_pin.sym} 20740 9640 0 0 {name=l31241 lab=BL104}
N 20760 9600 20740 9600 {}
C {lab_pin.sym} 20740 9600 0 0 {name=l31242 lab=BLB104}
N 20760 9560 20740 9560 {}
C {lab_pin.sym} 20740 9560 0 0 {name=l31243 lab=WL48}
N 20840 9640 20860 9640 {}
C {lab_pin.sym} 20860 9640 0 0 {name=l31244 lab=VDD}
N 20840 9560 20860 9560 {}
C {lab_pin.sym} 20860 9560 0 0 {name=l31245 lab=VSS}
C {bitcell_6t.sym} 21000 9600 0 0 {name=Xr48c105}
N 20960 9640 20940 9640 {}
C {lab_pin.sym} 20940 9640 0 0 {name=l31246 lab=BL105}
N 20960 9600 20940 9600 {}
C {lab_pin.sym} 20940 9600 0 0 {name=l31247 lab=BLB105}
N 20960 9560 20940 9560 {}
C {lab_pin.sym} 20940 9560 0 0 {name=l31248 lab=WL48}
N 21040 9640 21060 9640 {}
C {lab_pin.sym} 21060 9640 0 0 {name=l31249 lab=VDD}
N 21040 9560 21060 9560 {}
C {lab_pin.sym} 21060 9560 0 0 {name=l31250 lab=VSS}
C {bitcell_6t.sym} 21200 9600 0 0 {name=Xr48c106}
N 21160 9640 21140 9640 {}
C {lab_pin.sym} 21140 9640 0 0 {name=l31251 lab=BL106}
N 21160 9600 21140 9600 {}
C {lab_pin.sym} 21140 9600 0 0 {name=l31252 lab=BLB106}
N 21160 9560 21140 9560 {}
C {lab_pin.sym} 21140 9560 0 0 {name=l31253 lab=WL48}
N 21240 9640 21260 9640 {}
C {lab_pin.sym} 21260 9640 0 0 {name=l31254 lab=VDD}
N 21240 9560 21260 9560 {}
C {lab_pin.sym} 21260 9560 0 0 {name=l31255 lab=VSS}
C {bitcell_6t.sym} 21400 9600 0 0 {name=Xr48c107}
N 21360 9640 21340 9640 {}
C {lab_pin.sym} 21340 9640 0 0 {name=l31256 lab=BL107}
N 21360 9600 21340 9600 {}
C {lab_pin.sym} 21340 9600 0 0 {name=l31257 lab=BLB107}
N 21360 9560 21340 9560 {}
C {lab_pin.sym} 21340 9560 0 0 {name=l31258 lab=WL48}
N 21440 9640 21460 9640 {}
C {lab_pin.sym} 21460 9640 0 0 {name=l31259 lab=VDD}
N 21440 9560 21460 9560 {}
C {lab_pin.sym} 21460 9560 0 0 {name=l31260 lab=VSS}
C {bitcell_6t.sym} 21600 9600 0 0 {name=Xr48c108}
N 21560 9640 21540 9640 {}
C {lab_pin.sym} 21540 9640 0 0 {name=l31261 lab=BL108}
N 21560 9600 21540 9600 {}
C {lab_pin.sym} 21540 9600 0 0 {name=l31262 lab=BLB108}
N 21560 9560 21540 9560 {}
C {lab_pin.sym} 21540 9560 0 0 {name=l31263 lab=WL48}
N 21640 9640 21660 9640 {}
C {lab_pin.sym} 21660 9640 0 0 {name=l31264 lab=VDD}
N 21640 9560 21660 9560 {}
C {lab_pin.sym} 21660 9560 0 0 {name=l31265 lab=VSS}
C {bitcell_6t.sym} 21800 9600 0 0 {name=Xr48c109}
N 21760 9640 21740 9640 {}
C {lab_pin.sym} 21740 9640 0 0 {name=l31266 lab=BL109}
N 21760 9600 21740 9600 {}
C {lab_pin.sym} 21740 9600 0 0 {name=l31267 lab=BLB109}
N 21760 9560 21740 9560 {}
C {lab_pin.sym} 21740 9560 0 0 {name=l31268 lab=WL48}
N 21840 9640 21860 9640 {}
C {lab_pin.sym} 21860 9640 0 0 {name=l31269 lab=VDD}
N 21840 9560 21860 9560 {}
C {lab_pin.sym} 21860 9560 0 0 {name=l31270 lab=VSS}
C {bitcell_6t.sym} 22000 9600 0 0 {name=Xr48c110}
N 21960 9640 21940 9640 {}
C {lab_pin.sym} 21940 9640 0 0 {name=l31271 lab=BL110}
N 21960 9600 21940 9600 {}
C {lab_pin.sym} 21940 9600 0 0 {name=l31272 lab=BLB110}
N 21960 9560 21940 9560 {}
C {lab_pin.sym} 21940 9560 0 0 {name=l31273 lab=WL48}
N 22040 9640 22060 9640 {}
C {lab_pin.sym} 22060 9640 0 0 {name=l31274 lab=VDD}
N 22040 9560 22060 9560 {}
C {lab_pin.sym} 22060 9560 0 0 {name=l31275 lab=VSS}
C {bitcell_6t.sym} 22200 9600 0 0 {name=Xr48c111}
N 22160 9640 22140 9640 {}
C {lab_pin.sym} 22140 9640 0 0 {name=l31276 lab=BL111}
N 22160 9600 22140 9600 {}
C {lab_pin.sym} 22140 9600 0 0 {name=l31277 lab=BLB111}
N 22160 9560 22140 9560 {}
C {lab_pin.sym} 22140 9560 0 0 {name=l31278 lab=WL48}
N 22240 9640 22260 9640 {}
C {lab_pin.sym} 22260 9640 0 0 {name=l31279 lab=VDD}
N 22240 9560 22260 9560 {}
C {lab_pin.sym} 22260 9560 0 0 {name=l31280 lab=VSS}
C {bitcell_6t.sym} 22400 9600 0 0 {name=Xr48c112}
N 22360 9640 22340 9640 {}
C {lab_pin.sym} 22340 9640 0 0 {name=l31281 lab=BL112}
N 22360 9600 22340 9600 {}
C {lab_pin.sym} 22340 9600 0 0 {name=l31282 lab=BLB112}
N 22360 9560 22340 9560 {}
C {lab_pin.sym} 22340 9560 0 0 {name=l31283 lab=WL48}
N 22440 9640 22460 9640 {}
C {lab_pin.sym} 22460 9640 0 0 {name=l31284 lab=VDD}
N 22440 9560 22460 9560 {}
C {lab_pin.sym} 22460 9560 0 0 {name=l31285 lab=VSS}
C {bitcell_6t.sym} 22600 9600 0 0 {name=Xr48c113}
N 22560 9640 22540 9640 {}
C {lab_pin.sym} 22540 9640 0 0 {name=l31286 lab=BL113}
N 22560 9600 22540 9600 {}
C {lab_pin.sym} 22540 9600 0 0 {name=l31287 lab=BLB113}
N 22560 9560 22540 9560 {}
C {lab_pin.sym} 22540 9560 0 0 {name=l31288 lab=WL48}
N 22640 9640 22660 9640 {}
C {lab_pin.sym} 22660 9640 0 0 {name=l31289 lab=VDD}
N 22640 9560 22660 9560 {}
C {lab_pin.sym} 22660 9560 0 0 {name=l31290 lab=VSS}
C {bitcell_6t.sym} 22800 9600 0 0 {name=Xr48c114}
N 22760 9640 22740 9640 {}
C {lab_pin.sym} 22740 9640 0 0 {name=l31291 lab=BL114}
N 22760 9600 22740 9600 {}
C {lab_pin.sym} 22740 9600 0 0 {name=l31292 lab=BLB114}
N 22760 9560 22740 9560 {}
C {lab_pin.sym} 22740 9560 0 0 {name=l31293 lab=WL48}
N 22840 9640 22860 9640 {}
C {lab_pin.sym} 22860 9640 0 0 {name=l31294 lab=VDD}
N 22840 9560 22860 9560 {}
C {lab_pin.sym} 22860 9560 0 0 {name=l31295 lab=VSS}
C {bitcell_6t.sym} 23000 9600 0 0 {name=Xr48c115}
N 22960 9640 22940 9640 {}
C {lab_pin.sym} 22940 9640 0 0 {name=l31296 lab=BL115}
N 22960 9600 22940 9600 {}
C {lab_pin.sym} 22940 9600 0 0 {name=l31297 lab=BLB115}
N 22960 9560 22940 9560 {}
C {lab_pin.sym} 22940 9560 0 0 {name=l31298 lab=WL48}
N 23040 9640 23060 9640 {}
C {lab_pin.sym} 23060 9640 0 0 {name=l31299 lab=VDD}
N 23040 9560 23060 9560 {}
C {lab_pin.sym} 23060 9560 0 0 {name=l31300 lab=VSS}
C {bitcell_6t.sym} 23200 9600 0 0 {name=Xr48c116}
N 23160 9640 23140 9640 {}
C {lab_pin.sym} 23140 9640 0 0 {name=l31301 lab=BL116}
N 23160 9600 23140 9600 {}
C {lab_pin.sym} 23140 9600 0 0 {name=l31302 lab=BLB116}
N 23160 9560 23140 9560 {}
C {lab_pin.sym} 23140 9560 0 0 {name=l31303 lab=WL48}
N 23240 9640 23260 9640 {}
C {lab_pin.sym} 23260 9640 0 0 {name=l31304 lab=VDD}
N 23240 9560 23260 9560 {}
C {lab_pin.sym} 23260 9560 0 0 {name=l31305 lab=VSS}
C {bitcell_6t.sym} 23400 9600 0 0 {name=Xr48c117}
N 23360 9640 23340 9640 {}
C {lab_pin.sym} 23340 9640 0 0 {name=l31306 lab=BL117}
N 23360 9600 23340 9600 {}
C {lab_pin.sym} 23340 9600 0 0 {name=l31307 lab=BLB117}
N 23360 9560 23340 9560 {}
C {lab_pin.sym} 23340 9560 0 0 {name=l31308 lab=WL48}
N 23440 9640 23460 9640 {}
C {lab_pin.sym} 23460 9640 0 0 {name=l31309 lab=VDD}
N 23440 9560 23460 9560 {}
C {lab_pin.sym} 23460 9560 0 0 {name=l31310 lab=VSS}
C {bitcell_6t.sym} 23600 9600 0 0 {name=Xr48c118}
N 23560 9640 23540 9640 {}
C {lab_pin.sym} 23540 9640 0 0 {name=l31311 lab=BL118}
N 23560 9600 23540 9600 {}
C {lab_pin.sym} 23540 9600 0 0 {name=l31312 lab=BLB118}
N 23560 9560 23540 9560 {}
C {lab_pin.sym} 23540 9560 0 0 {name=l31313 lab=WL48}
N 23640 9640 23660 9640 {}
C {lab_pin.sym} 23660 9640 0 0 {name=l31314 lab=VDD}
N 23640 9560 23660 9560 {}
C {lab_pin.sym} 23660 9560 0 0 {name=l31315 lab=VSS}
C {bitcell_6t.sym} 23800 9600 0 0 {name=Xr48c119}
N 23760 9640 23740 9640 {}
C {lab_pin.sym} 23740 9640 0 0 {name=l31316 lab=BL119}
N 23760 9600 23740 9600 {}
C {lab_pin.sym} 23740 9600 0 0 {name=l31317 lab=BLB119}
N 23760 9560 23740 9560 {}
C {lab_pin.sym} 23740 9560 0 0 {name=l31318 lab=WL48}
N 23840 9640 23860 9640 {}
C {lab_pin.sym} 23860 9640 0 0 {name=l31319 lab=VDD}
N 23840 9560 23860 9560 {}
C {lab_pin.sym} 23860 9560 0 0 {name=l31320 lab=VSS}
C {bitcell_6t.sym} 24000 9600 0 0 {name=Xr48c120}
N 23960 9640 23940 9640 {}
C {lab_pin.sym} 23940 9640 0 0 {name=l31321 lab=BL120}
N 23960 9600 23940 9600 {}
C {lab_pin.sym} 23940 9600 0 0 {name=l31322 lab=BLB120}
N 23960 9560 23940 9560 {}
C {lab_pin.sym} 23940 9560 0 0 {name=l31323 lab=WL48}
N 24040 9640 24060 9640 {}
C {lab_pin.sym} 24060 9640 0 0 {name=l31324 lab=VDD}
N 24040 9560 24060 9560 {}
C {lab_pin.sym} 24060 9560 0 0 {name=l31325 lab=VSS}
C {bitcell_6t.sym} 24200 9600 0 0 {name=Xr48c121}
N 24160 9640 24140 9640 {}
C {lab_pin.sym} 24140 9640 0 0 {name=l31326 lab=BL121}
N 24160 9600 24140 9600 {}
C {lab_pin.sym} 24140 9600 0 0 {name=l31327 lab=BLB121}
N 24160 9560 24140 9560 {}
C {lab_pin.sym} 24140 9560 0 0 {name=l31328 lab=WL48}
N 24240 9640 24260 9640 {}
C {lab_pin.sym} 24260 9640 0 0 {name=l31329 lab=VDD}
N 24240 9560 24260 9560 {}
C {lab_pin.sym} 24260 9560 0 0 {name=l31330 lab=VSS}
C {bitcell_6t.sym} 24400 9600 0 0 {name=Xr48c122}
N 24360 9640 24340 9640 {}
C {lab_pin.sym} 24340 9640 0 0 {name=l31331 lab=BL122}
N 24360 9600 24340 9600 {}
C {lab_pin.sym} 24340 9600 0 0 {name=l31332 lab=BLB122}
N 24360 9560 24340 9560 {}
C {lab_pin.sym} 24340 9560 0 0 {name=l31333 lab=WL48}
N 24440 9640 24460 9640 {}
C {lab_pin.sym} 24460 9640 0 0 {name=l31334 lab=VDD}
N 24440 9560 24460 9560 {}
C {lab_pin.sym} 24460 9560 0 0 {name=l31335 lab=VSS}
C {bitcell_6t.sym} 24600 9600 0 0 {name=Xr48c123}
N 24560 9640 24540 9640 {}
C {lab_pin.sym} 24540 9640 0 0 {name=l31336 lab=BL123}
N 24560 9600 24540 9600 {}
C {lab_pin.sym} 24540 9600 0 0 {name=l31337 lab=BLB123}
N 24560 9560 24540 9560 {}
C {lab_pin.sym} 24540 9560 0 0 {name=l31338 lab=WL48}
N 24640 9640 24660 9640 {}
C {lab_pin.sym} 24660 9640 0 0 {name=l31339 lab=VDD}
N 24640 9560 24660 9560 {}
C {lab_pin.sym} 24660 9560 0 0 {name=l31340 lab=VSS}
C {bitcell_6t.sym} 24800 9600 0 0 {name=Xr48c124}
N 24760 9640 24740 9640 {}
C {lab_pin.sym} 24740 9640 0 0 {name=l31341 lab=BL124}
N 24760 9600 24740 9600 {}
C {lab_pin.sym} 24740 9600 0 0 {name=l31342 lab=BLB124}
N 24760 9560 24740 9560 {}
C {lab_pin.sym} 24740 9560 0 0 {name=l31343 lab=WL48}
N 24840 9640 24860 9640 {}
C {lab_pin.sym} 24860 9640 0 0 {name=l31344 lab=VDD}
N 24840 9560 24860 9560 {}
C {lab_pin.sym} 24860 9560 0 0 {name=l31345 lab=VSS}
C {bitcell_6t.sym} 25000 9600 0 0 {name=Xr48c125}
N 24960 9640 24940 9640 {}
C {lab_pin.sym} 24940 9640 0 0 {name=l31346 lab=BL125}
N 24960 9600 24940 9600 {}
C {lab_pin.sym} 24940 9600 0 0 {name=l31347 lab=BLB125}
N 24960 9560 24940 9560 {}
C {lab_pin.sym} 24940 9560 0 0 {name=l31348 lab=WL48}
N 25040 9640 25060 9640 {}
C {lab_pin.sym} 25060 9640 0 0 {name=l31349 lab=VDD}
N 25040 9560 25060 9560 {}
C {lab_pin.sym} 25060 9560 0 0 {name=l31350 lab=VSS}
C {bitcell_6t.sym} 25200 9600 0 0 {name=Xr48c126}
N 25160 9640 25140 9640 {}
C {lab_pin.sym} 25140 9640 0 0 {name=l31351 lab=BL126}
N 25160 9600 25140 9600 {}
C {lab_pin.sym} 25140 9600 0 0 {name=l31352 lab=BLB126}
N 25160 9560 25140 9560 {}
C {lab_pin.sym} 25140 9560 0 0 {name=l31353 lab=WL48}
N 25240 9640 25260 9640 {}
C {lab_pin.sym} 25260 9640 0 0 {name=l31354 lab=VDD}
N 25240 9560 25260 9560 {}
C {lab_pin.sym} 25260 9560 0 0 {name=l31355 lab=VSS}
C {bitcell_6t.sym} 25400 9600 0 0 {name=Xr48c127}
N 25360 9640 25340 9640 {}
C {lab_pin.sym} 25340 9640 0 0 {name=l31356 lab=BL127}
N 25360 9600 25340 9600 {}
C {lab_pin.sym} 25340 9600 0 0 {name=l31357 lab=BLB127}
N 25360 9560 25340 9560 {}
C {lab_pin.sym} 25340 9560 0 0 {name=l31358 lab=WL48}
N 25440 9640 25460 9640 {}
C {lab_pin.sym} 25460 9640 0 0 {name=l31359 lab=VDD}
N 25440 9560 25460 9560 {}
C {lab_pin.sym} 25460 9560 0 0 {name=l31360 lab=VSS}
C {bitcell_6t.sym} 0 9800 0 0 {name=Xr49c0}
N -40 9840 -60 9840 {}
C {lab_pin.sym} -60 9840 0 0 {name=l31361 lab=BL0}
N -40 9800 -60 9800 {}
C {lab_pin.sym} -60 9800 0 0 {name=l31362 lab=BLB0}
N -40 9760 -60 9760 {}
C {lab_pin.sym} -60 9760 0 0 {name=l31363 lab=WL49}
N 40 9840 60 9840 {}
C {lab_pin.sym} 60 9840 0 0 {name=l31364 lab=VDD}
N 40 9760 60 9760 {}
C {lab_pin.sym} 60 9760 0 0 {name=l31365 lab=VSS}
C {bitcell_6t.sym} 200 9800 0 0 {name=Xr49c1}
N 160 9840 140 9840 {}
C {lab_pin.sym} 140 9840 0 0 {name=l31366 lab=BL1}
N 160 9800 140 9800 {}
C {lab_pin.sym} 140 9800 0 0 {name=l31367 lab=BLB1}
N 160 9760 140 9760 {}
C {lab_pin.sym} 140 9760 0 0 {name=l31368 lab=WL49}
N 240 9840 260 9840 {}
C {lab_pin.sym} 260 9840 0 0 {name=l31369 lab=VDD}
N 240 9760 260 9760 {}
C {lab_pin.sym} 260 9760 0 0 {name=l31370 lab=VSS}
C {bitcell_6t.sym} 400 9800 0 0 {name=Xr49c2}
N 360 9840 340 9840 {}
C {lab_pin.sym} 340 9840 0 0 {name=l31371 lab=BL2}
N 360 9800 340 9800 {}
C {lab_pin.sym} 340 9800 0 0 {name=l31372 lab=BLB2}
N 360 9760 340 9760 {}
C {lab_pin.sym} 340 9760 0 0 {name=l31373 lab=WL49}
N 440 9840 460 9840 {}
C {lab_pin.sym} 460 9840 0 0 {name=l31374 lab=VDD}
N 440 9760 460 9760 {}
C {lab_pin.sym} 460 9760 0 0 {name=l31375 lab=VSS}
C {bitcell_6t.sym} 600 9800 0 0 {name=Xr49c3}
N 560 9840 540 9840 {}
C {lab_pin.sym} 540 9840 0 0 {name=l31376 lab=BL3}
N 560 9800 540 9800 {}
C {lab_pin.sym} 540 9800 0 0 {name=l31377 lab=BLB3}
N 560 9760 540 9760 {}
C {lab_pin.sym} 540 9760 0 0 {name=l31378 lab=WL49}
N 640 9840 660 9840 {}
C {lab_pin.sym} 660 9840 0 0 {name=l31379 lab=VDD}
N 640 9760 660 9760 {}
C {lab_pin.sym} 660 9760 0 0 {name=l31380 lab=VSS}
C {bitcell_6t.sym} 800 9800 0 0 {name=Xr49c4}
N 760 9840 740 9840 {}
C {lab_pin.sym} 740 9840 0 0 {name=l31381 lab=BL4}
N 760 9800 740 9800 {}
C {lab_pin.sym} 740 9800 0 0 {name=l31382 lab=BLB4}
N 760 9760 740 9760 {}
C {lab_pin.sym} 740 9760 0 0 {name=l31383 lab=WL49}
N 840 9840 860 9840 {}
C {lab_pin.sym} 860 9840 0 0 {name=l31384 lab=VDD}
N 840 9760 860 9760 {}
C {lab_pin.sym} 860 9760 0 0 {name=l31385 lab=VSS}
C {bitcell_6t.sym} 1000 9800 0 0 {name=Xr49c5}
N 960 9840 940 9840 {}
C {lab_pin.sym} 940 9840 0 0 {name=l31386 lab=BL5}
N 960 9800 940 9800 {}
C {lab_pin.sym} 940 9800 0 0 {name=l31387 lab=BLB5}
N 960 9760 940 9760 {}
C {lab_pin.sym} 940 9760 0 0 {name=l31388 lab=WL49}
N 1040 9840 1060 9840 {}
C {lab_pin.sym} 1060 9840 0 0 {name=l31389 lab=VDD}
N 1040 9760 1060 9760 {}
C {lab_pin.sym} 1060 9760 0 0 {name=l31390 lab=VSS}
C {bitcell_6t.sym} 1200 9800 0 0 {name=Xr49c6}
N 1160 9840 1140 9840 {}
C {lab_pin.sym} 1140 9840 0 0 {name=l31391 lab=BL6}
N 1160 9800 1140 9800 {}
C {lab_pin.sym} 1140 9800 0 0 {name=l31392 lab=BLB6}
N 1160 9760 1140 9760 {}
C {lab_pin.sym} 1140 9760 0 0 {name=l31393 lab=WL49}
N 1240 9840 1260 9840 {}
C {lab_pin.sym} 1260 9840 0 0 {name=l31394 lab=VDD}
N 1240 9760 1260 9760 {}
C {lab_pin.sym} 1260 9760 0 0 {name=l31395 lab=VSS}
C {bitcell_6t.sym} 1400 9800 0 0 {name=Xr49c7}
N 1360 9840 1340 9840 {}
C {lab_pin.sym} 1340 9840 0 0 {name=l31396 lab=BL7}
N 1360 9800 1340 9800 {}
C {lab_pin.sym} 1340 9800 0 0 {name=l31397 lab=BLB7}
N 1360 9760 1340 9760 {}
C {lab_pin.sym} 1340 9760 0 0 {name=l31398 lab=WL49}
N 1440 9840 1460 9840 {}
C {lab_pin.sym} 1460 9840 0 0 {name=l31399 lab=VDD}
N 1440 9760 1460 9760 {}
C {lab_pin.sym} 1460 9760 0 0 {name=l31400 lab=VSS}
C {bitcell_6t.sym} 1600 9800 0 0 {name=Xr49c8}
N 1560 9840 1540 9840 {}
C {lab_pin.sym} 1540 9840 0 0 {name=l31401 lab=BL8}
N 1560 9800 1540 9800 {}
C {lab_pin.sym} 1540 9800 0 0 {name=l31402 lab=BLB8}
N 1560 9760 1540 9760 {}
C {lab_pin.sym} 1540 9760 0 0 {name=l31403 lab=WL49}
N 1640 9840 1660 9840 {}
C {lab_pin.sym} 1660 9840 0 0 {name=l31404 lab=VDD}
N 1640 9760 1660 9760 {}
C {lab_pin.sym} 1660 9760 0 0 {name=l31405 lab=VSS}
C {bitcell_6t.sym} 1800 9800 0 0 {name=Xr49c9}
N 1760 9840 1740 9840 {}
C {lab_pin.sym} 1740 9840 0 0 {name=l31406 lab=BL9}
N 1760 9800 1740 9800 {}
C {lab_pin.sym} 1740 9800 0 0 {name=l31407 lab=BLB9}
N 1760 9760 1740 9760 {}
C {lab_pin.sym} 1740 9760 0 0 {name=l31408 lab=WL49}
N 1840 9840 1860 9840 {}
C {lab_pin.sym} 1860 9840 0 0 {name=l31409 lab=VDD}
N 1840 9760 1860 9760 {}
C {lab_pin.sym} 1860 9760 0 0 {name=l31410 lab=VSS}
C {bitcell_6t.sym} 2000 9800 0 0 {name=Xr49c10}
N 1960 9840 1940 9840 {}
C {lab_pin.sym} 1940 9840 0 0 {name=l31411 lab=BL10}
N 1960 9800 1940 9800 {}
C {lab_pin.sym} 1940 9800 0 0 {name=l31412 lab=BLB10}
N 1960 9760 1940 9760 {}
C {lab_pin.sym} 1940 9760 0 0 {name=l31413 lab=WL49}
N 2040 9840 2060 9840 {}
C {lab_pin.sym} 2060 9840 0 0 {name=l31414 lab=VDD}
N 2040 9760 2060 9760 {}
C {lab_pin.sym} 2060 9760 0 0 {name=l31415 lab=VSS}
C {bitcell_6t.sym} 2200 9800 0 0 {name=Xr49c11}
N 2160 9840 2140 9840 {}
C {lab_pin.sym} 2140 9840 0 0 {name=l31416 lab=BL11}
N 2160 9800 2140 9800 {}
C {lab_pin.sym} 2140 9800 0 0 {name=l31417 lab=BLB11}
N 2160 9760 2140 9760 {}
C {lab_pin.sym} 2140 9760 0 0 {name=l31418 lab=WL49}
N 2240 9840 2260 9840 {}
C {lab_pin.sym} 2260 9840 0 0 {name=l31419 lab=VDD}
N 2240 9760 2260 9760 {}
C {lab_pin.sym} 2260 9760 0 0 {name=l31420 lab=VSS}
C {bitcell_6t.sym} 2400 9800 0 0 {name=Xr49c12}
N 2360 9840 2340 9840 {}
C {lab_pin.sym} 2340 9840 0 0 {name=l31421 lab=BL12}
N 2360 9800 2340 9800 {}
C {lab_pin.sym} 2340 9800 0 0 {name=l31422 lab=BLB12}
N 2360 9760 2340 9760 {}
C {lab_pin.sym} 2340 9760 0 0 {name=l31423 lab=WL49}
N 2440 9840 2460 9840 {}
C {lab_pin.sym} 2460 9840 0 0 {name=l31424 lab=VDD}
N 2440 9760 2460 9760 {}
C {lab_pin.sym} 2460 9760 0 0 {name=l31425 lab=VSS}
C {bitcell_6t.sym} 2600 9800 0 0 {name=Xr49c13}
N 2560 9840 2540 9840 {}
C {lab_pin.sym} 2540 9840 0 0 {name=l31426 lab=BL13}
N 2560 9800 2540 9800 {}
C {lab_pin.sym} 2540 9800 0 0 {name=l31427 lab=BLB13}
N 2560 9760 2540 9760 {}
C {lab_pin.sym} 2540 9760 0 0 {name=l31428 lab=WL49}
N 2640 9840 2660 9840 {}
C {lab_pin.sym} 2660 9840 0 0 {name=l31429 lab=VDD}
N 2640 9760 2660 9760 {}
C {lab_pin.sym} 2660 9760 0 0 {name=l31430 lab=VSS}
C {bitcell_6t.sym} 2800 9800 0 0 {name=Xr49c14}
N 2760 9840 2740 9840 {}
C {lab_pin.sym} 2740 9840 0 0 {name=l31431 lab=BL14}
N 2760 9800 2740 9800 {}
C {lab_pin.sym} 2740 9800 0 0 {name=l31432 lab=BLB14}
N 2760 9760 2740 9760 {}
C {lab_pin.sym} 2740 9760 0 0 {name=l31433 lab=WL49}
N 2840 9840 2860 9840 {}
C {lab_pin.sym} 2860 9840 0 0 {name=l31434 lab=VDD}
N 2840 9760 2860 9760 {}
C {lab_pin.sym} 2860 9760 0 0 {name=l31435 lab=VSS}
C {bitcell_6t.sym} 3000 9800 0 0 {name=Xr49c15}
N 2960 9840 2940 9840 {}
C {lab_pin.sym} 2940 9840 0 0 {name=l31436 lab=BL15}
N 2960 9800 2940 9800 {}
C {lab_pin.sym} 2940 9800 0 0 {name=l31437 lab=BLB15}
N 2960 9760 2940 9760 {}
C {lab_pin.sym} 2940 9760 0 0 {name=l31438 lab=WL49}
N 3040 9840 3060 9840 {}
C {lab_pin.sym} 3060 9840 0 0 {name=l31439 lab=VDD}
N 3040 9760 3060 9760 {}
C {lab_pin.sym} 3060 9760 0 0 {name=l31440 lab=VSS}
C {bitcell_6t.sym} 3200 9800 0 0 {name=Xr49c16}
N 3160 9840 3140 9840 {}
C {lab_pin.sym} 3140 9840 0 0 {name=l31441 lab=BL16}
N 3160 9800 3140 9800 {}
C {lab_pin.sym} 3140 9800 0 0 {name=l31442 lab=BLB16}
N 3160 9760 3140 9760 {}
C {lab_pin.sym} 3140 9760 0 0 {name=l31443 lab=WL49}
N 3240 9840 3260 9840 {}
C {lab_pin.sym} 3260 9840 0 0 {name=l31444 lab=VDD}
N 3240 9760 3260 9760 {}
C {lab_pin.sym} 3260 9760 0 0 {name=l31445 lab=VSS}
C {bitcell_6t.sym} 3400 9800 0 0 {name=Xr49c17}
N 3360 9840 3340 9840 {}
C {lab_pin.sym} 3340 9840 0 0 {name=l31446 lab=BL17}
N 3360 9800 3340 9800 {}
C {lab_pin.sym} 3340 9800 0 0 {name=l31447 lab=BLB17}
N 3360 9760 3340 9760 {}
C {lab_pin.sym} 3340 9760 0 0 {name=l31448 lab=WL49}
N 3440 9840 3460 9840 {}
C {lab_pin.sym} 3460 9840 0 0 {name=l31449 lab=VDD}
N 3440 9760 3460 9760 {}
C {lab_pin.sym} 3460 9760 0 0 {name=l31450 lab=VSS}
C {bitcell_6t.sym} 3600 9800 0 0 {name=Xr49c18}
N 3560 9840 3540 9840 {}
C {lab_pin.sym} 3540 9840 0 0 {name=l31451 lab=BL18}
N 3560 9800 3540 9800 {}
C {lab_pin.sym} 3540 9800 0 0 {name=l31452 lab=BLB18}
N 3560 9760 3540 9760 {}
C {lab_pin.sym} 3540 9760 0 0 {name=l31453 lab=WL49}
N 3640 9840 3660 9840 {}
C {lab_pin.sym} 3660 9840 0 0 {name=l31454 lab=VDD}
N 3640 9760 3660 9760 {}
C {lab_pin.sym} 3660 9760 0 0 {name=l31455 lab=VSS}
C {bitcell_6t.sym} 3800 9800 0 0 {name=Xr49c19}
N 3760 9840 3740 9840 {}
C {lab_pin.sym} 3740 9840 0 0 {name=l31456 lab=BL19}
N 3760 9800 3740 9800 {}
C {lab_pin.sym} 3740 9800 0 0 {name=l31457 lab=BLB19}
N 3760 9760 3740 9760 {}
C {lab_pin.sym} 3740 9760 0 0 {name=l31458 lab=WL49}
N 3840 9840 3860 9840 {}
C {lab_pin.sym} 3860 9840 0 0 {name=l31459 lab=VDD}
N 3840 9760 3860 9760 {}
C {lab_pin.sym} 3860 9760 0 0 {name=l31460 lab=VSS}
C {bitcell_6t.sym} 4000 9800 0 0 {name=Xr49c20}
N 3960 9840 3940 9840 {}
C {lab_pin.sym} 3940 9840 0 0 {name=l31461 lab=BL20}
N 3960 9800 3940 9800 {}
C {lab_pin.sym} 3940 9800 0 0 {name=l31462 lab=BLB20}
N 3960 9760 3940 9760 {}
C {lab_pin.sym} 3940 9760 0 0 {name=l31463 lab=WL49}
N 4040 9840 4060 9840 {}
C {lab_pin.sym} 4060 9840 0 0 {name=l31464 lab=VDD}
N 4040 9760 4060 9760 {}
C {lab_pin.sym} 4060 9760 0 0 {name=l31465 lab=VSS}
C {bitcell_6t.sym} 4200 9800 0 0 {name=Xr49c21}
N 4160 9840 4140 9840 {}
C {lab_pin.sym} 4140 9840 0 0 {name=l31466 lab=BL21}
N 4160 9800 4140 9800 {}
C {lab_pin.sym} 4140 9800 0 0 {name=l31467 lab=BLB21}
N 4160 9760 4140 9760 {}
C {lab_pin.sym} 4140 9760 0 0 {name=l31468 lab=WL49}
N 4240 9840 4260 9840 {}
C {lab_pin.sym} 4260 9840 0 0 {name=l31469 lab=VDD}
N 4240 9760 4260 9760 {}
C {lab_pin.sym} 4260 9760 0 0 {name=l31470 lab=VSS}
C {bitcell_6t.sym} 4400 9800 0 0 {name=Xr49c22}
N 4360 9840 4340 9840 {}
C {lab_pin.sym} 4340 9840 0 0 {name=l31471 lab=BL22}
N 4360 9800 4340 9800 {}
C {lab_pin.sym} 4340 9800 0 0 {name=l31472 lab=BLB22}
N 4360 9760 4340 9760 {}
C {lab_pin.sym} 4340 9760 0 0 {name=l31473 lab=WL49}
N 4440 9840 4460 9840 {}
C {lab_pin.sym} 4460 9840 0 0 {name=l31474 lab=VDD}
N 4440 9760 4460 9760 {}
C {lab_pin.sym} 4460 9760 0 0 {name=l31475 lab=VSS}
C {bitcell_6t.sym} 4600 9800 0 0 {name=Xr49c23}
N 4560 9840 4540 9840 {}
C {lab_pin.sym} 4540 9840 0 0 {name=l31476 lab=BL23}
N 4560 9800 4540 9800 {}
C {lab_pin.sym} 4540 9800 0 0 {name=l31477 lab=BLB23}
N 4560 9760 4540 9760 {}
C {lab_pin.sym} 4540 9760 0 0 {name=l31478 lab=WL49}
N 4640 9840 4660 9840 {}
C {lab_pin.sym} 4660 9840 0 0 {name=l31479 lab=VDD}
N 4640 9760 4660 9760 {}
C {lab_pin.sym} 4660 9760 0 0 {name=l31480 lab=VSS}
C {bitcell_6t.sym} 4800 9800 0 0 {name=Xr49c24}
N 4760 9840 4740 9840 {}
C {lab_pin.sym} 4740 9840 0 0 {name=l31481 lab=BL24}
N 4760 9800 4740 9800 {}
C {lab_pin.sym} 4740 9800 0 0 {name=l31482 lab=BLB24}
N 4760 9760 4740 9760 {}
C {lab_pin.sym} 4740 9760 0 0 {name=l31483 lab=WL49}
N 4840 9840 4860 9840 {}
C {lab_pin.sym} 4860 9840 0 0 {name=l31484 lab=VDD}
N 4840 9760 4860 9760 {}
C {lab_pin.sym} 4860 9760 0 0 {name=l31485 lab=VSS}
C {bitcell_6t.sym} 5000 9800 0 0 {name=Xr49c25}
N 4960 9840 4940 9840 {}
C {lab_pin.sym} 4940 9840 0 0 {name=l31486 lab=BL25}
N 4960 9800 4940 9800 {}
C {lab_pin.sym} 4940 9800 0 0 {name=l31487 lab=BLB25}
N 4960 9760 4940 9760 {}
C {lab_pin.sym} 4940 9760 0 0 {name=l31488 lab=WL49}
N 5040 9840 5060 9840 {}
C {lab_pin.sym} 5060 9840 0 0 {name=l31489 lab=VDD}
N 5040 9760 5060 9760 {}
C {lab_pin.sym} 5060 9760 0 0 {name=l31490 lab=VSS}
C {bitcell_6t.sym} 5200 9800 0 0 {name=Xr49c26}
N 5160 9840 5140 9840 {}
C {lab_pin.sym} 5140 9840 0 0 {name=l31491 lab=BL26}
N 5160 9800 5140 9800 {}
C {lab_pin.sym} 5140 9800 0 0 {name=l31492 lab=BLB26}
N 5160 9760 5140 9760 {}
C {lab_pin.sym} 5140 9760 0 0 {name=l31493 lab=WL49}
N 5240 9840 5260 9840 {}
C {lab_pin.sym} 5260 9840 0 0 {name=l31494 lab=VDD}
N 5240 9760 5260 9760 {}
C {lab_pin.sym} 5260 9760 0 0 {name=l31495 lab=VSS}
C {bitcell_6t.sym} 5400 9800 0 0 {name=Xr49c27}
N 5360 9840 5340 9840 {}
C {lab_pin.sym} 5340 9840 0 0 {name=l31496 lab=BL27}
N 5360 9800 5340 9800 {}
C {lab_pin.sym} 5340 9800 0 0 {name=l31497 lab=BLB27}
N 5360 9760 5340 9760 {}
C {lab_pin.sym} 5340 9760 0 0 {name=l31498 lab=WL49}
N 5440 9840 5460 9840 {}
C {lab_pin.sym} 5460 9840 0 0 {name=l31499 lab=VDD}
N 5440 9760 5460 9760 {}
C {lab_pin.sym} 5460 9760 0 0 {name=l31500 lab=VSS}
C {bitcell_6t.sym} 5600 9800 0 0 {name=Xr49c28}
N 5560 9840 5540 9840 {}
C {lab_pin.sym} 5540 9840 0 0 {name=l31501 lab=BL28}
N 5560 9800 5540 9800 {}
C {lab_pin.sym} 5540 9800 0 0 {name=l31502 lab=BLB28}
N 5560 9760 5540 9760 {}
C {lab_pin.sym} 5540 9760 0 0 {name=l31503 lab=WL49}
N 5640 9840 5660 9840 {}
C {lab_pin.sym} 5660 9840 0 0 {name=l31504 lab=VDD}
N 5640 9760 5660 9760 {}
C {lab_pin.sym} 5660 9760 0 0 {name=l31505 lab=VSS}
C {bitcell_6t.sym} 5800 9800 0 0 {name=Xr49c29}
N 5760 9840 5740 9840 {}
C {lab_pin.sym} 5740 9840 0 0 {name=l31506 lab=BL29}
N 5760 9800 5740 9800 {}
C {lab_pin.sym} 5740 9800 0 0 {name=l31507 lab=BLB29}
N 5760 9760 5740 9760 {}
C {lab_pin.sym} 5740 9760 0 0 {name=l31508 lab=WL49}
N 5840 9840 5860 9840 {}
C {lab_pin.sym} 5860 9840 0 0 {name=l31509 lab=VDD}
N 5840 9760 5860 9760 {}
C {lab_pin.sym} 5860 9760 0 0 {name=l31510 lab=VSS}
C {bitcell_6t.sym} 6000 9800 0 0 {name=Xr49c30}
N 5960 9840 5940 9840 {}
C {lab_pin.sym} 5940 9840 0 0 {name=l31511 lab=BL30}
N 5960 9800 5940 9800 {}
C {lab_pin.sym} 5940 9800 0 0 {name=l31512 lab=BLB30}
N 5960 9760 5940 9760 {}
C {lab_pin.sym} 5940 9760 0 0 {name=l31513 lab=WL49}
N 6040 9840 6060 9840 {}
C {lab_pin.sym} 6060 9840 0 0 {name=l31514 lab=VDD}
N 6040 9760 6060 9760 {}
C {lab_pin.sym} 6060 9760 0 0 {name=l31515 lab=VSS}
C {bitcell_6t.sym} 6200 9800 0 0 {name=Xr49c31}
N 6160 9840 6140 9840 {}
C {lab_pin.sym} 6140 9840 0 0 {name=l31516 lab=BL31}
N 6160 9800 6140 9800 {}
C {lab_pin.sym} 6140 9800 0 0 {name=l31517 lab=BLB31}
N 6160 9760 6140 9760 {}
C {lab_pin.sym} 6140 9760 0 0 {name=l31518 lab=WL49}
N 6240 9840 6260 9840 {}
C {lab_pin.sym} 6260 9840 0 0 {name=l31519 lab=VDD}
N 6240 9760 6260 9760 {}
C {lab_pin.sym} 6260 9760 0 0 {name=l31520 lab=VSS}
C {bitcell_6t.sym} 6400 9800 0 0 {name=Xr49c32}
N 6360 9840 6340 9840 {}
C {lab_pin.sym} 6340 9840 0 0 {name=l31521 lab=BL32}
N 6360 9800 6340 9800 {}
C {lab_pin.sym} 6340 9800 0 0 {name=l31522 lab=BLB32}
N 6360 9760 6340 9760 {}
C {lab_pin.sym} 6340 9760 0 0 {name=l31523 lab=WL49}
N 6440 9840 6460 9840 {}
C {lab_pin.sym} 6460 9840 0 0 {name=l31524 lab=VDD}
N 6440 9760 6460 9760 {}
C {lab_pin.sym} 6460 9760 0 0 {name=l31525 lab=VSS}
C {bitcell_6t.sym} 6600 9800 0 0 {name=Xr49c33}
N 6560 9840 6540 9840 {}
C {lab_pin.sym} 6540 9840 0 0 {name=l31526 lab=BL33}
N 6560 9800 6540 9800 {}
C {lab_pin.sym} 6540 9800 0 0 {name=l31527 lab=BLB33}
N 6560 9760 6540 9760 {}
C {lab_pin.sym} 6540 9760 0 0 {name=l31528 lab=WL49}
N 6640 9840 6660 9840 {}
C {lab_pin.sym} 6660 9840 0 0 {name=l31529 lab=VDD}
N 6640 9760 6660 9760 {}
C {lab_pin.sym} 6660 9760 0 0 {name=l31530 lab=VSS}
C {bitcell_6t.sym} 6800 9800 0 0 {name=Xr49c34}
N 6760 9840 6740 9840 {}
C {lab_pin.sym} 6740 9840 0 0 {name=l31531 lab=BL34}
N 6760 9800 6740 9800 {}
C {lab_pin.sym} 6740 9800 0 0 {name=l31532 lab=BLB34}
N 6760 9760 6740 9760 {}
C {lab_pin.sym} 6740 9760 0 0 {name=l31533 lab=WL49}
N 6840 9840 6860 9840 {}
C {lab_pin.sym} 6860 9840 0 0 {name=l31534 lab=VDD}
N 6840 9760 6860 9760 {}
C {lab_pin.sym} 6860 9760 0 0 {name=l31535 lab=VSS}
C {bitcell_6t.sym} 7000 9800 0 0 {name=Xr49c35}
N 6960 9840 6940 9840 {}
C {lab_pin.sym} 6940 9840 0 0 {name=l31536 lab=BL35}
N 6960 9800 6940 9800 {}
C {lab_pin.sym} 6940 9800 0 0 {name=l31537 lab=BLB35}
N 6960 9760 6940 9760 {}
C {lab_pin.sym} 6940 9760 0 0 {name=l31538 lab=WL49}
N 7040 9840 7060 9840 {}
C {lab_pin.sym} 7060 9840 0 0 {name=l31539 lab=VDD}
N 7040 9760 7060 9760 {}
C {lab_pin.sym} 7060 9760 0 0 {name=l31540 lab=VSS}
C {bitcell_6t.sym} 7200 9800 0 0 {name=Xr49c36}
N 7160 9840 7140 9840 {}
C {lab_pin.sym} 7140 9840 0 0 {name=l31541 lab=BL36}
N 7160 9800 7140 9800 {}
C {lab_pin.sym} 7140 9800 0 0 {name=l31542 lab=BLB36}
N 7160 9760 7140 9760 {}
C {lab_pin.sym} 7140 9760 0 0 {name=l31543 lab=WL49}
N 7240 9840 7260 9840 {}
C {lab_pin.sym} 7260 9840 0 0 {name=l31544 lab=VDD}
N 7240 9760 7260 9760 {}
C {lab_pin.sym} 7260 9760 0 0 {name=l31545 lab=VSS}
C {bitcell_6t.sym} 7400 9800 0 0 {name=Xr49c37}
N 7360 9840 7340 9840 {}
C {lab_pin.sym} 7340 9840 0 0 {name=l31546 lab=BL37}
N 7360 9800 7340 9800 {}
C {lab_pin.sym} 7340 9800 0 0 {name=l31547 lab=BLB37}
N 7360 9760 7340 9760 {}
C {lab_pin.sym} 7340 9760 0 0 {name=l31548 lab=WL49}
N 7440 9840 7460 9840 {}
C {lab_pin.sym} 7460 9840 0 0 {name=l31549 lab=VDD}
N 7440 9760 7460 9760 {}
C {lab_pin.sym} 7460 9760 0 0 {name=l31550 lab=VSS}
C {bitcell_6t.sym} 7600 9800 0 0 {name=Xr49c38}
N 7560 9840 7540 9840 {}
C {lab_pin.sym} 7540 9840 0 0 {name=l31551 lab=BL38}
N 7560 9800 7540 9800 {}
C {lab_pin.sym} 7540 9800 0 0 {name=l31552 lab=BLB38}
N 7560 9760 7540 9760 {}
C {lab_pin.sym} 7540 9760 0 0 {name=l31553 lab=WL49}
N 7640 9840 7660 9840 {}
C {lab_pin.sym} 7660 9840 0 0 {name=l31554 lab=VDD}
N 7640 9760 7660 9760 {}
C {lab_pin.sym} 7660 9760 0 0 {name=l31555 lab=VSS}
C {bitcell_6t.sym} 7800 9800 0 0 {name=Xr49c39}
N 7760 9840 7740 9840 {}
C {lab_pin.sym} 7740 9840 0 0 {name=l31556 lab=BL39}
N 7760 9800 7740 9800 {}
C {lab_pin.sym} 7740 9800 0 0 {name=l31557 lab=BLB39}
N 7760 9760 7740 9760 {}
C {lab_pin.sym} 7740 9760 0 0 {name=l31558 lab=WL49}
N 7840 9840 7860 9840 {}
C {lab_pin.sym} 7860 9840 0 0 {name=l31559 lab=VDD}
N 7840 9760 7860 9760 {}
C {lab_pin.sym} 7860 9760 0 0 {name=l31560 lab=VSS}
C {bitcell_6t.sym} 8000 9800 0 0 {name=Xr49c40}
N 7960 9840 7940 9840 {}
C {lab_pin.sym} 7940 9840 0 0 {name=l31561 lab=BL40}
N 7960 9800 7940 9800 {}
C {lab_pin.sym} 7940 9800 0 0 {name=l31562 lab=BLB40}
N 7960 9760 7940 9760 {}
C {lab_pin.sym} 7940 9760 0 0 {name=l31563 lab=WL49}
N 8040 9840 8060 9840 {}
C {lab_pin.sym} 8060 9840 0 0 {name=l31564 lab=VDD}
N 8040 9760 8060 9760 {}
C {lab_pin.sym} 8060 9760 0 0 {name=l31565 lab=VSS}
C {bitcell_6t.sym} 8200 9800 0 0 {name=Xr49c41}
N 8160 9840 8140 9840 {}
C {lab_pin.sym} 8140 9840 0 0 {name=l31566 lab=BL41}
N 8160 9800 8140 9800 {}
C {lab_pin.sym} 8140 9800 0 0 {name=l31567 lab=BLB41}
N 8160 9760 8140 9760 {}
C {lab_pin.sym} 8140 9760 0 0 {name=l31568 lab=WL49}
N 8240 9840 8260 9840 {}
C {lab_pin.sym} 8260 9840 0 0 {name=l31569 lab=VDD}
N 8240 9760 8260 9760 {}
C {lab_pin.sym} 8260 9760 0 0 {name=l31570 lab=VSS}
C {bitcell_6t.sym} 8400 9800 0 0 {name=Xr49c42}
N 8360 9840 8340 9840 {}
C {lab_pin.sym} 8340 9840 0 0 {name=l31571 lab=BL42}
N 8360 9800 8340 9800 {}
C {lab_pin.sym} 8340 9800 0 0 {name=l31572 lab=BLB42}
N 8360 9760 8340 9760 {}
C {lab_pin.sym} 8340 9760 0 0 {name=l31573 lab=WL49}
N 8440 9840 8460 9840 {}
C {lab_pin.sym} 8460 9840 0 0 {name=l31574 lab=VDD}
N 8440 9760 8460 9760 {}
C {lab_pin.sym} 8460 9760 0 0 {name=l31575 lab=VSS}
C {bitcell_6t.sym} 8600 9800 0 0 {name=Xr49c43}
N 8560 9840 8540 9840 {}
C {lab_pin.sym} 8540 9840 0 0 {name=l31576 lab=BL43}
N 8560 9800 8540 9800 {}
C {lab_pin.sym} 8540 9800 0 0 {name=l31577 lab=BLB43}
N 8560 9760 8540 9760 {}
C {lab_pin.sym} 8540 9760 0 0 {name=l31578 lab=WL49}
N 8640 9840 8660 9840 {}
C {lab_pin.sym} 8660 9840 0 0 {name=l31579 lab=VDD}
N 8640 9760 8660 9760 {}
C {lab_pin.sym} 8660 9760 0 0 {name=l31580 lab=VSS}
C {bitcell_6t.sym} 8800 9800 0 0 {name=Xr49c44}
N 8760 9840 8740 9840 {}
C {lab_pin.sym} 8740 9840 0 0 {name=l31581 lab=BL44}
N 8760 9800 8740 9800 {}
C {lab_pin.sym} 8740 9800 0 0 {name=l31582 lab=BLB44}
N 8760 9760 8740 9760 {}
C {lab_pin.sym} 8740 9760 0 0 {name=l31583 lab=WL49}
N 8840 9840 8860 9840 {}
C {lab_pin.sym} 8860 9840 0 0 {name=l31584 lab=VDD}
N 8840 9760 8860 9760 {}
C {lab_pin.sym} 8860 9760 0 0 {name=l31585 lab=VSS}
C {bitcell_6t.sym} 9000 9800 0 0 {name=Xr49c45}
N 8960 9840 8940 9840 {}
C {lab_pin.sym} 8940 9840 0 0 {name=l31586 lab=BL45}
N 8960 9800 8940 9800 {}
C {lab_pin.sym} 8940 9800 0 0 {name=l31587 lab=BLB45}
N 8960 9760 8940 9760 {}
C {lab_pin.sym} 8940 9760 0 0 {name=l31588 lab=WL49}
N 9040 9840 9060 9840 {}
C {lab_pin.sym} 9060 9840 0 0 {name=l31589 lab=VDD}
N 9040 9760 9060 9760 {}
C {lab_pin.sym} 9060 9760 0 0 {name=l31590 lab=VSS}
C {bitcell_6t.sym} 9200 9800 0 0 {name=Xr49c46}
N 9160 9840 9140 9840 {}
C {lab_pin.sym} 9140 9840 0 0 {name=l31591 lab=BL46}
N 9160 9800 9140 9800 {}
C {lab_pin.sym} 9140 9800 0 0 {name=l31592 lab=BLB46}
N 9160 9760 9140 9760 {}
C {lab_pin.sym} 9140 9760 0 0 {name=l31593 lab=WL49}
N 9240 9840 9260 9840 {}
C {lab_pin.sym} 9260 9840 0 0 {name=l31594 lab=VDD}
N 9240 9760 9260 9760 {}
C {lab_pin.sym} 9260 9760 0 0 {name=l31595 lab=VSS}
C {bitcell_6t.sym} 9400 9800 0 0 {name=Xr49c47}
N 9360 9840 9340 9840 {}
C {lab_pin.sym} 9340 9840 0 0 {name=l31596 lab=BL47}
N 9360 9800 9340 9800 {}
C {lab_pin.sym} 9340 9800 0 0 {name=l31597 lab=BLB47}
N 9360 9760 9340 9760 {}
C {lab_pin.sym} 9340 9760 0 0 {name=l31598 lab=WL49}
N 9440 9840 9460 9840 {}
C {lab_pin.sym} 9460 9840 0 0 {name=l31599 lab=VDD}
N 9440 9760 9460 9760 {}
C {lab_pin.sym} 9460 9760 0 0 {name=l31600 lab=VSS}
C {bitcell_6t.sym} 9600 9800 0 0 {name=Xr49c48}
N 9560 9840 9540 9840 {}
C {lab_pin.sym} 9540 9840 0 0 {name=l31601 lab=BL48}
N 9560 9800 9540 9800 {}
C {lab_pin.sym} 9540 9800 0 0 {name=l31602 lab=BLB48}
N 9560 9760 9540 9760 {}
C {lab_pin.sym} 9540 9760 0 0 {name=l31603 lab=WL49}
N 9640 9840 9660 9840 {}
C {lab_pin.sym} 9660 9840 0 0 {name=l31604 lab=VDD}
N 9640 9760 9660 9760 {}
C {lab_pin.sym} 9660 9760 0 0 {name=l31605 lab=VSS}
C {bitcell_6t.sym} 9800 9800 0 0 {name=Xr49c49}
N 9760 9840 9740 9840 {}
C {lab_pin.sym} 9740 9840 0 0 {name=l31606 lab=BL49}
N 9760 9800 9740 9800 {}
C {lab_pin.sym} 9740 9800 0 0 {name=l31607 lab=BLB49}
N 9760 9760 9740 9760 {}
C {lab_pin.sym} 9740 9760 0 0 {name=l31608 lab=WL49}
N 9840 9840 9860 9840 {}
C {lab_pin.sym} 9860 9840 0 0 {name=l31609 lab=VDD}
N 9840 9760 9860 9760 {}
C {lab_pin.sym} 9860 9760 0 0 {name=l31610 lab=VSS}
C {bitcell_6t.sym} 10000 9800 0 0 {name=Xr49c50}
N 9960 9840 9940 9840 {}
C {lab_pin.sym} 9940 9840 0 0 {name=l31611 lab=BL50}
N 9960 9800 9940 9800 {}
C {lab_pin.sym} 9940 9800 0 0 {name=l31612 lab=BLB50}
N 9960 9760 9940 9760 {}
C {lab_pin.sym} 9940 9760 0 0 {name=l31613 lab=WL49}
N 10040 9840 10060 9840 {}
C {lab_pin.sym} 10060 9840 0 0 {name=l31614 lab=VDD}
N 10040 9760 10060 9760 {}
C {lab_pin.sym} 10060 9760 0 0 {name=l31615 lab=VSS}
C {bitcell_6t.sym} 10200 9800 0 0 {name=Xr49c51}
N 10160 9840 10140 9840 {}
C {lab_pin.sym} 10140 9840 0 0 {name=l31616 lab=BL51}
N 10160 9800 10140 9800 {}
C {lab_pin.sym} 10140 9800 0 0 {name=l31617 lab=BLB51}
N 10160 9760 10140 9760 {}
C {lab_pin.sym} 10140 9760 0 0 {name=l31618 lab=WL49}
N 10240 9840 10260 9840 {}
C {lab_pin.sym} 10260 9840 0 0 {name=l31619 lab=VDD}
N 10240 9760 10260 9760 {}
C {lab_pin.sym} 10260 9760 0 0 {name=l31620 lab=VSS}
C {bitcell_6t.sym} 10400 9800 0 0 {name=Xr49c52}
N 10360 9840 10340 9840 {}
C {lab_pin.sym} 10340 9840 0 0 {name=l31621 lab=BL52}
N 10360 9800 10340 9800 {}
C {lab_pin.sym} 10340 9800 0 0 {name=l31622 lab=BLB52}
N 10360 9760 10340 9760 {}
C {lab_pin.sym} 10340 9760 0 0 {name=l31623 lab=WL49}
N 10440 9840 10460 9840 {}
C {lab_pin.sym} 10460 9840 0 0 {name=l31624 lab=VDD}
N 10440 9760 10460 9760 {}
C {lab_pin.sym} 10460 9760 0 0 {name=l31625 lab=VSS}
C {bitcell_6t.sym} 10600 9800 0 0 {name=Xr49c53}
N 10560 9840 10540 9840 {}
C {lab_pin.sym} 10540 9840 0 0 {name=l31626 lab=BL53}
N 10560 9800 10540 9800 {}
C {lab_pin.sym} 10540 9800 0 0 {name=l31627 lab=BLB53}
N 10560 9760 10540 9760 {}
C {lab_pin.sym} 10540 9760 0 0 {name=l31628 lab=WL49}
N 10640 9840 10660 9840 {}
C {lab_pin.sym} 10660 9840 0 0 {name=l31629 lab=VDD}
N 10640 9760 10660 9760 {}
C {lab_pin.sym} 10660 9760 0 0 {name=l31630 lab=VSS}
C {bitcell_6t.sym} 10800 9800 0 0 {name=Xr49c54}
N 10760 9840 10740 9840 {}
C {lab_pin.sym} 10740 9840 0 0 {name=l31631 lab=BL54}
N 10760 9800 10740 9800 {}
C {lab_pin.sym} 10740 9800 0 0 {name=l31632 lab=BLB54}
N 10760 9760 10740 9760 {}
C {lab_pin.sym} 10740 9760 0 0 {name=l31633 lab=WL49}
N 10840 9840 10860 9840 {}
C {lab_pin.sym} 10860 9840 0 0 {name=l31634 lab=VDD}
N 10840 9760 10860 9760 {}
C {lab_pin.sym} 10860 9760 0 0 {name=l31635 lab=VSS}
C {bitcell_6t.sym} 11000 9800 0 0 {name=Xr49c55}
N 10960 9840 10940 9840 {}
C {lab_pin.sym} 10940 9840 0 0 {name=l31636 lab=BL55}
N 10960 9800 10940 9800 {}
C {lab_pin.sym} 10940 9800 0 0 {name=l31637 lab=BLB55}
N 10960 9760 10940 9760 {}
C {lab_pin.sym} 10940 9760 0 0 {name=l31638 lab=WL49}
N 11040 9840 11060 9840 {}
C {lab_pin.sym} 11060 9840 0 0 {name=l31639 lab=VDD}
N 11040 9760 11060 9760 {}
C {lab_pin.sym} 11060 9760 0 0 {name=l31640 lab=VSS}
C {bitcell_6t.sym} 11200 9800 0 0 {name=Xr49c56}
N 11160 9840 11140 9840 {}
C {lab_pin.sym} 11140 9840 0 0 {name=l31641 lab=BL56}
N 11160 9800 11140 9800 {}
C {lab_pin.sym} 11140 9800 0 0 {name=l31642 lab=BLB56}
N 11160 9760 11140 9760 {}
C {lab_pin.sym} 11140 9760 0 0 {name=l31643 lab=WL49}
N 11240 9840 11260 9840 {}
C {lab_pin.sym} 11260 9840 0 0 {name=l31644 lab=VDD}
N 11240 9760 11260 9760 {}
C {lab_pin.sym} 11260 9760 0 0 {name=l31645 lab=VSS}
C {bitcell_6t.sym} 11400 9800 0 0 {name=Xr49c57}
N 11360 9840 11340 9840 {}
C {lab_pin.sym} 11340 9840 0 0 {name=l31646 lab=BL57}
N 11360 9800 11340 9800 {}
C {lab_pin.sym} 11340 9800 0 0 {name=l31647 lab=BLB57}
N 11360 9760 11340 9760 {}
C {lab_pin.sym} 11340 9760 0 0 {name=l31648 lab=WL49}
N 11440 9840 11460 9840 {}
C {lab_pin.sym} 11460 9840 0 0 {name=l31649 lab=VDD}
N 11440 9760 11460 9760 {}
