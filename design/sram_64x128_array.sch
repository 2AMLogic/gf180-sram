C {bitcell_6t.sym} 25400 12400 0 0 {name=Xr62c127}
N 25360 12440 25340 12440 {}
C {lab_pin.sym} 25340 12440 0 0 {name=l40316 lab=BL127}
N 25360 12400 25340 12400 {}
C {lab_pin.sym} 25340 12400 0 0 {name=l40317 lab=BLB127}
N 25360 12360 25340 12360 {}
C {lab_pin.sym} 25340 12360 0 0 {name=l40318 lab=WL62}
N 25440 12440 25460 12440 {}
C {lab_pin.sym} 25460 12440 0 0 {name=l40319 lab=VDD}
N 25440 12360 25460 12360 {}
C {lab_pin.sym} 25460 12360 0 0 {name=l40320 lab=VSS}
C {bitcell_6t.sym} 0 12600 0 0 {name=Xr63c0}
N -40 12640 -60 12640 {}
C {lab_pin.sym} -60 12640 0 0 {name=l40321 lab=BL0}
N -40 12600 -60 12600 {}
C {lab_pin.sym} -60 12600 0 0 {name=l40322 lab=BLB0}
N -40 12560 -60 12560 {}
C {lab_pin.sym} -60 12560 0 0 {name=l40323 lab=WL63}
N 40 12640 60 12640 {}
C {lab_pin.sym} 60 12640 0 0 {name=l40324 lab=VDD}
N 40 12560 60 12560 {}
C {lab_pin.sym} 60 12560 0 0 {name=l40325 lab=VSS}
C {bitcell_6t.sym} 200 12600 0 0 {name=Xr63c1}
N 160 12640 140 12640 {}
C {lab_pin.sym} 140 12640 0 0 {name=l40326 lab=BL1}
N 160 12600 140 12600 {}
C {lab_pin.sym} 140 12600 0 0 {name=l40327 lab=BLB1}
N 160 12560 140 12560 {}
C {lab_pin.sym} 140 12560 0 0 {name=l40328 lab=WL63}
N 240 12640 260 12640 {}
C {lab_pin.sym} 260 12640 0 0 {name=l40329 lab=VDD}
N 240 12560 260 12560 {}
C {lab_pin.sym} 260 12560 0 0 {name=l40330 lab=VSS}
C {bitcell_6t.sym} 400 12600 0 0 {name=Xr63c2}
N 360 12640 340 12640 {}
C {lab_pin.sym} 340 12640 0 0 {name=l40331 lab=BL2}
N 360 12600 340 12600 {}
C {lab_pin.sym} 340 12600 0 0 {name=l40332 lab=BLB2}
N 360 12560 340 12560 {}
C {lab_pin.sym} 340 12560 0 0 {name=l40333 lab=WL63}
N 440 12640 460 12640 {}
C {lab_pin.sym} 460 12640 0 0 {name=l40334 lab=VDD}
N 440 12560 460 12560 {}
C {lab_pin.sym} 460 12560 0 0 {name=l40335 lab=VSS}
C {bitcell_6t.sym} 600 12600 0 0 {name=Xr63c3}
N 560 12640 540 12640 {}
C {lab_pin.sym} 540 12640 0 0 {name=l40336 lab=BL3}
N 560 12600 540 12600 {}
C {lab_pin.sym} 540 12600 0 0 {name=l40337 lab=BLB3}
N 560 12560 540 12560 {}
C {lab_pin.sym} 540 12560 0 0 {name=l40338 lab=WL63}
N 640 12640 660 12640 {}
C {lab_pin.sym} 660 12640 0 0 {name=l40339 lab=VDD}
N 640 12560 660 12560 {}
C {lab_pin.sym} 660 12560 0 0 {name=l40340 lab=VSS}
C {bitcell_6t.sym} 800 12600 0 0 {name=Xr63c4}
N 760 12640 740 12640 {}
C {lab_pin.sym} 740 12640 0 0 {name=l40341 lab=BL4}
N 760 12600 740 12600 {}
C {lab_pin.sym} 740 12600 0 0 {name=l40342 lab=BLB4}
N 760 12560 740 12560 {}
C {lab_pin.sym} 740 12560 0 0 {name=l40343 lab=WL63}
N 840 12640 860 12640 {}
C {lab_pin.sym} 860 12640 0 0 {name=l40344 lab=VDD}
N 840 12560 860 12560 {}
C {lab_pin.sym} 860 12560 0 0 {name=l40345 lab=VSS}
C {bitcell_6t.sym} 1000 12600 0 0 {name=Xr63c5}
N 960 12640 940 12640 {}
C {lab_pin.sym} 940 12640 0 0 {name=l40346 lab=BL5}
N 960 12600 940 12600 {}
C {lab_pin.sym} 940 12600 0 0 {name=l40347 lab=BLB5}
N 960 12560 940 12560 {}
C {lab_pin.sym} 940 12560 0 0 {name=l40348 lab=WL63}
N 1040 12640 1060 12640 {}
C {lab_pin.sym} 1060 12640 0 0 {name=l40349 lab=VDD}
N 1040 12560 1060 12560 {}
C {lab_pin.sym} 1060 12560 0 0 {name=l40350 lab=VSS}
C {bitcell_6t.sym} 1200 12600 0 0 {name=Xr63c6}
N 1160 12640 1140 12640 {}
C {lab_pin.sym} 1140 12640 0 0 {name=l40351 lab=BL6}
N 1160 12600 1140 12600 {}
C {lab_pin.sym} 1140 12600 0 0 {name=l40352 lab=BLB6}
N 1160 12560 1140 12560 {}
C {lab_pin.sym} 1140 12560 0 0 {name=l40353 lab=WL63}
N 1240 12640 1260 12640 {}
C {lab_pin.sym} 1260 12640 0 0 {name=l40354 lab=VDD}
N 1240 12560 1260 12560 {}
C {lab_pin.sym} 1260 12560 0 0 {name=l40355 lab=VSS}
C {bitcell_6t.sym} 1400 12600 0 0 {name=Xr63c7}
N 1360 12640 1340 12640 {}
C {lab_pin.sym} 1340 12640 0 0 {name=l40356 lab=BL7}
N 1360 12600 1340 12600 {}
C {lab_pin.sym} 1340 12600 0 0 {name=l40357 lab=BLB7}
N 1360 12560 1340 12560 {}
C {lab_pin.sym} 1340 12560 0 0 {name=l40358 lab=WL63}
N 1440 12640 1460 12640 {}
C {lab_pin.sym} 1460 12640 0 0 {name=l40359 lab=VDD}
N 1440 12560 1460 12560 {}
C {lab_pin.sym} 1460 12560 0 0 {name=l40360 lab=VSS}
C {bitcell_6t.sym} 1600 12600 0 0 {name=Xr63c8}
N 1560 12640 1540 12640 {}
C {lab_pin.sym} 1540 12640 0 0 {name=l40361 lab=BL8}
N 1560 12600 1540 12600 {}
C {lab_pin.sym} 1540 12600 0 0 {name=l40362 lab=BLB8}
N 1560 12560 1540 12560 {}
C {lab_pin.sym} 1540 12560 0 0 {name=l40363 lab=WL63}
N 1640 12640 1660 12640 {}
C {lab_pin.sym} 1660 12640 0 0 {name=l40364 lab=VDD}
N 1640 12560 1660 12560 {}
C {lab_pin.sym} 1660 12560 0 0 {name=l40365 lab=VSS}
C {bitcell_6t.sym} 1800 12600 0 0 {name=Xr63c9}
N 1760 12640 1740 12640 {}
C {lab_pin.sym} 1740 12640 0 0 {name=l40366 lab=BL9}
N 1760 12600 1740 12600 {}
C {lab_pin.sym} 1740 12600 0 0 {name=l40367 lab=BLB9}
N 1760 12560 1740 12560 {}
C {lab_pin.sym} 1740 12560 0 0 {name=l40368 lab=WL63}
N 1840 12640 1860 12640 {}
C {lab_pin.sym} 1860 12640 0 0 {name=l40369 lab=VDD}
N 1840 12560 1860 12560 {}
C {lab_pin.sym} 1860 12560 0 0 {name=l40370 lab=VSS}
C {bitcell_6t.sym} 2000 12600 0 0 {name=Xr63c10}
N 1960 12640 1940 12640 {}
C {lab_pin.sym} 1940 12640 0 0 {name=l40371 lab=BL10}
N 1960 12600 1940 12600 {}
C {lab_pin.sym} 1940 12600 0 0 {name=l40372 lab=BLB10}
N 1960 12560 1940 12560 {}
C {lab_pin.sym} 1940 12560 0 0 {name=l40373 lab=WL63}
N 2040 12640 2060 12640 {}
C {lab_pin.sym} 2060 12640 0 0 {name=l40374 lab=VDD}
N 2040 12560 2060 12560 {}
C {lab_pin.sym} 2060 12560 0 0 {name=l40375 lab=VSS}
C {bitcell_6t.sym} 2200 12600 0 0 {name=Xr63c11}
N 2160 12640 2140 12640 {}
C {lab_pin.sym} 2140 12640 0 0 {name=l40376 lab=BL11}
N 2160 12600 2140 12600 {}
C {lab_pin.sym} 2140 12600 0 0 {name=l40377 lab=BLB11}
N 2160 12560 2140 12560 {}
C {lab_pin.sym} 2140 12560 0 0 {name=l40378 lab=WL63}
N 2240 12640 2260 12640 {}
C {lab_pin.sym} 2260 12640 0 0 {name=l40379 lab=VDD}
N 2240 12560 2260 12560 {}
C {lab_pin.sym} 2260 12560 0 0 {name=l40380 lab=VSS}
C {bitcell_6t.sym} 2400 12600 0 0 {name=Xr63c12}
N 2360 12640 2340 12640 {}
C {lab_pin.sym} 2340 12640 0 0 {name=l40381 lab=BL12}
N 2360 12600 2340 12600 {}
C {lab_pin.sym} 2340 12600 0 0 {name=l40382 lab=BLB12}
N 2360 12560 2340 12560 {}
C {lab_pin.sym} 2340 12560 0 0 {name=l40383 lab=WL63}
N 2440 12640 2460 12640 {}
C {lab_pin.sym} 2460 12640 0 0 {name=l40384 lab=VDD}
N 2440 12560 2460 12560 {}
C {lab_pin.sym} 2460 12560 0 0 {name=l40385 lab=VSS}
C {bitcell_6t.sym} 2600 12600 0 0 {name=Xr63c13}
N 2560 12640 2540 12640 {}
C {lab_pin.sym} 2540 12640 0 0 {name=l40386 lab=BL13}
N 2560 12600 2540 12600 {}
C {lab_pin.sym} 2540 12600 0 0 {name=l40387 lab=BLB13}
N 2560 12560 2540 12560 {}
C {lab_pin.sym} 2540 12560 0 0 {name=l40388 lab=WL63}
N 2640 12640 2660 12640 {}
C {lab_pin.sym} 2660 12640 0 0 {name=l40389 lab=VDD}
N 2640 12560 2660 12560 {}
C {lab_pin.sym} 2660 12560 0 0 {name=l40390 lab=VSS}
C {bitcell_6t.sym} 2800 12600 0 0 {name=Xr63c14}
N 2760 12640 2740 12640 {}
C {lab_pin.sym} 2740 12640 0 0 {name=l40391 lab=BL14}
N 2760 12600 2740 12600 {}
C {lab_pin.sym} 2740 12600 0 0 {name=l40392 lab=BLB14}
N 2760 12560 2740 12560 {}
C {lab_pin.sym} 2740 12560 0 0 {name=l40393 lab=WL63}
N 2840 12640 2860 12640 {}
C {lab_pin.sym} 2860 12640 0 0 {name=l40394 lab=VDD}
N 2840 12560 2860 12560 {}
C {lab_pin.sym} 2860 12560 0 0 {name=l40395 lab=VSS}
C {bitcell_6t.sym} 3000 12600 0 0 {name=Xr63c15}
N 2960 12640 2940 12640 {}
C {lab_pin.sym} 2940 12640 0 0 {name=l40396 lab=BL15}
N 2960 12600 2940 12600 {}
C {lab_pin.sym} 2940 12600 0 0 {name=l40397 lab=BLB15}
N 2960 12560 2940 12560 {}
C {lab_pin.sym} 2940 12560 0 0 {name=l40398 lab=WL63}
N 3040 12640 3060 12640 {}
C {lab_pin.sym} 3060 12640 0 0 {name=l40399 lab=VDD}
N 3040 12560 3060 12560 {}
C {lab_pin.sym} 3060 12560 0 0 {name=l40400 lab=VSS}
C {bitcell_6t.sym} 3200 12600 0 0 {name=Xr63c16}
N 3160 12640 3140 12640 {}
C {lab_pin.sym} 3140 12640 0 0 {name=l40401 lab=BL16}
N 3160 12600 3140 12600 {}
C {lab_pin.sym} 3140 12600 0 0 {name=l40402 lab=BLB16}
N 3160 12560 3140 12560 {}
C {lab_pin.sym} 3140 12560 0 0 {name=l40403 lab=WL63}
N 3240 12640 3260 12640 {}
C {lab_pin.sym} 3260 12640 0 0 {name=l40404 lab=VDD}
N 3240 12560 3260 12560 {}
C {lab_pin.sym} 3260 12560 0 0 {name=l40405 lab=VSS}
C {bitcell_6t.sym} 3400 12600 0 0 {name=Xr63c17}
N 3360 12640 3340 12640 {}
C {lab_pin.sym} 3340 12640 0 0 {name=l40406 lab=BL17}
N 3360 12600 3340 12600 {}
C {lab_pin.sym} 3340 12600 0 0 {name=l40407 lab=BLB17}
N 3360 12560 3340 12560 {}
C {lab_pin.sym} 3340 12560 0 0 {name=l40408 lab=WL63}
N 3440 12640 3460 12640 {}
C {lab_pin.sym} 3460 12640 0 0 {name=l40409 lab=VDD}
N 3440 12560 3460 12560 {}
C {lab_pin.sym} 3460 12560 0 0 {name=l40410 lab=VSS}
C {bitcell_6t.sym} 3600 12600 0 0 {name=Xr63c18}
N 3560 12640 3540 12640 {}
C {lab_pin.sym} 3540 12640 0 0 {name=l40411 lab=BL18}
N 3560 12600 3540 12600 {}
C {lab_pin.sym} 3540 12600 0 0 {name=l40412 lab=BLB18}
N 3560 12560 3540 12560 {}
C {lab_pin.sym} 3540 12560 0 0 {name=l40413 lab=WL63}
N 3640 12640 3660 12640 {}
C {lab_pin.sym} 3660 12640 0 0 {name=l40414 lab=VDD}
N 3640 12560 3660 12560 {}
C {lab_pin.sym} 3660 12560 0 0 {name=l40415 lab=VSS}
C {bitcell_6t.sym} 3800 12600 0 0 {name=Xr63c19}
N 3760 12640 3740 12640 {}
C {lab_pin.sym} 3740 12640 0 0 {name=l40416 lab=BL19}
N 3760 12600 3740 12600 {}
C {lab_pin.sym} 3740 12600 0 0 {name=l40417 lab=BLB19}
N 3760 12560 3740 12560 {}
C {lab_pin.sym} 3740 12560 0 0 {name=l40418 lab=WL63}
N 3840 12640 3860 12640 {}
C {lab_pin.sym} 3860 12640 0 0 {name=l40419 lab=VDD}
N 3840 12560 3860 12560 {}
C {lab_pin.sym} 3860 12560 0 0 {name=l40420 lab=VSS}
C {bitcell_6t.sym} 4000 12600 0 0 {name=Xr63c20}
N 3960 12640 3940 12640 {}
C {lab_pin.sym} 3940 12640 0 0 {name=l40421 lab=BL20}
N 3960 12600 3940 12600 {}
C {lab_pin.sym} 3940 12600 0 0 {name=l40422 lab=BLB20}
N 3960 12560 3940 12560 {}
C {lab_pin.sym} 3940 12560 0 0 {name=l40423 lab=WL63}
N 4040 12640 4060 12640 {}
C {lab_pin.sym} 4060 12640 0 0 {name=l40424 lab=VDD}
N 4040 12560 4060 12560 {}
C {lab_pin.sym} 4060 12560 0 0 {name=l40425 lab=VSS}
C {bitcell_6t.sym} 4200 12600 0 0 {name=Xr63c21}
N 4160 12640 4140 12640 {}
C {lab_pin.sym} 4140 12640 0 0 {name=l40426 lab=BL21}
N 4160 12600 4140 12600 {}
C {lab_pin.sym} 4140 12600 0 0 {name=l40427 lab=BLB21}
N 4160 12560 4140 12560 {}
C {lab_pin.sym} 4140 12560 0 0 {name=l40428 lab=WL63}
N 4240 12640 4260 12640 {}
C {lab_pin.sym} 4260 12640 0 0 {name=l40429 lab=VDD}
N 4240 12560 4260 12560 {}
C {lab_pin.sym} 4260 12560 0 0 {name=l40430 lab=VSS}
C {bitcell_6t.sym} 4400 12600 0 0 {name=Xr63c22}
N 4360 12640 4340 12640 {}
C {lab_pin.sym} 4340 12640 0 0 {name=l40431 lab=BL22}
N 4360 12600 4340 12600 {}
C {lab_pin.sym} 4340 12600 0 0 {name=l40432 lab=BLB22}
N 4360 12560 4340 12560 {}
C {lab_pin.sym} 4340 12560 0 0 {name=l40433 lab=WL63}
N 4440 12640 4460 12640 {}
C {lab_pin.sym} 4460 12640 0 0 {name=l40434 lab=VDD}
N 4440 12560 4460 12560 {}
C {lab_pin.sym} 4460 12560 0 0 {name=l40435 lab=VSS}
C {bitcell_6t.sym} 4600 12600 0 0 {name=Xr63c23}
N 4560 12640 4540 12640 {}
C {lab_pin.sym} 4540 12640 0 0 {name=l40436 lab=BL23}
N 4560 12600 4540 12600 {}
C {lab_pin.sym} 4540 12600 0 0 {name=l40437 lab=BLB23}
N 4560 12560 4540 12560 {}
C {lab_pin.sym} 4540 12560 0 0 {name=l40438 lab=WL63}
N 4640 12640 4660 12640 {}
C {lab_pin.sym} 4660 12640 0 0 {name=l40439 lab=VDD}
N 4640 12560 4660 12560 {}
C {lab_pin.sym} 4660 12560 0 0 {name=l40440 lab=VSS}
C {bitcell_6t.sym} 4800 12600 0 0 {name=Xr63c24}
N 4760 12640 4740 12640 {}
C {lab_pin.sym} 4740 12640 0 0 {name=l40441 lab=BL24}
N 4760 12600 4740 12600 {}
C {lab_pin.sym} 4740 12600 0 0 {name=l40442 lab=BLB24}
N 4760 12560 4740 12560 {}
C {lab_pin.sym} 4740 12560 0 0 {name=l40443 lab=WL63}
N 4840 12640 4860 12640 {}
C {lab_pin.sym} 4860 12640 0 0 {name=l40444 lab=VDD}
N 4840 12560 4860 12560 {}
C {lab_pin.sym} 4860 12560 0 0 {name=l40445 lab=VSS}
C {bitcell_6t.sym} 5000 12600 0 0 {name=Xr63c25}
N 4960 12640 4940 12640 {}
C {lab_pin.sym} 4940 12640 0 0 {name=l40446 lab=BL25}
N 4960 12600 4940 12600 {}
C {lab_pin.sym} 4940 12600 0 0 {name=l40447 lab=BLB25}
N 4960 12560 4940 12560 {}
C {lab_pin.sym} 4940 12560 0 0 {name=l40448 lab=WL63}
N 5040 12640 5060 12640 {}
C {lab_pin.sym} 5060 12640 0 0 {name=l40449 lab=VDD}
N 5040 12560 5060 12560 {}
C {lab_pin.sym} 5060 12560 0 0 {name=l40450 lab=VSS}
C {bitcell_6t.sym} 5200 12600 0 0 {name=Xr63c26}
N 5160 12640 5140 12640 {}
C {lab_pin.sym} 5140 12640 0 0 {name=l40451 lab=BL26}
N 5160 12600 5140 12600 {}
C {lab_pin.sym} 5140 12600 0 0 {name=l40452 lab=BLB26}
N 5160 12560 5140 12560 {}
C {lab_pin.sym} 5140 12560 0 0 {name=l40453 lab=WL63}
N 5240 12640 5260 12640 {}
C {lab_pin.sym} 5260 12640 0 0 {name=l40454 lab=VDD}
N 5240 12560 5260 12560 {}
C {lab_pin.sym} 5260 12560 0 0 {name=l40455 lab=VSS}
C {bitcell_6t.sym} 5400 12600 0 0 {name=Xr63c27}
N 5360 12640 5340 12640 {}
C {lab_pin.sym} 5340 12640 0 0 {name=l40456 lab=BL27}
N 5360 12600 5340 12600 {}
C {lab_pin.sym} 5340 12600 0 0 {name=l40457 lab=BLB27}
N 5360 12560 5340 12560 {}
C {lab_pin.sym} 5340 12560 0 0 {name=l40458 lab=WL63}
N 5440 12640 5460 12640 {}
C {lab_pin.sym} 5460 12640 0 0 {name=l40459 lab=VDD}
N 5440 12560 5460 12560 {}
C {lab_pin.sym} 5460 12560 0 0 {name=l40460 lab=VSS}
C {bitcell_6t.sym} 5600 12600 0 0 {name=Xr63c28}
N 5560 12640 5540 12640 {}
C {lab_pin.sym} 5540 12640 0 0 {name=l40461 lab=BL28}
N 5560 12600 5540 12600 {}
C {lab_pin.sym} 5540 12600 0 0 {name=l40462 lab=BLB28}
N 5560 12560 5540 12560 {}
C {lab_pin.sym} 5540 12560 0 0 {name=l40463 lab=WL63}
N 5640 12640 5660 12640 {}
C {lab_pin.sym} 5660 12640 0 0 {name=l40464 lab=VDD}
N 5640 12560 5660 12560 {}
C {lab_pin.sym} 5660 12560 0 0 {name=l40465 lab=VSS}
C {bitcell_6t.sym} 5800 12600 0 0 {name=Xr63c29}
N 5760 12640 5740 12640 {}
C {lab_pin.sym} 5740 12640 0 0 {name=l40466 lab=BL29}
N 5760 12600 5740 12600 {}
C {lab_pin.sym} 5740 12600 0 0 {name=l40467 lab=BLB29}
N 5760 12560 5740 12560 {}
C {lab_pin.sym} 5740 12560 0 0 {name=l40468 lab=WL63}
N 5840 12640 5860 12640 {}
C {lab_pin.sym} 5860 12640 0 0 {name=l40469 lab=VDD}
N 5840 12560 5860 12560 {}
C {lab_pin.sym} 5860 12560 0 0 {name=l40470 lab=VSS}
C {bitcell_6t.sym} 6000 12600 0 0 {name=Xr63c30}
N 5960 12640 5940 12640 {}
C {lab_pin.sym} 5940 12640 0 0 {name=l40471 lab=BL30}
N 5960 12600 5940 12600 {}
C {lab_pin.sym} 5940 12600 0 0 {name=l40472 lab=BLB30}
N 5960 12560 5940 12560 {}
C {lab_pin.sym} 5940 12560 0 0 {name=l40473 lab=WL63}
N 6040 12640 6060 12640 {}
C {lab_pin.sym} 6060 12640 0 0 {name=l40474 lab=VDD}
N 6040 12560 6060 12560 {}
C {lab_pin.sym} 6060 12560 0 0 {name=l40475 lab=VSS}
C {bitcell_6t.sym} 6200 12600 0 0 {name=Xr63c31}
N 6160 12640 6140 12640 {}
C {lab_pin.sym} 6140 12640 0 0 {name=l40476 lab=BL31}
N 6160 12600 6140 12600 {}
C {lab_pin.sym} 6140 12600 0 0 {name=l40477 lab=BLB31}
N 6160 12560 6140 12560 {}
C {lab_pin.sym} 6140 12560 0 0 {name=l40478 lab=WL63}
N 6240 12640 6260 12640 {}
C {lab_pin.sym} 6260 12640 0 0 {name=l40479 lab=VDD}
N 6240 12560 6260 12560 {}
C {lab_pin.sym} 6260 12560 0 0 {name=l40480 lab=VSS}
C {bitcell_6t.sym} 6400 12600 0 0 {name=Xr63c32}
N 6360 12640 6340 12640 {}
C {lab_pin.sym} 6340 12640 0 0 {name=l40481 lab=BL32}
N 6360 12600 6340 12600 {}
C {lab_pin.sym} 6340 12600 0 0 {name=l40482 lab=BLB32}
N 6360 12560 6340 12560 {}
C {lab_pin.sym} 6340 12560 0 0 {name=l40483 lab=WL63}
N 6440 12640 6460 12640 {}
C {lab_pin.sym} 6460 12640 0 0 {name=l40484 lab=VDD}
N 6440 12560 6460 12560 {}
C {lab_pin.sym} 6460 12560 0 0 {name=l40485 lab=VSS}
C {bitcell_6t.sym} 6600 12600 0 0 {name=Xr63c33}
N 6560 12640 6540 12640 {}
C {lab_pin.sym} 6540 12640 0 0 {name=l40486 lab=BL33}
N 6560 12600 6540 12600 {}
C {lab_pin.sym} 6540 12600 0 0 {name=l40487 lab=BLB33}
N 6560 12560 6540 12560 {}
C {lab_pin.sym} 6540 12560 0 0 {name=l40488 lab=WL63}
N 6640 12640 6660 12640 {}
C {lab_pin.sym} 6660 12640 0 0 {name=l40489 lab=VDD}
N 6640 12560 6660 12560 {}
C {lab_pin.sym} 6660 12560 0 0 {name=l40490 lab=VSS}
C {bitcell_6t.sym} 6800 12600 0 0 {name=Xr63c34}
N 6760 12640 6740 12640 {}
C {lab_pin.sym} 6740 12640 0 0 {name=l40491 lab=BL34}
N 6760 12600 6740 12600 {}
C {lab_pin.sym} 6740 12600 0 0 {name=l40492 lab=BLB34}
N 6760 12560 6740 12560 {}
C {lab_pin.sym} 6740 12560 0 0 {name=l40493 lab=WL63}
N 6840 12640 6860 12640 {}
C {lab_pin.sym} 6860 12640 0 0 {name=l40494 lab=VDD}
N 6840 12560 6860 12560 {}
C {lab_pin.sym} 6860 12560 0 0 {name=l40495 lab=VSS}
C {bitcell_6t.sym} 7000 12600 0 0 {name=Xr63c35}
N 6960 12640 6940 12640 {}
C {lab_pin.sym} 6940 12640 0 0 {name=l40496 lab=BL35}
N 6960 12600 6940 12600 {}
C {lab_pin.sym} 6940 12600 0 0 {name=l40497 lab=BLB35}
N 6960 12560 6940 12560 {}
C {lab_pin.sym} 6940 12560 0 0 {name=l40498 lab=WL63}
N 7040 12640 7060 12640 {}
C {lab_pin.sym} 7060 12640 0 0 {name=l40499 lab=VDD}
N 7040 12560 7060 12560 {}
C {lab_pin.sym} 7060 12560 0 0 {name=l40500 lab=VSS}
C {bitcell_6t.sym} 7200 12600 0 0 {name=Xr63c36}
N 7160 12640 7140 12640 {}
C {lab_pin.sym} 7140 12640 0 0 {name=l40501 lab=BL36}
N 7160 12600 7140 12600 {}
C {lab_pin.sym} 7140 12600 0 0 {name=l40502 lab=BLB36}
N 7160 12560 7140 12560 {}
C {lab_pin.sym} 7140 12560 0 0 {name=l40503 lab=WL63}
N 7240 12640 7260 12640 {}
C {lab_pin.sym} 7260 12640 0 0 {name=l40504 lab=VDD}
N 7240 12560 7260 12560 {}
C {lab_pin.sym} 7260 12560 0 0 {name=l40505 lab=VSS}
C {bitcell_6t.sym} 7400 12600 0 0 {name=Xr63c37}
N 7360 12640 7340 12640 {}
C {lab_pin.sym} 7340 12640 0 0 {name=l40506 lab=BL37}
N 7360 12600 7340 12600 {}
C {lab_pin.sym} 7340 12600 0 0 {name=l40507 lab=BLB37}
N 7360 12560 7340 12560 {}
C {lab_pin.sym} 7340 12560 0 0 {name=l40508 lab=WL63}
N 7440 12640 7460 12640 {}
C {lab_pin.sym} 7460 12640 0 0 {name=l40509 lab=VDD}
N 7440 12560 7460 12560 {}
C {lab_pin.sym} 7460 12560 0 0 {name=l40510 lab=VSS}
C {bitcell_6t.sym} 7600 12600 0 0 {name=Xr63c38}
N 7560 12640 7540 12640 {}
C {lab_pin.sym} 7540 12640 0 0 {name=l40511 lab=BL38}
N 7560 12600 7540 12600 {}
C {lab_pin.sym} 7540 12600 0 0 {name=l40512 lab=BLB38}
N 7560 12560 7540 12560 {}
C {lab_pin.sym} 7540 12560 0 0 {name=l40513 lab=WL63}
N 7640 12640 7660 12640 {}
C {lab_pin.sym} 7660 12640 0 0 {name=l40514 lab=VDD}
N 7640 12560 7660 12560 {}
C {lab_pin.sym} 7660 12560 0 0 {name=l40515 lab=VSS}
C {bitcell_6t.sym} 7800 12600 0 0 {name=Xr63c39}
N 7760 12640 7740 12640 {}
C {lab_pin.sym} 7740 12640 0 0 {name=l40516 lab=BL39}
N 7760 12600 7740 12600 {}
C {lab_pin.sym} 7740 12600 0 0 {name=l40517 lab=BLB39}
N 7760 12560 7740 12560 {}
C {lab_pin.sym} 7740 12560 0 0 {name=l40518 lab=WL63}
N 7840 12640 7860 12640 {}
C {lab_pin.sym} 7860 12640 0 0 {name=l40519 lab=VDD}
N 7840 12560 7860 12560 {}
C {lab_pin.sym} 7860 12560 0 0 {name=l40520 lab=VSS}
C {bitcell_6t.sym} 8000 12600 0 0 {name=Xr63c40}
N 7960 12640 7940 12640 {}
C {lab_pin.sym} 7940 12640 0 0 {name=l40521 lab=BL40}
N 7960 12600 7940 12600 {}
C {lab_pin.sym} 7940 12600 0 0 {name=l40522 lab=BLB40}
N 7960 12560 7940 12560 {}
C {lab_pin.sym} 7940 12560 0 0 {name=l40523 lab=WL63}
N 8040 12640 8060 12640 {}
C {lab_pin.sym} 8060 12640 0 0 {name=l40524 lab=VDD}
N 8040 12560 8060 12560 {}
C {lab_pin.sym} 8060 12560 0 0 {name=l40525 lab=VSS}
C {bitcell_6t.sym} 8200 12600 0 0 {name=Xr63c41}
N 8160 12640 8140 12640 {}
C {lab_pin.sym} 8140 12640 0 0 {name=l40526 lab=BL41}
N 8160 12600 8140 12600 {}
C {lab_pin.sym} 8140 12600 0 0 {name=l40527 lab=BLB41}
N 8160 12560 8140 12560 {}
C {lab_pin.sym} 8140 12560 0 0 {name=l40528 lab=WL63}
N 8240 12640 8260 12640 {}
C {lab_pin.sym} 8260 12640 0 0 {name=l40529 lab=VDD}
N 8240 12560 8260 12560 {}
C {lab_pin.sym} 8260 12560 0 0 {name=l40530 lab=VSS}
C {bitcell_6t.sym} 8400 12600 0 0 {name=Xr63c42}
N 8360 12640 8340 12640 {}
C {lab_pin.sym} 8340 12640 0 0 {name=l40531 lab=BL42}
N 8360 12600 8340 12600 {}
C {lab_pin.sym} 8340 12600 0 0 {name=l40532 lab=BLB42}
N 8360 12560 8340 12560 {}
C {lab_pin.sym} 8340 12560 0 0 {name=l40533 lab=WL63}
N 8440 12640 8460 12640 {}
C {lab_pin.sym} 8460 12640 0 0 {name=l40534 lab=VDD}
N 8440 12560 8460 12560 {}
C {lab_pin.sym} 8460 12560 0 0 {name=l40535 lab=VSS}
C {bitcell_6t.sym} 8600 12600 0 0 {name=Xr63c43}
N 8560 12640 8540 12640 {}
C {lab_pin.sym} 8540 12640 0 0 {name=l40536 lab=BL43}
N 8560 12600 8540 12600 {}
C {lab_pin.sym} 8540 12600 0 0 {name=l40537 lab=BLB43}
N 8560 12560 8540 12560 {}
C {lab_pin.sym} 8540 12560 0 0 {name=l40538 lab=WL63}
N 8640 12640 8660 12640 {}
C {lab_pin.sym} 8660 12640 0 0 {name=l40539 lab=VDD}
N 8640 12560 8660 12560 {}
C {lab_pin.sym} 8660 12560 0 0 {name=l40540 lab=VSS}
C {bitcell_6t.sym} 8800 12600 0 0 {name=Xr63c44}
N 8760 12640 8740 12640 {}
C {lab_pin.sym} 8740 12640 0 0 {name=l40541 lab=BL44}
N 8760 12600 8740 12600 {}
C {lab_pin.sym} 8740 12600 0 0 {name=l40542 lab=BLB44}
N 8760 12560 8740 12560 {}
C {lab_pin.sym} 8740 12560 0 0 {name=l40543 lab=WL63}
N 8840 12640 8860 12640 {}
C {lab_pin.sym} 8860 12640 0 0 {name=l40544 lab=VDD}
N 8840 12560 8860 12560 {}
C {lab_pin.sym} 8860 12560 0 0 {name=l40545 lab=VSS}
C {bitcell_6t.sym} 9000 12600 0 0 {name=Xr63c45}
N 8960 12640 8940 12640 {}
C {lab_pin.sym} 8940 12640 0 0 {name=l40546 lab=BL45}
N 8960 12600 8940 12600 {}
C {lab_pin.sym} 8940 12600 0 0 {name=l40547 lab=BLB45}
N 8960 12560 8940 12560 {}
C {lab_pin.sym} 8940 12560 0 0 {name=l40548 lab=WL63}
N 9040 12640 9060 12640 {}
C {lab_pin.sym} 9060 12640 0 0 {name=l40549 lab=VDD}
N 9040 12560 9060 12560 {}
C {lab_pin.sym} 9060 12560 0 0 {name=l40550 lab=VSS}
C {bitcell_6t.sym} 9200 12600 0 0 {name=Xr63c46}
N 9160 12640 9140 12640 {}
C {lab_pin.sym} 9140 12640 0 0 {name=l40551 lab=BL46}
N 9160 12600 9140 12600 {}
C {lab_pin.sym} 9140 12600 0 0 {name=l40552 lab=BLB46}
N 9160 12560 9140 12560 {}
C {lab_pin.sym} 9140 12560 0 0 {name=l40553 lab=WL63}
N 9240 12640 9260 12640 {}
C {lab_pin.sym} 9260 12640 0 0 {name=l40554 lab=VDD}
N 9240 12560 9260 12560 {}
C {lab_pin.sym} 9260 12560 0 0 {name=l40555 lab=VSS}
C {bitcell_6t.sym} 9400 12600 0 0 {name=Xr63c47}
N 9360 12640 9340 12640 {}
C {lab_pin.sym} 9340 12640 0 0 {name=l40556 lab=BL47}
N 9360 12600 9340 12600 {}
C {lab_pin.sym} 9340 12600 0 0 {name=l40557 lab=BLB47}
N 9360 12560 9340 12560 {}
C {lab_pin.sym} 9340 12560 0 0 {name=l40558 lab=WL63}
N 9440 12640 9460 12640 {}
C {lab_pin.sym} 9460 12640 0 0 {name=l40559 lab=VDD}
N 9440 12560 9460 12560 {}
C {lab_pin.sym} 9460 12560 0 0 {name=l40560 lab=VSS}
C {bitcell_6t.sym} 9600 12600 0 0 {name=Xr63c48}
N 9560 12640 9540 12640 {}
C {lab_pin.sym} 9540 12640 0 0 {name=l40561 lab=BL48}
N 9560 12600 9540 12600 {}
C {lab_pin.sym} 9540 12600 0 0 {name=l40562 lab=BLB48}
N 9560 12560 9540 12560 {}
C {lab_pin.sym} 9540 12560 0 0 {name=l40563 lab=WL63}
N 9640 12640 9660 12640 {}
C {lab_pin.sym} 9660 12640 0 0 {name=l40564 lab=VDD}
N 9640 12560 9660 12560 {}
C {lab_pin.sym} 9660 12560 0 0 {name=l40565 lab=VSS}
C {bitcell_6t.sym} 9800 12600 0 0 {name=Xr63c49}
N 9760 12640 9740 12640 {}
C {lab_pin.sym} 9740 12640 0 0 {name=l40566 lab=BL49}
N 9760 12600 9740 12600 {}
C {lab_pin.sym} 9740 12600 0 0 {name=l40567 lab=BLB49}
N 9760 12560 9740 12560 {}
C {lab_pin.sym} 9740 12560 0 0 {name=l40568 lab=WL63}
N 9840 12640 9860 12640 {}
C {lab_pin.sym} 9860 12640 0 0 {name=l40569 lab=VDD}
N 9840 12560 9860 12560 {}
C {lab_pin.sym} 9860 12560 0 0 {name=l40570 lab=VSS}
C {bitcell_6t.sym} 10000 12600 0 0 {name=Xr63c50}
N 9960 12640 9940 12640 {}
C {lab_pin.sym} 9940 12640 0 0 {name=l40571 lab=BL50}
N 9960 12600 9940 12600 {}
C {lab_pin.sym} 9940 12600 0 0 {name=l40572 lab=BLB50}
N 9960 12560 9940 12560 {}
C {lab_pin.sym} 9940 12560 0 0 {name=l40573 lab=WL63}
N 10040 12640 10060 12640 {}
C {lab_pin.sym} 10060 12640 0 0 {name=l40574 lab=VDD}
N 10040 12560 10060 12560 {}
C {lab_pin.sym} 10060 12560 0 0 {name=l40575 lab=VSS}
C {bitcell_6t.sym} 10200 12600 0 0 {name=Xr63c51}
N 10160 12640 10140 12640 {}
C {lab_pin.sym} 10140 12640 0 0 {name=l40576 lab=BL51}
N 10160 12600 10140 12600 {}
C {lab_pin.sym} 10140 12600 0 0 {name=l40577 lab=BLB51}
N 10160 12560 10140 12560 {}
C {lab_pin.sym} 10140 12560 0 0 {name=l40578 lab=WL63}
N 10240 12640 10260 12640 {}
C {lab_pin.sym} 10260 12640 0 0 {name=l40579 lab=VDD}
N 10240 12560 10260 12560 {}
C {lab_pin.sym} 10260 12560 0 0 {name=l40580 lab=VSS}
C {bitcell_6t.sym} 10400 12600 0 0 {name=Xr63c52}
N 10360 12640 10340 12640 {}
C {lab_pin.sym} 10340 12640 0 0 {name=l40581 lab=BL52}
N 10360 12600 10340 12600 {}
C {lab_pin.sym} 10340 12600 0 0 {name=l40582 lab=BLB52}
N 10360 12560 10340 12560 {}
C {lab_pin.sym} 10340 12560 0 0 {name=l40583 lab=WL63}
N 10440 12640 10460 12640 {}
C {lab_pin.sym} 10460 12640 0 0 {name=l40584 lab=VDD}
N 10440 12560 10460 12560 {}
C {lab_pin.sym} 10460 12560 0 0 {name=l40585 lab=VSS}
C {bitcell_6t.sym} 10600 12600 0 0 {name=Xr63c53}
N 10560 12640 10540 12640 {}
C {lab_pin.sym} 10540 12640 0 0 {name=l40586 lab=BL53}
N 10560 12600 10540 12600 {}
C {lab_pin.sym} 10540 12600 0 0 {name=l40587 lab=BLB53}
N 10560 12560 10540 12560 {}
C {lab_pin.sym} 10540 12560 0 0 {name=l40588 lab=WL63}
N 10640 12640 10660 12640 {}
C {lab_pin.sym} 10660 12640 0 0 {name=l40589 lab=VDD}
N 10640 12560 10660 12560 {}
C {lab_pin.sym} 10660 12560 0 0 {name=l40590 lab=VSS}
C {bitcell_6t.sym} 10800 12600 0 0 {name=Xr63c54}
N 10760 12640 10740 12640 {}
C {lab_pin.sym} 10740 12640 0 0 {name=l40591 lab=BL54}
N 10760 12600 10740 12600 {}
C {lab_pin.sym} 10740 12600 0 0 {name=l40592 lab=BLB54}
N 10760 12560 10740 12560 {}
C {lab_pin.sym} 10740 12560 0 0 {name=l40593 lab=WL63}
N 10840 12640 10860 12640 {}
C {lab_pin.sym} 10860 12640 0 0 {name=l40594 lab=VDD}
N 10840 12560 10860 12560 {}
C {lab_pin.sym} 10860 12560 0 0 {name=l40595 lab=VSS}
C {bitcell_6t.sym} 11000 12600 0 0 {name=Xr63c55}
N 10960 12640 10940 12640 {}
C {lab_pin.sym} 10940 12640 0 0 {name=l40596 lab=BL55}
N 10960 12600 10940 12600 {}
C {lab_pin.sym} 10940 12600 0 0 {name=l40597 lab=BLB55}
N 10960 12560 10940 12560 {}
C {lab_pin.sym} 10940 12560 0 0 {name=l40598 lab=WL63}
N 11040 12640 11060 12640 {}
C {lab_pin.sym} 11060 12640 0 0 {name=l40599 lab=VDD}
N 11040 12560 11060 12560 {}
C {lab_pin.sym} 11060 12560 0 0 {name=l40600 lab=VSS}
C {bitcell_6t.sym} 11200 12600 0 0 {name=Xr63c56}
N 11160 12640 11140 12640 {}
C {lab_pin.sym} 11140 12640 0 0 {name=l40601 lab=BL56}
N 11160 12600 11140 12600 {}
C {lab_pin.sym} 11140 12600 0 0 {name=l40602 lab=BLB56}
N 11160 12560 11140 12560 {}
C {lab_pin.sym} 11140 12560 0 0 {name=l40603 lab=WL63}
N 11240 12640 11260 12640 {}
C {lab_pin.sym} 11260 12640 0 0 {name=l40604 lab=VDD}
N 11240 12560 11260 12560 {}
C {lab_pin.sym} 11260 12560 0 0 {name=l40605 lab=VSS}
C {bitcell_6t.sym} 11400 12600 0 0 {name=Xr63c57}
N 11360 12640 11340 12640 {}
C {lab_pin.sym} 11340 12640 0 0 {name=l40606 lab=BL57}
N 11360 12600 11340 12600 {}
C {lab_pin.sym} 11340 12600 0 0 {name=l40607 lab=BLB57}
N 11360 12560 11340 12560 {}
C {lab_pin.sym} 11340 12560 0 0 {name=l40608 lab=WL63}
N 11440 12640 11460 12640 {}
C {lab_pin.sym} 11460 12640 0 0 {name=l40609 lab=VDD}
N 11440 12560 11460 12560 {}
C {lab_pin.sym} 11460 12560 0 0 {name=l40610 lab=VSS}
C {bitcell_6t.sym} 11600 12600 0 0 {name=Xr63c58}
N 11560 12640 11540 12640 {}
C {lab_pin.sym} 11540 12640 0 0 {name=l40611 lab=BL58}
N 11560 12600 11540 12600 {}
C {lab_pin.sym} 11540 12600 0 0 {name=l40612 lab=BLB58}
N 11560 12560 11540 12560 {}
C {lab_pin.sym} 11540 12560 0 0 {name=l40613 lab=WL63}
N 11640 12640 11660 12640 {}
C {lab_pin.sym} 11660 12640 0 0 {name=l40614 lab=VDD}
N 11640 12560 11660 12560 {}
C {lab_pin.sym} 11660 12560 0 0 {name=l40615 lab=VSS}
C {bitcell_6t.sym} 11800 12600 0 0 {name=Xr63c59}
N 11760 12640 11740 12640 {}
C {lab_pin.sym} 11740 12640 0 0 {name=l40616 lab=BL59}
N 11760 12600 11740 12600 {}
C {lab_pin.sym} 11740 12600 0 0 {name=l40617 lab=BLB59}
N 11760 12560 11740 12560 {}
C {lab_pin.sym} 11740 12560 0 0 {name=l40618 lab=WL63}
N 11840 12640 11860 12640 {}
C {lab_pin.sym} 11860 12640 0 0 {name=l40619 lab=VDD}
N 11840 12560 11860 12560 {}
C {lab_pin.sym} 11860 12560 0 0 {name=l40620 lab=VSS}
C {bitcell_6t.sym} 12000 12600 0 0 {name=Xr63c60}
N 11960 12640 11940 12640 {}
C {lab_pin.sym} 11940 12640 0 0 {name=l40621 lab=BL60}
N 11960 12600 11940 12600 {}
C {lab_pin.sym} 11940 12600 0 0 {name=l40622 lab=BLB60}
N 11960 12560 11940 12560 {}
C {lab_pin.sym} 11940 12560 0 0 {name=l40623 lab=WL63}
N 12040 12640 12060 12640 {}
C {lab_pin.sym} 12060 12640 0 0 {name=l40624 lab=VDD}
N 12040 12560 12060 12560 {}
C {lab_pin.sym} 12060 12560 0 0 {name=l40625 lab=VSS}
C {bitcell_6t.sym} 12200 12600 0 0 {name=Xr63c61}
N 12160 12640 12140 12640 {}
C {lab_pin.sym} 12140 12640 0 0 {name=l40626 lab=BL61}
N 12160 12600 12140 12600 {}
C {lab_pin.sym} 12140 12600 0 0 {name=l40627 lab=BLB61}
N 12160 12560 12140 12560 {}
C {lab_pin.sym} 12140 12560 0 0 {name=l40628 lab=WL63}
N 12240 12640 12260 12640 {}
C {lab_pin.sym} 12260 12640 0 0 {name=l40629 lab=VDD}
N 12240 12560 12260 12560 {}
C {lab_pin.sym} 12260 12560 0 0 {name=l40630 lab=VSS}
C {bitcell_6t.sym} 12400 12600 0 0 {name=Xr63c62}
N 12360 12640 12340 12640 {}
C {lab_pin.sym} 12340 12640 0 0 {name=l40631 lab=BL62}
N 12360 12600 12340 12600 {}
C {lab_pin.sym} 12340 12600 0 0 {name=l40632 lab=BLB62}
N 12360 12560 12340 12560 {}
C {lab_pin.sym} 12340 12560 0 0 {name=l40633 lab=WL63}
N 12440 12640 12460 12640 {}
C {lab_pin.sym} 12460 12640 0 0 {name=l40634 lab=VDD}
N 12440 12560 12460 12560 {}
C {lab_pin.sym} 12460 12560 0 0 {name=l40635 lab=VSS}
C {bitcell_6t.sym} 12600 12600 0 0 {name=Xr63c63}
N 12560 12640 12540 12640 {}
C {lab_pin.sym} 12540 12640 0 0 {name=l40636 lab=BL63}
N 12560 12600 12540 12600 {}
C {lab_pin.sym} 12540 12600 0 0 {name=l40637 lab=BLB63}
N 12560 12560 12540 12560 {}
C {lab_pin.sym} 12540 12560 0 0 {name=l40638 lab=WL63}
N 12640 12640 12660 12640 {}
C {lab_pin.sym} 12660 12640 0 0 {name=l40639 lab=VDD}
N 12640 12560 12660 12560 {}
C {lab_pin.sym} 12660 12560 0 0 {name=l40640 lab=VSS}
C {bitcell_6t.sym} 12800 12600 0 0 {name=Xr63c64}
N 12760 12640 12740 12640 {}
C {lab_pin.sym} 12740 12640 0 0 {name=l40641 lab=BL64}
N 12760 12600 12740 12600 {}
C {lab_pin.sym} 12740 12600 0 0 {name=l40642 lab=BLB64}
N 12760 12560 12740 12560 {}
C {lab_pin.sym} 12740 12560 0 0 {name=l40643 lab=WL63}
N 12840 12640 12860 12640 {}
C {lab_pin.sym} 12860 12640 0 0 {name=l40644 lab=VDD}
N 12840 12560 12860 12560 {}
C {lab_pin.sym} 12860 12560 0 0 {name=l40645 lab=VSS}
C {bitcell_6t.sym} 13000 12600 0 0 {name=Xr63c65}
N 12960 12640 12940 12640 {}
C {lab_pin.sym} 12940 12640 0 0 {name=l40646 lab=BL65}
N 12960 12600 12940 12600 {}
C {lab_pin.sym} 12940 12600 0 0 {name=l40647 lab=BLB65}
N 12960 12560 12940 12560 {}
C {lab_pin.sym} 12940 12560 0 0 {name=l40648 lab=WL63}
N 13040 12640 13060 12640 {}
C {lab_pin.sym} 13060 12640 0 0 {name=l40649 lab=VDD}
N 13040 12560 13060 12560 {}
C {lab_pin.sym} 13060 12560 0 0 {name=l40650 lab=VSS}
C {bitcell_6t.sym} 13200 12600 0 0 {name=Xr63c66}
N 13160 12640 13140 12640 {}
C {lab_pin.sym} 13140 12640 0 0 {name=l40651 lab=BL66}
N 13160 12600 13140 12600 {}
C {lab_pin.sym} 13140 12600 0 0 {name=l40652 lab=BLB66}
N 13160 12560 13140 12560 {}
C {lab_pin.sym} 13140 12560 0 0 {name=l40653 lab=WL63}
N 13240 12640 13260 12640 {}
C {lab_pin.sym} 13260 12640 0 0 {name=l40654 lab=VDD}
N 13240 12560 13260 12560 {}
C {lab_pin.sym} 13260 12560 0 0 {name=l40655 lab=VSS}
C {bitcell_6t.sym} 13400 12600 0 0 {name=Xr63c67}
N 13360 12640 13340 12640 {}
C {lab_pin.sym} 13340 12640 0 0 {name=l40656 lab=BL67}
N 13360 12600 13340 12600 {}
C {lab_pin.sym} 13340 12600 0 0 {name=l40657 lab=BLB67}
N 13360 12560 13340 12560 {}
C {lab_pin.sym} 13340 12560 0 0 {name=l40658 lab=WL63}
N 13440 12640 13460 12640 {}
C {lab_pin.sym} 13460 12640 0 0 {name=l40659 lab=VDD}
N 13440 12560 13460 12560 {}
C {lab_pin.sym} 13460 12560 0 0 {name=l40660 lab=VSS}
C {bitcell_6t.sym} 13600 12600 0 0 {name=Xr63c68}
N 13560 12640 13540 12640 {}
C {lab_pin.sym} 13540 12640 0 0 {name=l40661 lab=BL68}
N 13560 12600 13540 12600 {}
C {lab_pin.sym} 13540 12600 0 0 {name=l40662 lab=BLB68}
N 13560 12560 13540 12560 {}
C {lab_pin.sym} 13540 12560 0 0 {name=l40663 lab=WL63}
N 13640 12640 13660 12640 {}
C {lab_pin.sym} 13660 12640 0 0 {name=l40664 lab=VDD}
N 13640 12560 13660 12560 {}
C {lab_pin.sym} 13660 12560 0 0 {name=l40665 lab=VSS}
C {bitcell_6t.sym} 13800 12600 0 0 {name=Xr63c69}
N 13760 12640 13740 12640 {}
C {lab_pin.sym} 13740 12640 0 0 {name=l40666 lab=BL69}
N 13760 12600 13740 12600 {}
C {lab_pin.sym} 13740 12600 0 0 {name=l40667 lab=BLB69}
N 13760 12560 13740 12560 {}
C {lab_pin.sym} 13740 12560 0 0 {name=l40668 lab=WL63}
N 13840 12640 13860 12640 {}
C {lab_pin.sym} 13860 12640 0 0 {name=l40669 lab=VDD}
N 13840 12560 13860 12560 {}
C {lab_pin.sym} 13860 12560 0 0 {name=l40670 lab=VSS}
C {bitcell_6t.sym} 14000 12600 0 0 {name=Xr63c70}
N 13960 12640 13940 12640 {}
C {lab_pin.sym} 13940 12640 0 0 {name=l40671 lab=BL70}
N 13960 12600 13940 12600 {}
C {lab_pin.sym} 13940 12600 0 0 {name=l40672 lab=BLB70}
N 13960 12560 13940 12560 {}
C {lab_pin.sym} 13940 12560 0 0 {name=l40673 lab=WL63}
N 14040 12640 14060 12640 {}
C {lab_pin.sym} 14060 12640 0 0 {name=l40674 lab=VDD}
N 14040 12560 14060 12560 {}
C {lab_pin.sym} 14060 12560 0 0 {name=l40675 lab=VSS}
C {bitcell_6t.sym} 14200 12600 0 0 {name=Xr63c71}
N 14160 12640 14140 12640 {}
C {lab_pin.sym} 14140 12640 0 0 {name=l40676 lab=BL71}
N 14160 12600 14140 12600 {}
C {lab_pin.sym} 14140 12600 0 0 {name=l40677 lab=BLB71}
N 14160 12560 14140 12560 {}
C {lab_pin.sym} 14140 12560 0 0 {name=l40678 lab=WL63}
N 14240 12640 14260 12640 {}
C {lab_pin.sym} 14260 12640 0 0 {name=l40679 lab=VDD}
N 14240 12560 14260 12560 {}
C {lab_pin.sym} 14260 12560 0 0 {name=l40680 lab=VSS}
C {bitcell_6t.sym} 14400 12600 0 0 {name=Xr63c72}
N 14360 12640 14340 12640 {}
C {lab_pin.sym} 14340 12640 0 0 {name=l40681 lab=BL72}
N 14360 12600 14340 12600 {}
C {lab_pin.sym} 14340 12600 0 0 {name=l40682 lab=BLB72}
N 14360 12560 14340 12560 {}
C {lab_pin.sym} 14340 12560 0 0 {name=l40683 lab=WL63}
N 14440 12640 14460 12640 {}
C {lab_pin.sym} 14460 12640 0 0 {name=l40684 lab=VDD}
N 14440 12560 14460 12560 {}
C {lab_pin.sym} 14460 12560 0 0 {name=l40685 lab=VSS}
C {bitcell_6t.sym} 14600 12600 0 0 {name=Xr63c73}
N 14560 12640 14540 12640 {}
C {lab_pin.sym} 14540 12640 0 0 {name=l40686 lab=BL73}
N 14560 12600 14540 12600 {}
C {lab_pin.sym} 14540 12600 0 0 {name=l40687 lab=BLB73}
N 14560 12560 14540 12560 {}
C {lab_pin.sym} 14540 12560 0 0 {name=l40688 lab=WL63}
N 14640 12640 14660 12640 {}
C {lab_pin.sym} 14660 12640 0 0 {name=l40689 lab=VDD}
N 14640 12560 14660 12560 {}
C {lab_pin.sym} 14660 12560 0 0 {name=l40690 lab=VSS}
C {bitcell_6t.sym} 14800 12600 0 0 {name=Xr63c74}
N 14760 12640 14740 12640 {}
C {lab_pin.sym} 14740 12640 0 0 {name=l40691 lab=BL74}
N 14760 12600 14740 12600 {}
C {lab_pin.sym} 14740 12600 0 0 {name=l40692 lab=BLB74}
N 14760 12560 14740 12560 {}
C {lab_pin.sym} 14740 12560 0 0 {name=l40693 lab=WL63}
N 14840 12640 14860 12640 {}
C {lab_pin.sym} 14860 12640 0 0 {name=l40694 lab=VDD}
N 14840 12560 14860 12560 {}
C {lab_pin.sym} 14860 12560 0 0 {name=l40695 lab=VSS}
C {bitcell_6t.sym} 15000 12600 0 0 {name=Xr63c75}
N 14960 12640 14940 12640 {}
C {lab_pin.sym} 14940 12640 0 0 {name=l40696 lab=BL75}
N 14960 12600 14940 12600 {}
C {lab_pin.sym} 14940 12600 0 0 {name=l40697 lab=BLB75}
N 14960 12560 14940 12560 {}
C {lab_pin.sym} 14940 12560 0 0 {name=l40698 lab=WL63}
N 15040 12640 15060 12640 {}
C {lab_pin.sym} 15060 12640 0 0 {name=l40699 lab=VDD}
N 15040 12560 15060 12560 {}
C {lab_pin.sym} 15060 12560 0 0 {name=l40700 lab=VSS}
C {bitcell_6t.sym} 15200 12600 0 0 {name=Xr63c76}
N 15160 12640 15140 12640 {}
C {lab_pin.sym} 15140 12640 0 0 {name=l40701 lab=BL76}
N 15160 12600 15140 12600 {}
C {lab_pin.sym} 15140 12600 0 0 {name=l40702 lab=BLB76}
N 15160 12560 15140 12560 {}
C {lab_pin.sym} 15140 12560 0 0 {name=l40703 lab=WL63}
N 15240 12640 15260 12640 {}
C {lab_pin.sym} 15260 12640 0 0 {name=l40704 lab=VDD}
N 15240 12560 15260 12560 {}
C {lab_pin.sym} 15260 12560 0 0 {name=l40705 lab=VSS}
C {bitcell_6t.sym} 15400 12600 0 0 {name=Xr63c77}
N 15360 12640 15340 12640 {}
C {lab_pin.sym} 15340 12640 0 0 {name=l40706 lab=BL77}
N 15360 12600 15340 12600 {}
C {lab_pin.sym} 15340 12600 0 0 {name=l40707 lab=BLB77}
N 15360 12560 15340 12560 {}
C {lab_pin.sym} 15340 12560 0 0 {name=l40708 lab=WL63}
N 15440 12640 15460 12640 {}
C {lab_pin.sym} 15460 12640 0 0 {name=l40709 lab=VDD}
N 15440 12560 15460 12560 {}
C {lab_pin.sym} 15460 12560 0 0 {name=l40710 lab=VSS}
C {bitcell_6t.sym} 15600 12600 0 0 {name=Xr63c78}
N 15560 12640 15540 12640 {}
C {lab_pin.sym} 15540 12640 0 0 {name=l40711 lab=BL78}
N 15560 12600 15540 12600 {}
C {lab_pin.sym} 15540 12600 0 0 {name=l40712 lab=BLB78}
N 15560 12560 15540 12560 {}
C {lab_pin.sym} 15540 12560 0 0 {name=l40713 lab=WL63}
N 15640 12640 15660 12640 {}
C {lab_pin.sym} 15660 12640 0 0 {name=l40714 lab=VDD}
N 15640 12560 15660 12560 {}
C {lab_pin.sym} 15660 12560 0 0 {name=l40715 lab=VSS}
C {bitcell_6t.sym} 15800 12600 0 0 {name=Xr63c79}
N 15760 12640 15740 12640 {}
C {lab_pin.sym} 15740 12640 0 0 {name=l40716 lab=BL79}
N 15760 12600 15740 12600 {}
C {lab_pin.sym} 15740 12600 0 0 {name=l40717 lab=BLB79}
N 15760 12560 15740 12560 {}
C {lab_pin.sym} 15740 12560 0 0 {name=l40718 lab=WL63}
N 15840 12640 15860 12640 {}
C {lab_pin.sym} 15860 12640 0 0 {name=l40719 lab=VDD}
N 15840 12560 15860 12560 {}
C {lab_pin.sym} 15860 12560 0 0 {name=l40720 lab=VSS}
C {bitcell_6t.sym} 16000 12600 0 0 {name=Xr63c80}
N 15960 12640 15940 12640 {}
C {lab_pin.sym} 15940 12640 0 0 {name=l40721 lab=BL80}
N 15960 12600 15940 12600 {}
C {lab_pin.sym} 15940 12600 0 0 {name=l40722 lab=BLB80}
N 15960 12560 15940 12560 {}
C {lab_pin.sym} 15940 12560 0 0 {name=l40723 lab=WL63}
N 16040 12640 16060 12640 {}
C {lab_pin.sym} 16060 12640 0 0 {name=l40724 lab=VDD}
N 16040 12560 16060 12560 {}
C {lab_pin.sym} 16060 12560 0 0 {name=l40725 lab=VSS}
C {bitcell_6t.sym} 16200 12600 0 0 {name=Xr63c81}
N 16160 12640 16140 12640 {}
C {lab_pin.sym} 16140 12640 0 0 {name=l40726 lab=BL81}
N 16160 12600 16140 12600 {}
C {lab_pin.sym} 16140 12600 0 0 {name=l40727 lab=BLB81}
N 16160 12560 16140 12560 {}
C {lab_pin.sym} 16140 12560 0 0 {name=l40728 lab=WL63}
N 16240 12640 16260 12640 {}
C {lab_pin.sym} 16260 12640 0 0 {name=l40729 lab=VDD}
N 16240 12560 16260 12560 {}
C {lab_pin.sym} 16260 12560 0 0 {name=l40730 lab=VSS}
C {bitcell_6t.sym} 16400 12600 0 0 {name=Xr63c82}
N 16360 12640 16340 12640 {}
C {lab_pin.sym} 16340 12640 0 0 {name=l40731 lab=BL82}
N 16360 12600 16340 12600 {}
C {lab_pin.sym} 16340 12600 0 0 {name=l40732 lab=BLB82}
N 16360 12560 16340 12560 {}
C {lab_pin.sym} 16340 12560 0 0 {name=l40733 lab=WL63}
N 16440 12640 16460 12640 {}
C {lab_pin.sym} 16460 12640 0 0 {name=l40734 lab=VDD}
N 16440 12560 16460 12560 {}
C {lab_pin.sym} 16460 12560 0 0 {name=l40735 lab=VSS}
C {bitcell_6t.sym} 16600 12600 0 0 {name=Xr63c83}
N 16560 12640 16540 12640 {}
C {lab_pin.sym} 16540 12640 0 0 {name=l40736 lab=BL83}
N 16560 12600 16540 12600 {}
C {lab_pin.sym} 16540 12600 0 0 {name=l40737 lab=BLB83}
N 16560 12560 16540 12560 {}
C {lab_pin.sym} 16540 12560 0 0 {name=l40738 lab=WL63}
N 16640 12640 16660 12640 {}
C {lab_pin.sym} 16660 12640 0 0 {name=l40739 lab=VDD}
N 16640 12560 16660 12560 {}
C {lab_pin.sym} 16660 12560 0 0 {name=l40740 lab=VSS}
C {bitcell_6t.sym} 16800 12600 0 0 {name=Xr63c84}
N 16760 12640 16740 12640 {}
C {lab_pin.sym} 16740 12640 0 0 {name=l40741 lab=BL84}
N 16760 12600 16740 12600 {}
C {lab_pin.sym} 16740 12600 0 0 {name=l40742 lab=BLB84}
N 16760 12560 16740 12560 {}
C {lab_pin.sym} 16740 12560 0 0 {name=l40743 lab=WL63}
N 16840 12640 16860 12640 {}
C {lab_pin.sym} 16860 12640 0 0 {name=l40744 lab=VDD}
N 16840 12560 16860 12560 {}
C {lab_pin.sym} 16860 12560 0 0 {name=l40745 lab=VSS}
C {bitcell_6t.sym} 17000 12600 0 0 {name=Xr63c85}
N 16960 12640 16940 12640 {}
C {lab_pin.sym} 16940 12640 0 0 {name=l40746 lab=BL85}
N 16960 12600 16940 12600 {}
C {lab_pin.sym} 16940 12600 0 0 {name=l40747 lab=BLB85}
N 16960 12560 16940 12560 {}
C {lab_pin.sym} 16940 12560 0 0 {name=l40748 lab=WL63}
N 17040 12640 17060 12640 {}
C {lab_pin.sym} 17060 12640 0 0 {name=l40749 lab=VDD}
N 17040 12560 17060 12560 {}
C {lab_pin.sym} 17060 12560 0 0 {name=l40750 lab=VSS}
C {bitcell_6t.sym} 17200 12600 0 0 {name=Xr63c86}
N 17160 12640 17140 12640 {}
C {lab_pin.sym} 17140 12640 0 0 {name=l40751 lab=BL86}
N 17160 12600 17140 12600 {}
C {lab_pin.sym} 17140 12600 0 0 {name=l40752 lab=BLB86}
N 17160 12560 17140 12560 {}
C {lab_pin.sym} 17140 12560 0 0 {name=l40753 lab=WL63}
N 17240 12640 17260 12640 {}
C {lab_pin.sym} 17260 12640 0 0 {name=l40754 lab=VDD}
N 17240 12560 17260 12560 {}
C {lab_pin.sym} 17260 12560 0 0 {name=l40755 lab=VSS}
C {bitcell_6t.sym} 17400 12600 0 0 {name=Xr63c87}
N 17360 12640 17340 12640 {}
C {lab_pin.sym} 17340 12640 0 0 {name=l40756 lab=BL87}
N 17360 12600 17340 12600 {}
C {lab_pin.sym} 17340 12600 0 0 {name=l40757 lab=BLB87}
N 17360 12560 17340 12560 {}
C {lab_pin.sym} 17340 12560 0 0 {name=l40758 lab=WL63}
N 17440 12640 17460 12640 {}
C {lab_pin.sym} 17460 12640 0 0 {name=l40759 lab=VDD}
N 17440 12560 17460 12560 {}
C {lab_pin.sym} 17460 12560 0 0 {name=l40760 lab=VSS}
C {bitcell_6t.sym} 17600 12600 0 0 {name=Xr63c88}
N 17560 12640 17540 12640 {}
C {lab_pin.sym} 17540 12640 0 0 {name=l40761 lab=BL88}
N 17560 12600 17540 12600 {}
C {lab_pin.sym} 17540 12600 0 0 {name=l40762 lab=BLB88}
N 17560 12560 17540 12560 {}
C {lab_pin.sym} 17540 12560 0 0 {name=l40763 lab=WL63}
N 17640 12640 17660 12640 {}
C {lab_pin.sym} 17660 12640 0 0 {name=l40764 lab=VDD}
N 17640 12560 17660 12560 {}
C {lab_pin.sym} 17660 12560 0 0 {name=l40765 lab=VSS}
C {bitcell_6t.sym} 17800 12600 0 0 {name=Xr63c89}
N 17760 12640 17740 12640 {}
C {lab_pin.sym} 17740 12640 0 0 {name=l40766 lab=BL89}
N 17760 12600 17740 12600 {}
C {lab_pin.sym} 17740 12600 0 0 {name=l40767 lab=BLB89}
N 17760 12560 17740 12560 {}
C {lab_pin.sym} 17740 12560 0 0 {name=l40768 lab=WL63}
N 17840 12640 17860 12640 {}
C {lab_pin.sym} 17860 12640 0 0 {name=l40769 lab=VDD}
N 17840 12560 17860 12560 {}
C {lab_pin.sym} 17860 12560 0 0 {name=l40770 lab=VSS}
C {bitcell_6t.sym} 18000 12600 0 0 {name=Xr63c90}
N 17960 12640 17940 12640 {}
C {lab_pin.sym} 17940 12640 0 0 {name=l40771 lab=BL90}
N 17960 12600 17940 12600 {}
C {lab_pin.sym} 17940 12600 0 0 {name=l40772 lab=BLB90}
N 17960 12560 17940 12560 {}
C {lab_pin.sym} 17940 12560 0 0 {name=l40773 lab=WL63}
N 18040 12640 18060 12640 {}
C {lab_pin.sym} 18060 12640 0 0 {name=l40774 lab=VDD}
N 18040 12560 18060 12560 {}
C {lab_pin.sym} 18060 12560 0 0 {name=l40775 lab=VSS}
C {bitcell_6t.sym} 18200 12600 0 0 {name=Xr63c91}
N 18160 12640 18140 12640 {}
C {lab_pin.sym} 18140 12640 0 0 {name=l40776 lab=BL91}
N 18160 12600 18140 12600 {}
C {lab_pin.sym} 18140 12600 0 0 {name=l40777 lab=BLB91}
N 18160 12560 18140 12560 {}
C {lab_pin.sym} 18140 12560 0 0 {name=l40778 lab=WL63}
N 18240 12640 18260 12640 {}
C {lab_pin.sym} 18260 12640 0 0 {name=l40779 lab=VDD}
N 18240 12560 18260 12560 {}
C {lab_pin.sym} 18260 12560 0 0 {name=l40780 lab=VSS}
C {bitcell_6t.sym} 18400 12600 0 0 {name=Xr63c92}
N 18360 12640 18340 12640 {}
C {lab_pin.sym} 18340 12640 0 0 {name=l40781 lab=BL92}
N 18360 12600 18340 12600 {}
C {lab_pin.sym} 18340 12600 0 0 {name=l40782 lab=BLB92}
N 18360 12560 18340 12560 {}
C {lab_pin.sym} 18340 12560 0 0 {name=l40783 lab=WL63}
N 18440 12640 18460 12640 {}
C {lab_pin.sym} 18460 12640 0 0 {name=l40784 lab=VDD}
N 18440 12560 18460 12560 {}
C {lab_pin.sym} 18460 12560 0 0 {name=l40785 lab=VSS}
C {bitcell_6t.sym} 18600 12600 0 0 {name=Xr63c93}
N 18560 12640 18540 12640 {}
C {lab_pin.sym} 18540 12640 0 0 {name=l40786 lab=BL93}
N 18560 12600 18540 12600 {}
C {lab_pin.sym} 18540 12600 0 0 {name=l40787 lab=BLB93}
N 18560 12560 18540 12560 {}
C {lab_pin.sym} 18540 12560 0 0 {name=l40788 lab=WL63}
N 18640 12640 18660 12640 {}
C {lab_pin.sym} 18660 12640 0 0 {name=l40789 lab=VDD}
N 18640 12560 18660 12560 {}
C {lab_pin.sym} 18660 12560 0 0 {name=l40790 lab=VSS}
C {bitcell_6t.sym} 18800 12600 0 0 {name=Xr63c94}
N 18760 12640 18740 12640 {}
C {lab_pin.sym} 18740 12640 0 0 {name=l40791 lab=BL94}
N 18760 12600 18740 12600 {}
C {lab_pin.sym} 18740 12600 0 0 {name=l40792 lab=BLB94}
N 18760 12560 18740 12560 {}
C {lab_pin.sym} 18740 12560 0 0 {name=l40793 lab=WL63}
N 18840 12640 18860 12640 {}
C {lab_pin.sym} 18860 12640 0 0 {name=l40794 lab=VDD}
N 18840 12560 18860 12560 {}
C {lab_pin.sym} 18860 12560 0 0 {name=l40795 lab=VSS}
C {bitcell_6t.sym} 19000 12600 0 0 {name=Xr63c95}
N 18960 12640 18940 12640 {}
C {lab_pin.sym} 18940 12640 0 0 {name=l40796 lab=BL95}
N 18960 12600 18940 12600 {}
C {lab_pin.sym} 18940 12600 0 0 {name=l40797 lab=BLB95}
N 18960 12560 18940 12560 {}
C {lab_pin.sym} 18940 12560 0 0 {name=l40798 lab=WL63}
N 19040 12640 19060 12640 {}
C {lab_pin.sym} 19060 12640 0 0 {name=l40799 lab=VDD}
N 19040 12560 19060 12560 {}
C {lab_pin.sym} 19060 12560 0 0 {name=l40800 lab=VSS}
C {bitcell_6t.sym} 19200 12600 0 0 {name=Xr63c96}
N 19160 12640 19140 12640 {}
C {lab_pin.sym} 19140 12640 0 0 {name=l40801 lab=BL96}
N 19160 12600 19140 12600 {}
C {lab_pin.sym} 19140 12600 0 0 {name=l40802 lab=BLB96}
N 19160 12560 19140 12560 {}
C {lab_pin.sym} 19140 12560 0 0 {name=l40803 lab=WL63}
N 19240 12640 19260 12640 {}
C {lab_pin.sym} 19260 12640 0 0 {name=l40804 lab=VDD}
N 19240 12560 19260 12560 {}
C {lab_pin.sym} 19260 12560 0 0 {name=l40805 lab=VSS}
C {bitcell_6t.sym} 19400 12600 0 0 {name=Xr63c97}
N 19360 12640 19340 12640 {}
C {lab_pin.sym} 19340 12640 0 0 {name=l40806 lab=BL97}
N 19360 12600 19340 12600 {}
C {lab_pin.sym} 19340 12600 0 0 {name=l40807 lab=BLB97}
N 19360 12560 19340 12560 {}
C {lab_pin.sym} 19340 12560 0 0 {name=l40808 lab=WL63}
N 19440 12640 19460 12640 {}
C {lab_pin.sym} 19460 12640 0 0 {name=l40809 lab=VDD}
N 19440 12560 19460 12560 {}
C {lab_pin.sym} 19460 12560 0 0 {name=l40810 lab=VSS}
C {bitcell_6t.sym} 19600 12600 0 0 {name=Xr63c98}
N 19560 12640 19540 12640 {}
C {lab_pin.sym} 19540 12640 0 0 {name=l40811 lab=BL98}
N 19560 12600 19540 12600 {}
C {lab_pin.sym} 19540 12600 0 0 {name=l40812 lab=BLB98}
N 19560 12560 19540 12560 {}
C {lab_pin.sym} 19540 12560 0 0 {name=l40813 lab=WL63}
N 19640 12640 19660 12640 {}
C {lab_pin.sym} 19660 12640 0 0 {name=l40814 lab=VDD}
N 19640 12560 19660 12560 {}
C {lab_pin.sym} 19660 12560 0 0 {name=l40815 lab=VSS}
C {bitcell_6t.sym} 19800 12600 0 0 {name=Xr63c99}
N 19760 12640 19740 12640 {}
C {lab_pin.sym} 19740 12640 0 0 {name=l40816 lab=BL99}
N 19760 12600 19740 12600 {}
C {lab_pin.sym} 19740 12600 0 0 {name=l40817 lab=BLB99}
N 19760 12560 19740 12560 {}
C {lab_pin.sym} 19740 12560 0 0 {name=l40818 lab=WL63}
N 19840 12640 19860 12640 {}
C {lab_pin.sym} 19860 12640 0 0 {name=l40819 lab=VDD}
N 19840 12560 19860 12560 {}
C {lab_pin.sym} 19860 12560 0 0 {name=l40820 lab=VSS}
C {bitcell_6t.sym} 20000 12600 0 0 {name=Xr63c100}
N 19960 12640 19940 12640 {}
C {lab_pin.sym} 19940 12640 0 0 {name=l40821 lab=BL100}
N 19960 12600 19940 12600 {}
C {lab_pin.sym} 19940 12600 0 0 {name=l40822 lab=BLB100}
N 19960 12560 19940 12560 {}
C {lab_pin.sym} 19940 12560 0 0 {name=l40823 lab=WL63}
N 20040 12640 20060 12640 {}
C {lab_pin.sym} 20060 12640 0 0 {name=l40824 lab=VDD}
N 20040 12560 20060 12560 {}
C {lab_pin.sym} 20060 12560 0 0 {name=l40825 lab=VSS}
C {bitcell_6t.sym} 20200 12600 0 0 {name=Xr63c101}
N 20160 12640 20140 12640 {}
C {lab_pin.sym} 20140 12640 0 0 {name=l40826 lab=BL101}
N 20160 12600 20140 12600 {}
C {lab_pin.sym} 20140 12600 0 0 {name=l40827 lab=BLB101}
N 20160 12560 20140 12560 {}
C {lab_pin.sym} 20140 12560 0 0 {name=l40828 lab=WL63}
N 20240 12640 20260 12640 {}
C {lab_pin.sym} 20260 12640 0 0 {name=l40829 lab=VDD}
N 20240 12560 20260 12560 {}
C {lab_pin.sym} 20260 12560 0 0 {name=l40830 lab=VSS}
C {bitcell_6t.sym} 20400 12600 0 0 {name=Xr63c102}
N 20360 12640 20340 12640 {}
C {lab_pin.sym} 20340 12640 0 0 {name=l40831 lab=BL102}
N 20360 12600 20340 12600 {}
C {lab_pin.sym} 20340 12600 0 0 {name=l40832 lab=BLB102}
N 20360 12560 20340 12560 {}
C {lab_pin.sym} 20340 12560 0 0 {name=l40833 lab=WL63}
N 20440 12640 20460 12640 {}
C {lab_pin.sym} 20460 12640 0 0 {name=l40834 lab=VDD}
N 20440 12560 20460 12560 {}
C {lab_pin.sym} 20460 12560 0 0 {name=l40835 lab=VSS}
C {bitcell_6t.sym} 20600 12600 0 0 {name=Xr63c103}
N 20560 12640 20540 12640 {}
C {lab_pin.sym} 20540 12640 0 0 {name=l40836 lab=BL103}
N 20560 12600 20540 12600 {}
C {lab_pin.sym} 20540 12600 0 0 {name=l40837 lab=BLB103}
N 20560 12560 20540 12560 {}
C {lab_pin.sym} 20540 12560 0 0 {name=l40838 lab=WL63}
N 20640 12640 20660 12640 {}
C {lab_pin.sym} 20660 12640 0 0 {name=l40839 lab=VDD}
N 20640 12560 20660 12560 {}
C {lab_pin.sym} 20660 12560 0 0 {name=l40840 lab=VSS}
C {bitcell_6t.sym} 20800 12600 0 0 {name=Xr63c104}
N 20760 12640 20740 12640 {}
C {lab_pin.sym} 20740 12640 0 0 {name=l40841 lab=BL104}
N 20760 12600 20740 12600 {}
C {lab_pin.sym} 20740 12600 0 0 {name=l40842 lab=BLB104}
N 20760 12560 20740 12560 {}
C {lab_pin.sym} 20740 12560 0 0 {name=l40843 lab=WL63}
N 20840 12640 20860 12640 {}
C {lab_pin.sym} 20860 12640 0 0 {name=l40844 lab=VDD}
N 20840 12560 20860 12560 {}
C {lab_pin.sym} 20860 12560 0 0 {name=l40845 lab=VSS}
C {bitcell_6t.sym} 21000 12600 0 0 {name=Xr63c105}
N 20960 12640 20940 12640 {}
C {lab_pin.sym} 20940 12640 0 0 {name=l40846 lab=BL105}
N 20960 12600 20940 12600 {}
C {lab_pin.sym} 20940 12600 0 0 {name=l40847 lab=BLB105}
N 20960 12560 20940 12560 {}
C {lab_pin.sym} 20940 12560 0 0 {name=l40848 lab=WL63}
N 21040 12640 21060 12640 {}
C {lab_pin.sym} 21060 12640 0 0 {name=l40849 lab=VDD}
N 21040 12560 21060 12560 {}
C {lab_pin.sym} 21060 12560 0 0 {name=l40850 lab=VSS}
C {bitcell_6t.sym} 21200 12600 0 0 {name=Xr63c106}
N 21160 12640 21140 12640 {}
C {lab_pin.sym} 21140 12640 0 0 {name=l40851 lab=BL106}
N 21160 12600 21140 12600 {}
C {lab_pin.sym} 21140 12600 0 0 {name=l40852 lab=BLB106}
N 21160 12560 21140 12560 {}
C {lab_pin.sym} 21140 12560 0 0 {name=l40853 lab=WL63}
N 21240 12640 21260 12640 {}
C {lab_pin.sym} 21260 12640 0 0 {name=l40854 lab=VDD}
N 21240 12560 21260 12560 {}
C {lab_pin.sym} 21260 12560 0 0 {name=l40855 lab=VSS}
C {bitcell_6t.sym} 21400 12600 0 0 {name=Xr63c107}
N 21360 12640 21340 12640 {}
C {lab_pin.sym} 21340 12640 0 0 {name=l40856 lab=BL107}
N 21360 12600 21340 12600 {}
C {lab_pin.sym} 21340 12600 0 0 {name=l40857 lab=BLB107}
N 21360 12560 21340 12560 {}
C {lab_pin.sym} 21340 12560 0 0 {name=l40858 lab=WL63}
N 21440 12640 21460 12640 {}
C {lab_pin.sym} 21460 12640 0 0 {name=l40859 lab=VDD}
N 21440 12560 21460 12560 {}
C {lab_pin.sym} 21460 12560 0 0 {name=l40860 lab=VSS}
C {bitcell_6t.sym} 21600 12600 0 0 {name=Xr63c108}
N 21560 12640 21540 12640 {}
C {lab_pin.sym} 21540 12640 0 0 {name=l40861 lab=BL108}
N 21560 12600 21540 12600 {}
C {lab_pin.sym} 21540 12600 0 0 {name=l40862 lab=BLB108}
N 21560 12560 21540 12560 {}
C {lab_pin.sym} 21540 12560 0 0 {name=l40863 lab=WL63}
N 21640 12640 21660 12640 {}
C {lab_pin.sym} 21660 12640 0 0 {name=l40864 lab=VDD}
N 21640 12560 21660 12560 {}
C {lab_pin.sym} 21660 12560 0 0 {name=l40865 lab=VSS}
C {bitcell_6t.sym} 21800 12600 0 0 {name=Xr63c109}
N 21760 12640 21740 12640 {}
C {lab_pin.sym} 21740 12640 0 0 {name=l40866 lab=BL109}
N 21760 12600 21740 12600 {}
C {lab_pin.sym} 21740 12600 0 0 {name=l40867 lab=BLB109}
N 21760 12560 21740 12560 {}
C {lab_pin.sym} 21740 12560 0 0 {name=l40868 lab=WL63}
N 21840 12640 21860 12640 {}
C {lab_pin.sym} 21860 12640 0 0 {name=l40869 lab=VDD}
N 21840 12560 21860 12560 {}
C {lab_pin.sym} 21860 12560 0 0 {name=l40870 lab=VSS}
C {bitcell_6t.sym} 22000 12600 0 0 {name=Xr63c110}
N 21960 12640 21940 12640 {}
C {lab_pin.sym} 21940 12640 0 0 {name=l40871 lab=BL110}
N 21960 12600 21940 12600 {}
C {lab_pin.sym} 21940 12600 0 0 {name=l40872 lab=BLB110}
N 21960 12560 21940 12560 {}
C {lab_pin.sym} 21940 12560 0 0 {name=l40873 lab=WL63}
N 22040 12640 22060 12640 {}
C {lab_pin.sym} 22060 12640 0 0 {name=l40874 lab=VDD}
N 22040 12560 22060 12560 {}
C {lab_pin.sym} 22060 12560 0 0 {name=l40875 lab=VSS}
C {bitcell_6t.sym} 22200 12600 0 0 {name=Xr63c111}
N 22160 12640 22140 12640 {}
C {lab_pin.sym} 22140 12640 0 0 {name=l40876 lab=BL111}
N 22160 12600 22140 12600 {}
C {lab_pin.sym} 22140 12600 0 0 {name=l40877 lab=BLB111}
N 22160 12560 22140 12560 {}
C {lab_pin.sym} 22140 12560 0 0 {name=l40878 lab=WL63}
N 22240 12640 22260 12640 {}
C {lab_pin.sym} 22260 12640 0 0 {name=l40879 lab=VDD}
N 22240 12560 22260 12560 {}
C {lab_pin.sym} 22260 12560 0 0 {name=l40880 lab=VSS}
C {bitcell_6t.sym} 22400 12600 0 0 {name=Xr63c112}
N 22360 12640 22340 12640 {}
C {lab_pin.sym} 22340 12640 0 0 {name=l40881 lab=BL112}
N 22360 12600 22340 12600 {}
C {lab_pin.sym} 22340 12600 0 0 {name=l40882 lab=BLB112}
N 22360 12560 22340 12560 {}
C {lab_pin.sym} 22340 12560 0 0 {name=l40883 lab=WL63}
N 22440 12640 22460 12640 {}
C {lab_pin.sym} 22460 12640 0 0 {name=l40884 lab=VDD}
N 22440 12560 22460 12560 {}
C {lab_pin.sym} 22460 12560 0 0 {name=l40885 lab=VSS}
C {bitcell_6t.sym} 22600 12600 0 0 {name=Xr63c113}
N 22560 12640 22540 12640 {}
C {lab_pin.sym} 22540 12640 0 0 {name=l40886 lab=BL113}
N 22560 12600 22540 12600 {}
C {lab_pin.sym} 22540 12600 0 0 {name=l40887 lab=BLB113}
N 22560 12560 22540 12560 {}
C {lab_pin.sym} 22540 12560 0 0 {name=l40888 lab=WL63}
N 22640 12640 22660 12640 {}
C {lab_pin.sym} 22660 12640 0 0 {name=l40889 lab=VDD}
N 22640 12560 22660 12560 {}
C {lab_pin.sym} 22660 12560 0 0 {name=l40890 lab=VSS}
C {bitcell_6t.sym} 22800 12600 0 0 {name=Xr63c114}
N 22760 12640 22740 12640 {}
C {lab_pin.sym} 22740 12640 0 0 {name=l40891 lab=BL114}
N 22760 12600 22740 12600 {}
C {lab_pin.sym} 22740 12600 0 0 {name=l40892 lab=BLB114}
N 22760 12560 22740 12560 {}
C {lab_pin.sym} 22740 12560 0 0 {name=l40893 lab=WL63}
N 22840 12640 22860 12640 {}
C {lab_pin.sym} 22860 12640 0 0 {name=l40894 lab=VDD}
N 22840 12560 22860 12560 {}
C {lab_pin.sym} 22860 12560 0 0 {name=l40895 lab=VSS}
C {bitcell_6t.sym} 23000 12600 0 0 {name=Xr63c115}
N 22960 12640 22940 12640 {}
C {lab_pin.sym} 22940 12640 0 0 {name=l40896 lab=BL115}
N 22960 12600 22940 12600 {}
C {lab_pin.sym} 22940 12600 0 0 {name=l40897 lab=BLB115}
N 22960 12560 22940 12560 {}
C {lab_pin.sym} 22940 12560 0 0 {name=l40898 lab=WL63}
N 23040 12640 23060 12640 {}
C {lab_pin.sym} 23060 12640 0 0 {name=l40899 lab=VDD}
N 23040 12560 23060 12560 {}
C {lab_pin.sym} 23060 12560 0 0 {name=l40900 lab=VSS}
C {bitcell_6t.sym} 23200 12600 0 0 {name=Xr63c116}
N 23160 12640 23140 12640 {}
C {lab_pin.sym} 23140 12640 0 0 {name=l40901 lab=BL116}
N 23160 12600 23140 12600 {}
C {lab_pin.sym} 23140 12600 0 0 {name=l40902 lab=BLB116}
N 23160 12560 23140 12560 {}
C {lab_pin.sym} 23140 12560 0 0 {name=l40903 lab=WL63}
N 23240 12640 23260 12640 {}
C {lab_pin.sym} 23260 12640 0 0 {name=l40904 lab=VDD}
N 23240 12560 23260 12560 {}
C {lab_pin.sym} 23260 12560 0 0 {name=l40905 lab=VSS}
C {bitcell_6t.sym} 23400 12600 0 0 {name=Xr63c117}
N 23360 12640 23340 12640 {}
C {lab_pin.sym} 23340 12640 0 0 {name=l40906 lab=BL117}
N 23360 12600 23340 12600 {}
C {lab_pin.sym} 23340 12600 0 0 {name=l40907 lab=BLB117}
N 23360 12560 23340 12560 {}
C {lab_pin.sym} 23340 12560 0 0 {name=l40908 lab=WL63}
N 23440 12640 23460 12640 {}
C {lab_pin.sym} 23460 12640 0 0 {name=l40909 lab=VDD}
N 23440 12560 23460 12560 {}
C {lab_pin.sym} 23460 12560 0 0 {name=l40910 lab=VSS}
C {bitcell_6t.sym} 23600 12600 0 0 {name=Xr63c118}
N 23560 12640 23540 12640 {}
C {lab_pin.sym} 23540 12640 0 0 {name=l40911 lab=BL118}
N 23560 12600 23540 12600 {}
C {lab_pin.sym} 23540 12600 0 0 {name=l40912 lab=BLB118}
N 23560 12560 23540 12560 {}
C {lab_pin.sym} 23540 12560 0 0 {name=l40913 lab=WL63}
N 23640 12640 23660 12640 {}
C {lab_pin.sym} 23660 12640 0 0 {name=l40914 lab=VDD}
N 23640 12560 23660 12560 {}
C {lab_pin.sym} 23660 12560 0 0 {name=l40915 lab=VSS}
C {bitcell_6t.sym} 23800 12600 0 0 {name=Xr63c119}
N 23760 12640 23740 12640 {}
C {lab_pin.sym} 23740 12640 0 0 {name=l40916 lab=BL119}
N 23760 12600 23740 12600 {}
C {lab_pin.sym} 23740 12600 0 0 {name=l40917 lab=BLB119}
N 23760 12560 23740 12560 {}
C {lab_pin.sym} 23740 12560 0 0 {name=l40918 lab=WL63}
N 23840 12640 23860 12640 {}
C {lab_pin.sym} 23860 12640 0 0 {name=l40919 lab=VDD}
N 23840 12560 23860 12560 {}
C {lab_pin.sym} 23860 12560 0 0 {name=l40920 lab=VSS}
C {bitcell_6t.sym} 24000 12600 0 0 {name=Xr63c120}
N 23960 12640 23940 12640 {}
C {lab_pin.sym} 23940 12640 0 0 {name=l40921 lab=BL120}
N 23960 12600 23940 12600 {}
C {lab_pin.sym} 23940 12600 0 0 {name=l40922 lab=BLB120}
N 23960 12560 23940 12560 {}
C {lab_pin.sym} 23940 12560 0 0 {name=l40923 lab=WL63}
N 24040 12640 24060 12640 {}
C {lab_pin.sym} 24060 12640 0 0 {name=l40924 lab=VDD}
N 24040 12560 24060 12560 {}
C {lab_pin.sym} 24060 12560 0 0 {name=l40925 lab=VSS}
C {bitcell_6t.sym} 24200 12600 0 0 {name=Xr63c121}
N 24160 12640 24140 12640 {}
C {lab_pin.sym} 24140 12640 0 0 {name=l40926 lab=BL121}
N 24160 12600 24140 12600 {}
C {lab_pin.sym} 24140 12600 0 0 {name=l40927 lab=BLB121}
N 24160 12560 24140 12560 {}
C {lab_pin.sym} 24140 12560 0 0 {name=l40928 lab=WL63}
N 24240 12640 24260 12640 {}
C {lab_pin.sym} 24260 12640 0 0 {name=l40929 lab=VDD}
N 24240 12560 24260 12560 {}
C {lab_pin.sym} 24260 12560 0 0 {name=l40930 lab=VSS}
C {bitcell_6t.sym} 24400 12600 0 0 {name=Xr63c122}
N 24360 12640 24340 12640 {}
C {lab_pin.sym} 24340 12640 0 0 {name=l40931 lab=BL122}
N 24360 12600 24340 12600 {}
C {lab_pin.sym} 24340 12600 0 0 {name=l40932 lab=BLB122}
N 24360 12560 24340 12560 {}
C {lab_pin.sym} 24340 12560 0 0 {name=l40933 lab=WL63}
N 24440 12640 24460 12640 {}
C {lab_pin.sym} 24460 12640 0 0 {name=l40934 lab=VDD}
N 24440 12560 24460 12560 {}
C {lab_pin.sym} 24460 12560 0 0 {name=l40935 lab=VSS}
C {bitcell_6t.sym} 24600 12600 0 0 {name=Xr63c123}
N 24560 12640 24540 12640 {}
C {lab_pin.sym} 24540 12640 0 0 {name=l40936 lab=BL123}
N 24560 12600 24540 12600 {}
C {lab_pin.sym} 24540 12600 0 0 {name=l40937 lab=BLB123}
N 24560 12560 24540 12560 {}
C {lab_pin.sym} 24540 12560 0 0 {name=l40938 lab=WL63}
N 24640 12640 24660 12640 {}
C {lab_pin.sym} 24660 12640 0 0 {name=l40939 lab=VDD}
N 24640 12560 24660 12560 {}
C {lab_pin.sym} 24660 12560 0 0 {name=l40940 lab=VSS}
C {bitcell_6t.sym} 24800 12600 0 0 {name=Xr63c124}
N 24760 12640 24740 12640 {}
C {lab_pin.sym} 24740 12640 0 0 {name=l40941 lab=BL124}
N 24760 12600 24740 12600 {}
C {lab_pin.sym} 24740 12600 0 0 {name=l40942 lab=BLB124}
N 24760 12560 24740 12560 {}
C {lab_pin.sym} 24740 12560 0 0 {name=l40943 lab=WL63}
N 24840 12640 24860 12640 {}
C {lab_pin.sym} 24860 12640 0 0 {name=l40944 lab=VDD}
N 24840 12560 24860 12560 {}
C {lab_pin.sym} 24860 12560 0 0 {name=l40945 lab=VSS}
C {bitcell_6t.sym} 25000 12600 0 0 {name=Xr63c125}
N 24960 12640 24940 12640 {}
C {lab_pin.sym} 24940 12640 0 0 {name=l40946 lab=BL125}
N 24960 12600 24940 12600 {}
C {lab_pin.sym} 24940 12600 0 0 {name=l40947 lab=BLB125}
N 24960 12560 24940 12560 {}
C {lab_pin.sym} 24940 12560 0 0 {name=l40948 lab=WL63}
N 25040 12640 25060 12640 {}
C {lab_pin.sym} 25060 12640 0 0 {name=l40949 lab=VDD}
N 25040 12560 25060 12560 {}
C {lab_pin.sym} 25060 12560 0 0 {name=l40950 lab=VSS}
C {bitcell_6t.sym} 25200 12600 0 0 {name=Xr63c126}
N 25160 12640 25140 12640 {}
C {lab_pin.sym} 25140 12640 0 0 {name=l40951 lab=BL126}
N 25160 12600 25140 12600 {}
C {lab_pin.sym} 25140 12600 0 0 {name=l40952 lab=BLB126}
N 25160 12560 25140 12560 {}
C {lab_pin.sym} 25140 12560 0 0 {name=l40953 lab=WL63}
N 25240 12640 25260 12640 {}
C {lab_pin.sym} 25260 12640 0 0 {name=l40954 lab=VDD}
N 25240 12560 25260 12560 {}
C {lab_pin.sym} 25260 12560 0 0 {name=l40955 lab=VSS}
C {bitcell_6t.sym} 25400 12600 0 0 {name=Xr63c127}
N 25360 12640 25340 12640 {}
C {lab_pin.sym} 25340 12640 0 0 {name=l40956 lab=BL127}
N 25360 12600 25340 12600 {}
C {lab_pin.sym} 25340 12600 0 0 {name=l40957 lab=BLB127}
N 25360 12560 25340 12560 {}
C {lab_pin.sym} 25340 12560 0 0 {name=l40958 lab=WL63}
N 25440 12640 25460 12640 {}
C {lab_pin.sym} 25460 12640 0 0 {name=l40959 lab=VDD}
N 25440 12560 25460 12560 {}
C {lab_pin.sym} 25460 12560 0 0 {name=l40960 lab=VSS}
* --- top-level ports ---
C {ipin.sym} -300 0 0 0 {name=pwl1 lab=WL0}
C {ipin.sym} -300 200 0 0 {name=pwl2 lab=WL1}
C {ipin.sym} -300 400 0 0 {name=pwl3 lab=WL2}
C {ipin.sym} -300 600 0 0 {name=pwl4 lab=WL3}
C {ipin.sym} -300 800 0 0 {name=pwl5 lab=WL4}
C {ipin.sym} -300 1000 0 0 {name=pwl6 lab=WL5}
C {ipin.sym} -300 1200 0 0 {name=pwl7 lab=WL6}
C {ipin.sym} -300 1400 0 0 {name=pwl8 lab=WL7}
C {ipin.sym} -300 1600 0 0 {name=pwl9 lab=WL8}
C {ipin.sym} -300 1800 0 0 {name=pwl10 lab=WL9}
C {ipin.sym} -300 2000 0 0 {name=pwl11 lab=WL10}
C {ipin.sym} -300 2200 0 0 {name=pwl12 lab=WL11}
C {ipin.sym} -300 2400 0 0 {name=pwl13 lab=WL12}
C {ipin.sym} -300 2600 0 0 {name=pwl14 lab=WL13}
C {ipin.sym} -300 2800 0 0 {name=pwl15 lab=WL14}
C {ipin.sym} -300 3000 0 0 {name=pwl16 lab=WL15}
C {ipin.sym} -300 3200 0 0 {name=pwl17 lab=WL16}
C {ipin.sym} -300 3400 0 0 {name=pwl18 lab=WL17}
C {ipin.sym} -300 3600 0 0 {name=pwl19 lab=WL18}
C {ipin.sym} -300 3800 0 0 {name=pwl20 lab=WL19}
C {ipin.sym} -300 4000 0 0 {name=pwl21 lab=WL20}
C {ipin.sym} -300 4200 0 0 {name=pwl22 lab=WL21}
C {ipin.sym} -300 4400 0 0 {name=pwl23 lab=WL22}
C {ipin.sym} -300 4600 0 0 {name=pwl24 lab=WL23}
C {ipin.sym} -300 4800 0 0 {name=pwl25 lab=WL24}
C {ipin.sym} -300 5000 0 0 {name=pwl26 lab=WL25}
C {ipin.sym} -300 5200 0 0 {name=pwl27 lab=WL26}
C {ipin.sym} -300 5400 0 0 {name=pwl28 lab=WL27}
C {ipin.sym} -300 5600 0 0 {name=pwl29 lab=WL28}
C {ipin.sym} -300 5800 0 0 {name=pwl30 lab=WL29}
C {ipin.sym} -300 6000 0 0 {name=pwl31 lab=WL30}
C {ipin.sym} -300 6200 0 0 {name=pwl32 lab=WL31}
C {ipin.sym} -300 6400 0 0 {name=pwl33 lab=WL32}
C {ipin.sym} -300 6600 0 0 {name=pwl34 lab=WL33}
C {ipin.sym} -300 6800 0 0 {name=pwl35 lab=WL34}
C {ipin.sym} -300 7000 0 0 {name=pwl36 lab=WL35}
C {ipin.sym} -300 7200 0 0 {name=pwl37 lab=WL36}
C {ipin.sym} -300 7400 0 0 {name=pwl38 lab=WL37}
C {ipin.sym} -300 7600 0 0 {name=pwl39 lab=WL38}
C {ipin.sym} -300 7800 0 0 {name=pwl40 lab=WL39}
C {ipin.sym} -300 8000 0 0 {name=pwl41 lab=WL40}
C {ipin.sym} -300 8200 0 0 {name=pwl42 lab=WL41}
C {ipin.sym} -300 8400 0 0 {name=pwl43 lab=WL42}
C {ipin.sym} -300 8600 0 0 {name=pwl44 lab=WL43}
C {ipin.sym} -300 8800 0 0 {name=pwl45 lab=WL44}
C {ipin.sym} -300 9000 0 0 {name=pwl46 lab=WL45}
C {ipin.sym} -300 9200 0 0 {name=pwl47 lab=WL46}
C {ipin.sym} -300 9400 0 0 {name=pwl48 lab=WL47}
C {ipin.sym} -300 9600 0 0 {name=pwl49 lab=WL48}
C {ipin.sym} -300 9800 0 0 {name=pwl50 lab=WL49}
C {ipin.sym} -300 10000 0 0 {name=pwl51 lab=WL50}
C {ipin.sym} -300 10200 0 0 {name=pwl52 lab=WL51}
C {ipin.sym} -300 10400 0 0 {name=pwl53 lab=WL52}
C {ipin.sym} -300 10600 0 0 {name=pwl54 lab=WL53}
C {ipin.sym} -300 10800 0 0 {name=pwl55 lab=WL54}
C {ipin.sym} -300 11000 0 0 {name=pwl56 lab=WL55}
C {ipin.sym} -300 11200 0 0 {name=pwl57 lab=WL56}
C {ipin.sym} -300 11400 0 0 {name=pwl58 lab=WL57}
C {ipin.sym} -300 11600 0 0 {name=pwl59 lab=WL58}
C {ipin.sym} -300 11800 0 0 {name=pwl60 lab=WL59}
C {ipin.sym} -300 12000 0 0 {name=pwl61 lab=WL60}
C {ipin.sym} -300 12200 0 0 {name=pwl62 lab=WL61}
C {ipin.sym} -300 12400 0 0 {name=pwl63 lab=WL62}
C {ipin.sym} -300 12600 0 0 {name=pwl64 lab=WL63}
C {iopin.sym} 0 12900 0 0 {name=pbl65 lab=BL0}
C {iopin.sym} 0 13000 0 0 {name=pblb66 lab=BLB0}
C {iopin.sym} 200 12900 0 0 {name=pbl67 lab=BL1}
C {iopin.sym} 200 13000 0 0 {name=pblb68 lab=BLB1}
C {iopin.sym} 400 12900 0 0 {name=pbl69 lab=BL2}
C {iopin.sym} 400 13000 0 0 {name=pblb70 lab=BLB2}
C {iopin.sym} 600 12900 0 0 {name=pbl71 lab=BL3}
C {iopin.sym} 600 13000 0 0 {name=pblb72 lab=BLB3}
C {iopin.sym} 800 12900 0 0 {name=pbl73 lab=BL4}
C {iopin.sym} 800 13000 0 0 {name=pblb74 lab=BLB4}
C {iopin.sym} 1000 12900 0 0 {name=pbl75 lab=BL5}
C {iopin.sym} 1000 13000 0 0 {name=pblb76 lab=BLB5}
C {iopin.sym} 1200 12900 0 0 {name=pbl77 lab=BL6}
C {iopin.sym} 1200 13000 0 0 {name=pblb78 lab=BLB6}
C {iopin.sym} 1400 12900 0 0 {name=pbl79 lab=BL7}
C {iopin.sym} 1400 13000 0 0 {name=pblb80 lab=BLB7}
C {iopin.sym} 1600 12900 0 0 {name=pbl81 lab=BL8}
C {iopin.sym} 1600 13000 0 0 {name=pblb82 lab=BLB8}
C {iopin.sym} 1800 12900 0 0 {name=pbl83 lab=BL9}
C {iopin.sym} 1800 13000 0 0 {name=pblb84 lab=BLB9}
C {iopin.sym} 2000 12900 0 0 {name=pbl85 lab=BL10}
C {iopin.sym} 2000 13000 0 0 {name=pblb86 lab=BLB10}
C {iopin.sym} 2200 12900 0 0 {name=pbl87 lab=BL11}
C {iopin.sym} 2200 13000 0 0 {name=pblb88 lab=BLB11}
C {iopin.sym} 2400 12900 0 0 {name=pbl89 lab=BL12}
C {iopin.sym} 2400 13000 0 0 {name=pblb90 lab=BLB12}
C {iopin.sym} 2600 12900 0 0 {name=pbl91 lab=BL13}
C {iopin.sym} 2600 13000 0 0 {name=pblb92 lab=BLB13}
C {iopin.sym} 2800 12900 0 0 {name=pbl93 lab=BL14}
C {iopin.sym} 2800 13000 0 0 {name=pblb94 lab=BLB14}
C {iopin.sym} 3000 12900 0 0 {name=pbl95 lab=BL15}
C {iopin.sym} 3000 13000 0 0 {name=pblb96 lab=BLB15}
C {iopin.sym} 3200 12900 0 0 {name=pbl97 lab=BL16}
C {iopin.sym} 3200 13000 0 0 {name=pblb98 lab=BLB16}
C {iopin.sym} 3400 12900 0 0 {name=pbl99 lab=BL17}
C {iopin.sym} 3400 13000 0 0 {name=pblb100 lab=BLB17}
C {iopin.sym} 3600 12900 0 0 {name=pbl101 lab=BL18}
C {iopin.sym} 3600 13000 0 0 {name=pblb102 lab=BLB18}
C {iopin.sym} 3800 12900 0 0 {name=pbl103 lab=BL19}
C {iopin.sym} 3800 13000 0 0 {name=pblb104 lab=BLB19}
C {iopin.sym} 4000 12900 0 0 {name=pbl105 lab=BL20}
C {iopin.sym} 4000 13000 0 0 {name=pblb106 lab=BLB20}
C {iopin.sym} 4200 12900 0 0 {name=pbl107 lab=BL21}
C {iopin.sym} 4200 13000 0 0 {name=pblb108 lab=BLB21}
C {iopin.sym} 4400 12900 0 0 {name=pbl109 lab=BL22}
C {iopin.sym} 4400 13000 0 0 {name=pblb110 lab=BLB22}
C {iopin.sym} 4600 12900 0 0 {name=pbl111 lab=BL23}
C {iopin.sym} 4600 13000 0 0 {name=pblb112 lab=BLB23}
C {iopin.sym} 4800 12900 0 0 {name=pbl113 lab=BL24}
C {iopin.sym} 4800 13000 0 0 {name=pblb114 lab=BLB24}
C {iopin.sym} 5000 12900 0 0 {name=pbl115 lab=BL25}
C {iopin.sym} 5000 13000 0 0 {name=pblb116 lab=BLB25}
C {iopin.sym} 5200 12900 0 0 {name=pbl117 lab=BL26}
C {iopin.sym} 5200 13000 0 0 {name=pblb118 lab=BLB26}
C {iopin.sym} 5400 12900 0 0 {name=pbl119 lab=BL27}
C {iopin.sym} 5400 13000 0 0 {name=pblb120 lab=BLB27}
C {iopin.sym} 5600 12900 0 0 {name=pbl121 lab=BL28}
C {iopin.sym} 5600 13000 0 0 {name=pblb122 lab=BLB28}
C {iopin.sym} 5800 12900 0 0 {name=pbl123 lab=BL29}
C {iopin.sym} 5800 13000 0 0 {name=pblb124 lab=BLB29}
C {iopin.sym} 6000 12900 0 0 {name=pbl125 lab=BL30}
C {iopin.sym} 6000 13000 0 0 {name=pblb126 lab=BLB30}
C {iopin.sym} 6200 12900 0 0 {name=pbl127 lab=BL31}
C {iopin.sym} 6200 13000 0 0 {name=pblb128 lab=BLB31}
C {iopin.sym} 6400 12900 0 0 {name=pbl129 lab=BL32}
C {iopin.sym} 6400 13000 0 0 {name=pblb130 lab=BLB32}
C {iopin.sym} 6600 12900 0 0 {name=pbl131 lab=BL33}
C {iopin.sym} 6600 13000 0 0 {name=pblb132 lab=BLB33}
C {iopin.sym} 6800 12900 0 0 {name=pbl133 lab=BL34}
C {iopin.sym} 6800 13000 0 0 {name=pblb134 lab=BLB34}
C {iopin.sym} 7000 12900 0 0 {name=pbl135 lab=BL35}
C {iopin.sym} 7000 13000 0 0 {name=pblb136 lab=BLB35}
C {iopin.sym} 7200 12900 0 0 {name=pbl137 lab=BL36}
C {iopin.sym} 7200 13000 0 0 {name=pblb138 lab=BLB36}
C {iopin.sym} 7400 12900 0 0 {name=pbl139 lab=BL37}
C {iopin.sym} 7400 13000 0 0 {name=pblb140 lab=BLB37}
C {iopin.sym} 7600 12900 0 0 {name=pbl141 lab=BL38}
C {iopin.sym} 7600 13000 0 0 {name=pblb142 lab=BLB38}
C {iopin.sym} 7800 12900 0 0 {name=pbl143 lab=BL39}
C {iopin.sym} 7800 13000 0 0 {name=pblb144 lab=BLB39}
C {iopin.sym} 8000 12900 0 0 {name=pbl145 lab=BL40}
C {iopin.sym} 8000 13000 0 0 {name=pblb146 lab=BLB40}
C {iopin.sym} 8200 12900 0 0 {name=pbl147 lab=BL41}
C {iopin.sym} 8200 13000 0 0 {name=pblb148 lab=BLB41}
C {iopin.sym} 8400 12900 0 0 {name=pbl149 lab=BL42}
C {iopin.sym} 8400 13000 0 0 {name=pblb150 lab=BLB42}
C {iopin.sym} 8600 12900 0 0 {name=pbl151 lab=BL43}
C {iopin.sym} 8600 13000 0 0 {name=pblb152 lab=BLB43}
C {iopin.sym} 8800 12900 0 0 {name=pbl153 lab=BL44}
C {iopin.sym} 8800 13000 0 0 {name=pblb154 lab=BLB44}
C {iopin.sym} 9000 12900 0 0 {name=pbl155 lab=BL45}
C {iopin.sym} 9000 13000 0 0 {name=pblb156 lab=BLB45}
C {iopin.sym} 9200 12900 0 0 {name=pbl157 lab=BL46}
C {iopin.sym} 9200 13000 0 0 {name=pblb158 lab=BLB46}
C {iopin.sym} 9400 12900 0 0 {name=pbl159 lab=BL47}
C {iopin.sym} 9400 13000 0 0 {name=pblb160 lab=BLB47}
C {iopin.sym} 9600 12900 0 0 {name=pbl161 lab=BL48}
C {iopin.sym} 9600 13000 0 0 {name=pblb162 lab=BLB48}
C {iopin.sym} 9800 12900 0 0 {name=pbl163 lab=BL49}
C {iopin.sym} 9800 13000 0 0 {name=pblb164 lab=BLB49}
C {iopin.sym} 10000 12900 0 0 {name=pbl165 lab=BL50}
C {iopin.sym} 10000 13000 0 0 {name=pblb166 lab=BLB50}
C {iopin.sym} 10200 12900 0 0 {name=pbl167 lab=BL51}
C {iopin.sym} 10200 13000 0 0 {name=pblb168 lab=BLB51}
C {iopin.sym} 10400 12900 0 0 {name=pbl169 lab=BL52}
C {iopin.sym} 10400 13000 0 0 {name=pblb170 lab=BLB52}
C {iopin.sym} 10600 12900 0 0 {name=pbl171 lab=BL53}
C {iopin.sym} 10600 13000 0 0 {name=pblb172 lab=BLB53}
C {iopin.sym} 10800 12900 0 0 {name=pbl173 lab=BL54}
C {iopin.sym} 10800 13000 0 0 {name=pblb174 lab=BLB54}
C {iopin.sym} 11000 12900 0 0 {name=pbl175 lab=BL55}
C {iopin.sym} 11000 13000 0 0 {name=pblb176 lab=BLB55}
C {iopin.sym} 11200 12900 0 0 {name=pbl177 lab=BL56}
C {iopin.sym} 11200 13000 0 0 {name=pblb178 lab=BLB56}
C {iopin.sym} 11400 12900 0 0 {name=pbl179 lab=BL57}
C {iopin.sym} 11400 13000 0 0 {name=pblb180 lab=BLB57}
C {iopin.sym} 11600 12900 0 0 {name=pbl181 lab=BL58}
C {iopin.sym} 11600 13000 0 0 {name=pblb182 lab=BLB58}
C {iopin.sym} 11800 12900 0 0 {name=pbl183 lab=BL59}
C {iopin.sym} 11800 13000 0 0 {name=pblb184 lab=BLB59}
C {iopin.sym} 12000 12900 0 0 {name=pbl185 lab=BL60}
C {iopin.sym} 12000 13000 0 0 {name=pblb186 lab=BLB60}
C {iopin.sym} 12200 12900 0 0 {name=pbl187 lab=BL61}
C {iopin.sym} 12200 13000 0 0 {name=pblb188 lab=BLB61}
C {iopin.sym} 12400 12900 0 0 {name=pbl189 lab=BL62}
C {iopin.sym} 12400 13000 0 0 {name=pblb190 lab=BLB62}
C {iopin.sym} 12600 12900 0 0 {name=pbl191 lab=BL63}
C {iopin.sym} 12600 13000 0 0 {name=pblb192 lab=BLB63}
C {iopin.sym} 12800 12900 0 0 {name=pbl193 lab=BL64}
C {iopin.sym} 12800 13000 0 0 {name=pblb194 lab=BLB64}
C {iopin.sym} 13000 12900 0 0 {name=pbl195 lab=BL65}
C {iopin.sym} 13000 13000 0 0 {name=pblb196 lab=BLB65}
C {iopin.sym} 13200 12900 0 0 {name=pbl197 lab=BL66}
C {iopin.sym} 13200 13000 0 0 {name=pblb198 lab=BLB66}
C {iopin.sym} 13400 12900 0 0 {name=pbl199 lab=BL67}
C {iopin.sym} 13400 13000 0 0 {name=pblb200 lab=BLB67}
C {iopin.sym} 13600 12900 0 0 {name=pbl201 lab=BL68}
C {iopin.sym} 13600 13000 0 0 {name=pblb202 lab=BLB68}
C {iopin.sym} 13800 12900 0 0 {name=pbl203 lab=BL69}
C {iopin.sym} 13800 13000 0 0 {name=pblb204 lab=BLB69}
C {iopin.sym} 14000 12900 0 0 {name=pbl205 lab=BL70}
C {iopin.sym} 14000 13000 0 0 {name=pblb206 lab=BLB70}
C {iopin.sym} 14200 12900 0 0 {name=pbl207 lab=BL71}
C {iopin.sym} 14200 13000 0 0 {name=pblb208 lab=BLB71}
C {iopin.sym} 14400 12900 0 0 {name=pbl209 lab=BL72}
C {iopin.sym} 14400 13000 0 0 {name=pblb210 lab=BLB72}
C {iopin.sym} 14600 12900 0 0 {name=pbl211 lab=BL73}
C {iopin.sym} 14600 13000 0 0 {name=pblb212 lab=BLB73}
C {iopin.sym} 14800 12900 0 0 {name=pbl213 lab=BL74}
C {iopin.sym} 14800 13000 0 0 {name=pblb214 lab=BLB74}
C {iopin.sym} 15000 12900 0 0 {name=pbl215 lab=BL75}
C {iopin.sym} 15000 13000 0 0 {name=pblb216 lab=BLB75}
C {iopin.sym} 15200 12900 0 0 {name=pbl217 lab=BL76}
C {iopin.sym} 15200 13000 0 0 {name=pblb218 lab=BLB76}
C {iopin.sym} 15400 12900 0 0 {name=pbl219 lab=BL77}
C {iopin.sym} 15400 13000 0 0 {name=pblb220 lab=BLB77}
C {iopin.sym} 15600 12900 0 0 {name=pbl221 lab=BL78}
C {iopin.sym} 15600 13000 0 0 {name=pblb222 lab=BLB78}
C {iopin.sym} 15800 12900 0 0 {name=pbl223 lab=BL79}
C {iopin.sym} 15800 13000 0 0 {name=pblb224 lab=BLB79}
C {iopin.sym} 16000 12900 0 0 {name=pbl225 lab=BL80}
C {iopin.sym} 16000 13000 0 0 {name=pblb226 lab=BLB80}
C {iopin.sym} 16200 12900 0 0 {name=pbl227 lab=BL81}
C {iopin.sym} 16200 13000 0 0 {name=pblb228 lab=BLB81}
C {iopin.sym} 16400 12900 0 0 {name=pbl229 lab=BL82}
C {iopin.sym} 16400 13000 0 0 {name=pblb230 lab=BLB82}
C {iopin.sym} 16600 12900 0 0 {name=pbl231 lab=BL83}
C {iopin.sym} 16600 13000 0 0 {name=pblb232 lab=BLB83}
C {iopin.sym} 16800 12900 0 0 {name=pbl233 lab=BL84}
C {iopin.sym} 16800 13000 0 0 {name=pblb234 lab=BLB84}
C {iopin.sym} 17000 12900 0 0 {name=pbl235 lab=BL85}
C {iopin.sym} 17000 13000 0 0 {name=pblb236 lab=BLB85}
C {iopin.sym} 17200 12900 0 0 {name=pbl237 lab=BL86}
C {iopin.sym} 17200 13000 0 0 {name=pblb238 lab=BLB86}
C {iopin.sym} 17400 12900 0 0 {name=pbl239 lab=BL87}
C {iopin.sym} 17400 13000 0 0 {name=pblb240 lab=BLB87}
C {iopin.sym} 17600 12900 0 0 {name=pbl241 lab=BL88}
C {iopin.sym} 17600 13000 0 0 {name=pblb242 lab=BLB88}
C {iopin.sym} 17800 12900 0 0 {name=pbl243 lab=BL89}
C {iopin.sym} 17800 13000 0 0 {name=pblb244 lab=BLB89}
C {iopin.sym} 18000 12900 0 0 {name=pbl245 lab=BL90}
C {iopin.sym} 18000 13000 0 0 {name=pblb246 lab=BLB90}
C {iopin.sym} 18200 12900 0 0 {name=pbl247 lab=BL91}
C {iopin.sym} 18200 13000 0 0 {name=pblb248 lab=BLB91}
C {iopin.sym} 18400 12900 0 0 {name=pbl249 lab=BL92}
C {iopin.sym} 18400 13000 0 0 {name=pblb250 lab=BLB92}
C {iopin.sym} 18600 12900 0 0 {name=pbl251 lab=BL93}
C {iopin.sym} 18600 13000 0 0 {name=pblb252 lab=BLB93}
C {iopin.sym} 18800 12900 0 0 {name=pbl253 lab=BL94}
C {iopin.sym} 18800 13000 0 0 {name=pblb254 lab=BLB94}
C {iopin.sym} 19000 12900 0 0 {name=pbl255 lab=BL95}
C {iopin.sym} 19000 13000 0 0 {name=pblb256 lab=BLB95}
C {iopin.sym} 19200 12900 0 0 {name=pbl257 lab=BL96}
C {iopin.sym} 19200 13000 0 0 {name=pblb258 lab=BLB96}
C {iopin.sym} 19400 12900 0 0 {name=pbl259 lab=BL97}
C {iopin.sym} 19400 13000 0 0 {name=pblb260 lab=BLB97}
C {iopin.sym} 19600 12900 0 0 {name=pbl261 lab=BL98}
C {iopin.sym} 19600 13000 0 0 {name=pblb262 lab=BLB98}
C {iopin.sym} 19800 12900 0 0 {name=pbl263 lab=BL99}
C {iopin.sym} 19800 13000 0 0 {name=pblb264 lab=BLB99}
C {iopin.sym} 20000 12900 0 0 {name=pbl265 lab=BL100}
C {iopin.sym} 20000 13000 0 0 {name=pblb266 lab=BLB100}
C {iopin.sym} 20200 12900 0 0 {name=pbl267 lab=BL101}
C {iopin.sym} 20200 13000 0 0 {name=pblb268 lab=BLB101}
C {iopin.sym} 20400 12900 0 0 {name=pbl269 lab=BL102}
C {iopin.sym} 20400 13000 0 0 {name=pblb270 lab=BLB102}
C {iopin.sym} 20600 12900 0 0 {name=pbl271 lab=BL103}
C {iopin.sym} 20600 13000 0 0 {name=pblb272 lab=BLB103}
C {iopin.sym} 20800 12900 0 0 {name=pbl273 lab=BL104}
C {iopin.sym} 20800 13000 0 0 {name=pblb274 lab=BLB104}
C {iopin.sym} 21000 12900 0 0 {name=pbl275 lab=BL105}
C {iopin.sym} 21000 13000 0 0 {name=pblb276 lab=BLB105}
C {iopin.sym} 21200 12900 0 0 {name=pbl277 lab=BL106}
C {iopin.sym} 21200 13000 0 0 {name=pblb278 lab=BLB106}
C {iopin.sym} 21400 12900 0 0 {name=pbl279 lab=BL107}
C {iopin.sym} 21400 13000 0 0 {name=pblb280 lab=BLB107}
C {iopin.sym} 21600 12900 0 0 {name=pbl281 lab=BL108}
C {iopin.sym} 21600 13000 0 0 {name=pblb282 lab=BLB108}
C {iopin.sym} 21800 12900 0 0 {name=pbl283 lab=BL109}
C {iopin.sym} 21800 13000 0 0 {name=pblb284 lab=BLB109}
C {iopin.sym} 22000 12900 0 0 {name=pbl285 lab=BL110}
C {iopin.sym} 22000 13000 0 0 {name=pblb286 lab=BLB110}
C {iopin.sym} 22200 12900 0 0 {name=pbl287 lab=BL111}
C {iopin.sym} 22200 13000 0 0 {name=pblb288 lab=BLB111}
C {iopin.sym} 22400 12900 0 0 {name=pbl289 lab=BL112}
C {iopin.sym} 22400 13000 0 0 {name=pblb290 lab=BLB112}
C {iopin.sym} 22600 12900 0 0 {name=pbl291 lab=BL113}
C {iopin.sym} 22600 13000 0 0 {name=pblb292 lab=BLB113}
C {iopin.sym} 22800 12900 0 0 {name=pbl293 lab=BL114}
C {iopin.sym} 22800 13000 0 0 {name=pblb294 lab=BLB114}
C {iopin.sym} 23000 12900 0 0 {name=pbl295 lab=BL115}
C {iopin.sym} 23000 13000 0 0 {name=pblb296 lab=BLB115}
C {iopin.sym} 23200 12900 0 0 {name=pbl297 lab=BL116}
C {iopin.sym} 23200 13000 0 0 {name=pblb298 lab=BLB116}
C {iopin.sym} 23400 12900 0 0 {name=pbl299 lab=BL117}
C {iopin.sym} 23400 13000 0 0 {name=pblb300 lab=BLB117}
C {iopin.sym} 23600 12900 0 0 {name=pbl301 lab=BL118}
C {iopin.sym} 23600 13000 0 0 {name=pblb302 lab=BLB118}
C {iopin.sym} 23800 12900 0 0 {name=pbl303 lab=BL119}
C {iopin.sym} 23800 13000 0 0 {name=pblb304 lab=BLB119}
C {iopin.sym} 24000 12900 0 0 {name=pbl305 lab=BL120}
C {iopin.sym} 24000 13000 0 0 {name=pblb306 lab=BLB120}
C {iopin.sym} 24200 12900 0 0 {name=pbl307 lab=BL121}
C {iopin.sym} 24200 13000 0 0 {name=pblb308 lab=BLB121}
C {iopin.sym} 24400 12900 0 0 {name=pbl309 lab=BL122}
C {iopin.sym} 24400 13000 0 0 {name=pblb310 lab=BLB122}
C {iopin.sym} 24600 12900 0 0 {name=pbl311 lab=BL123}
C {iopin.sym} 24600 13000 0 0 {name=pblb312 lab=BLB123}
C {iopin.sym} 24800 12900 0 0 {name=pbl313 lab=BL124}
C {iopin.sym} 24800 13000 0 0 {name=pblb314 lab=BLB124}
C {iopin.sym} 25000 12900 0 0 {name=pbl315 lab=BL125}
C {iopin.sym} 25000 13000 0 0 {name=pblb316 lab=BLB125}
C {iopin.sym} 25200 12900 0 0 {name=pbl317 lab=BL126}
C {iopin.sym} 25200 13000 0 0 {name=pblb318 lab=BLB126}
C {iopin.sym} 25400 12900 0 0 {name=pbl319 lab=BL127}
C {iopin.sym} 25400 13000 0 0 {name=pblb320 lab=BLB127}
C {iopin.sym} -300 13100 0 0 {name=pvdd321 lab=VDD}
C {iopin.sym} -300 13200 0 0 {name=pvss322 lab=VSS}
