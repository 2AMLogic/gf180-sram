C {lab_pin.sym} 11460 9760 0 0 {name=l31650 lab=VSS}
C {bitcell_6t.sym} 11600 9800 0 0 {name=Xr49c58}
N 11560 9840 11540 9840 {}
C {lab_pin.sym} 11540 9840 0 0 {name=l31651 lab=BL58}
N 11560 9800 11540 9800 {}
C {lab_pin.sym} 11540 9800 0 0 {name=l31652 lab=BLB58}
N 11560 9760 11540 9760 {}
C {lab_pin.sym} 11540 9760 0 0 {name=l31653 lab=WL49}
N 11640 9840 11660 9840 {}
C {lab_pin.sym} 11660 9840 0 0 {name=l31654 lab=VDD}
N 11640 9760 11660 9760 {}
C {lab_pin.sym} 11660 9760 0 0 {name=l31655 lab=VSS}
C {bitcell_6t.sym} 11800 9800 0 0 {name=Xr49c59}
N 11760 9840 11740 9840 {}
C {lab_pin.sym} 11740 9840 0 0 {name=l31656 lab=BL59}
N 11760 9800 11740 9800 {}
C {lab_pin.sym} 11740 9800 0 0 {name=l31657 lab=BLB59}
N 11760 9760 11740 9760 {}
C {lab_pin.sym} 11740 9760 0 0 {name=l31658 lab=WL49}
N 11840 9840 11860 9840 {}
C {lab_pin.sym} 11860 9840 0 0 {name=l31659 lab=VDD}
N 11840 9760 11860 9760 {}
C {lab_pin.sym} 11860 9760 0 0 {name=l31660 lab=VSS}
C {bitcell_6t.sym} 12000 9800 0 0 {name=Xr49c60}
N 11960 9840 11940 9840 {}
C {lab_pin.sym} 11940 9840 0 0 {name=l31661 lab=BL60}
N 11960 9800 11940 9800 {}
C {lab_pin.sym} 11940 9800 0 0 {name=l31662 lab=BLB60}
N 11960 9760 11940 9760 {}
C {lab_pin.sym} 11940 9760 0 0 {name=l31663 lab=WL49}
N 12040 9840 12060 9840 {}
C {lab_pin.sym} 12060 9840 0 0 {name=l31664 lab=VDD}
N 12040 9760 12060 9760 {}
C {lab_pin.sym} 12060 9760 0 0 {name=l31665 lab=VSS}
C {bitcell_6t.sym} 12200 9800 0 0 {name=Xr49c61}
N 12160 9840 12140 9840 {}
C {lab_pin.sym} 12140 9840 0 0 {name=l31666 lab=BL61}
N 12160 9800 12140 9800 {}
C {lab_pin.sym} 12140 9800 0 0 {name=l31667 lab=BLB61}
N 12160 9760 12140 9760 {}
C {lab_pin.sym} 12140 9760 0 0 {name=l31668 lab=WL49}
N 12240 9840 12260 9840 {}
C {lab_pin.sym} 12260 9840 0 0 {name=l31669 lab=VDD}
N 12240 9760 12260 9760 {}
C {lab_pin.sym} 12260 9760 0 0 {name=l31670 lab=VSS}
C {bitcell_6t.sym} 12400 9800 0 0 {name=Xr49c62}
N 12360 9840 12340 9840 {}
C {lab_pin.sym} 12340 9840 0 0 {name=l31671 lab=BL62}
N 12360 9800 12340 9800 {}
C {lab_pin.sym} 12340 9800 0 0 {name=l31672 lab=BLB62}
N 12360 9760 12340 9760 {}
C {lab_pin.sym} 12340 9760 0 0 {name=l31673 lab=WL49}
N 12440 9840 12460 9840 {}
C {lab_pin.sym} 12460 9840 0 0 {name=l31674 lab=VDD}
N 12440 9760 12460 9760 {}
C {lab_pin.sym} 12460 9760 0 0 {name=l31675 lab=VSS}
C {bitcell_6t.sym} 12600 9800 0 0 {name=Xr49c63}
N 12560 9840 12540 9840 {}
C {lab_pin.sym} 12540 9840 0 0 {name=l31676 lab=BL63}
N 12560 9800 12540 9800 {}
C {lab_pin.sym} 12540 9800 0 0 {name=l31677 lab=BLB63}
N 12560 9760 12540 9760 {}
C {lab_pin.sym} 12540 9760 0 0 {name=l31678 lab=WL49}
N 12640 9840 12660 9840 {}
C {lab_pin.sym} 12660 9840 0 0 {name=l31679 lab=VDD}
N 12640 9760 12660 9760 {}
C {lab_pin.sym} 12660 9760 0 0 {name=l31680 lab=VSS}
C {bitcell_6t.sym} 12800 9800 0 0 {name=Xr49c64}
N 12760 9840 12740 9840 {}
C {lab_pin.sym} 12740 9840 0 0 {name=l31681 lab=BL64}
N 12760 9800 12740 9800 {}
C {lab_pin.sym} 12740 9800 0 0 {name=l31682 lab=BLB64}
N 12760 9760 12740 9760 {}
C {lab_pin.sym} 12740 9760 0 0 {name=l31683 lab=WL49}
N 12840 9840 12860 9840 {}
C {lab_pin.sym} 12860 9840 0 0 {name=l31684 lab=VDD}
N 12840 9760 12860 9760 {}
C {lab_pin.sym} 12860 9760 0 0 {name=l31685 lab=VSS}
C {bitcell_6t.sym} 13000 9800 0 0 {name=Xr49c65}
N 12960 9840 12940 9840 {}
C {lab_pin.sym} 12940 9840 0 0 {name=l31686 lab=BL65}
N 12960 9800 12940 9800 {}
C {lab_pin.sym} 12940 9800 0 0 {name=l31687 lab=BLB65}
N 12960 9760 12940 9760 {}
C {lab_pin.sym} 12940 9760 0 0 {name=l31688 lab=WL49}
N 13040 9840 13060 9840 {}
C {lab_pin.sym} 13060 9840 0 0 {name=l31689 lab=VDD}
N 13040 9760 13060 9760 {}
C {lab_pin.sym} 13060 9760 0 0 {name=l31690 lab=VSS}
C {bitcell_6t.sym} 13200 9800 0 0 {name=Xr49c66}
N 13160 9840 13140 9840 {}
C {lab_pin.sym} 13140 9840 0 0 {name=l31691 lab=BL66}
N 13160 9800 13140 9800 {}
C {lab_pin.sym} 13140 9800 0 0 {name=l31692 lab=BLB66}
N 13160 9760 13140 9760 {}
C {lab_pin.sym} 13140 9760 0 0 {name=l31693 lab=WL49}
N 13240 9840 13260 9840 {}
C {lab_pin.sym} 13260 9840 0 0 {name=l31694 lab=VDD}
N 13240 9760 13260 9760 {}
C {lab_pin.sym} 13260 9760 0 0 {name=l31695 lab=VSS}
C {bitcell_6t.sym} 13400 9800 0 0 {name=Xr49c67}
N 13360 9840 13340 9840 {}
C {lab_pin.sym} 13340 9840 0 0 {name=l31696 lab=BL67}
N 13360 9800 13340 9800 {}
C {lab_pin.sym} 13340 9800 0 0 {name=l31697 lab=BLB67}
N 13360 9760 13340 9760 {}
C {lab_pin.sym} 13340 9760 0 0 {name=l31698 lab=WL49}
N 13440 9840 13460 9840 {}
C {lab_pin.sym} 13460 9840 0 0 {name=l31699 lab=VDD}
N 13440 9760 13460 9760 {}
C {lab_pin.sym} 13460 9760 0 0 {name=l31700 lab=VSS}
C {bitcell_6t.sym} 13600 9800 0 0 {name=Xr49c68}
N 13560 9840 13540 9840 {}
C {lab_pin.sym} 13540 9840 0 0 {name=l31701 lab=BL68}
N 13560 9800 13540 9800 {}
C {lab_pin.sym} 13540 9800 0 0 {name=l31702 lab=BLB68}
N 13560 9760 13540 9760 {}
C {lab_pin.sym} 13540 9760 0 0 {name=l31703 lab=WL49}
N 13640 9840 13660 9840 {}
C {lab_pin.sym} 13660 9840 0 0 {name=l31704 lab=VDD}
N 13640 9760 13660 9760 {}
C {lab_pin.sym} 13660 9760 0 0 {name=l31705 lab=VSS}
C {bitcell_6t.sym} 13800 9800 0 0 {name=Xr49c69}
N 13760 9840 13740 9840 {}
C {lab_pin.sym} 13740 9840 0 0 {name=l31706 lab=BL69}
N 13760 9800 13740 9800 {}
C {lab_pin.sym} 13740 9800 0 0 {name=l31707 lab=BLB69}
N 13760 9760 13740 9760 {}
C {lab_pin.sym} 13740 9760 0 0 {name=l31708 lab=WL49}
N 13840 9840 13860 9840 {}
C {lab_pin.sym} 13860 9840 0 0 {name=l31709 lab=VDD}
N 13840 9760 13860 9760 {}
C {lab_pin.sym} 13860 9760 0 0 {name=l31710 lab=VSS}
C {bitcell_6t.sym} 14000 9800 0 0 {name=Xr49c70}
N 13960 9840 13940 9840 {}
C {lab_pin.sym} 13940 9840 0 0 {name=l31711 lab=BL70}
N 13960 9800 13940 9800 {}
C {lab_pin.sym} 13940 9800 0 0 {name=l31712 lab=BLB70}
N 13960 9760 13940 9760 {}
C {lab_pin.sym} 13940 9760 0 0 {name=l31713 lab=WL49}
N 14040 9840 14060 9840 {}
C {lab_pin.sym} 14060 9840 0 0 {name=l31714 lab=VDD}
N 14040 9760 14060 9760 {}
C {lab_pin.sym} 14060 9760 0 0 {name=l31715 lab=VSS}
C {bitcell_6t.sym} 14200 9800 0 0 {name=Xr49c71}
N 14160 9840 14140 9840 {}
C {lab_pin.sym} 14140 9840 0 0 {name=l31716 lab=BL71}
N 14160 9800 14140 9800 {}
C {lab_pin.sym} 14140 9800 0 0 {name=l31717 lab=BLB71}
N 14160 9760 14140 9760 {}
C {lab_pin.sym} 14140 9760 0 0 {name=l31718 lab=WL49}
N 14240 9840 14260 9840 {}
C {lab_pin.sym} 14260 9840 0 0 {name=l31719 lab=VDD}
N 14240 9760 14260 9760 {}
C {lab_pin.sym} 14260 9760 0 0 {name=l31720 lab=VSS}
C {bitcell_6t.sym} 14400 9800 0 0 {name=Xr49c72}
N 14360 9840 14340 9840 {}
C {lab_pin.sym} 14340 9840 0 0 {name=l31721 lab=BL72}
N 14360 9800 14340 9800 {}
C {lab_pin.sym} 14340 9800 0 0 {name=l31722 lab=BLB72}
N 14360 9760 14340 9760 {}
C {lab_pin.sym} 14340 9760 0 0 {name=l31723 lab=WL49}
N 14440 9840 14460 9840 {}
C {lab_pin.sym} 14460 9840 0 0 {name=l31724 lab=VDD}
N 14440 9760 14460 9760 {}
C {lab_pin.sym} 14460 9760 0 0 {name=l31725 lab=VSS}
C {bitcell_6t.sym} 14600 9800 0 0 {name=Xr49c73}
N 14560 9840 14540 9840 {}
C {lab_pin.sym} 14540 9840 0 0 {name=l31726 lab=BL73}
N 14560 9800 14540 9800 {}
C {lab_pin.sym} 14540 9800 0 0 {name=l31727 lab=BLB73}
N 14560 9760 14540 9760 {}
C {lab_pin.sym} 14540 9760 0 0 {name=l31728 lab=WL49}
N 14640 9840 14660 9840 {}
C {lab_pin.sym} 14660 9840 0 0 {name=l31729 lab=VDD}
N 14640 9760 14660 9760 {}
C {lab_pin.sym} 14660 9760 0 0 {name=l31730 lab=VSS}
C {bitcell_6t.sym} 14800 9800 0 0 {name=Xr49c74}
N 14760 9840 14740 9840 {}
C {lab_pin.sym} 14740 9840 0 0 {name=l31731 lab=BL74}
N 14760 9800 14740 9800 {}
C {lab_pin.sym} 14740 9800 0 0 {name=l31732 lab=BLB74}
N 14760 9760 14740 9760 {}
C {lab_pin.sym} 14740 9760 0 0 {name=l31733 lab=WL49}
N 14840 9840 14860 9840 {}
C {lab_pin.sym} 14860 9840 0 0 {name=l31734 lab=VDD}
N 14840 9760 14860 9760 {}
C {lab_pin.sym} 14860 9760 0 0 {name=l31735 lab=VSS}
C {bitcell_6t.sym} 15000 9800 0 0 {name=Xr49c75}
N 14960 9840 14940 9840 {}
C {lab_pin.sym} 14940 9840 0 0 {name=l31736 lab=BL75}
N 14960 9800 14940 9800 {}
C {lab_pin.sym} 14940 9800 0 0 {name=l31737 lab=BLB75}
N 14960 9760 14940 9760 {}
C {lab_pin.sym} 14940 9760 0 0 {name=l31738 lab=WL49}
N 15040 9840 15060 9840 {}
C {lab_pin.sym} 15060 9840 0 0 {name=l31739 lab=VDD}
N 15040 9760 15060 9760 {}
C {lab_pin.sym} 15060 9760 0 0 {name=l31740 lab=VSS}
C {bitcell_6t.sym} 15200 9800 0 0 {name=Xr49c76}
N 15160 9840 15140 9840 {}
C {lab_pin.sym} 15140 9840 0 0 {name=l31741 lab=BL76}
N 15160 9800 15140 9800 {}
C {lab_pin.sym} 15140 9800 0 0 {name=l31742 lab=BLB76}
N 15160 9760 15140 9760 {}
C {lab_pin.sym} 15140 9760 0 0 {name=l31743 lab=WL49}
N 15240 9840 15260 9840 {}
C {lab_pin.sym} 15260 9840 0 0 {name=l31744 lab=VDD}
N 15240 9760 15260 9760 {}
C {lab_pin.sym} 15260 9760 0 0 {name=l31745 lab=VSS}
C {bitcell_6t.sym} 15400 9800 0 0 {name=Xr49c77}
N 15360 9840 15340 9840 {}
C {lab_pin.sym} 15340 9840 0 0 {name=l31746 lab=BL77}
N 15360 9800 15340 9800 {}
C {lab_pin.sym} 15340 9800 0 0 {name=l31747 lab=BLB77}
N 15360 9760 15340 9760 {}
C {lab_pin.sym} 15340 9760 0 0 {name=l31748 lab=WL49}
N 15440 9840 15460 9840 {}
C {lab_pin.sym} 15460 9840 0 0 {name=l31749 lab=VDD}
N 15440 9760 15460 9760 {}
C {lab_pin.sym} 15460 9760 0 0 {name=l31750 lab=VSS}
C {bitcell_6t.sym} 15600 9800 0 0 {name=Xr49c78}
N 15560 9840 15540 9840 {}
C {lab_pin.sym} 15540 9840 0 0 {name=l31751 lab=BL78}
N 15560 9800 15540 9800 {}
C {lab_pin.sym} 15540 9800 0 0 {name=l31752 lab=BLB78}
N 15560 9760 15540 9760 {}
C {lab_pin.sym} 15540 9760 0 0 {name=l31753 lab=WL49}
N 15640 9840 15660 9840 {}
C {lab_pin.sym} 15660 9840 0 0 {name=l31754 lab=VDD}
N 15640 9760 15660 9760 {}
C {lab_pin.sym} 15660 9760 0 0 {name=l31755 lab=VSS}
C {bitcell_6t.sym} 15800 9800 0 0 {name=Xr49c79}
N 15760 9840 15740 9840 {}
C {lab_pin.sym} 15740 9840 0 0 {name=l31756 lab=BL79}
N 15760 9800 15740 9800 {}
C {lab_pin.sym} 15740 9800 0 0 {name=l31757 lab=BLB79}
N 15760 9760 15740 9760 {}
C {lab_pin.sym} 15740 9760 0 0 {name=l31758 lab=WL49}
N 15840 9840 15860 9840 {}
C {lab_pin.sym} 15860 9840 0 0 {name=l31759 lab=VDD}
N 15840 9760 15860 9760 {}
C {lab_pin.sym} 15860 9760 0 0 {name=l31760 lab=VSS}
C {bitcell_6t.sym} 16000 9800 0 0 {name=Xr49c80}
N 15960 9840 15940 9840 {}
C {lab_pin.sym} 15940 9840 0 0 {name=l31761 lab=BL80}
N 15960 9800 15940 9800 {}
C {lab_pin.sym} 15940 9800 0 0 {name=l31762 lab=BLB80}
N 15960 9760 15940 9760 {}
C {lab_pin.sym} 15940 9760 0 0 {name=l31763 lab=WL49}
N 16040 9840 16060 9840 {}
C {lab_pin.sym} 16060 9840 0 0 {name=l31764 lab=VDD}
N 16040 9760 16060 9760 {}
C {lab_pin.sym} 16060 9760 0 0 {name=l31765 lab=VSS}
C {bitcell_6t.sym} 16200 9800 0 0 {name=Xr49c81}
N 16160 9840 16140 9840 {}
C {lab_pin.sym} 16140 9840 0 0 {name=l31766 lab=BL81}
N 16160 9800 16140 9800 {}
C {lab_pin.sym} 16140 9800 0 0 {name=l31767 lab=BLB81}
N 16160 9760 16140 9760 {}
C {lab_pin.sym} 16140 9760 0 0 {name=l31768 lab=WL49}
N 16240 9840 16260 9840 {}
C {lab_pin.sym} 16260 9840 0 0 {name=l31769 lab=VDD}
N 16240 9760 16260 9760 {}
C {lab_pin.sym} 16260 9760 0 0 {name=l31770 lab=VSS}
C {bitcell_6t.sym} 16400 9800 0 0 {name=Xr49c82}
N 16360 9840 16340 9840 {}
C {lab_pin.sym} 16340 9840 0 0 {name=l31771 lab=BL82}
N 16360 9800 16340 9800 {}
C {lab_pin.sym} 16340 9800 0 0 {name=l31772 lab=BLB82}
N 16360 9760 16340 9760 {}
C {lab_pin.sym} 16340 9760 0 0 {name=l31773 lab=WL49}
N 16440 9840 16460 9840 {}
C {lab_pin.sym} 16460 9840 0 0 {name=l31774 lab=VDD}
N 16440 9760 16460 9760 {}
C {lab_pin.sym} 16460 9760 0 0 {name=l31775 lab=VSS}
C {bitcell_6t.sym} 16600 9800 0 0 {name=Xr49c83}
N 16560 9840 16540 9840 {}
C {lab_pin.sym} 16540 9840 0 0 {name=l31776 lab=BL83}
N 16560 9800 16540 9800 {}
C {lab_pin.sym} 16540 9800 0 0 {name=l31777 lab=BLB83}
N 16560 9760 16540 9760 {}
C {lab_pin.sym} 16540 9760 0 0 {name=l31778 lab=WL49}
N 16640 9840 16660 9840 {}
C {lab_pin.sym} 16660 9840 0 0 {name=l31779 lab=VDD}
N 16640 9760 16660 9760 {}
C {lab_pin.sym} 16660 9760 0 0 {name=l31780 lab=VSS}
C {bitcell_6t.sym} 16800 9800 0 0 {name=Xr49c84}
N 16760 9840 16740 9840 {}
C {lab_pin.sym} 16740 9840 0 0 {name=l31781 lab=BL84}
N 16760 9800 16740 9800 {}
C {lab_pin.sym} 16740 9800 0 0 {name=l31782 lab=BLB84}
N 16760 9760 16740 9760 {}
C {lab_pin.sym} 16740 9760 0 0 {name=l31783 lab=WL49}
N 16840 9840 16860 9840 {}
C {lab_pin.sym} 16860 9840 0 0 {name=l31784 lab=VDD}
N 16840 9760 16860 9760 {}
C {lab_pin.sym} 16860 9760 0 0 {name=l31785 lab=VSS}
C {bitcell_6t.sym} 17000 9800 0 0 {name=Xr49c85}
N 16960 9840 16940 9840 {}
C {lab_pin.sym} 16940 9840 0 0 {name=l31786 lab=BL85}
N 16960 9800 16940 9800 {}
C {lab_pin.sym} 16940 9800 0 0 {name=l31787 lab=BLB85}
N 16960 9760 16940 9760 {}
C {lab_pin.sym} 16940 9760 0 0 {name=l31788 lab=WL49}
N 17040 9840 17060 9840 {}
C {lab_pin.sym} 17060 9840 0 0 {name=l31789 lab=VDD}
N 17040 9760 17060 9760 {}
C {lab_pin.sym} 17060 9760 0 0 {name=l31790 lab=VSS}
C {bitcell_6t.sym} 17200 9800 0 0 {name=Xr49c86}
N 17160 9840 17140 9840 {}
C {lab_pin.sym} 17140 9840 0 0 {name=l31791 lab=BL86}
N 17160 9800 17140 9800 {}
C {lab_pin.sym} 17140 9800 0 0 {name=l31792 lab=BLB86}
N 17160 9760 17140 9760 {}
C {lab_pin.sym} 17140 9760 0 0 {name=l31793 lab=WL49}
N 17240 9840 17260 9840 {}
C {lab_pin.sym} 17260 9840 0 0 {name=l31794 lab=VDD}
N 17240 9760 17260 9760 {}
C {lab_pin.sym} 17260 9760 0 0 {name=l31795 lab=VSS}
C {bitcell_6t.sym} 17400 9800 0 0 {name=Xr49c87}
N 17360 9840 17340 9840 {}
C {lab_pin.sym} 17340 9840 0 0 {name=l31796 lab=BL87}
N 17360 9800 17340 9800 {}
C {lab_pin.sym} 17340 9800 0 0 {name=l31797 lab=BLB87}
N 17360 9760 17340 9760 {}
C {lab_pin.sym} 17340 9760 0 0 {name=l31798 lab=WL49}
N 17440 9840 17460 9840 {}
C {lab_pin.sym} 17460 9840 0 0 {name=l31799 lab=VDD}
N 17440 9760 17460 9760 {}
C {lab_pin.sym} 17460 9760 0 0 {name=l31800 lab=VSS}
C {bitcell_6t.sym} 17600 9800 0 0 {name=Xr49c88}
N 17560 9840 17540 9840 {}
C {lab_pin.sym} 17540 9840 0 0 {name=l31801 lab=BL88}
N 17560 9800 17540 9800 {}
C {lab_pin.sym} 17540 9800 0 0 {name=l31802 lab=BLB88}
N 17560 9760 17540 9760 {}
C {lab_pin.sym} 17540 9760 0 0 {name=l31803 lab=WL49}
N 17640 9840 17660 9840 {}
C {lab_pin.sym} 17660 9840 0 0 {name=l31804 lab=VDD}
N 17640 9760 17660 9760 {}
C {lab_pin.sym} 17660 9760 0 0 {name=l31805 lab=VSS}
C {bitcell_6t.sym} 17800 9800 0 0 {name=Xr49c89}
N 17760 9840 17740 9840 {}
C {lab_pin.sym} 17740 9840 0 0 {name=l31806 lab=BL89}
N 17760 9800 17740 9800 {}
C {lab_pin.sym} 17740 9800 0 0 {name=l31807 lab=BLB89}
N 17760 9760 17740 9760 {}
C {lab_pin.sym} 17740 9760 0 0 {name=l31808 lab=WL49}
N 17840 9840 17860 9840 {}
C {lab_pin.sym} 17860 9840 0 0 {name=l31809 lab=VDD}
N 17840 9760 17860 9760 {}
C {lab_pin.sym} 17860 9760 0 0 {name=l31810 lab=VSS}
C {bitcell_6t.sym} 18000 9800 0 0 {name=Xr49c90}
N 17960 9840 17940 9840 {}
C {lab_pin.sym} 17940 9840 0 0 {name=l31811 lab=BL90}
N 17960 9800 17940 9800 {}
C {lab_pin.sym} 17940 9800 0 0 {name=l31812 lab=BLB90}
N 17960 9760 17940 9760 {}
C {lab_pin.sym} 17940 9760 0 0 {name=l31813 lab=WL49}
N 18040 9840 18060 9840 {}
C {lab_pin.sym} 18060 9840 0 0 {name=l31814 lab=VDD}
N 18040 9760 18060 9760 {}
C {lab_pin.sym} 18060 9760 0 0 {name=l31815 lab=VSS}
C {bitcell_6t.sym} 18200 9800 0 0 {name=Xr49c91}
N 18160 9840 18140 9840 {}
C {lab_pin.sym} 18140 9840 0 0 {name=l31816 lab=BL91}
N 18160 9800 18140 9800 {}
C {lab_pin.sym} 18140 9800 0 0 {name=l31817 lab=BLB91}
N 18160 9760 18140 9760 {}
C {lab_pin.sym} 18140 9760 0 0 {name=l31818 lab=WL49}
N 18240 9840 18260 9840 {}
C {lab_pin.sym} 18260 9840 0 0 {name=l31819 lab=VDD}
N 18240 9760 18260 9760 {}
C {lab_pin.sym} 18260 9760 0 0 {name=l31820 lab=VSS}
C {bitcell_6t.sym} 18400 9800 0 0 {name=Xr49c92}
N 18360 9840 18340 9840 {}
C {lab_pin.sym} 18340 9840 0 0 {name=l31821 lab=BL92}
N 18360 9800 18340 9800 {}
C {lab_pin.sym} 18340 9800 0 0 {name=l31822 lab=BLB92}
N 18360 9760 18340 9760 {}
C {lab_pin.sym} 18340 9760 0 0 {name=l31823 lab=WL49}
N 18440 9840 18460 9840 {}
C {lab_pin.sym} 18460 9840 0 0 {name=l31824 lab=VDD}
N 18440 9760 18460 9760 {}
C {lab_pin.sym} 18460 9760 0 0 {name=l31825 lab=VSS}
C {bitcell_6t.sym} 18600 9800 0 0 {name=Xr49c93}
N 18560 9840 18540 9840 {}
C {lab_pin.sym} 18540 9840 0 0 {name=l31826 lab=BL93}
N 18560 9800 18540 9800 {}
C {lab_pin.sym} 18540 9800 0 0 {name=l31827 lab=BLB93}
N 18560 9760 18540 9760 {}
C {lab_pin.sym} 18540 9760 0 0 {name=l31828 lab=WL49}
N 18640 9840 18660 9840 {}
C {lab_pin.sym} 18660 9840 0 0 {name=l31829 lab=VDD}
N 18640 9760 18660 9760 {}
C {lab_pin.sym} 18660 9760 0 0 {name=l31830 lab=VSS}
C {bitcell_6t.sym} 18800 9800 0 0 {name=Xr49c94}
N 18760 9840 18740 9840 {}
C {lab_pin.sym} 18740 9840 0 0 {name=l31831 lab=BL94}
N 18760 9800 18740 9800 {}
C {lab_pin.sym} 18740 9800 0 0 {name=l31832 lab=BLB94}
N 18760 9760 18740 9760 {}
C {lab_pin.sym} 18740 9760 0 0 {name=l31833 lab=WL49}
N 18840 9840 18860 9840 {}
C {lab_pin.sym} 18860 9840 0 0 {name=l31834 lab=VDD}
N 18840 9760 18860 9760 {}
C {lab_pin.sym} 18860 9760 0 0 {name=l31835 lab=VSS}
C {bitcell_6t.sym} 19000 9800 0 0 {name=Xr49c95}
N 18960 9840 18940 9840 {}
C {lab_pin.sym} 18940 9840 0 0 {name=l31836 lab=BL95}
N 18960 9800 18940 9800 {}
C {lab_pin.sym} 18940 9800 0 0 {name=l31837 lab=BLB95}
N 18960 9760 18940 9760 {}
C {lab_pin.sym} 18940 9760 0 0 {name=l31838 lab=WL49}
N 19040 9840 19060 9840 {}
C {lab_pin.sym} 19060 9840 0 0 {name=l31839 lab=VDD}
N 19040 9760 19060 9760 {}
C {lab_pin.sym} 19060 9760 0 0 {name=l31840 lab=VSS}
C {bitcell_6t.sym} 19200 9800 0 0 {name=Xr49c96}
N 19160 9840 19140 9840 {}
C {lab_pin.sym} 19140 9840 0 0 {name=l31841 lab=BL96}
N 19160 9800 19140 9800 {}
C {lab_pin.sym} 19140 9800 0 0 {name=l31842 lab=BLB96}
N 19160 9760 19140 9760 {}
C {lab_pin.sym} 19140 9760 0 0 {name=l31843 lab=WL49}
N 19240 9840 19260 9840 {}
C {lab_pin.sym} 19260 9840 0 0 {name=l31844 lab=VDD}
N 19240 9760 19260 9760 {}
C {lab_pin.sym} 19260 9760 0 0 {name=l31845 lab=VSS}
C {bitcell_6t.sym} 19400 9800 0 0 {name=Xr49c97}
N 19360 9840 19340 9840 {}
C {lab_pin.sym} 19340 9840 0 0 {name=l31846 lab=BL97}
N 19360 9800 19340 9800 {}
C {lab_pin.sym} 19340 9800 0 0 {name=l31847 lab=BLB97}
N 19360 9760 19340 9760 {}
C {lab_pin.sym} 19340 9760 0 0 {name=l31848 lab=WL49}
N 19440 9840 19460 9840 {}
C {lab_pin.sym} 19460 9840 0 0 {name=l31849 lab=VDD}
N 19440 9760 19460 9760 {}
C {lab_pin.sym} 19460 9760 0 0 {name=l31850 lab=VSS}
C {bitcell_6t.sym} 19600 9800 0 0 {name=Xr49c98}
N 19560 9840 19540 9840 {}
C {lab_pin.sym} 19540 9840 0 0 {name=l31851 lab=BL98}
N 19560 9800 19540 9800 {}
C {lab_pin.sym} 19540 9800 0 0 {name=l31852 lab=BLB98}
N 19560 9760 19540 9760 {}
C {lab_pin.sym} 19540 9760 0 0 {name=l31853 lab=WL49}
N 19640 9840 19660 9840 {}
C {lab_pin.sym} 19660 9840 0 0 {name=l31854 lab=VDD}
N 19640 9760 19660 9760 {}
C {lab_pin.sym} 19660 9760 0 0 {name=l31855 lab=VSS}
C {bitcell_6t.sym} 19800 9800 0 0 {name=Xr49c99}
N 19760 9840 19740 9840 {}
C {lab_pin.sym} 19740 9840 0 0 {name=l31856 lab=BL99}
N 19760 9800 19740 9800 {}
C {lab_pin.sym} 19740 9800 0 0 {name=l31857 lab=BLB99}
N 19760 9760 19740 9760 {}
C {lab_pin.sym} 19740 9760 0 0 {name=l31858 lab=WL49}
N 19840 9840 19860 9840 {}
C {lab_pin.sym} 19860 9840 0 0 {name=l31859 lab=VDD}
N 19840 9760 19860 9760 {}
C {lab_pin.sym} 19860 9760 0 0 {name=l31860 lab=VSS}
C {bitcell_6t.sym} 20000 9800 0 0 {name=Xr49c100}
N 19960 9840 19940 9840 {}
C {lab_pin.sym} 19940 9840 0 0 {name=l31861 lab=BL100}
N 19960 9800 19940 9800 {}
C {lab_pin.sym} 19940 9800 0 0 {name=l31862 lab=BLB100}
N 19960 9760 19940 9760 {}
C {lab_pin.sym} 19940 9760 0 0 {name=l31863 lab=WL49}
N 20040 9840 20060 9840 {}
C {lab_pin.sym} 20060 9840 0 0 {name=l31864 lab=VDD}
N 20040 9760 20060 9760 {}
C {lab_pin.sym} 20060 9760 0 0 {name=l31865 lab=VSS}
C {bitcell_6t.sym} 20200 9800 0 0 {name=Xr49c101}
N 20160 9840 20140 9840 {}
C {lab_pin.sym} 20140 9840 0 0 {name=l31866 lab=BL101}
N 20160 9800 20140 9800 {}
C {lab_pin.sym} 20140 9800 0 0 {name=l31867 lab=BLB101}
N 20160 9760 20140 9760 {}
C {lab_pin.sym} 20140 9760 0 0 {name=l31868 lab=WL49}
N 20240 9840 20260 9840 {}
C {lab_pin.sym} 20260 9840 0 0 {name=l31869 lab=VDD}
N 20240 9760 20260 9760 {}
C {lab_pin.sym} 20260 9760 0 0 {name=l31870 lab=VSS}
C {bitcell_6t.sym} 20400 9800 0 0 {name=Xr49c102}
N 20360 9840 20340 9840 {}
C {lab_pin.sym} 20340 9840 0 0 {name=l31871 lab=BL102}
N 20360 9800 20340 9800 {}
C {lab_pin.sym} 20340 9800 0 0 {name=l31872 lab=BLB102}
N 20360 9760 20340 9760 {}
C {lab_pin.sym} 20340 9760 0 0 {name=l31873 lab=WL49}
N 20440 9840 20460 9840 {}
C {lab_pin.sym} 20460 9840 0 0 {name=l31874 lab=VDD}
N 20440 9760 20460 9760 {}
C {lab_pin.sym} 20460 9760 0 0 {name=l31875 lab=VSS}
C {bitcell_6t.sym} 20600 9800 0 0 {name=Xr49c103}
N 20560 9840 20540 9840 {}
C {lab_pin.sym} 20540 9840 0 0 {name=l31876 lab=BL103}
N 20560 9800 20540 9800 {}
C {lab_pin.sym} 20540 9800 0 0 {name=l31877 lab=BLB103}
N 20560 9760 20540 9760 {}
C {lab_pin.sym} 20540 9760 0 0 {name=l31878 lab=WL49}
N 20640 9840 20660 9840 {}
C {lab_pin.sym} 20660 9840 0 0 {name=l31879 lab=VDD}
N 20640 9760 20660 9760 {}
C {lab_pin.sym} 20660 9760 0 0 {name=l31880 lab=VSS}
C {bitcell_6t.sym} 20800 9800 0 0 {name=Xr49c104}
N 20760 9840 20740 9840 {}
C {lab_pin.sym} 20740 9840 0 0 {name=l31881 lab=BL104}
N 20760 9800 20740 9800 {}
C {lab_pin.sym} 20740 9800 0 0 {name=l31882 lab=BLB104}
N 20760 9760 20740 9760 {}
C {lab_pin.sym} 20740 9760 0 0 {name=l31883 lab=WL49}
N 20840 9840 20860 9840 {}
C {lab_pin.sym} 20860 9840 0 0 {name=l31884 lab=VDD}
N 20840 9760 20860 9760 {}
C {lab_pin.sym} 20860 9760 0 0 {name=l31885 lab=VSS}
C {bitcell_6t.sym} 21000 9800 0 0 {name=Xr49c105}
N 20960 9840 20940 9840 {}
C {lab_pin.sym} 20940 9840 0 0 {name=l31886 lab=BL105}
N 20960 9800 20940 9800 {}
C {lab_pin.sym} 20940 9800 0 0 {name=l31887 lab=BLB105}
N 20960 9760 20940 9760 {}
C {lab_pin.sym} 20940 9760 0 0 {name=l31888 lab=WL49}
N 21040 9840 21060 9840 {}
C {lab_pin.sym} 21060 9840 0 0 {name=l31889 lab=VDD}
N 21040 9760 21060 9760 {}
C {lab_pin.sym} 21060 9760 0 0 {name=l31890 lab=VSS}
C {bitcell_6t.sym} 21200 9800 0 0 {name=Xr49c106}
N 21160 9840 21140 9840 {}
C {lab_pin.sym} 21140 9840 0 0 {name=l31891 lab=BL106}
N 21160 9800 21140 9800 {}
C {lab_pin.sym} 21140 9800 0 0 {name=l31892 lab=BLB106}
N 21160 9760 21140 9760 {}
C {lab_pin.sym} 21140 9760 0 0 {name=l31893 lab=WL49}
N 21240 9840 21260 9840 {}
C {lab_pin.sym} 21260 9840 0 0 {name=l31894 lab=VDD}
N 21240 9760 21260 9760 {}
C {lab_pin.sym} 21260 9760 0 0 {name=l31895 lab=VSS}
C {bitcell_6t.sym} 21400 9800 0 0 {name=Xr49c107}
N 21360 9840 21340 9840 {}
C {lab_pin.sym} 21340 9840 0 0 {name=l31896 lab=BL107}
N 21360 9800 21340 9800 {}
C {lab_pin.sym} 21340 9800 0 0 {name=l31897 lab=BLB107}
N 21360 9760 21340 9760 {}
C {lab_pin.sym} 21340 9760 0 0 {name=l31898 lab=WL49}
N 21440 9840 21460 9840 {}
C {lab_pin.sym} 21460 9840 0 0 {name=l31899 lab=VDD}
N 21440 9760 21460 9760 {}
C {lab_pin.sym} 21460 9760 0 0 {name=l31900 lab=VSS}
C {bitcell_6t.sym} 21600 9800 0 0 {name=Xr49c108}
N 21560 9840 21540 9840 {}
C {lab_pin.sym} 21540 9840 0 0 {name=l31901 lab=BL108}
N 21560 9800 21540 9800 {}
C {lab_pin.sym} 21540 9800 0 0 {name=l31902 lab=BLB108}
N 21560 9760 21540 9760 {}
C {lab_pin.sym} 21540 9760 0 0 {name=l31903 lab=WL49}
N 21640 9840 21660 9840 {}
C {lab_pin.sym} 21660 9840 0 0 {name=l31904 lab=VDD}
N 21640 9760 21660 9760 {}
C {lab_pin.sym} 21660 9760 0 0 {name=l31905 lab=VSS}
C {bitcell_6t.sym} 21800 9800 0 0 {name=Xr49c109}
N 21760 9840 21740 9840 {}
C {lab_pin.sym} 21740 9840 0 0 {name=l31906 lab=BL109}
N 21760 9800 21740 9800 {}
C {lab_pin.sym} 21740 9800 0 0 {name=l31907 lab=BLB109}
N 21760 9760 21740 9760 {}
C {lab_pin.sym} 21740 9760 0 0 {name=l31908 lab=WL49}
N 21840 9840 21860 9840 {}
C {lab_pin.sym} 21860 9840 0 0 {name=l31909 lab=VDD}
N 21840 9760 21860 9760 {}
C {lab_pin.sym} 21860 9760 0 0 {name=l31910 lab=VSS}
C {bitcell_6t.sym} 22000 9800 0 0 {name=Xr49c110}
N 21960 9840 21940 9840 {}
C {lab_pin.sym} 21940 9840 0 0 {name=l31911 lab=BL110}
N 21960 9800 21940 9800 {}
C {lab_pin.sym} 21940 9800 0 0 {name=l31912 lab=BLB110}
N 21960 9760 21940 9760 {}
C {lab_pin.sym} 21940 9760 0 0 {name=l31913 lab=WL49}
N 22040 9840 22060 9840 {}
C {lab_pin.sym} 22060 9840 0 0 {name=l31914 lab=VDD}
N 22040 9760 22060 9760 {}
C {lab_pin.sym} 22060 9760 0 0 {name=l31915 lab=VSS}
C {bitcell_6t.sym} 22200 9800 0 0 {name=Xr49c111}
N 22160 9840 22140 9840 {}
C {lab_pin.sym} 22140 9840 0 0 {name=l31916 lab=BL111}
N 22160 9800 22140 9800 {}
C {lab_pin.sym} 22140 9800 0 0 {name=l31917 lab=BLB111}
N 22160 9760 22140 9760 {}
C {lab_pin.sym} 22140 9760 0 0 {name=l31918 lab=WL49}
N 22240 9840 22260 9840 {}
C {lab_pin.sym} 22260 9840 0 0 {name=l31919 lab=VDD}
N 22240 9760 22260 9760 {}
C {lab_pin.sym} 22260 9760 0 0 {name=l31920 lab=VSS}
C {bitcell_6t.sym} 22400 9800 0 0 {name=Xr49c112}
N 22360 9840 22340 9840 {}
C {lab_pin.sym} 22340 9840 0 0 {name=l31921 lab=BL112}
N 22360 9800 22340 9800 {}
C {lab_pin.sym} 22340 9800 0 0 {name=l31922 lab=BLB112}
N 22360 9760 22340 9760 {}
C {lab_pin.sym} 22340 9760 0 0 {name=l31923 lab=WL49}
N 22440 9840 22460 9840 {}
C {lab_pin.sym} 22460 9840 0 0 {name=l31924 lab=VDD}
N 22440 9760 22460 9760 {}
C {lab_pin.sym} 22460 9760 0 0 {name=l31925 lab=VSS}
C {bitcell_6t.sym} 22600 9800 0 0 {name=Xr49c113}
N 22560 9840 22540 9840 {}
C {lab_pin.sym} 22540 9840 0 0 {name=l31926 lab=BL113}
N 22560 9800 22540 9800 {}
C {lab_pin.sym} 22540 9800 0 0 {name=l31927 lab=BLB113}
N 22560 9760 22540 9760 {}
C {lab_pin.sym} 22540 9760 0 0 {name=l31928 lab=WL49}
N 22640 9840 22660 9840 {}
C {lab_pin.sym} 22660 9840 0 0 {name=l31929 lab=VDD}
N 22640 9760 22660 9760 {}
C {lab_pin.sym} 22660 9760 0 0 {name=l31930 lab=VSS}
C {bitcell_6t.sym} 22800 9800 0 0 {name=Xr49c114}
N 22760 9840 22740 9840 {}
C {lab_pin.sym} 22740 9840 0 0 {name=l31931 lab=BL114}
N 22760 9800 22740 9800 {}
C {lab_pin.sym} 22740 9800 0 0 {name=l31932 lab=BLB114}
N 22760 9760 22740 9760 {}
C {lab_pin.sym} 22740 9760 0 0 {name=l31933 lab=WL49}
N 22840 9840 22860 9840 {}
C {lab_pin.sym} 22860 9840 0 0 {name=l31934 lab=VDD}
N 22840 9760 22860 9760 {}
C {lab_pin.sym} 22860 9760 0 0 {name=l31935 lab=VSS}
C {bitcell_6t.sym} 23000 9800 0 0 {name=Xr49c115}
N 22960 9840 22940 9840 {}
C {lab_pin.sym} 22940 9840 0 0 {name=l31936 lab=BL115}
N 22960 9800 22940 9800 {}
C {lab_pin.sym} 22940 9800 0 0 {name=l31937 lab=BLB115}
N 22960 9760 22940 9760 {}
C {lab_pin.sym} 22940 9760 0 0 {name=l31938 lab=WL49}
N 23040 9840 23060 9840 {}
C {lab_pin.sym} 23060 9840 0 0 {name=l31939 lab=VDD}
N 23040 9760 23060 9760 {}
C {lab_pin.sym} 23060 9760 0 0 {name=l31940 lab=VSS}
C {bitcell_6t.sym} 23200 9800 0 0 {name=Xr49c116}
N 23160 9840 23140 9840 {}
C {lab_pin.sym} 23140 9840 0 0 {name=l31941 lab=BL116}
N 23160 9800 23140 9800 {}
C {lab_pin.sym} 23140 9800 0 0 {name=l31942 lab=BLB116}
N 23160 9760 23140 9760 {}
C {lab_pin.sym} 23140 9760 0 0 {name=l31943 lab=WL49}
N 23240 9840 23260 9840 {}
C {lab_pin.sym} 23260 9840 0 0 {name=l31944 lab=VDD}
N 23240 9760 23260 9760 {}
C {lab_pin.sym} 23260 9760 0 0 {name=l31945 lab=VSS}
C {bitcell_6t.sym} 23400 9800 0 0 {name=Xr49c117}
N 23360 9840 23340 9840 {}
C {lab_pin.sym} 23340 9840 0 0 {name=l31946 lab=BL117}
N 23360 9800 23340 9800 {}
C {lab_pin.sym} 23340 9800 0 0 {name=l31947 lab=BLB117}
N 23360 9760 23340 9760 {}
C {lab_pin.sym} 23340 9760 0 0 {name=l31948 lab=WL49}
N 23440 9840 23460 9840 {}
C {lab_pin.sym} 23460 9840 0 0 {name=l31949 lab=VDD}
N 23440 9760 23460 9760 {}
C {lab_pin.sym} 23460 9760 0 0 {name=l31950 lab=VSS}
C {bitcell_6t.sym} 23600 9800 0 0 {name=Xr49c118}
N 23560 9840 23540 9840 {}
C {lab_pin.sym} 23540 9840 0 0 {name=l31951 lab=BL118}
N 23560 9800 23540 9800 {}
C {lab_pin.sym} 23540 9800 0 0 {name=l31952 lab=BLB118}
N 23560 9760 23540 9760 {}
C {lab_pin.sym} 23540 9760 0 0 {name=l31953 lab=WL49}
N 23640 9840 23660 9840 {}
C {lab_pin.sym} 23660 9840 0 0 {name=l31954 lab=VDD}
N 23640 9760 23660 9760 {}
C {lab_pin.sym} 23660 9760 0 0 {name=l31955 lab=VSS}
C {bitcell_6t.sym} 23800 9800 0 0 {name=Xr49c119}
N 23760 9840 23740 9840 {}
C {lab_pin.sym} 23740 9840 0 0 {name=l31956 lab=BL119}
N 23760 9800 23740 9800 {}
C {lab_pin.sym} 23740 9800 0 0 {name=l31957 lab=BLB119}
N 23760 9760 23740 9760 {}
C {lab_pin.sym} 23740 9760 0 0 {name=l31958 lab=WL49}
N 23840 9840 23860 9840 {}
C {lab_pin.sym} 23860 9840 0 0 {name=l31959 lab=VDD}
N 23840 9760 23860 9760 {}
C {lab_pin.sym} 23860 9760 0 0 {name=l31960 lab=VSS}
C {bitcell_6t.sym} 24000 9800 0 0 {name=Xr49c120}
N 23960 9840 23940 9840 {}
C {lab_pin.sym} 23940 9840 0 0 {name=l31961 lab=BL120}
N 23960 9800 23940 9800 {}
C {lab_pin.sym} 23940 9800 0 0 {name=l31962 lab=BLB120}
N 23960 9760 23940 9760 {}
C {lab_pin.sym} 23940 9760 0 0 {name=l31963 lab=WL49}
N 24040 9840 24060 9840 {}
C {lab_pin.sym} 24060 9840 0 0 {name=l31964 lab=VDD}
N 24040 9760 24060 9760 {}
C {lab_pin.sym} 24060 9760 0 0 {name=l31965 lab=VSS}
C {bitcell_6t.sym} 24200 9800 0 0 {name=Xr49c121}
N 24160 9840 24140 9840 {}
C {lab_pin.sym} 24140 9840 0 0 {name=l31966 lab=BL121}
N 24160 9800 24140 9800 {}
C {lab_pin.sym} 24140 9800 0 0 {name=l31967 lab=BLB121}
N 24160 9760 24140 9760 {}
C {lab_pin.sym} 24140 9760 0 0 {name=l31968 lab=WL49}
N 24240 9840 24260 9840 {}
C {lab_pin.sym} 24260 9840 0 0 {name=l31969 lab=VDD}
N 24240 9760 24260 9760 {}
C {lab_pin.sym} 24260 9760 0 0 {name=l31970 lab=VSS}
C {bitcell_6t.sym} 24400 9800 0 0 {name=Xr49c122}
N 24360 9840 24340 9840 {}
C {lab_pin.sym} 24340 9840 0 0 {name=l31971 lab=BL122}
N 24360 9800 24340 9800 {}
C {lab_pin.sym} 24340 9800 0 0 {name=l31972 lab=BLB122}
N 24360 9760 24340 9760 {}
C {lab_pin.sym} 24340 9760 0 0 {name=l31973 lab=WL49}
N 24440 9840 24460 9840 {}
C {lab_pin.sym} 24460 9840 0 0 {name=l31974 lab=VDD}
N 24440 9760 24460 9760 {}
C {lab_pin.sym} 24460 9760 0 0 {name=l31975 lab=VSS}
C {bitcell_6t.sym} 24600 9800 0 0 {name=Xr49c123}
N 24560 9840 24540 9840 {}
C {lab_pin.sym} 24540 9840 0 0 {name=l31976 lab=BL123}
N 24560 9800 24540 9800 {}
C {lab_pin.sym} 24540 9800 0 0 {name=l31977 lab=BLB123}
N 24560 9760 24540 9760 {}
C {lab_pin.sym} 24540 9760 0 0 {name=l31978 lab=WL49}
N 24640 9840 24660 9840 {}
C {lab_pin.sym} 24660 9840 0 0 {name=l31979 lab=VDD}
N 24640 9760 24660 9760 {}
C {lab_pin.sym} 24660 9760 0 0 {name=l31980 lab=VSS}
C {bitcell_6t.sym} 24800 9800 0 0 {name=Xr49c124}
N 24760 9840 24740 9840 {}
C {lab_pin.sym} 24740 9840 0 0 {name=l31981 lab=BL124}
N 24760 9800 24740 9800 {}
C {lab_pin.sym} 24740 9800 0 0 {name=l31982 lab=BLB124}
N 24760 9760 24740 9760 {}
C {lab_pin.sym} 24740 9760 0 0 {name=l31983 lab=WL49}
N 24840 9840 24860 9840 {}
C {lab_pin.sym} 24860 9840 0 0 {name=l31984 lab=VDD}
N 24840 9760 24860 9760 {}
C {lab_pin.sym} 24860 9760 0 0 {name=l31985 lab=VSS}
C {bitcell_6t.sym} 25000 9800 0 0 {name=Xr49c125}
N 24960 9840 24940 9840 {}
C {lab_pin.sym} 24940 9840 0 0 {name=l31986 lab=BL125}
N 24960 9800 24940 9800 {}
C {lab_pin.sym} 24940 9800 0 0 {name=l31987 lab=BLB125}
N 24960 9760 24940 9760 {}
C {lab_pin.sym} 24940 9760 0 0 {name=l31988 lab=WL49}
N 25040 9840 25060 9840 {}
C {lab_pin.sym} 25060 9840 0 0 {name=l31989 lab=VDD}
N 25040 9760 25060 9760 {}
C {lab_pin.sym} 25060 9760 0 0 {name=l31990 lab=VSS}
C {bitcell_6t.sym} 25200 9800 0 0 {name=Xr49c126}
N 25160 9840 25140 9840 {}
C {lab_pin.sym} 25140 9840 0 0 {name=l31991 lab=BL126}
N 25160 9800 25140 9800 {}
C {lab_pin.sym} 25140 9800 0 0 {name=l31992 lab=BLB126}
N 25160 9760 25140 9760 {}
C {lab_pin.sym} 25140 9760 0 0 {name=l31993 lab=WL49}
N 25240 9840 25260 9840 {}
C {lab_pin.sym} 25260 9840 0 0 {name=l31994 lab=VDD}
N 25240 9760 25260 9760 {}
C {lab_pin.sym} 25260 9760 0 0 {name=l31995 lab=VSS}
C {bitcell_6t.sym} 25400 9800 0 0 {name=Xr49c127}
N 25360 9840 25340 9840 {}
C {lab_pin.sym} 25340 9840 0 0 {name=l31996 lab=BL127}
N 25360 9800 25340 9800 {}
C {lab_pin.sym} 25340 9800 0 0 {name=l31997 lab=BLB127}
N 25360 9760 25340 9760 {}
C {lab_pin.sym} 25340 9760 0 0 {name=l31998 lab=WL49}
N 25440 9840 25460 9840 {}
C {lab_pin.sym} 25460 9840 0 0 {name=l31999 lab=VDD}
N 25440 9760 25460 9760 {}
C {lab_pin.sym} 25460 9760 0 0 {name=l32000 lab=VSS}
C {bitcell_6t.sym} 0 10000 0 0 {name=Xr50c0}
N -40 10040 -60 10040 {}
C {lab_pin.sym} -60 10040 0 0 {name=l32001 lab=BL0}
N -40 10000 -60 10000 {}
C {lab_pin.sym} -60 10000 0 0 {name=l32002 lab=BLB0}
N -40 9960 -60 9960 {}
C {lab_pin.sym} -60 9960 0 0 {name=l32003 lab=WL50}
N 40 10040 60 10040 {}
C {lab_pin.sym} 60 10040 0 0 {name=l32004 lab=VDD}
N 40 9960 60 9960 {}
C {lab_pin.sym} 60 9960 0 0 {name=l32005 lab=VSS}
C {bitcell_6t.sym} 200 10000 0 0 {name=Xr50c1}
N 160 10040 140 10040 {}
C {lab_pin.sym} 140 10040 0 0 {name=l32006 lab=BL1}
N 160 10000 140 10000 {}
C {lab_pin.sym} 140 10000 0 0 {name=l32007 lab=BLB1}
N 160 9960 140 9960 {}
C {lab_pin.sym} 140 9960 0 0 {name=l32008 lab=WL50}
N 240 10040 260 10040 {}
C {lab_pin.sym} 260 10040 0 0 {name=l32009 lab=VDD}
N 240 9960 260 9960 {}
C {lab_pin.sym} 260 9960 0 0 {name=l32010 lab=VSS}
C {bitcell_6t.sym} 400 10000 0 0 {name=Xr50c2}
N 360 10040 340 10040 {}
C {lab_pin.sym} 340 10040 0 0 {name=l32011 lab=BL2}
N 360 10000 340 10000 {}
C {lab_pin.sym} 340 10000 0 0 {name=l32012 lab=BLB2}
N 360 9960 340 9960 {}
C {lab_pin.sym} 340 9960 0 0 {name=l32013 lab=WL50}
N 440 10040 460 10040 {}
C {lab_pin.sym} 460 10040 0 0 {name=l32014 lab=VDD}
N 440 9960 460 9960 {}
C {lab_pin.sym} 460 9960 0 0 {name=l32015 lab=VSS}
C {bitcell_6t.sym} 600 10000 0 0 {name=Xr50c3}
N 560 10040 540 10040 {}
C {lab_pin.sym} 540 10040 0 0 {name=l32016 lab=BL3}
N 560 10000 540 10000 {}
C {lab_pin.sym} 540 10000 0 0 {name=l32017 lab=BLB3}
N 560 9960 540 9960 {}
C {lab_pin.sym} 540 9960 0 0 {name=l32018 lab=WL50}
N 640 10040 660 10040 {}
C {lab_pin.sym} 660 10040 0 0 {name=l32019 lab=VDD}
N 640 9960 660 9960 {}
C {lab_pin.sym} 660 9960 0 0 {name=l32020 lab=VSS}
C {bitcell_6t.sym} 800 10000 0 0 {name=Xr50c4}
N 760 10040 740 10040 {}
C {lab_pin.sym} 740 10040 0 0 {name=l32021 lab=BL4}
N 760 10000 740 10000 {}
C {lab_pin.sym} 740 10000 0 0 {name=l32022 lab=BLB4}
N 760 9960 740 9960 {}
C {lab_pin.sym} 740 9960 0 0 {name=l32023 lab=WL50}
N 840 10040 860 10040 {}
C {lab_pin.sym} 860 10040 0 0 {name=l32024 lab=VDD}
N 840 9960 860 9960 {}
C {lab_pin.sym} 860 9960 0 0 {name=l32025 lab=VSS}
C {bitcell_6t.sym} 1000 10000 0 0 {name=Xr50c5}
N 960 10040 940 10040 {}
C {lab_pin.sym} 940 10040 0 0 {name=l32026 lab=BL5}
N 960 10000 940 10000 {}
C {lab_pin.sym} 940 10000 0 0 {name=l32027 lab=BLB5}
N 960 9960 940 9960 {}
C {lab_pin.sym} 940 9960 0 0 {name=l32028 lab=WL50}
N 1040 10040 1060 10040 {}
C {lab_pin.sym} 1060 10040 0 0 {name=l32029 lab=VDD}
N 1040 9960 1060 9960 {}
C {lab_pin.sym} 1060 9960 0 0 {name=l32030 lab=VSS}
C {bitcell_6t.sym} 1200 10000 0 0 {name=Xr50c6}
N 1160 10040 1140 10040 {}
C {lab_pin.sym} 1140 10040 0 0 {name=l32031 lab=BL6}
N 1160 10000 1140 10000 {}
C {lab_pin.sym} 1140 10000 0 0 {name=l32032 lab=BLB6}
N 1160 9960 1140 9960 {}
C {lab_pin.sym} 1140 9960 0 0 {name=l32033 lab=WL50}
N 1240 10040 1260 10040 {}
C {lab_pin.sym} 1260 10040 0 0 {name=l32034 lab=VDD}
N 1240 9960 1260 9960 {}
C {lab_pin.sym} 1260 9960 0 0 {name=l32035 lab=VSS}
C {bitcell_6t.sym} 1400 10000 0 0 {name=Xr50c7}
N 1360 10040 1340 10040 {}
C {lab_pin.sym} 1340 10040 0 0 {name=l32036 lab=BL7}
N 1360 10000 1340 10000 {}
C {lab_pin.sym} 1340 10000 0 0 {name=l32037 lab=BLB7}
N 1360 9960 1340 9960 {}
C {lab_pin.sym} 1340 9960 0 0 {name=l32038 lab=WL50}
N 1440 10040 1460 10040 {}
C {lab_pin.sym} 1460 10040 0 0 {name=l32039 lab=VDD}
N 1440 9960 1460 9960 {}
C {lab_pin.sym} 1460 9960 0 0 {name=l32040 lab=VSS}
C {bitcell_6t.sym} 1600 10000 0 0 {name=Xr50c8}
N 1560 10040 1540 10040 {}
C {lab_pin.sym} 1540 10040 0 0 {name=l32041 lab=BL8}
N 1560 10000 1540 10000 {}
C {lab_pin.sym} 1540 10000 0 0 {name=l32042 lab=BLB8}
N 1560 9960 1540 9960 {}
C {lab_pin.sym} 1540 9960 0 0 {name=l32043 lab=WL50}
N 1640 10040 1660 10040 {}
C {lab_pin.sym} 1660 10040 0 0 {name=l32044 lab=VDD}
N 1640 9960 1660 9960 {}
C {lab_pin.sym} 1660 9960 0 0 {name=l32045 lab=VSS}
C {bitcell_6t.sym} 1800 10000 0 0 {name=Xr50c9}
N 1760 10040 1740 10040 {}
C {lab_pin.sym} 1740 10040 0 0 {name=l32046 lab=BL9}
N 1760 10000 1740 10000 {}
C {lab_pin.sym} 1740 10000 0 0 {name=l32047 lab=BLB9}
N 1760 9960 1740 9960 {}
C {lab_pin.sym} 1740 9960 0 0 {name=l32048 lab=WL50}
N 1840 10040 1860 10040 {}
C {lab_pin.sym} 1860 10040 0 0 {name=l32049 lab=VDD}
N 1840 9960 1860 9960 {}
C {lab_pin.sym} 1860 9960 0 0 {name=l32050 lab=VSS}
C {bitcell_6t.sym} 2000 10000 0 0 {name=Xr50c10}
N 1960 10040 1940 10040 {}
C {lab_pin.sym} 1940 10040 0 0 {name=l32051 lab=BL10}
N 1960 10000 1940 10000 {}
C {lab_pin.sym} 1940 10000 0 0 {name=l32052 lab=BLB10}
N 1960 9960 1940 9960 {}
C {lab_pin.sym} 1940 9960 0 0 {name=l32053 lab=WL50}
N 2040 10040 2060 10040 {}
C {lab_pin.sym} 2060 10040 0 0 {name=l32054 lab=VDD}
N 2040 9960 2060 9960 {}
C {lab_pin.sym} 2060 9960 0 0 {name=l32055 lab=VSS}
C {bitcell_6t.sym} 2200 10000 0 0 {name=Xr50c11}
N 2160 10040 2140 10040 {}
C {lab_pin.sym} 2140 10040 0 0 {name=l32056 lab=BL11}
N 2160 10000 2140 10000 {}
C {lab_pin.sym} 2140 10000 0 0 {name=l32057 lab=BLB11}
N 2160 9960 2140 9960 {}
C {lab_pin.sym} 2140 9960 0 0 {name=l32058 lab=WL50}
N 2240 10040 2260 10040 {}
C {lab_pin.sym} 2260 10040 0 0 {name=l32059 lab=VDD}
N 2240 9960 2260 9960 {}
C {lab_pin.sym} 2260 9960 0 0 {name=l32060 lab=VSS}
C {bitcell_6t.sym} 2400 10000 0 0 {name=Xr50c12}
N 2360 10040 2340 10040 {}
C {lab_pin.sym} 2340 10040 0 0 {name=l32061 lab=BL12}
N 2360 10000 2340 10000 {}
C {lab_pin.sym} 2340 10000 0 0 {name=l32062 lab=BLB12}
N 2360 9960 2340 9960 {}
C {lab_pin.sym} 2340 9960 0 0 {name=l32063 lab=WL50}
N 2440 10040 2460 10040 {}
C {lab_pin.sym} 2460 10040 0 0 {name=l32064 lab=VDD}
N 2440 9960 2460 9960 {}
C {lab_pin.sym} 2460 9960 0 0 {name=l32065 lab=VSS}
C {bitcell_6t.sym} 2600 10000 0 0 {name=Xr50c13}
N 2560 10040 2540 10040 {}
C {lab_pin.sym} 2540 10040 0 0 {name=l32066 lab=BL13}
N 2560 10000 2540 10000 {}
C {lab_pin.sym} 2540 10000 0 0 {name=l32067 lab=BLB13}
N 2560 9960 2540 9960 {}
C {lab_pin.sym} 2540 9960 0 0 {name=l32068 lab=WL50}
N 2640 10040 2660 10040 {}
C {lab_pin.sym} 2660 10040 0 0 {name=l32069 lab=VDD}
N 2640 9960 2660 9960 {}
C {lab_pin.sym} 2660 9960 0 0 {name=l32070 lab=VSS}
C {bitcell_6t.sym} 2800 10000 0 0 {name=Xr50c14}
N 2760 10040 2740 10040 {}
C {lab_pin.sym} 2740 10040 0 0 {name=l32071 lab=BL14}
N 2760 10000 2740 10000 {}
C {lab_pin.sym} 2740 10000 0 0 {name=l32072 lab=BLB14}
N 2760 9960 2740 9960 {}
C {lab_pin.sym} 2740 9960 0 0 {name=l32073 lab=WL50}
N 2840 10040 2860 10040 {}
C {lab_pin.sym} 2860 10040 0 0 {name=l32074 lab=VDD}
N 2840 9960 2860 9960 {}
C {lab_pin.sym} 2860 9960 0 0 {name=l32075 lab=VSS}
C {bitcell_6t.sym} 3000 10000 0 0 {name=Xr50c15}
N 2960 10040 2940 10040 {}
C {lab_pin.sym} 2940 10040 0 0 {name=l32076 lab=BL15}
N 2960 10000 2940 10000 {}
C {lab_pin.sym} 2940 10000 0 0 {name=l32077 lab=BLB15}
N 2960 9960 2940 9960 {}
C {lab_pin.sym} 2940 9960 0 0 {name=l32078 lab=WL50}
N 3040 10040 3060 10040 {}
C {lab_pin.sym} 3060 10040 0 0 {name=l32079 lab=VDD}
N 3040 9960 3060 9960 {}
C {lab_pin.sym} 3060 9960 0 0 {name=l32080 lab=VSS}
C {bitcell_6t.sym} 3200 10000 0 0 {name=Xr50c16}
N 3160 10040 3140 10040 {}
C {lab_pin.sym} 3140 10040 0 0 {name=l32081 lab=BL16}
N 3160 10000 3140 10000 {}
C {lab_pin.sym} 3140 10000 0 0 {name=l32082 lab=BLB16}
N 3160 9960 3140 9960 {}
C {lab_pin.sym} 3140 9960 0 0 {name=l32083 lab=WL50}
N 3240 10040 3260 10040 {}
C {lab_pin.sym} 3260 10040 0 0 {name=l32084 lab=VDD}
N 3240 9960 3260 9960 {}
C {lab_pin.sym} 3260 9960 0 0 {name=l32085 lab=VSS}
C {bitcell_6t.sym} 3400 10000 0 0 {name=Xr50c17}
N 3360 10040 3340 10040 {}
C {lab_pin.sym} 3340 10040 0 0 {name=l32086 lab=BL17}
N 3360 10000 3340 10000 {}
C {lab_pin.sym} 3340 10000 0 0 {name=l32087 lab=BLB17}
N 3360 9960 3340 9960 {}
C {lab_pin.sym} 3340 9960 0 0 {name=l32088 lab=WL50}
N 3440 10040 3460 10040 {}
C {lab_pin.sym} 3460 10040 0 0 {name=l32089 lab=VDD}
N 3440 9960 3460 9960 {}
C {lab_pin.sym} 3460 9960 0 0 {name=l32090 lab=VSS}
C {bitcell_6t.sym} 3600 10000 0 0 {name=Xr50c18}
N 3560 10040 3540 10040 {}
C {lab_pin.sym} 3540 10040 0 0 {name=l32091 lab=BL18}
N 3560 10000 3540 10000 {}
C {lab_pin.sym} 3540 10000 0 0 {name=l32092 lab=BLB18}
N 3560 9960 3540 9960 {}
C {lab_pin.sym} 3540 9960 0 0 {name=l32093 lab=WL50}
N 3640 10040 3660 10040 {}
C {lab_pin.sym} 3660 10040 0 0 {name=l32094 lab=VDD}
N 3640 9960 3660 9960 {}
C {lab_pin.sym} 3660 9960 0 0 {name=l32095 lab=VSS}
C {bitcell_6t.sym} 3800 10000 0 0 {name=Xr50c19}
N 3760 10040 3740 10040 {}
C {lab_pin.sym} 3740 10040 0 0 {name=l32096 lab=BL19}
N 3760 10000 3740 10000 {}
C {lab_pin.sym} 3740 10000 0 0 {name=l32097 lab=BLB19}
N 3760 9960 3740 9960 {}
C {lab_pin.sym} 3740 9960 0 0 {name=l32098 lab=WL50}
N 3840 10040 3860 10040 {}
C {lab_pin.sym} 3860 10040 0 0 {name=l32099 lab=VDD}
N 3840 9960 3860 9960 {}
C {lab_pin.sym} 3860 9960 0 0 {name=l32100 lab=VSS}
C {bitcell_6t.sym} 4000 10000 0 0 {name=Xr50c20}
N 3960 10040 3940 10040 {}
C {lab_pin.sym} 3940 10040 0 0 {name=l32101 lab=BL20}
N 3960 10000 3940 10000 {}
C {lab_pin.sym} 3940 10000 0 0 {name=l32102 lab=BLB20}
N 3960 9960 3940 9960 {}
C {lab_pin.sym} 3940 9960 0 0 {name=l32103 lab=WL50}
N 4040 10040 4060 10040 {}
C {lab_pin.sym} 4060 10040 0 0 {name=l32104 lab=VDD}
N 4040 9960 4060 9960 {}
C {lab_pin.sym} 4060 9960 0 0 {name=l32105 lab=VSS}
C {bitcell_6t.sym} 4200 10000 0 0 {name=Xr50c21}
N 4160 10040 4140 10040 {}
C {lab_pin.sym} 4140 10040 0 0 {name=l32106 lab=BL21}
N 4160 10000 4140 10000 {}
C {lab_pin.sym} 4140 10000 0 0 {name=l32107 lab=BLB21}
N 4160 9960 4140 9960 {}
C {lab_pin.sym} 4140 9960 0 0 {name=l32108 lab=WL50}
N 4240 10040 4260 10040 {}
C {lab_pin.sym} 4260 10040 0 0 {name=l32109 lab=VDD}
N 4240 9960 4260 9960 {}
C {lab_pin.sym} 4260 9960 0 0 {name=l32110 lab=VSS}
C {bitcell_6t.sym} 4400 10000 0 0 {name=Xr50c22}
N 4360 10040 4340 10040 {}
C {lab_pin.sym} 4340 10040 0 0 {name=l32111 lab=BL22}
N 4360 10000 4340 10000 {}
C {lab_pin.sym} 4340 10000 0 0 {name=l32112 lab=BLB22}
N 4360 9960 4340 9960 {}
C {lab_pin.sym} 4340 9960 0 0 {name=l32113 lab=WL50}
N 4440 10040 4460 10040 {}
C {lab_pin.sym} 4460 10040 0 0 {name=l32114 lab=VDD}
N 4440 9960 4460 9960 {}
C {lab_pin.sym} 4460 9960 0 0 {name=l32115 lab=VSS}
C {bitcell_6t.sym} 4600 10000 0 0 {name=Xr50c23}
N 4560 10040 4540 10040 {}
C {lab_pin.sym} 4540 10040 0 0 {name=l32116 lab=BL23}
N 4560 10000 4540 10000 {}
C {lab_pin.sym} 4540 10000 0 0 {name=l32117 lab=BLB23}
N 4560 9960 4540 9960 {}
C {lab_pin.sym} 4540 9960 0 0 {name=l32118 lab=WL50}
N 4640 10040 4660 10040 {}
C {lab_pin.sym} 4660 10040 0 0 {name=l32119 lab=VDD}
N 4640 9960 4660 9960 {}
C {lab_pin.sym} 4660 9960 0 0 {name=l32120 lab=VSS}
C {bitcell_6t.sym} 4800 10000 0 0 {name=Xr50c24}
N 4760 10040 4740 10040 {}
C {lab_pin.sym} 4740 10040 0 0 {name=l32121 lab=BL24}
N 4760 10000 4740 10000 {}
C {lab_pin.sym} 4740 10000 0 0 {name=l32122 lab=BLB24}
N 4760 9960 4740 9960 {}
C {lab_pin.sym} 4740 9960 0 0 {name=l32123 lab=WL50}
N 4840 10040 4860 10040 {}
C {lab_pin.sym} 4860 10040 0 0 {name=l32124 lab=VDD}
N 4840 9960 4860 9960 {}
C {lab_pin.sym} 4860 9960 0 0 {name=l32125 lab=VSS}
C {bitcell_6t.sym} 5000 10000 0 0 {name=Xr50c25}
N 4960 10040 4940 10040 {}
C {lab_pin.sym} 4940 10040 0 0 {name=l32126 lab=BL25}
N 4960 10000 4940 10000 {}
C {lab_pin.sym} 4940 10000 0 0 {name=l32127 lab=BLB25}
N 4960 9960 4940 9960 {}
C {lab_pin.sym} 4940 9960 0 0 {name=l32128 lab=WL50}
N 5040 10040 5060 10040 {}
C {lab_pin.sym} 5060 10040 0 0 {name=l32129 lab=VDD}
N 5040 9960 5060 9960 {}
C {lab_pin.sym} 5060 9960 0 0 {name=l32130 lab=VSS}
C {bitcell_6t.sym} 5200 10000 0 0 {name=Xr50c26}
N 5160 10040 5140 10040 {}
C {lab_pin.sym} 5140 10040 0 0 {name=l32131 lab=BL26}
N 5160 10000 5140 10000 {}
C {lab_pin.sym} 5140 10000 0 0 {name=l32132 lab=BLB26}
N 5160 9960 5140 9960 {}
C {lab_pin.sym} 5140 9960 0 0 {name=l32133 lab=WL50}
N 5240 10040 5260 10040 {}
C {lab_pin.sym} 5260 10040 0 0 {name=l32134 lab=VDD}
N 5240 9960 5260 9960 {}
C {lab_pin.sym} 5260 9960 0 0 {name=l32135 lab=VSS}
C {bitcell_6t.sym} 5400 10000 0 0 {name=Xr50c27}
N 5360 10040 5340 10040 {}
C {lab_pin.sym} 5340 10040 0 0 {name=l32136 lab=BL27}
N 5360 10000 5340 10000 {}
C {lab_pin.sym} 5340 10000 0 0 {name=l32137 lab=BLB27}
N 5360 9960 5340 9960 {}
C {lab_pin.sym} 5340 9960 0 0 {name=l32138 lab=WL50}
N 5440 10040 5460 10040 {}
C {lab_pin.sym} 5460 10040 0 0 {name=l32139 lab=VDD}
N 5440 9960 5460 9960 {}
C {lab_pin.sym} 5460 9960 0 0 {name=l32140 lab=VSS}
C {bitcell_6t.sym} 5600 10000 0 0 {name=Xr50c28}
N 5560 10040 5540 10040 {}
C {lab_pin.sym} 5540 10040 0 0 {name=l32141 lab=BL28}
N 5560 10000 5540 10000 {}
C {lab_pin.sym} 5540 10000 0 0 {name=l32142 lab=BLB28}
N 5560 9960 5540 9960 {}
C {lab_pin.sym} 5540 9960 0 0 {name=l32143 lab=WL50}
N 5640 10040 5660 10040 {}
C {lab_pin.sym} 5660 10040 0 0 {name=l32144 lab=VDD}
N 5640 9960 5660 9960 {}
C {lab_pin.sym} 5660 9960 0 0 {name=l32145 lab=VSS}
C {bitcell_6t.sym} 5800 10000 0 0 {name=Xr50c29}
N 5760 10040 5740 10040 {}
C {lab_pin.sym} 5740 10040 0 0 {name=l32146 lab=BL29}
N 5760 10000 5740 10000 {}
C {lab_pin.sym} 5740 10000 0 0 {name=l32147 lab=BLB29}
N 5760 9960 5740 9960 {}
C {lab_pin.sym} 5740 9960 0 0 {name=l32148 lab=WL50}
N 5840 10040 5860 10040 {}
C {lab_pin.sym} 5860 10040 0 0 {name=l32149 lab=VDD}
N 5840 9960 5860 9960 {}
C {lab_pin.sym} 5860 9960 0 0 {name=l32150 lab=VSS}
C {bitcell_6t.sym} 6000 10000 0 0 {name=Xr50c30}
N 5960 10040 5940 10040 {}
C {lab_pin.sym} 5940 10040 0 0 {name=l32151 lab=BL30}
N 5960 10000 5940 10000 {}
C {lab_pin.sym} 5940 10000 0 0 {name=l32152 lab=BLB30}
N 5960 9960 5940 9960 {}
C {lab_pin.sym} 5940 9960 0 0 {name=l32153 lab=WL50}
N 6040 10040 6060 10040 {}
C {lab_pin.sym} 6060 10040 0 0 {name=l32154 lab=VDD}
N 6040 9960 6060 9960 {}
C {lab_pin.sym} 6060 9960 0 0 {name=l32155 lab=VSS}
C {bitcell_6t.sym} 6200 10000 0 0 {name=Xr50c31}
N 6160 10040 6140 10040 {}
C {lab_pin.sym} 6140 10040 0 0 {name=l32156 lab=BL31}
N 6160 10000 6140 10000 {}
C {lab_pin.sym} 6140 10000 0 0 {name=l32157 lab=BLB31}
N 6160 9960 6140 9960 {}
C {lab_pin.sym} 6140 9960 0 0 {name=l32158 lab=WL50}
N 6240 10040 6260 10040 {}
C {lab_pin.sym} 6260 10040 0 0 {name=l32159 lab=VDD}
N 6240 9960 6260 9960 {}
C {lab_pin.sym} 6260 9960 0 0 {name=l32160 lab=VSS}
C {bitcell_6t.sym} 6400 10000 0 0 {name=Xr50c32}
N 6360 10040 6340 10040 {}
C {lab_pin.sym} 6340 10040 0 0 {name=l32161 lab=BL32}
N 6360 10000 6340 10000 {}
C {lab_pin.sym} 6340 10000 0 0 {name=l32162 lab=BLB32}
N 6360 9960 6340 9960 {}
C {lab_pin.sym} 6340 9960 0 0 {name=l32163 lab=WL50}
N 6440 10040 6460 10040 {}
C {lab_pin.sym} 6460 10040 0 0 {name=l32164 lab=VDD}
N 6440 9960 6460 9960 {}
C {lab_pin.sym} 6460 9960 0 0 {name=l32165 lab=VSS}
C {bitcell_6t.sym} 6600 10000 0 0 {name=Xr50c33}
N 6560 10040 6540 10040 {}
C {lab_pin.sym} 6540 10040 0 0 {name=l32166 lab=BL33}
N 6560 10000 6540 10000 {}
C {lab_pin.sym} 6540 10000 0 0 {name=l32167 lab=BLB33}
N 6560 9960 6540 9960 {}
C {lab_pin.sym} 6540 9960 0 0 {name=l32168 lab=WL50}
N 6640 10040 6660 10040 {}
C {lab_pin.sym} 6660 10040 0 0 {name=l32169 lab=VDD}
N 6640 9960 6660 9960 {}
C {lab_pin.sym} 6660 9960 0 0 {name=l32170 lab=VSS}
C {bitcell_6t.sym} 6800 10000 0 0 {name=Xr50c34}
N 6760 10040 6740 10040 {}
C {lab_pin.sym} 6740 10040 0 0 {name=l32171 lab=BL34}
N 6760 10000 6740 10000 {}
C {lab_pin.sym} 6740 10000 0 0 {name=l32172 lab=BLB34}
N 6760 9960 6740 9960 {}
C {lab_pin.sym} 6740 9960 0 0 {name=l32173 lab=WL50}
N 6840 10040 6860 10040 {}
C {lab_pin.sym} 6860 10040 0 0 {name=l32174 lab=VDD}
N 6840 9960 6860 9960 {}
C {lab_pin.sym} 6860 9960 0 0 {name=l32175 lab=VSS}
C {bitcell_6t.sym} 7000 10000 0 0 {name=Xr50c35}
N 6960 10040 6940 10040 {}
C {lab_pin.sym} 6940 10040 0 0 {name=l32176 lab=BL35}
N 6960 10000 6940 10000 {}
C {lab_pin.sym} 6940 10000 0 0 {name=l32177 lab=BLB35}
N 6960 9960 6940 9960 {}
C {lab_pin.sym} 6940 9960 0 0 {name=l32178 lab=WL50}
N 7040 10040 7060 10040 {}
C {lab_pin.sym} 7060 10040 0 0 {name=l32179 lab=VDD}
N 7040 9960 7060 9960 {}
C {lab_pin.sym} 7060 9960 0 0 {name=l32180 lab=VSS}
C {bitcell_6t.sym} 7200 10000 0 0 {name=Xr50c36}
N 7160 10040 7140 10040 {}
C {lab_pin.sym} 7140 10040 0 0 {name=l32181 lab=BL36}
N 7160 10000 7140 10000 {}
C {lab_pin.sym} 7140 10000 0 0 {name=l32182 lab=BLB36}
N 7160 9960 7140 9960 {}
C {lab_pin.sym} 7140 9960 0 0 {name=l32183 lab=WL50}
N 7240 10040 7260 10040 {}
C {lab_pin.sym} 7260 10040 0 0 {name=l32184 lab=VDD}
N 7240 9960 7260 9960 {}
C {lab_pin.sym} 7260 9960 0 0 {name=l32185 lab=VSS}
C {bitcell_6t.sym} 7400 10000 0 0 {name=Xr50c37}
N 7360 10040 7340 10040 {}
C {lab_pin.sym} 7340 10040 0 0 {name=l32186 lab=BL37}
N 7360 10000 7340 10000 {}
C {lab_pin.sym} 7340 10000 0 0 {name=l32187 lab=BLB37}
N 7360 9960 7340 9960 {}
C {lab_pin.sym} 7340 9960 0 0 {name=l32188 lab=WL50}
N 7440 10040 7460 10040 {}
C {lab_pin.sym} 7460 10040 0 0 {name=l32189 lab=VDD}
N 7440 9960 7460 9960 {}
C {lab_pin.sym} 7460 9960 0 0 {name=l32190 lab=VSS}
C {bitcell_6t.sym} 7600 10000 0 0 {name=Xr50c38}
N 7560 10040 7540 10040 {}
C {lab_pin.sym} 7540 10040 0 0 {name=l32191 lab=BL38}
N 7560 10000 7540 10000 {}
C {lab_pin.sym} 7540 10000 0 0 {name=l32192 lab=BLB38}
N 7560 9960 7540 9960 {}
C {lab_pin.sym} 7540 9960 0 0 {name=l32193 lab=WL50}
N 7640 10040 7660 10040 {}
C {lab_pin.sym} 7660 10040 0 0 {name=l32194 lab=VDD}
N 7640 9960 7660 9960 {}
C {lab_pin.sym} 7660 9960 0 0 {name=l32195 lab=VSS}
C {bitcell_6t.sym} 7800 10000 0 0 {name=Xr50c39}
N 7760 10040 7740 10040 {}
C {lab_pin.sym} 7740 10040 0 0 {name=l32196 lab=BL39}
N 7760 10000 7740 10000 {}
C {lab_pin.sym} 7740 10000 0 0 {name=l32197 lab=BLB39}
N 7760 9960 7740 9960 {}
C {lab_pin.sym} 7740 9960 0 0 {name=l32198 lab=WL50}
N 7840 10040 7860 10040 {}
C {lab_pin.sym} 7860 10040 0 0 {name=l32199 lab=VDD}
N 7840 9960 7860 9960 {}
C {lab_pin.sym} 7860 9960 0 0 {name=l32200 lab=VSS}
C {bitcell_6t.sym} 8000 10000 0 0 {name=Xr50c40}
N 7960 10040 7940 10040 {}
C {lab_pin.sym} 7940 10040 0 0 {name=l32201 lab=BL40}
N 7960 10000 7940 10000 {}
C {lab_pin.sym} 7940 10000 0 0 {name=l32202 lab=BLB40}
N 7960 9960 7940 9960 {}
C {lab_pin.sym} 7940 9960 0 0 {name=l32203 lab=WL50}
N 8040 10040 8060 10040 {}
C {lab_pin.sym} 8060 10040 0 0 {name=l32204 lab=VDD}
N 8040 9960 8060 9960 {}
C {lab_pin.sym} 8060 9960 0 0 {name=l32205 lab=VSS}
C {bitcell_6t.sym} 8200 10000 0 0 {name=Xr50c41}
N 8160 10040 8140 10040 {}
C {lab_pin.sym} 8140 10040 0 0 {name=l32206 lab=BL41}
N 8160 10000 8140 10000 {}
C {lab_pin.sym} 8140 10000 0 0 {name=l32207 lab=BLB41}
N 8160 9960 8140 9960 {}
C {lab_pin.sym} 8140 9960 0 0 {name=l32208 lab=WL50}
N 8240 10040 8260 10040 {}
C {lab_pin.sym} 8260 10040 0 0 {name=l32209 lab=VDD}
N 8240 9960 8260 9960 {}
C {lab_pin.sym} 8260 9960 0 0 {name=l32210 lab=VSS}
C {bitcell_6t.sym} 8400 10000 0 0 {name=Xr50c42}
N 8360 10040 8340 10040 {}
C {lab_pin.sym} 8340 10040 0 0 {name=l32211 lab=BL42}
N 8360 10000 8340 10000 {}
C {lab_pin.sym} 8340 10000 0 0 {name=l32212 lab=BLB42}
N 8360 9960 8340 9960 {}
C {lab_pin.sym} 8340 9960 0 0 {name=l32213 lab=WL50}
N 8440 10040 8460 10040 {}
C {lab_pin.sym} 8460 10040 0 0 {name=l32214 lab=VDD}
N 8440 9960 8460 9960 {}
C {lab_pin.sym} 8460 9960 0 0 {name=l32215 lab=VSS}
C {bitcell_6t.sym} 8600 10000 0 0 {name=Xr50c43}
N 8560 10040 8540 10040 {}
C {lab_pin.sym} 8540 10040 0 0 {name=l32216 lab=BL43}
N 8560 10000 8540 10000 {}
C {lab_pin.sym} 8540 10000 0 0 {name=l32217 lab=BLB43}
N 8560 9960 8540 9960 {}
C {lab_pin.sym} 8540 9960 0 0 {name=l32218 lab=WL50}
N 8640 10040 8660 10040 {}
C {lab_pin.sym} 8660 10040 0 0 {name=l32219 lab=VDD}
N 8640 9960 8660 9960 {}
C {lab_pin.sym} 8660 9960 0 0 {name=l32220 lab=VSS}
C {bitcell_6t.sym} 8800 10000 0 0 {name=Xr50c44}
N 8760 10040 8740 10040 {}
C {lab_pin.sym} 8740 10040 0 0 {name=l32221 lab=BL44}
N 8760 10000 8740 10000 {}
C {lab_pin.sym} 8740 10000 0 0 {name=l32222 lab=BLB44}
N 8760 9960 8740 9960 {}
C {lab_pin.sym} 8740 9960 0 0 {name=l32223 lab=WL50}
N 8840 10040 8860 10040 {}
C {lab_pin.sym} 8860 10040 0 0 {name=l32224 lab=VDD}
N 8840 9960 8860 9960 {}
C {lab_pin.sym} 8860 9960 0 0 {name=l32225 lab=VSS}
C {bitcell_6t.sym} 9000 10000 0 0 {name=Xr50c45}
N 8960 10040 8940 10040 {}
C {lab_pin.sym} 8940 10040 0 0 {name=l32226 lab=BL45}
N 8960 10000 8940 10000 {}
C {lab_pin.sym} 8940 10000 0 0 {name=l32227 lab=BLB45}
N 8960 9960 8940 9960 {}
C {lab_pin.sym} 8940 9960 0 0 {name=l32228 lab=WL50}
N 9040 10040 9060 10040 {}
C {lab_pin.sym} 9060 10040 0 0 {name=l32229 lab=VDD}
N 9040 9960 9060 9960 {}
C {lab_pin.sym} 9060 9960 0 0 {name=l32230 lab=VSS}
C {bitcell_6t.sym} 9200 10000 0 0 {name=Xr50c46}
N 9160 10040 9140 10040 {}
C {lab_pin.sym} 9140 10040 0 0 {name=l32231 lab=BL46}
N 9160 10000 9140 10000 {}
C {lab_pin.sym} 9140 10000 0 0 {name=l32232 lab=BLB46}
N 9160 9960 9140 9960 {}
C {lab_pin.sym} 9140 9960 0 0 {name=l32233 lab=WL50}
N 9240 10040 9260 10040 {}
C {lab_pin.sym} 9260 10040 0 0 {name=l32234 lab=VDD}
N 9240 9960 9260 9960 {}
C {lab_pin.sym} 9260 9960 0 0 {name=l32235 lab=VSS}
C {bitcell_6t.sym} 9400 10000 0 0 {name=Xr50c47}
N 9360 10040 9340 10040 {}
C {lab_pin.sym} 9340 10040 0 0 {name=l32236 lab=BL47}
N 9360 10000 9340 10000 {}
C {lab_pin.sym} 9340 10000 0 0 {name=l32237 lab=BLB47}
N 9360 9960 9340 9960 {}
C {lab_pin.sym} 9340 9960 0 0 {name=l32238 lab=WL50}
N 9440 10040 9460 10040 {}
C {lab_pin.sym} 9460 10040 0 0 {name=l32239 lab=VDD}
N 9440 9960 9460 9960 {}
C {lab_pin.sym} 9460 9960 0 0 {name=l32240 lab=VSS}
C {bitcell_6t.sym} 9600 10000 0 0 {name=Xr50c48}
N 9560 10040 9540 10040 {}
C {lab_pin.sym} 9540 10040 0 0 {name=l32241 lab=BL48}
N 9560 10000 9540 10000 {}
C {lab_pin.sym} 9540 10000 0 0 {name=l32242 lab=BLB48}
N 9560 9960 9540 9960 {}
C {lab_pin.sym} 9540 9960 0 0 {name=l32243 lab=WL50}
N 9640 10040 9660 10040 {}
C {lab_pin.sym} 9660 10040 0 0 {name=l32244 lab=VDD}
N 9640 9960 9660 9960 {}
C {lab_pin.sym} 9660 9960 0 0 {name=l32245 lab=VSS}
C {bitcell_6t.sym} 9800 10000 0 0 {name=Xr50c49}
N 9760 10040 9740 10040 {}
C {lab_pin.sym} 9740 10040 0 0 {name=l32246 lab=BL49}
N 9760 10000 9740 10000 {}
C {lab_pin.sym} 9740 10000 0 0 {name=l32247 lab=BLB49}
N 9760 9960 9740 9960 {}
C {lab_pin.sym} 9740 9960 0 0 {name=l32248 lab=WL50}
N 9840 10040 9860 10040 {}
C {lab_pin.sym} 9860 10040 0 0 {name=l32249 lab=VDD}
N 9840 9960 9860 9960 {}
C {lab_pin.sym} 9860 9960 0 0 {name=l32250 lab=VSS}
C {bitcell_6t.sym} 10000 10000 0 0 {name=Xr50c50}
N 9960 10040 9940 10040 {}
C {lab_pin.sym} 9940 10040 0 0 {name=l32251 lab=BL50}
N 9960 10000 9940 10000 {}
C {lab_pin.sym} 9940 10000 0 0 {name=l32252 lab=BLB50}
N 9960 9960 9940 9960 {}
C {lab_pin.sym} 9940 9960 0 0 {name=l32253 lab=WL50}
N 10040 10040 10060 10040 {}
C {lab_pin.sym} 10060 10040 0 0 {name=l32254 lab=VDD}
N 10040 9960 10060 9960 {}
C {lab_pin.sym} 10060 9960 0 0 {name=l32255 lab=VSS}
C {bitcell_6t.sym} 10200 10000 0 0 {name=Xr50c51}
N 10160 10040 10140 10040 {}
C {lab_pin.sym} 10140 10040 0 0 {name=l32256 lab=BL51}
N 10160 10000 10140 10000 {}
C {lab_pin.sym} 10140 10000 0 0 {name=l32257 lab=BLB51}
N 10160 9960 10140 9960 {}
C {lab_pin.sym} 10140 9960 0 0 {name=l32258 lab=WL50}
N 10240 10040 10260 10040 {}
C {lab_pin.sym} 10260 10040 0 0 {name=l32259 lab=VDD}
N 10240 9960 10260 9960 {}
C {lab_pin.sym} 10260 9960 0 0 {name=l32260 lab=VSS}
C {bitcell_6t.sym} 10400 10000 0 0 {name=Xr50c52}
N 10360 10040 10340 10040 {}
C {lab_pin.sym} 10340 10040 0 0 {name=l32261 lab=BL52}
N 10360 10000 10340 10000 {}
C {lab_pin.sym} 10340 10000 0 0 {name=l32262 lab=BLB52}
N 10360 9960 10340 9960 {}
C {lab_pin.sym} 10340 9960 0 0 {name=l32263 lab=WL50}
N 10440 10040 10460 10040 {}
C {lab_pin.sym} 10460 10040 0 0 {name=l32264 lab=VDD}
N 10440 9960 10460 9960 {}
C {lab_pin.sym} 10460 9960 0 0 {name=l32265 lab=VSS}
C {bitcell_6t.sym} 10600 10000 0 0 {name=Xr50c53}
N 10560 10040 10540 10040 {}
C {lab_pin.sym} 10540 10040 0 0 {name=l32266 lab=BL53}
N 10560 10000 10540 10000 {}
C {lab_pin.sym} 10540 10000 0 0 {name=l32267 lab=BLB53}
N 10560 9960 10540 9960 {}
C {lab_pin.sym} 10540 9960 0 0 {name=l32268 lab=WL50}
N 10640 10040 10660 10040 {}
C {lab_pin.sym} 10660 10040 0 0 {name=l32269 lab=VDD}
N 10640 9960 10660 9960 {}
C {lab_pin.sym} 10660 9960 0 0 {name=l32270 lab=VSS}
C {bitcell_6t.sym} 10800 10000 0 0 {name=Xr50c54}
N 10760 10040 10740 10040 {}
C {lab_pin.sym} 10740 10040 0 0 {name=l32271 lab=BL54}
N 10760 10000 10740 10000 {}
C {lab_pin.sym} 10740 10000 0 0 {name=l32272 lab=BLB54}
N 10760 9960 10740 9960 {}
C {lab_pin.sym} 10740 9960 0 0 {name=l32273 lab=WL50}
N 10840 10040 10860 10040 {}
C {lab_pin.sym} 10860 10040 0 0 {name=l32274 lab=VDD}
N 10840 9960 10860 9960 {}
C {lab_pin.sym} 10860 9960 0 0 {name=l32275 lab=VSS}
C {bitcell_6t.sym} 11000 10000 0 0 {name=Xr50c55}
N 10960 10040 10940 10040 {}
C {lab_pin.sym} 10940 10040 0 0 {name=l32276 lab=BL55}
N 10960 10000 10940 10000 {}
C {lab_pin.sym} 10940 10000 0 0 {name=l32277 lab=BLB55}
N 10960 9960 10940 9960 {}
C {lab_pin.sym} 10940 9960 0 0 {name=l32278 lab=WL50}
N 11040 10040 11060 10040 {}
C {lab_pin.sym} 11060 10040 0 0 {name=l32279 lab=VDD}
N 11040 9960 11060 9960 {}
C {lab_pin.sym} 11060 9960 0 0 {name=l32280 lab=VSS}
C {bitcell_6t.sym} 11200 10000 0 0 {name=Xr50c56}
N 11160 10040 11140 10040 {}
C {lab_pin.sym} 11140 10040 0 0 {name=l32281 lab=BL56}
N 11160 10000 11140 10000 {}
C {lab_pin.sym} 11140 10000 0 0 {name=l32282 lab=BLB56}
N 11160 9960 11140 9960 {}
C {lab_pin.sym} 11140 9960 0 0 {name=l32283 lab=WL50}
N 11240 10040 11260 10040 {}
C {lab_pin.sym} 11260 10040 0 0 {name=l32284 lab=VDD}
N 11240 9960 11260 9960 {}
C {lab_pin.sym} 11260 9960 0 0 {name=l32285 lab=VSS}
C {bitcell_6t.sym} 11400 10000 0 0 {name=Xr50c57}
N 11360 10040 11340 10040 {}
C {lab_pin.sym} 11340 10040 0 0 {name=l32286 lab=BL57}
N 11360 10000 11340 10000 {}
C {lab_pin.sym} 11340 10000 0 0 {name=l32287 lab=BLB57}
N 11360 9960 11340 9960 {}
C {lab_pin.sym} 11340 9960 0 0 {name=l32288 lab=WL50}
N 11440 10040 11460 10040 {}
C {lab_pin.sym} 11460 10040 0 0 {name=l32289 lab=VDD}
N 11440 9960 11460 9960 {}
C {lab_pin.sym} 11460 9960 0 0 {name=l32290 lab=VSS}
C {bitcell_6t.sym} 11600 10000 0 0 {name=Xr50c58}
N 11560 10040 11540 10040 {}
C {lab_pin.sym} 11540 10040 0 0 {name=l32291 lab=BL58}
N 11560 10000 11540 10000 {}
C {lab_pin.sym} 11540 10000 0 0 {name=l32292 lab=BLB58}
N 11560 9960 11540 9960 {}
C {lab_pin.sym} 11540 9960 0 0 {name=l32293 lab=WL50}
N 11640 10040 11660 10040 {}
C {lab_pin.sym} 11660 10040 0 0 {name=l32294 lab=VDD}
N 11640 9960 11660 9960 {}
C {lab_pin.sym} 11660 9960 0 0 {name=l32295 lab=VSS}
C {bitcell_6t.sym} 11800 10000 0 0 {name=Xr50c59}
N 11760 10040 11740 10040 {}
C {lab_pin.sym} 11740 10040 0 0 {name=l32296 lab=BL59}
N 11760 10000 11740 10000 {}
C {lab_pin.sym} 11740 10000 0 0 {name=l32297 lab=BLB59}
N 11760 9960 11740 9960 {}
C {lab_pin.sym} 11740 9960 0 0 {name=l32298 lab=WL50}
N 11840 10040 11860 10040 {}
C {lab_pin.sym} 11860 10040 0 0 {name=l32299 lab=VDD}
N 11840 9960 11860 9960 {}
C {lab_pin.sym} 11860 9960 0 0 {name=l32300 lab=VSS}
C {bitcell_6t.sym} 12000 10000 0 0 {name=Xr50c60}
N 11960 10040 11940 10040 {}
C {lab_pin.sym} 11940 10040 0 0 {name=l32301 lab=BL60}
N 11960 10000 11940 10000 {}
C {lab_pin.sym} 11940 10000 0 0 {name=l32302 lab=BLB60}
N 11960 9960 11940 9960 {}
C {lab_pin.sym} 11940 9960 0 0 {name=l32303 lab=WL50}
N 12040 10040 12060 10040 {}
C {lab_pin.sym} 12060 10040 0 0 {name=l32304 lab=VDD}
N 12040 9960 12060 9960 {}
C {lab_pin.sym} 12060 9960 0 0 {name=l32305 lab=VSS}
C {bitcell_6t.sym} 12200 10000 0 0 {name=Xr50c61}
N 12160 10040 12140 10040 {}
C {lab_pin.sym} 12140 10040 0 0 {name=l32306 lab=BL61}
N 12160 10000 12140 10000 {}
C {lab_pin.sym} 12140 10000 0 0 {name=l32307 lab=BLB61}
N 12160 9960 12140 9960 {}
C {lab_pin.sym} 12140 9960 0 0 {name=l32308 lab=WL50}
N 12240 10040 12260 10040 {}
C {lab_pin.sym} 12260 10040 0 0 {name=l32309 lab=VDD}
N 12240 9960 12260 9960 {}
C {lab_pin.sym} 12260 9960 0 0 {name=l32310 lab=VSS}
C {bitcell_6t.sym} 12400 10000 0 0 {name=Xr50c62}
N 12360 10040 12340 10040 {}
C {lab_pin.sym} 12340 10040 0 0 {name=l32311 lab=BL62}
N 12360 10000 12340 10000 {}
C {lab_pin.sym} 12340 10000 0 0 {name=l32312 lab=BLB62}
N 12360 9960 12340 9960 {}
C {lab_pin.sym} 12340 9960 0 0 {name=l32313 lab=WL50}
N 12440 10040 12460 10040 {}
C {lab_pin.sym} 12460 10040 0 0 {name=l32314 lab=VDD}
N 12440 9960 12460 9960 {}
C {lab_pin.sym} 12460 9960 0 0 {name=l32315 lab=VSS}
C {bitcell_6t.sym} 12600 10000 0 0 {name=Xr50c63}
N 12560 10040 12540 10040 {}
C {lab_pin.sym} 12540 10040 0 0 {name=l32316 lab=BL63}
N 12560 10000 12540 10000 {}
C {lab_pin.sym} 12540 10000 0 0 {name=l32317 lab=BLB63}
N 12560 9960 12540 9960 {}
C {lab_pin.sym} 12540 9960 0 0 {name=l32318 lab=WL50}
N 12640 10040 12660 10040 {}
C {lab_pin.sym} 12660 10040 0 0 {name=l32319 lab=VDD}
N 12640 9960 12660 9960 {}
C {lab_pin.sym} 12660 9960 0 0 {name=l32320 lab=VSS}
C {bitcell_6t.sym} 12800 10000 0 0 {name=Xr50c64}
N 12760 10040 12740 10040 {}
C {lab_pin.sym} 12740 10040 0 0 {name=l32321 lab=BL64}
N 12760 10000 12740 10000 {}
C {lab_pin.sym} 12740 10000 0 0 {name=l32322 lab=BLB64}
N 12760 9960 12740 9960 {}
C {lab_pin.sym} 12740 9960 0 0 {name=l32323 lab=WL50}
N 12840 10040 12860 10040 {}
C {lab_pin.sym} 12860 10040 0 0 {name=l32324 lab=VDD}
N 12840 9960 12860 9960 {}
C {lab_pin.sym} 12860 9960 0 0 {name=l32325 lab=VSS}
C {bitcell_6t.sym} 13000 10000 0 0 {name=Xr50c65}
N 12960 10040 12940 10040 {}
C {lab_pin.sym} 12940 10040 0 0 {name=l32326 lab=BL65}
N 12960 10000 12940 10000 {}
C {lab_pin.sym} 12940 10000 0 0 {name=l32327 lab=BLB65}
N 12960 9960 12940 9960 {}
C {lab_pin.sym} 12940 9960 0 0 {name=l32328 lab=WL50}
N 13040 10040 13060 10040 {}
C {lab_pin.sym} 13060 10040 0 0 {name=l32329 lab=VDD}
N 13040 9960 13060 9960 {}
C {lab_pin.sym} 13060 9960 0 0 {name=l32330 lab=VSS}
C {bitcell_6t.sym} 13200 10000 0 0 {name=Xr50c66}
N 13160 10040 13140 10040 {}
C {lab_pin.sym} 13140 10040 0 0 {name=l32331 lab=BL66}
N 13160 10000 13140 10000 {}
C {lab_pin.sym} 13140 10000 0 0 {name=l32332 lab=BLB66}
N 13160 9960 13140 9960 {}
C {lab_pin.sym} 13140 9960 0 0 {name=l32333 lab=WL50}
N 13240 10040 13260 10040 {}
C {lab_pin.sym} 13260 10040 0 0 {name=l32334 lab=VDD}
N 13240 9960 13260 9960 {}
C {lab_pin.sym} 13260 9960 0 0 {name=l32335 lab=VSS}
C {bitcell_6t.sym} 13400 10000 0 0 {name=Xr50c67}
N 13360 10040 13340 10040 {}
C {lab_pin.sym} 13340 10040 0 0 {name=l32336 lab=BL67}
N 13360 10000 13340 10000 {}
C {lab_pin.sym} 13340 10000 0 0 {name=l32337 lab=BLB67}
N 13360 9960 13340 9960 {}
C {lab_pin.sym} 13340 9960 0 0 {name=l32338 lab=WL50}
N 13440 10040 13460 10040 {}
C {lab_pin.sym} 13460 10040 0 0 {name=l32339 lab=VDD}
N 13440 9960 13460 9960 {}
C {lab_pin.sym} 13460 9960 0 0 {name=l32340 lab=VSS}
C {bitcell_6t.sym} 13600 10000 0 0 {name=Xr50c68}
N 13560 10040 13540 10040 {}
C {lab_pin.sym} 13540 10040 0 0 {name=l32341 lab=BL68}
N 13560 10000 13540 10000 {}
C {lab_pin.sym} 13540 10000 0 0 {name=l32342 lab=BLB68}
N 13560 9960 13540 9960 {}
C {lab_pin.sym} 13540 9960 0 0 {name=l32343 lab=WL50}
N 13640 10040 13660 10040 {}
C {lab_pin.sym} 13660 10040 0 0 {name=l32344 lab=VDD}
N 13640 9960 13660 9960 {}
C {lab_pin.sym} 13660 9960 0 0 {name=l32345 lab=VSS}
C {bitcell_6t.sym} 13800 10000 0 0 {name=Xr50c69}
N 13760 10040 13740 10040 {}
C {lab_pin.sym} 13740 10040 0 0 {name=l32346 lab=BL69}
N 13760 10000 13740 10000 {}
C {lab_pin.sym} 13740 10000 0 0 {name=l32347 lab=BLB69}
N 13760 9960 13740 9960 {}
C {lab_pin.sym} 13740 9960 0 0 {name=l32348 lab=WL50}
N 13840 10040 13860 10040 {}
C {lab_pin.sym} 13860 10040 0 0 {name=l32349 lab=VDD}
N 13840 9960 13860 9960 {}
C {lab_pin.sym} 13860 9960 0 0 {name=l32350 lab=VSS}
C {bitcell_6t.sym} 14000 10000 0 0 {name=Xr50c70}
N 13960 10040 13940 10040 {}
C {lab_pin.sym} 13940 10040 0 0 {name=l32351 lab=BL70}
N 13960 10000 13940 10000 {}
C {lab_pin.sym} 13940 10000 0 0 {name=l32352 lab=BLB70}
N 13960 9960 13940 9960 {}
C {lab_pin.sym} 13940 9960 0 0 {name=l32353 lab=WL50}
N 14040 10040 14060 10040 {}
C {lab_pin.sym} 14060 10040 0 0 {name=l32354 lab=VDD}
N 14040 9960 14060 9960 {}
C {lab_pin.sym} 14060 9960 0 0 {name=l32355 lab=VSS}
C {bitcell_6t.sym} 14200 10000 0 0 {name=Xr50c71}
N 14160 10040 14140 10040 {}
C {lab_pin.sym} 14140 10040 0 0 {name=l32356 lab=BL71}
N 14160 10000 14140 10000 {}
C {lab_pin.sym} 14140 10000 0 0 {name=l32357 lab=BLB71}
N 14160 9960 14140 9960 {}
C {lab_pin.sym} 14140 9960 0 0 {name=l32358 lab=WL50}
N 14240 10040 14260 10040 {}
C {lab_pin.sym} 14260 10040 0 0 {name=l32359 lab=VDD}
N 14240 9960 14260 9960 {}
C {lab_pin.sym} 14260 9960 0 0 {name=l32360 lab=VSS}
C {bitcell_6t.sym} 14400 10000 0 0 {name=Xr50c72}
N 14360 10040 14340 10040 {}
C {lab_pin.sym} 14340 10040 0 0 {name=l32361 lab=BL72}
N 14360 10000 14340 10000 {}
C {lab_pin.sym} 14340 10000 0 0 {name=l32362 lab=BLB72}
N 14360 9960 14340 9960 {}
C {lab_pin.sym} 14340 9960 0 0 {name=l32363 lab=WL50}
N 14440 10040 14460 10040 {}
C {lab_pin.sym} 14460 10040 0 0 {name=l32364 lab=VDD}
N 14440 9960 14460 9960 {}
C {lab_pin.sym} 14460 9960 0 0 {name=l32365 lab=VSS}
C {bitcell_6t.sym} 14600 10000 0 0 {name=Xr50c73}
N 14560 10040 14540 10040 {}
C {lab_pin.sym} 14540 10040 0 0 {name=l32366 lab=BL73}
N 14560 10000 14540 10000 {}
C {lab_pin.sym} 14540 10000 0 0 {name=l32367 lab=BLB73}
N 14560 9960 14540 9960 {}
C {lab_pin.sym} 14540 9960 0 0 {name=l32368 lab=WL50}
N 14640 10040 14660 10040 {}
C {lab_pin.sym} 14660 10040 0 0 {name=l32369 lab=VDD}
N 14640 9960 14660 9960 {}
C {lab_pin.sym} 14660 9960 0 0 {name=l32370 lab=VSS}
C {bitcell_6t.sym} 14800 10000 0 0 {name=Xr50c74}
N 14760 10040 14740 10040 {}
C {lab_pin.sym} 14740 10040 0 0 {name=l32371 lab=BL74}
N 14760 10000 14740 10000 {}
C {lab_pin.sym} 14740 10000 0 0 {name=l32372 lab=BLB74}
N 14760 9960 14740 9960 {}
C {lab_pin.sym} 14740 9960 0 0 {name=l32373 lab=WL50}
N 14840 10040 14860 10040 {}
C {lab_pin.sym} 14860 10040 0 0 {name=l32374 lab=VDD}
N 14840 9960 14860 9960 {}
C {lab_pin.sym} 14860 9960 0 0 {name=l32375 lab=VSS}
C {bitcell_6t.sym} 15000 10000 0 0 {name=Xr50c75}
N 14960 10040 14940 10040 {}
C {lab_pin.sym} 14940 10040 0 0 {name=l32376 lab=BL75}
N 14960 10000 14940 10000 {}
C {lab_pin.sym} 14940 10000 0 0 {name=l32377 lab=BLB75}
N 14960 9960 14940 9960 {}
C {lab_pin.sym} 14940 9960 0 0 {name=l32378 lab=WL50}
N 15040 10040 15060 10040 {}
C {lab_pin.sym} 15060 10040 0 0 {name=l32379 lab=VDD}
N 15040 9960 15060 9960 {}
C {lab_pin.sym} 15060 9960 0 0 {name=l32380 lab=VSS}
C {bitcell_6t.sym} 15200 10000 0 0 {name=Xr50c76}
N 15160 10040 15140 10040 {}
C {lab_pin.sym} 15140 10040 0 0 {name=l32381 lab=BL76}
N 15160 10000 15140 10000 {}
C {lab_pin.sym} 15140 10000 0 0 {name=l32382 lab=BLB76}
N 15160 9960 15140 9960 {}
C {lab_pin.sym} 15140 9960 0 0 {name=l32383 lab=WL50}
N 15240 10040 15260 10040 {}
C {lab_pin.sym} 15260 10040 0 0 {name=l32384 lab=VDD}
N 15240 9960 15260 9960 {}
C {lab_pin.sym} 15260 9960 0 0 {name=l32385 lab=VSS}
C {bitcell_6t.sym} 15400 10000 0 0 {name=Xr50c77}
N 15360 10040 15340 10040 {}
C {lab_pin.sym} 15340 10040 0 0 {name=l32386 lab=BL77}
N 15360 10000 15340 10000 {}
C {lab_pin.sym} 15340 10000 0 0 {name=l32387 lab=BLB77}
N 15360 9960 15340 9960 {}
C {lab_pin.sym} 15340 9960 0 0 {name=l32388 lab=WL50}
N 15440 10040 15460 10040 {}
C {lab_pin.sym} 15460 10040 0 0 {name=l32389 lab=VDD}
N 15440 9960 15460 9960 {}
C {lab_pin.sym} 15460 9960 0 0 {name=l32390 lab=VSS}
C {bitcell_6t.sym} 15600 10000 0 0 {name=Xr50c78}
N 15560 10040 15540 10040 {}
C {lab_pin.sym} 15540 10040 0 0 {name=l32391 lab=BL78}
N 15560 10000 15540 10000 {}
C {lab_pin.sym} 15540 10000 0 0 {name=l32392 lab=BLB78}
N 15560 9960 15540 9960 {}
C {lab_pin.sym} 15540 9960 0 0 {name=l32393 lab=WL50}
N 15640 10040 15660 10040 {}
C {lab_pin.sym} 15660 10040 0 0 {name=l32394 lab=VDD}
N 15640 9960 15660 9960 {}
C {lab_pin.sym} 15660 9960 0 0 {name=l32395 lab=VSS}
C {bitcell_6t.sym} 15800 10000 0 0 {name=Xr50c79}
N 15760 10040 15740 10040 {}
C {lab_pin.sym} 15740 10040 0 0 {name=l32396 lab=BL79}
N 15760 10000 15740 10000 {}
C {lab_pin.sym} 15740 10000 0 0 {name=l32397 lab=BLB79}
N 15760 9960 15740 9960 {}
C {lab_pin.sym} 15740 9960 0 0 {name=l32398 lab=WL50}
N 15840 10040 15860 10040 {}
C {lab_pin.sym} 15860 10040 0 0 {name=l32399 lab=VDD}
N 15840 9960 15860 9960 {}
C {lab_pin.sym} 15860 9960 0 0 {name=l32400 lab=VSS}
C {bitcell_6t.sym} 16000 10000 0 0 {name=Xr50c80}
N 15960 10040 15940 10040 {}
C {lab_pin.sym} 15940 10040 0 0 {name=l32401 lab=BL80}
N 15960 10000 15940 10000 {}
C {lab_pin.sym} 15940 10000 0 0 {name=l32402 lab=BLB80}
N 15960 9960 15940 9960 {}
C {lab_pin.sym} 15940 9960 0 0 {name=l32403 lab=WL50}
N 16040 10040 16060 10040 {}
C {lab_pin.sym} 16060 10040 0 0 {name=l32404 lab=VDD}
N 16040 9960 16060 9960 {}
C {lab_pin.sym} 16060 9960 0 0 {name=l32405 lab=VSS}
C {bitcell_6t.sym} 16200 10000 0 0 {name=Xr50c81}
N 16160 10040 16140 10040 {}
C {lab_pin.sym} 16140 10040 0 0 {name=l32406 lab=BL81}
N 16160 10000 16140 10000 {}
C {lab_pin.sym} 16140 10000 0 0 {name=l32407 lab=BLB81}
N 16160 9960 16140 9960 {}
C {lab_pin.sym} 16140 9960 0 0 {name=l32408 lab=WL50}
N 16240 10040 16260 10040 {}
C {lab_pin.sym} 16260 10040 0 0 {name=l32409 lab=VDD}
N 16240 9960 16260 9960 {}
C {lab_pin.sym} 16260 9960 0 0 {name=l32410 lab=VSS}
C {bitcell_6t.sym} 16400 10000 0 0 {name=Xr50c82}
N 16360 10040 16340 10040 {}
C {lab_pin.sym} 16340 10040 0 0 {name=l32411 lab=BL82}
N 16360 10000 16340 10000 {}
C {lab_pin.sym} 16340 10000 0 0 {name=l32412 lab=BLB82}
N 16360 9960 16340 9960 {}
C {lab_pin.sym} 16340 9960 0 0 {name=l32413 lab=WL50}
N 16440 10040 16460 10040 {}
C {lab_pin.sym} 16460 10040 0 0 {name=l32414 lab=VDD}
N 16440 9960 16460 9960 {}
C {lab_pin.sym} 16460 9960 0 0 {name=l32415 lab=VSS}
C {bitcell_6t.sym} 16600 10000 0 0 {name=Xr50c83}
N 16560 10040 16540 10040 {}
C {lab_pin.sym} 16540 10040 0 0 {name=l32416 lab=BL83}
N 16560 10000 16540 10000 {}
C {lab_pin.sym} 16540 10000 0 0 {name=l32417 lab=BLB83}
N 16560 9960 16540 9960 {}
C {lab_pin.sym} 16540 9960 0 0 {name=l32418 lab=WL50}
N 16640 10040 16660 10040 {}
C {lab_pin.sym} 16660 10040 0 0 {name=l32419 lab=VDD}
N 16640 9960 16660 9960 {}
C {lab_pin.sym} 16660 9960 0 0 {name=l32420 lab=VSS}
C {bitcell_6t.sym} 16800 10000 0 0 {name=Xr50c84}
N 16760 10040 16740 10040 {}
C {lab_pin.sym} 16740 10040 0 0 {name=l32421 lab=BL84}
N 16760 10000 16740 10000 {}
C {lab_pin.sym} 16740 10000 0 0 {name=l32422 lab=BLB84}
N 16760 9960 16740 9960 {}
C {lab_pin.sym} 16740 9960 0 0 {name=l32423 lab=WL50}
N 16840 10040 16860 10040 {}
C {lab_pin.sym} 16860 10040 0 0 {name=l32424 lab=VDD}
N 16840 9960 16860 9960 {}
C {lab_pin.sym} 16860 9960 0 0 {name=l32425 lab=VSS}
C {bitcell_6t.sym} 17000 10000 0 0 {name=Xr50c85}
N 16960 10040 16940 10040 {}
C {lab_pin.sym} 16940 10040 0 0 {name=l32426 lab=BL85}
N 16960 10000 16940 10000 {}
C {lab_pin.sym} 16940 10000 0 0 {name=l32427 lab=BLB85}
N 16960 9960 16940 9960 {}
C {lab_pin.sym} 16940 9960 0 0 {name=l32428 lab=WL50}
N 17040 10040 17060 10040 {}
C {lab_pin.sym} 17060 10040 0 0 {name=l32429 lab=VDD}
N 17040 9960 17060 9960 {}
C {lab_pin.sym} 17060 9960 0 0 {name=l32430 lab=VSS}
C {bitcell_6t.sym} 17200 10000 0 0 {name=Xr50c86}
N 17160 10040 17140 10040 {}
C {lab_pin.sym} 17140 10040 0 0 {name=l32431 lab=BL86}
N 17160 10000 17140 10000 {}
C {lab_pin.sym} 17140 10000 0 0 {name=l32432 lab=BLB86}
N 17160 9960 17140 9960 {}
C {lab_pin.sym} 17140 9960 0 0 {name=l32433 lab=WL50}
N 17240 10040 17260 10040 {}
C {lab_pin.sym} 17260 10040 0 0 {name=l32434 lab=VDD}
N 17240 9960 17260 9960 {}
C {lab_pin.sym} 17260 9960 0 0 {name=l32435 lab=VSS}
C {bitcell_6t.sym} 17400 10000 0 0 {name=Xr50c87}
N 17360 10040 17340 10040 {}
C {lab_pin.sym} 17340 10040 0 0 {name=l32436 lab=BL87}
N 17360 10000 17340 10000 {}
C {lab_pin.sym} 17340 10000 0 0 {name=l32437 lab=BLB87}
N 17360 9960 17340 9960 {}
C {lab_pin.sym} 17340 9960 0 0 {name=l32438 lab=WL50}
N 17440 10040 17460 10040 {}
C {lab_pin.sym} 17460 10040 0 0 {name=l32439 lab=VDD}
N 17440 9960 17460 9960 {}
C {lab_pin.sym} 17460 9960 0 0 {name=l32440 lab=VSS}
C {bitcell_6t.sym} 17600 10000 0 0 {name=Xr50c88}
N 17560 10040 17540 10040 {}
C {lab_pin.sym} 17540 10040 0 0 {name=l32441 lab=BL88}
N 17560 10000 17540 10000 {}
C {lab_pin.sym} 17540 10000 0 0 {name=l32442 lab=BLB88}
N 17560 9960 17540 9960 {}
C {lab_pin.sym} 17540 9960 0 0 {name=l32443 lab=WL50}
N 17640 10040 17660 10040 {}
C {lab_pin.sym} 17660 10040 0 0 {name=l32444 lab=VDD}
N 17640 9960 17660 9960 {}
C {lab_pin.sym} 17660 9960 0 0 {name=l32445 lab=VSS}
C {bitcell_6t.sym} 17800 10000 0 0 {name=Xr50c89}
N 17760 10040 17740 10040 {}
C {lab_pin.sym} 17740 10040 0 0 {name=l32446 lab=BL89}
N 17760 10000 17740 10000 {}
C {lab_pin.sym} 17740 10000 0 0 {name=l32447 lab=BLB89}
N 17760 9960 17740 9960 {}
C {lab_pin.sym} 17740 9960 0 0 {name=l32448 lab=WL50}
N 17840 10040 17860 10040 {}
C {lab_pin.sym} 17860 10040 0 0 {name=l32449 lab=VDD}
N 17840 9960 17860 9960 {}
C {lab_pin.sym} 17860 9960 0 0 {name=l32450 lab=VSS}
C {bitcell_6t.sym} 18000 10000 0 0 {name=Xr50c90}
N 17960 10040 17940 10040 {}
C {lab_pin.sym} 17940 10040 0 0 {name=l32451 lab=BL90}
N 17960 10000 17940 10000 {}
C {lab_pin.sym} 17940 10000 0 0 {name=l32452 lab=BLB90}
N 17960 9960 17940 9960 {}
C {lab_pin.sym} 17940 9960 0 0 {name=l32453 lab=WL50}
N 18040 10040 18060 10040 {}
C {lab_pin.sym} 18060 10040 0 0 {name=l32454 lab=VDD}
N 18040 9960 18060 9960 {}
C {lab_pin.sym} 18060 9960 0 0 {name=l32455 lab=VSS}
C {bitcell_6t.sym} 18200 10000 0 0 {name=Xr50c91}
N 18160 10040 18140 10040 {}
C {lab_pin.sym} 18140 10040 0 0 {name=l32456 lab=BL91}
N 18160 10000 18140 10000 {}
C {lab_pin.sym} 18140 10000 0 0 {name=l32457 lab=BLB91}
N 18160 9960 18140 9960 {}
C {lab_pin.sym} 18140 9960 0 0 {name=l32458 lab=WL50}
N 18240 10040 18260 10040 {}
C {lab_pin.sym} 18260 10040 0 0 {name=l32459 lab=VDD}
N 18240 9960 18260 9960 {}
C {lab_pin.sym} 18260 9960 0 0 {name=l32460 lab=VSS}
C {bitcell_6t.sym} 18400 10000 0 0 {name=Xr50c92}
N 18360 10040 18340 10040 {}
C {lab_pin.sym} 18340 10040 0 0 {name=l32461 lab=BL92}
N 18360 10000 18340 10000 {}
C {lab_pin.sym} 18340 10000 0 0 {name=l32462 lab=BLB92}
N 18360 9960 18340 9960 {}
C {lab_pin.sym} 18340 9960 0 0 {name=l32463 lab=WL50}
N 18440 10040 18460 10040 {}
C {lab_pin.sym} 18460 10040 0 0 {name=l32464 lab=VDD}
N 18440 9960 18460 9960 {}
C {lab_pin.sym} 18460 9960 0 0 {name=l32465 lab=VSS}
C {bitcell_6t.sym} 18600 10000 0 0 {name=Xr50c93}
N 18560 10040 18540 10040 {}
C {lab_pin.sym} 18540 10040 0 0 {name=l32466 lab=BL93}
N 18560 10000 18540 10000 {}
C {lab_pin.sym} 18540 10000 0 0 {name=l32467 lab=BLB93}
N 18560 9960 18540 9960 {}
C {lab_pin.sym} 18540 9960 0 0 {name=l32468 lab=WL50}
N 18640 10040 18660 10040 {}
C {lab_pin.sym} 18660 10040 0 0 {name=l32469 lab=VDD}
N 18640 9960 18660 9960 {}
C {lab_pin.sym} 18660 9960 0 0 {name=l32470 lab=VSS}
C {bitcell_6t.sym} 18800 10000 0 0 {name=Xr50c94}
N 18760 10040 18740 10040 {}
C {lab_pin.sym} 18740 10040 0 0 {name=l32471 lab=BL94}
N 18760 10000 18740 10000 {}
C {lab_pin.sym} 18740 10000 0 0 {name=l32472 lab=BLB94}
N 18760 9960 18740 9960 {}
C {lab_pin.sym} 18740 9960 0 0 {name=l32473 lab=WL50}
N 18840 10040 18860 10040 {}
C {lab_pin.sym} 18860 10040 0 0 {name=l32474 lab=VDD}
N 18840 9960 18860 9960 {}
C {lab_pin.sym} 18860 9960 0 0 {name=l32475 lab=VSS}
C {bitcell_6t.sym} 19000 10000 0 0 {name=Xr50c95}
N 18960 10040 18940 10040 {}
C {lab_pin.sym} 18940 10040 0 0 {name=l32476 lab=BL95}
N 18960 10000 18940 10000 {}
C {lab_pin.sym} 18940 10000 0 0 {name=l32477 lab=BLB95}
N 18960 9960 18940 9960 {}
C {lab_pin.sym} 18940 9960 0 0 {name=l32478 lab=WL50}
N 19040 10040 19060 10040 {}
C {lab_pin.sym} 19060 10040 0 0 {name=l32479 lab=VDD}
N 19040 9960 19060 9960 {}
C {lab_pin.sym} 19060 9960 0 0 {name=l32480 lab=VSS}
C {bitcell_6t.sym} 19200 10000 0 0 {name=Xr50c96}
N 19160 10040 19140 10040 {}
C {lab_pin.sym} 19140 10040 0 0 {name=l32481 lab=BL96}
N 19160 10000 19140 10000 {}
C {lab_pin.sym} 19140 10000 0 0 {name=l32482 lab=BLB96}
N 19160 9960 19140 9960 {}
C {lab_pin.sym} 19140 9960 0 0 {name=l32483 lab=WL50}
N 19240 10040 19260 10040 {}
C {lab_pin.sym} 19260 10040 0 0 {name=l32484 lab=VDD}
N 19240 9960 19260 9960 {}
C {lab_pin.sym} 19260 9960 0 0 {name=l32485 lab=VSS}
C {bitcell_6t.sym} 19400 10000 0 0 {name=Xr50c97}
N 19360 10040 19340 10040 {}
C {lab_pin.sym} 19340 10040 0 0 {name=l32486 lab=BL97}
N 19360 10000 19340 10000 {}
C {lab_pin.sym} 19340 10000 0 0 {name=l32487 lab=BLB97}
N 19360 9960 19340 9960 {}
C {lab_pin.sym} 19340 9960 0 0 {name=l32488 lab=WL50}
N 19440 10040 19460 10040 {}
C {lab_pin.sym} 19460 10040 0 0 {name=l32489 lab=VDD}
N 19440 9960 19460 9960 {}
C {lab_pin.sym} 19460 9960 0 0 {name=l32490 lab=VSS}
C {bitcell_6t.sym} 19600 10000 0 0 {name=Xr50c98}
N 19560 10040 19540 10040 {}
C {lab_pin.sym} 19540 10040 0 0 {name=l32491 lab=BL98}
N 19560 10000 19540 10000 {}
C {lab_pin.sym} 19540 10000 0 0 {name=l32492 lab=BLB98}
N 19560 9960 19540 9960 {}
C {lab_pin.sym} 19540 9960 0 0 {name=l32493 lab=WL50}
N 19640 10040 19660 10040 {}
C {lab_pin.sym} 19660 10040 0 0 {name=l32494 lab=VDD}
N 19640 9960 19660 9960 {}
C {lab_pin.sym} 19660 9960 0 0 {name=l32495 lab=VSS}
C {bitcell_6t.sym} 19800 10000 0 0 {name=Xr50c99}
N 19760 10040 19740 10040 {}
C {lab_pin.sym} 19740 10040 0 0 {name=l32496 lab=BL99}
N 19760 10000 19740 10000 {}
C {lab_pin.sym} 19740 10000 0 0 {name=l32497 lab=BLB99}
N 19760 9960 19740 9960 {}
C {lab_pin.sym} 19740 9960 0 0 {name=l32498 lab=WL50}
N 19840 10040 19860 10040 {}
C {lab_pin.sym} 19860 10040 0 0 {name=l32499 lab=VDD}
N 19840 9960 19860 9960 {}
C {lab_pin.sym} 19860 9960 0 0 {name=l32500 lab=VSS}
C {bitcell_6t.sym} 20000 10000 0 0 {name=Xr50c100}
N 19960 10040 19940 10040 {}
C {lab_pin.sym} 19940 10040 0 0 {name=l32501 lab=BL100}
N 19960 10000 19940 10000 {}
C {lab_pin.sym} 19940 10000 0 0 {name=l32502 lab=BLB100}
N 19960 9960 19940 9960 {}
C {lab_pin.sym} 19940 9960 0 0 {name=l32503 lab=WL50}
N 20040 10040 20060 10040 {}
C {lab_pin.sym} 20060 10040 0 0 {name=l32504 lab=VDD}
N 20040 9960 20060 9960 {}
C {lab_pin.sym} 20060 9960 0 0 {name=l32505 lab=VSS}
C {bitcell_6t.sym} 20200 10000 0 0 {name=Xr50c101}
N 20160 10040 20140 10040 {}
C {lab_pin.sym} 20140 10040 0 0 {name=l32506 lab=BL101}
N 20160 10000 20140 10000 {}
C {lab_pin.sym} 20140 10000 0 0 {name=l32507 lab=BLB101}
N 20160 9960 20140 9960 {}
C {lab_pin.sym} 20140 9960 0 0 {name=l32508 lab=WL50}
N 20240 10040 20260 10040 {}
C {lab_pin.sym} 20260 10040 0 0 {name=l32509 lab=VDD}
N 20240 9960 20260 9960 {}
C {lab_pin.sym} 20260 9960 0 0 {name=l32510 lab=VSS}
C {bitcell_6t.sym} 20400 10000 0 0 {name=Xr50c102}
N 20360 10040 20340 10040 {}
C {lab_pin.sym} 20340 10040 0 0 {name=l32511 lab=BL102}
N 20360 10000 20340 10000 {}
C {lab_pin.sym} 20340 10000 0 0 {name=l32512 lab=BLB102}
N 20360 9960 20340 9960 {}
C {lab_pin.sym} 20340 9960 0 0 {name=l32513 lab=WL50}
N 20440 10040 20460 10040 {}
C {lab_pin.sym} 20460 10040 0 0 {name=l32514 lab=VDD}
N 20440 9960 20460 9960 {}
C {lab_pin.sym} 20460 9960 0 0 {name=l32515 lab=VSS}
C {bitcell_6t.sym} 20600 10000 0 0 {name=Xr50c103}
N 20560 10040 20540 10040 {}
C {lab_pin.sym} 20540 10040 0 0 {name=l32516 lab=BL103}
N 20560 10000 20540 10000 {}
C {lab_pin.sym} 20540 10000 0 0 {name=l32517 lab=BLB103}
N 20560 9960 20540 9960 {}
C {lab_pin.sym} 20540 9960 0 0 {name=l32518 lab=WL50}
N 20640 10040 20660 10040 {}
C {lab_pin.sym} 20660 10040 0 0 {name=l32519 lab=VDD}
N 20640 9960 20660 9960 {}
C {lab_pin.sym} 20660 9960 0 0 {name=l32520 lab=VSS}
C {bitcell_6t.sym} 20800 10000 0 0 {name=Xr50c104}
N 20760 10040 20740 10040 {}
C {lab_pin.sym} 20740 10040 0 0 {name=l32521 lab=BL104}
N 20760 10000 20740 10000 {}
C {lab_pin.sym} 20740 10000 0 0 {name=l32522 lab=BLB104}
N 20760 9960 20740 9960 {}
C {lab_pin.sym} 20740 9960 0 0 {name=l32523 lab=WL50}
N 20840 10040 20860 10040 {}
C {lab_pin.sym} 20860 10040 0 0 {name=l32524 lab=VDD}
N 20840 9960 20860 9960 {}
C {lab_pin.sym} 20860 9960 0 0 {name=l32525 lab=VSS}
C {bitcell_6t.sym} 21000 10000 0 0 {name=Xr50c105}
N 20960 10040 20940 10040 {}
C {lab_pin.sym} 20940 10040 0 0 {name=l32526 lab=BL105}
N 20960 10000 20940 10000 {}
C {lab_pin.sym} 20940 10000 0 0 {name=l32527 lab=BLB105}
N 20960 9960 20940 9960 {}
C {lab_pin.sym} 20940 9960 0 0 {name=l32528 lab=WL50}
N 21040 10040 21060 10040 {}
C {lab_pin.sym} 21060 10040 0 0 {name=l32529 lab=VDD}
N 21040 9960 21060 9960 {}
C {lab_pin.sym} 21060 9960 0 0 {name=l32530 lab=VSS}
C {bitcell_6t.sym} 21200 10000 0 0 {name=Xr50c106}
N 21160 10040 21140 10040 {}
C {lab_pin.sym} 21140 10040 0 0 {name=l32531 lab=BL106}
N 21160 10000 21140 10000 {}
C {lab_pin.sym} 21140 10000 0 0 {name=l32532 lab=BLB106}
N 21160 9960 21140 9960 {}
C {lab_pin.sym} 21140 9960 0 0 {name=l32533 lab=WL50}
N 21240 10040 21260 10040 {}
C {lab_pin.sym} 21260 10040 0 0 {name=l32534 lab=VDD}
N 21240 9960 21260 9960 {}
C {lab_pin.sym} 21260 9960 0 0 {name=l32535 lab=VSS}
C {bitcell_6t.sym} 21400 10000 0 0 {name=Xr50c107}
N 21360 10040 21340 10040 {}
C {lab_pin.sym} 21340 10040 0 0 {name=l32536 lab=BL107}
N 21360 10000 21340 10000 {}
C {lab_pin.sym} 21340 10000 0 0 {name=l32537 lab=BLB107}
N 21360 9960 21340 9960 {}
C {lab_pin.sym} 21340 9960 0 0 {name=l32538 lab=WL50}
N 21440 10040 21460 10040 {}
C {lab_pin.sym} 21460 10040 0 0 {name=l32539 lab=VDD}
N 21440 9960 21460 9960 {}
C {lab_pin.sym} 21460 9960 0 0 {name=l32540 lab=VSS}
C {bitcell_6t.sym} 21600 10000 0 0 {name=Xr50c108}
N 21560 10040 21540 10040 {}
C {lab_pin.sym} 21540 10040 0 0 {name=l32541 lab=BL108}
N 21560 10000 21540 10000 {}
C {lab_pin.sym} 21540 10000 0 0 {name=l32542 lab=BLB108}
N 21560 9960 21540 9960 {}
C {lab_pin.sym} 21540 9960 0 0 {name=l32543 lab=WL50}
N 21640 10040 21660 10040 {}
C {lab_pin.sym} 21660 10040 0 0 {name=l32544 lab=VDD}
N 21640 9960 21660 9960 {}
C {lab_pin.sym} 21660 9960 0 0 {name=l32545 lab=VSS}
C {bitcell_6t.sym} 21800 10000 0 0 {name=Xr50c109}
N 21760 10040 21740 10040 {}
C {lab_pin.sym} 21740 10040 0 0 {name=l32546 lab=BL109}
N 21760 10000 21740 10000 {}
C {lab_pin.sym} 21740 10000 0 0 {name=l32547 lab=BLB109}
N 21760 9960 21740 9960 {}
C {lab_pin.sym} 21740 9960 0 0 {name=l32548 lab=WL50}
N 21840 10040 21860 10040 {}
C {lab_pin.sym} 21860 10040 0 0 {name=l32549 lab=VDD}
N 21840 9960 21860 9960 {}
C {lab_pin.sym} 21860 9960 0 0 {name=l32550 lab=VSS}
C {bitcell_6t.sym} 22000 10000 0 0 {name=Xr50c110}
N 21960 10040 21940 10040 {}
C {lab_pin.sym} 21940 10040 0 0 {name=l32551 lab=BL110}
N 21960 10000 21940 10000 {}
C {lab_pin.sym} 21940 10000 0 0 {name=l32552 lab=BLB110}
N 21960 9960 21940 9960 {}
C {lab_pin.sym} 21940 9960 0 0 {name=l32553 lab=WL50}
N 22040 10040 22060 10040 {}
C {lab_pin.sym} 22060 10040 0 0 {name=l32554 lab=VDD}
N 22040 9960 22060 9960 {}
C {lab_pin.sym} 22060 9960 0 0 {name=l32555 lab=VSS}
C {bitcell_6t.sym} 22200 10000 0 0 {name=Xr50c111}
N 22160 10040 22140 10040 {}
C {lab_pin.sym} 22140 10040 0 0 {name=l32556 lab=BL111}
N 22160 10000 22140 10000 {}
C {lab_pin.sym} 22140 10000 0 0 {name=l32557 lab=BLB111}
N 22160 9960 22140 9960 {}
C {lab_pin.sym} 22140 9960 0 0 {name=l32558 lab=WL50}
N 22240 10040 22260 10040 {}
C {lab_pin.sym} 22260 10040 0 0 {name=l32559 lab=VDD}
N 22240 9960 22260 9960 {}
C {lab_pin.sym} 22260 9960 0 0 {name=l32560 lab=VSS}
C {bitcell_6t.sym} 22400 10000 0 0 {name=Xr50c112}
N 22360 10040 22340 10040 {}
C {lab_pin.sym} 22340 10040 0 0 {name=l32561 lab=BL112}
N 22360 10000 22340 10000 {}
C {lab_pin.sym} 22340 10000 0 0 {name=l32562 lab=BLB112}
N 22360 9960 22340 9960 {}
C {lab_pin.sym} 22340 9960 0 0 {name=l32563 lab=WL50}
N 22440 10040 22460 10040 {}
C {lab_pin.sym} 22460 10040 0 0 {name=l32564 lab=VDD}
N 22440 9960 22460 9960 {}
C {lab_pin.sym} 22460 9960 0 0 {name=l32565 lab=VSS}
C {bitcell_6t.sym} 22600 10000 0 0 {name=Xr50c113}
N 22560 10040 22540 10040 {}
C {lab_pin.sym} 22540 10040 0 0 {name=l32566 lab=BL113}
N 22560 10000 22540 10000 {}
C {lab_pin.sym} 22540 10000 0 0 {name=l32567 lab=BLB113}
N 22560 9960 22540 9960 {}
C {lab_pin.sym} 22540 9960 0 0 {name=l32568 lab=WL50}
N 22640 10040 22660 10040 {}
C {lab_pin.sym} 22660 10040 0 0 {name=l32569 lab=VDD}
N 22640 9960 22660 9960 {}
C {lab_pin.sym} 22660 9960 0 0 {name=l32570 lab=VSS}
C {bitcell_6t.sym} 22800 10000 0 0 {name=Xr50c114}
N 22760 10040 22740 10040 {}
C {lab_pin.sym} 22740 10040 0 0 {name=l32571 lab=BL114}
N 22760 10000 22740 10000 {}
C {lab_pin.sym} 22740 10000 0 0 {name=l32572 lab=BLB114}
N 22760 9960 22740 9960 {}
C {lab_pin.sym} 22740 9960 0 0 {name=l32573 lab=WL50}
N 22840 10040 22860 10040 {}
C {lab_pin.sym} 22860 10040 0 0 {name=l32574 lab=VDD}
N 22840 9960 22860 9960 {}
C {lab_pin.sym} 22860 9960 0 0 {name=l32575 lab=VSS}
C {bitcell_6t.sym} 23000 10000 0 0 {name=Xr50c115}
N 22960 10040 22940 10040 {}
C {lab_pin.sym} 22940 10040 0 0 {name=l32576 lab=BL115}
N 22960 10000 22940 10000 {}
C {lab_pin.sym} 22940 10000 0 0 {name=l32577 lab=BLB115}
N 22960 9960 22940 9960 {}
C {lab_pin.sym} 22940 9960 0 0 {name=l32578 lab=WL50}
N 23040 10040 23060 10040 {}
C {lab_pin.sym} 23060 10040 0 0 {name=l32579 lab=VDD}
N 23040 9960 23060 9960 {}
C {lab_pin.sym} 23060 9960 0 0 {name=l32580 lab=VSS}
C {bitcell_6t.sym} 23200 10000 0 0 {name=Xr50c116}
N 23160 10040 23140 10040 {}
C {lab_pin.sym} 23140 10040 0 0 {name=l32581 lab=BL116}
N 23160 10000 23140 10000 {}
C {lab_pin.sym} 23140 10000 0 0 {name=l32582 lab=BLB116}
N 23160 9960 23140 9960 {}
C {lab_pin.sym} 23140 9960 0 0 {name=l32583 lab=WL50}
N 23240 10040 23260 10040 {}
C {lab_pin.sym} 23260 10040 0 0 {name=l32584 lab=VDD}
N 23240 9960 23260 9960 {}
C {lab_pin.sym} 23260 9960 0 0 {name=l32585 lab=VSS}
C {bitcell_6t.sym} 23400 10000 0 0 {name=Xr50c117}
N 23360 10040 23340 10040 {}
C {lab_pin.sym} 23340 10040 0 0 {name=l32586 lab=BL117}
N 23360 10000 23340 10000 {}
C {lab_pin.sym} 23340 10000 0 0 {name=l32587 lab=BLB117}
N 23360 9960 23340 9960 {}
C {lab_pin.sym} 23340 9960 0 0 {name=l32588 lab=WL50}
N 23440 10040 23460 10040 {}
C {lab_pin.sym} 23460 10040 0 0 {name=l32589 lab=VDD}
N 23440 9960 23460 9960 {}
C {lab_pin.sym} 23460 9960 0 0 {name=l32590 lab=VSS}
C {bitcell_6t.sym} 23600 10000 0 0 {name=Xr50c118}
N 23560 10040 23540 10040 {}
C {lab_pin.sym} 23540 10040 0 0 {name=l32591 lab=BL118}
N 23560 10000 23540 10000 {}
C {lab_pin.sym} 23540 10000 0 0 {name=l32592 lab=BLB118}
N 23560 9960 23540 9960 {}
C {lab_pin.sym} 23540 9960 0 0 {name=l32593 lab=WL50}
N 23640 10040 23660 10040 {}
C {lab_pin.sym} 23660 10040 0 0 {name=l32594 lab=VDD}
N 23640 9960 23660 9960 {}
C {lab_pin.sym} 23660 9960 0 0 {name=l32595 lab=VSS}
C {bitcell_6t.sym} 23800 10000 0 0 {name=Xr50c119}
N 23760 10040 23740 10040 {}
C {lab_pin.sym} 23740 10040 0 0 {name=l32596 lab=BL119}
N 23760 10000 23740 10000 {}
C {lab_pin.sym} 23740 10000 0 0 {name=l32597 lab=BLB119}
N 23760 9960 23740 9960 {}
C {lab_pin.sym} 23740 9960 0 0 {name=l32598 lab=WL50}
N 23840 10040 23860 10040 {}
C {lab_pin.sym} 23860 10040 0 0 {name=l32599 lab=VDD}
N 23840 9960 23860 9960 {}
C {lab_pin.sym} 23860 9960 0 0 {name=l32600 lab=VSS}
C {bitcell_6t.sym} 24000 10000 0 0 {name=Xr50c120}
N 23960 10040 23940 10040 {}
C {lab_pin.sym} 23940 10040 0 0 {name=l32601 lab=BL120}
N 23960 10000 23940 10000 {}
C {lab_pin.sym} 23940 10000 0 0 {name=l32602 lab=BLB120}
N 23960 9960 23940 9960 {}
C {lab_pin.sym} 23940 9960 0 0 {name=l32603 lab=WL50}
N 24040 10040 24060 10040 {}
C {lab_pin.sym} 24060 10040 0 0 {name=l32604 lab=VDD}
N 24040 9960 24060 9960 {}
C {lab_pin.sym} 24060 9960 0 0 {name=l32605 lab=VSS}
C {bitcell_6t.sym} 24200 10000 0 0 {name=Xr50c121}
N 24160 10040 24140 10040 {}
C {lab_pin.sym} 24140 10040 0 0 {name=l32606 lab=BL121}
N 24160 10000 24140 10000 {}
C {lab_pin.sym} 24140 10000 0 0 {name=l32607 lab=BLB121}
N 24160 9960 24140 9960 {}
C {lab_pin.sym} 24140 9960 0 0 {name=l32608 lab=WL50}
N 24240 10040 24260 10040 {}
C {lab_pin.sym} 24260 10040 0 0 {name=l32609 lab=VDD}
N 24240 9960 24260 9960 {}
C {lab_pin.sym} 24260 9960 0 0 {name=l32610 lab=VSS}
C {bitcell_6t.sym} 24400 10000 0 0 {name=Xr50c122}
N 24360 10040 24340 10040 {}
C {lab_pin.sym} 24340 10040 0 0 {name=l32611 lab=BL122}
N 24360 10000 24340 10000 {}
C {lab_pin.sym} 24340 10000 0 0 {name=l32612 lab=BLB122}
N 24360 9960 24340 9960 {}
C {lab_pin.sym} 24340 9960 0 0 {name=l32613 lab=WL50}
N 24440 10040 24460 10040 {}
C {lab_pin.sym} 24460 10040 0 0 {name=l32614 lab=VDD}
N 24440 9960 24460 9960 {}
C {lab_pin.sym} 24460 9960 0 0 {name=l32615 lab=VSS}
C {bitcell_6t.sym} 24600 10000 0 0 {name=Xr50c123}
N 24560 10040 24540 10040 {}
C {lab_pin.sym} 24540 10040 0 0 {name=l32616 lab=BL123}
N 24560 10000 24540 10000 {}
C {lab_pin.sym} 24540 10000 0 0 {name=l32617 lab=BLB123}
N 24560 9960 24540 9960 {}
C {lab_pin.sym} 24540 9960 0 0 {name=l32618 lab=WL50}
N 24640 10040 24660 10040 {}
C {lab_pin.sym} 24660 10040 0 0 {name=l32619 lab=VDD}
N 24640 9960 24660 9960 {}
C {lab_pin.sym} 24660 9960 0 0 {name=l32620 lab=VSS}
C {bitcell_6t.sym} 24800 10000 0 0 {name=Xr50c124}
N 24760 10040 24740 10040 {}
C {lab_pin.sym} 24740 10040 0 0 {name=l32621 lab=BL124}
N 24760 10000 24740 10000 {}
C {lab_pin.sym} 24740 10000 0 0 {name=l32622 lab=BLB124}
N 24760 9960 24740 9960 {}
C {lab_pin.sym} 24740 9960 0 0 {name=l32623 lab=WL50}
N 24840 10040 24860 10040 {}
C {lab_pin.sym} 24860 10040 0 0 {name=l32624 lab=VDD}
N 24840 9960 24860 9960 {}
C {lab_pin.sym} 24860 9960 0 0 {name=l32625 lab=VSS}
C {bitcell_6t.sym} 25000 10000 0 0 {name=Xr50c125}
N 24960 10040 24940 10040 {}
C {lab_pin.sym} 24940 10040 0 0 {name=l32626 lab=BL125}
N 24960 10000 24940 10000 {}
C {lab_pin.sym} 24940 10000 0 0 {name=l32627 lab=BLB125}
N 24960 9960 24940 9960 {}
C {lab_pin.sym} 24940 9960 0 0 {name=l32628 lab=WL50}
N 25040 10040 25060 10040 {}
C {lab_pin.sym} 25060 10040 0 0 {name=l32629 lab=VDD}
N 25040 9960 25060 9960 {}
C {lab_pin.sym} 25060 9960 0 0 {name=l32630 lab=VSS}
C {bitcell_6t.sym} 25200 10000 0 0 {name=Xr50c126}
N 25160 10040 25140 10040 {}
C {lab_pin.sym} 25140 10040 0 0 {name=l32631 lab=BL126}
N 25160 10000 25140 10000 {}
C {lab_pin.sym} 25140 10000 0 0 {name=l32632 lab=BLB126}
N 25160 9960 25140 9960 {}
C {lab_pin.sym} 25140 9960 0 0 {name=l32633 lab=WL50}
N 25240 10040 25260 10040 {}
C {lab_pin.sym} 25260 10040 0 0 {name=l32634 lab=VDD}
N 25240 9960 25260 9960 {}
C {lab_pin.sym} 25260 9960 0 0 {name=l32635 lab=VSS}
C {bitcell_6t.sym} 25400 10000 0 0 {name=Xr50c127}
N 25360 10040 25340 10040 {}
C {lab_pin.sym} 25340 10040 0 0 {name=l32636 lab=BL127}
N 25360 10000 25340 10000 {}
C {lab_pin.sym} 25340 10000 0 0 {name=l32637 lab=BLB127}
N 25360 9960 25340 9960 {}
C {lab_pin.sym} 25340 9960 0 0 {name=l32638 lab=WL50}
N 25440 10040 25460 10040 {}
C {lab_pin.sym} 25460 10040 0 0 {name=l32639 lab=VDD}
N 25440 9960 25460 9960 {}
C {lab_pin.sym} 25460 9960 0 0 {name=l32640 lab=VSS}
C {bitcell_6t.sym} 0 10200 0 0 {name=Xr51c0}
N -40 10240 -60 10240 {}
C {lab_pin.sym} -60 10240 0 0 {name=l32641 lab=BL0}
N -40 10200 -60 10200 {}
C {lab_pin.sym} -60 10200 0 0 {name=l32642 lab=BLB0}
N -40 10160 -60 10160 {}
C {lab_pin.sym} -60 10160 0 0 {name=l32643 lab=WL51}
N 40 10240 60 10240 {}
C {lab_pin.sym} 60 10240 0 0 {name=l32644 lab=VDD}
N 40 10160 60 10160 {}
C {lab_pin.sym} 60 10160 0 0 {name=l32645 lab=VSS}
C {bitcell_6t.sym} 200 10200 0 0 {name=Xr51c1}
N 160 10240 140 10240 {}
C {lab_pin.sym} 140 10240 0 0 {name=l32646 lab=BL1}
N 160 10200 140 10200 {}
C {lab_pin.sym} 140 10200 0 0 {name=l32647 lab=BLB1}
N 160 10160 140 10160 {}
C {lab_pin.sym} 140 10160 0 0 {name=l32648 lab=WL51}
N 240 10240 260 10240 {}
C {lab_pin.sym} 260 10240 0 0 {name=l32649 lab=VDD}
N 240 10160 260 10160 {}
C {lab_pin.sym} 260 10160 0 0 {name=l32650 lab=VSS}
C {bitcell_6t.sym} 400 10200 0 0 {name=Xr51c2}
N 360 10240 340 10240 {}
C {lab_pin.sym} 340 10240 0 0 {name=l32651 lab=BL2}
N 360 10200 340 10200 {}
C {lab_pin.sym} 340 10200 0 0 {name=l32652 lab=BLB2}
N 360 10160 340 10160 {}
C {lab_pin.sym} 340 10160 0 0 {name=l32653 lab=WL51}
N 440 10240 460 10240 {}
C {lab_pin.sym} 460 10240 0 0 {name=l32654 lab=VDD}
N 440 10160 460 10160 {}
C {lab_pin.sym} 460 10160 0 0 {name=l32655 lab=VSS}
C {bitcell_6t.sym} 600 10200 0 0 {name=Xr51c3}
N 560 10240 540 10240 {}
C {lab_pin.sym} 540 10240 0 0 {name=l32656 lab=BL3}
N 560 10200 540 10200 {}
C {lab_pin.sym} 540 10200 0 0 {name=l32657 lab=BLB3}
N 560 10160 540 10160 {}
C {lab_pin.sym} 540 10160 0 0 {name=l32658 lab=WL51}
N 640 10240 660 10240 {}
C {lab_pin.sym} 660 10240 0 0 {name=l32659 lab=VDD}
N 640 10160 660 10160 {}
C {lab_pin.sym} 660 10160 0 0 {name=l32660 lab=VSS}
C {bitcell_6t.sym} 800 10200 0 0 {name=Xr51c4}
N 760 10240 740 10240 {}
C {lab_pin.sym} 740 10240 0 0 {name=l32661 lab=BL4}
N 760 10200 740 10200 {}
C {lab_pin.sym} 740 10200 0 0 {name=l32662 lab=BLB4}
N 760 10160 740 10160 {}
C {lab_pin.sym} 740 10160 0 0 {name=l32663 lab=WL51}
N 840 10240 860 10240 {}
C {lab_pin.sym} 860 10240 0 0 {name=l32664 lab=VDD}
N 840 10160 860 10160 {}
C {lab_pin.sym} 860 10160 0 0 {name=l32665 lab=VSS}
C {bitcell_6t.sym} 1000 10200 0 0 {name=Xr51c5}
N 960 10240 940 10240 {}
C {lab_pin.sym} 940 10240 0 0 {name=l32666 lab=BL5}
N 960 10200 940 10200 {}
C {lab_pin.sym} 940 10200 0 0 {name=l32667 lab=BLB5}
N 960 10160 940 10160 {}
C {lab_pin.sym} 940 10160 0 0 {name=l32668 lab=WL51}
N 1040 10240 1060 10240 {}
C {lab_pin.sym} 1060 10240 0 0 {name=l32669 lab=VDD}
N 1040 10160 1060 10160 {}
C {lab_pin.sym} 1060 10160 0 0 {name=l32670 lab=VSS}
C {bitcell_6t.sym} 1200 10200 0 0 {name=Xr51c6}
N 1160 10240 1140 10240 {}
C {lab_pin.sym} 1140 10240 0 0 {name=l32671 lab=BL6}
N 1160 10200 1140 10200 {}
C {lab_pin.sym} 1140 10200 0 0 {name=l32672 lab=BLB6}
N 1160 10160 1140 10160 {}
C {lab_pin.sym} 1140 10160 0 0 {name=l32673 lab=WL51}
N 1240 10240 1260 10240 {}
C {lab_pin.sym} 1260 10240 0 0 {name=l32674 lab=VDD}
N 1240 10160 1260 10160 {}
C {lab_pin.sym} 1260 10160 0 0 {name=l32675 lab=VSS}
C {bitcell_6t.sym} 1400 10200 0 0 {name=Xr51c7}
N 1360 10240 1340 10240 {}
C {lab_pin.sym} 1340 10240 0 0 {name=l32676 lab=BL7}
N 1360 10200 1340 10200 {}
C {lab_pin.sym} 1340 10200 0 0 {name=l32677 lab=BLB7}
N 1360 10160 1340 10160 {}
C {lab_pin.sym} 1340 10160 0 0 {name=l32678 lab=WL51}
N 1440 10240 1460 10240 {}
C {lab_pin.sym} 1460 10240 0 0 {name=l32679 lab=VDD}
N 1440 10160 1460 10160 {}
C {lab_pin.sym} 1460 10160 0 0 {name=l32680 lab=VSS}
C {bitcell_6t.sym} 1600 10200 0 0 {name=Xr51c8}
N 1560 10240 1540 10240 {}
C {lab_pin.sym} 1540 10240 0 0 {name=l32681 lab=BL8}
N 1560 10200 1540 10200 {}
C {lab_pin.sym} 1540 10200 0 0 {name=l32682 lab=BLB8}
N 1560 10160 1540 10160 {}
C {lab_pin.sym} 1540 10160 0 0 {name=l32683 lab=WL51}
N 1640 10240 1660 10240 {}
C {lab_pin.sym} 1660 10240 0 0 {name=l32684 lab=VDD}
N 1640 10160 1660 10160 {}
C {lab_pin.sym} 1660 10160 0 0 {name=l32685 lab=VSS}
C {bitcell_6t.sym} 1800 10200 0 0 {name=Xr51c9}
N 1760 10240 1740 10240 {}
C {lab_pin.sym} 1740 10240 0 0 {name=l32686 lab=BL9}
N 1760 10200 1740 10200 {}
C {lab_pin.sym} 1740 10200 0 0 {name=l32687 lab=BLB9}
N 1760 10160 1740 10160 {}
C {lab_pin.sym} 1740 10160 0 0 {name=l32688 lab=WL51}
N 1840 10240 1860 10240 {}
C {lab_pin.sym} 1860 10240 0 0 {name=l32689 lab=VDD}
N 1840 10160 1860 10160 {}
C {lab_pin.sym} 1860 10160 0 0 {name=l32690 lab=VSS}
C {bitcell_6t.sym} 2000 10200 0 0 {name=Xr51c10}
N 1960 10240 1940 10240 {}
C {lab_pin.sym} 1940 10240 0 0 {name=l32691 lab=BL10}
N 1960 10200 1940 10200 {}
C {lab_pin.sym} 1940 10200 0 0 {name=l32692 lab=BLB10}
N 1960 10160 1940 10160 {}
C {lab_pin.sym} 1940 10160 0 0 {name=l32693 lab=WL51}
N 2040 10240 2060 10240 {}
C {lab_pin.sym} 2060 10240 0 0 {name=l32694 lab=VDD}
N 2040 10160 2060 10160 {}
C {lab_pin.sym} 2060 10160 0 0 {name=l32695 lab=VSS}
C {bitcell_6t.sym} 2200 10200 0 0 {name=Xr51c11}
N 2160 10240 2140 10240 {}
C {lab_pin.sym} 2140 10240 0 0 {name=l32696 lab=BL11}
N 2160 10200 2140 10200 {}
C {lab_pin.sym} 2140 10200 0 0 {name=l32697 lab=BLB11}
N 2160 10160 2140 10160 {}
C {lab_pin.sym} 2140 10160 0 0 {name=l32698 lab=WL51}
N 2240 10240 2260 10240 {}
C {lab_pin.sym} 2260 10240 0 0 {name=l32699 lab=VDD}
N 2240 10160 2260 10160 {}
C {lab_pin.sym} 2260 10160 0 0 {name=l32700 lab=VSS}
C {bitcell_6t.sym} 2400 10200 0 0 {name=Xr51c12}
N 2360 10240 2340 10240 {}
C {lab_pin.sym} 2340 10240 0 0 {name=l32701 lab=BL12}
N 2360 10200 2340 10200 {}
C {lab_pin.sym} 2340 10200 0 0 {name=l32702 lab=BLB12}
N 2360 10160 2340 10160 {}
C {lab_pin.sym} 2340 10160 0 0 {name=l32703 lab=WL51}
N 2440 10240 2460 10240 {}
C {lab_pin.sym} 2460 10240 0 0 {name=l32704 lab=VDD}
N 2440 10160 2460 10160 {}
C {lab_pin.sym} 2460 10160 0 0 {name=l32705 lab=VSS}
C {bitcell_6t.sym} 2600 10200 0 0 {name=Xr51c13}
N 2560 10240 2540 10240 {}
C {lab_pin.sym} 2540 10240 0 0 {name=l32706 lab=BL13}
N 2560 10200 2540 10200 {}
C {lab_pin.sym} 2540 10200 0 0 {name=l32707 lab=BLB13}
N 2560 10160 2540 10160 {}
C {lab_pin.sym} 2540 10160 0 0 {name=l32708 lab=WL51}
N 2640 10240 2660 10240 {}
C {lab_pin.sym} 2660 10240 0 0 {name=l32709 lab=VDD}
N 2640 10160 2660 10160 {}
C {lab_pin.sym} 2660 10160 0 0 {name=l32710 lab=VSS}
C {bitcell_6t.sym} 2800 10200 0 0 {name=Xr51c14}
N 2760 10240 2740 10240 {}
C {lab_pin.sym} 2740 10240 0 0 {name=l32711 lab=BL14}
N 2760 10200 2740 10200 {}
C {lab_pin.sym} 2740 10200 0 0 {name=l32712 lab=BLB14}
N 2760 10160 2740 10160 {}
C {lab_pin.sym} 2740 10160 0 0 {name=l32713 lab=WL51}
N 2840 10240 2860 10240 {}
C {lab_pin.sym} 2860 10240 0 0 {name=l32714 lab=VDD}
N 2840 10160 2860 10160 {}
C {lab_pin.sym} 2860 10160 0 0 {name=l32715 lab=VSS}
C {bitcell_6t.sym} 3000 10200 0 0 {name=Xr51c15}
N 2960 10240 2940 10240 {}
C {lab_pin.sym} 2940 10240 0 0 {name=l32716 lab=BL15}
N 2960 10200 2940 10200 {}
C {lab_pin.sym} 2940 10200 0 0 {name=l32717 lab=BLB15}
N 2960 10160 2940 10160 {}
C {lab_pin.sym} 2940 10160 0 0 {name=l32718 lab=WL51}
N 3040 10240 3060 10240 {}
C {lab_pin.sym} 3060 10240 0 0 {name=l32719 lab=VDD}
N 3040 10160 3060 10160 {}
C {lab_pin.sym} 3060 10160 0 0 {name=l32720 lab=VSS}
C {bitcell_6t.sym} 3200 10200 0 0 {name=Xr51c16}
N 3160 10240 3140 10240 {}
C {lab_pin.sym} 3140 10240 0 0 {name=l32721 lab=BL16}
N 3160 10200 3140 10200 {}
C {lab_pin.sym} 3140 10200 0 0 {name=l32722 lab=BLB16}
N 3160 10160 3140 10160 {}
C {lab_pin.sym} 3140 10160 0 0 {name=l32723 lab=WL51}
N 3240 10240 3260 10240 {}
C {lab_pin.sym} 3260 10240 0 0 {name=l32724 lab=VDD}
N 3240 10160 3260 10160 {}
C {lab_pin.sym} 3260 10160 0 0 {name=l32725 lab=VSS}
C {bitcell_6t.sym} 3400 10200 0 0 {name=Xr51c17}
N 3360 10240 3340 10240 {}
C {lab_pin.sym} 3340 10240 0 0 {name=l32726 lab=BL17}
N 3360 10200 3340 10200 {}
C {lab_pin.sym} 3340 10200 0 0 {name=l32727 lab=BLB17}
N 3360 10160 3340 10160 {}
C {lab_pin.sym} 3340 10160 0 0 {name=l32728 lab=WL51}
N 3440 10240 3460 10240 {}
C {lab_pin.sym} 3460 10240 0 0 {name=l32729 lab=VDD}
N 3440 10160 3460 10160 {}
C {lab_pin.sym} 3460 10160 0 0 {name=l32730 lab=VSS}
C {bitcell_6t.sym} 3600 10200 0 0 {name=Xr51c18}
N 3560 10240 3540 10240 {}
C {lab_pin.sym} 3540 10240 0 0 {name=l32731 lab=BL18}
N 3560 10200 3540 10200 {}
C {lab_pin.sym} 3540 10200 0 0 {name=l32732 lab=BLB18}
N 3560 10160 3540 10160 {}
C {lab_pin.sym} 3540 10160 0 0 {name=l32733 lab=WL51}
N 3640 10240 3660 10240 {}
C {lab_pin.sym} 3660 10240 0 0 {name=l32734 lab=VDD}
N 3640 10160 3660 10160 {}
C {lab_pin.sym} 3660 10160 0 0 {name=l32735 lab=VSS}
C {bitcell_6t.sym} 3800 10200 0 0 {name=Xr51c19}
N 3760 10240 3740 10240 {}
C {lab_pin.sym} 3740 10240 0 0 {name=l32736 lab=BL19}
N 3760 10200 3740 10200 {}
C {lab_pin.sym} 3740 10200 0 0 {name=l32737 lab=BLB19}
N 3760 10160 3740 10160 {}
C {lab_pin.sym} 3740 10160 0 0 {name=l32738 lab=WL51}
N 3840 10240 3860 10240 {}
C {lab_pin.sym} 3860 10240 0 0 {name=l32739 lab=VDD}
N 3840 10160 3860 10160 {}
C {lab_pin.sym} 3860 10160 0 0 {name=l32740 lab=VSS}
C {bitcell_6t.sym} 4000 10200 0 0 {name=Xr51c20}
N 3960 10240 3940 10240 {}
C {lab_pin.sym} 3940 10240 0 0 {name=l32741 lab=BL20}
N 3960 10200 3940 10200 {}
C {lab_pin.sym} 3940 10200 0 0 {name=l32742 lab=BLB20}
N 3960 10160 3940 10160 {}
C {lab_pin.sym} 3940 10160 0 0 {name=l32743 lab=WL51}
N 4040 10240 4060 10240 {}
C {lab_pin.sym} 4060 10240 0 0 {name=l32744 lab=VDD}
N 4040 10160 4060 10160 {}
C {lab_pin.sym} 4060 10160 0 0 {name=l32745 lab=VSS}
C {bitcell_6t.sym} 4200 10200 0 0 {name=Xr51c21}
N 4160 10240 4140 10240 {}
C {lab_pin.sym} 4140 10240 0 0 {name=l32746 lab=BL21}
N 4160 10200 4140 10200 {}
C {lab_pin.sym} 4140 10200 0 0 {name=l32747 lab=BLB21}
N 4160 10160 4140 10160 {}
C {lab_pin.sym} 4140 10160 0 0 {name=l32748 lab=WL51}
N 4240 10240 4260 10240 {}
C {lab_pin.sym} 4260 10240 0 0 {name=l32749 lab=VDD}
N 4240 10160 4260 10160 {}
C {lab_pin.sym} 4260 10160 0 0 {name=l32750 lab=VSS}
C {bitcell_6t.sym} 4400 10200 0 0 {name=Xr51c22}
N 4360 10240 4340 10240 {}
C {lab_pin.sym} 4340 10240 0 0 {name=l32751 lab=BL22}
N 4360 10200 4340 10200 {}
C {lab_pin.sym} 4340 10200 0 0 {name=l32752 lab=BLB22}
N 4360 10160 4340 10160 {}
C {lab_pin.sym} 4340 10160 0 0 {name=l32753 lab=WL51}
N 4440 10240 4460 10240 {}
C {lab_pin.sym} 4460 10240 0 0 {name=l32754 lab=VDD}
N 4440 10160 4460 10160 {}
C {lab_pin.sym} 4460 10160 0 0 {name=l32755 lab=VSS}
C {bitcell_6t.sym} 4600 10200 0 0 {name=Xr51c23}
N 4560 10240 4540 10240 {}
C {lab_pin.sym} 4540 10240 0 0 {name=l32756 lab=BL23}
N 4560 10200 4540 10200 {}
C {lab_pin.sym} 4540 10200 0 0 {name=l32757 lab=BLB23}
N 4560 10160 4540 10160 {}
C {lab_pin.sym} 4540 10160 0 0 {name=l32758 lab=WL51}
N 4640 10240 4660 10240 {}
C {lab_pin.sym} 4660 10240 0 0 {name=l32759 lab=VDD}
N 4640 10160 4660 10160 {}
C {lab_pin.sym} 4660 10160 0 0 {name=l32760 lab=VSS}
C {bitcell_6t.sym} 4800 10200 0 0 {name=Xr51c24}
N 4760 10240 4740 10240 {}
C {lab_pin.sym} 4740 10240 0 0 {name=l32761 lab=BL24}
N 4760 10200 4740 10200 {}
C {lab_pin.sym} 4740 10200 0 0 {name=l32762 lab=BLB24}
N 4760 10160 4740 10160 {}
C {lab_pin.sym} 4740 10160 0 0 {name=l32763 lab=WL51}
N 4840 10240 4860 10240 {}
C {lab_pin.sym} 4860 10240 0 0 {name=l32764 lab=VDD}
N 4840 10160 4860 10160 {}
C {lab_pin.sym} 4860 10160 0 0 {name=l32765 lab=VSS}
C {bitcell_6t.sym} 5000 10200 0 0 {name=Xr51c25}
N 4960 10240 4940 10240 {}
C {lab_pin.sym} 4940 10240 0 0 {name=l32766 lab=BL25}
N 4960 10200 4940 10200 {}
C {lab_pin.sym} 4940 10200 0 0 {name=l32767 lab=BLB25}
N 4960 10160 4940 10160 {}
C {lab_pin.sym} 4940 10160 0 0 {name=l32768 lab=WL51}
N 5040 10240 5060 10240 {}
C {lab_pin.sym} 5060 10240 0 0 {name=l32769 lab=VDD}
N 5040 10160 5060 10160 {}
C {lab_pin.sym} 5060 10160 0 0 {name=l32770 lab=VSS}
C {bitcell_6t.sym} 5200 10200 0 0 {name=Xr51c26}
N 5160 10240 5140 10240 {}
C {lab_pin.sym} 5140 10240 0 0 {name=l32771 lab=BL26}
N 5160 10200 5140 10200 {}
C {lab_pin.sym} 5140 10200 0 0 {name=l32772 lab=BLB26}
N 5160 10160 5140 10160 {}
C {lab_pin.sym} 5140 10160 0 0 {name=l32773 lab=WL51}
N 5240 10240 5260 10240 {}
C {lab_pin.sym} 5260 10240 0 0 {name=l32774 lab=VDD}
N 5240 10160 5260 10160 {}
C {lab_pin.sym} 5260 10160 0 0 {name=l32775 lab=VSS}
C {bitcell_6t.sym} 5400 10200 0 0 {name=Xr51c27}
N 5360 10240 5340 10240 {}
C {lab_pin.sym} 5340 10240 0 0 {name=l32776 lab=BL27}
N 5360 10200 5340 10200 {}
C {lab_pin.sym} 5340 10200 0 0 {name=l32777 lab=BLB27}
N 5360 10160 5340 10160 {}
C {lab_pin.sym} 5340 10160 0 0 {name=l32778 lab=WL51}
N 5440 10240 5460 10240 {}
C {lab_pin.sym} 5460 10240 0 0 {name=l32779 lab=VDD}
N 5440 10160 5460 10160 {}
C {lab_pin.sym} 5460 10160 0 0 {name=l32780 lab=VSS}
C {bitcell_6t.sym} 5600 10200 0 0 {name=Xr51c28}
N 5560 10240 5540 10240 {}
C {lab_pin.sym} 5540 10240 0 0 {name=l32781 lab=BL28}
N 5560 10200 5540 10200 {}
C {lab_pin.sym} 5540 10200 0 0 {name=l32782 lab=BLB28}
N 5560 10160 5540 10160 {}
C {lab_pin.sym} 5540 10160 0 0 {name=l32783 lab=WL51}
N 5640 10240 5660 10240 {}
C {lab_pin.sym} 5660 10240 0 0 {name=l32784 lab=VDD}
N 5640 10160 5660 10160 {}
C {lab_pin.sym} 5660 10160 0 0 {name=l32785 lab=VSS}
C {bitcell_6t.sym} 5800 10200 0 0 {name=Xr51c29}
N 5760 10240 5740 10240 {}
C {lab_pin.sym} 5740 10240 0 0 {name=l32786 lab=BL29}
N 5760 10200 5740 10200 {}
C {lab_pin.sym} 5740 10200 0 0 {name=l32787 lab=BLB29}
N 5760 10160 5740 10160 {}
C {lab_pin.sym} 5740 10160 0 0 {name=l32788 lab=WL51}
N 5840 10240 5860 10240 {}
C {lab_pin.sym} 5860 10240 0 0 {name=l32789 lab=VDD}
N 5840 10160 5860 10160 {}
C {lab_pin.sym} 5860 10160 0 0 {name=l32790 lab=VSS}
C {bitcell_6t.sym} 6000 10200 0 0 {name=Xr51c30}
N 5960 10240 5940 10240 {}
C {lab_pin.sym} 5940 10240 0 0 {name=l32791 lab=BL30}
N 5960 10200 5940 10200 {}
C {lab_pin.sym} 5940 10200 0 0 {name=l32792 lab=BLB30}
N 5960 10160 5940 10160 {}
C {lab_pin.sym} 5940 10160 0 0 {name=l32793 lab=WL51}
N 6040 10240 6060 10240 {}
C {lab_pin.sym} 6060 10240 0 0 {name=l32794 lab=VDD}
N 6040 10160 6060 10160 {}
C {lab_pin.sym} 6060 10160 0 0 {name=l32795 lab=VSS}
C {bitcell_6t.sym} 6200 10200 0 0 {name=Xr51c31}
N 6160 10240 6140 10240 {}
C {lab_pin.sym} 6140 10240 0 0 {name=l32796 lab=BL31}
N 6160 10200 6140 10200 {}
C {lab_pin.sym} 6140 10200 0 0 {name=l32797 lab=BLB31}
N 6160 10160 6140 10160 {}
C {lab_pin.sym} 6140 10160 0 0 {name=l32798 lab=WL51}
N 6240 10240 6260 10240 {}
C {lab_pin.sym} 6260 10240 0 0 {name=l32799 lab=VDD}
N 6240 10160 6260 10160 {}
C {lab_pin.sym} 6260 10160 0 0 {name=l32800 lab=VSS}
C {bitcell_6t.sym} 6400 10200 0 0 {name=Xr51c32}
N 6360 10240 6340 10240 {}
C {lab_pin.sym} 6340 10240 0 0 {name=l32801 lab=BL32}
N 6360 10200 6340 10200 {}
C {lab_pin.sym} 6340 10200 0 0 {name=l32802 lab=BLB32}
N 6360 10160 6340 10160 {}
C {lab_pin.sym} 6340 10160 0 0 {name=l32803 lab=WL51}
N 6440 10240 6460 10240 {}
C {lab_pin.sym} 6460 10240 0 0 {name=l32804 lab=VDD}
N 6440 10160 6460 10160 {}
C {lab_pin.sym} 6460 10160 0 0 {name=l32805 lab=VSS}
C {bitcell_6t.sym} 6600 10200 0 0 {name=Xr51c33}
N 6560 10240 6540 10240 {}
C {lab_pin.sym} 6540 10240 0 0 {name=l32806 lab=BL33}
N 6560 10200 6540 10200 {}
C {lab_pin.sym} 6540 10200 0 0 {name=l32807 lab=BLB33}
N 6560 10160 6540 10160 {}
C {lab_pin.sym} 6540 10160 0 0 {name=l32808 lab=WL51}
N 6640 10240 6660 10240 {}
C {lab_pin.sym} 6660 10240 0 0 {name=l32809 lab=VDD}
N 6640 10160 6660 10160 {}
C {lab_pin.sym} 6660 10160 0 0 {name=l32810 lab=VSS}
C {bitcell_6t.sym} 6800 10200 0 0 {name=Xr51c34}
N 6760 10240 6740 10240 {}
C {lab_pin.sym} 6740 10240 0 0 {name=l32811 lab=BL34}
N 6760 10200 6740 10200 {}
C {lab_pin.sym} 6740 10200 0 0 {name=l32812 lab=BLB34}
N 6760 10160 6740 10160 {}
C {lab_pin.sym} 6740 10160 0 0 {name=l32813 lab=WL51}
N 6840 10240 6860 10240 {}
C {lab_pin.sym} 6860 10240 0 0 {name=l32814 lab=VDD}
N 6840 10160 6860 10160 {}
C {lab_pin.sym} 6860 10160 0 0 {name=l32815 lab=VSS}
C {bitcell_6t.sym} 7000 10200 0 0 {name=Xr51c35}
N 6960 10240 6940 10240 {}
C {lab_pin.sym} 6940 10240 0 0 {name=l32816 lab=BL35}
N 6960 10200 6940 10200 {}
C {lab_pin.sym} 6940 10200 0 0 {name=l32817 lab=BLB35}
N 6960 10160 6940 10160 {}
C {lab_pin.sym} 6940 10160 0 0 {name=l32818 lab=WL51}
N 7040 10240 7060 10240 {}
C {lab_pin.sym} 7060 10240 0 0 {name=l32819 lab=VDD}
N 7040 10160 7060 10160 {}
C {lab_pin.sym} 7060 10160 0 0 {name=l32820 lab=VSS}
C {bitcell_6t.sym} 7200 10200 0 0 {name=Xr51c36}
N 7160 10240 7140 10240 {}
C {lab_pin.sym} 7140 10240 0 0 {name=l32821 lab=BL36}
N 7160 10200 7140 10200 {}
C {lab_pin.sym} 7140 10200 0 0 {name=l32822 lab=BLB36}
N 7160 10160 7140 10160 {}
C {lab_pin.sym} 7140 10160 0 0 {name=l32823 lab=WL51}
N 7240 10240 7260 10240 {}
C {lab_pin.sym} 7260 10240 0 0 {name=l32824 lab=VDD}
N 7240 10160 7260 10160 {}
C {lab_pin.sym} 7260 10160 0 0 {name=l32825 lab=VSS}
C {bitcell_6t.sym} 7400 10200 0 0 {name=Xr51c37}
N 7360 10240 7340 10240 {}
C {lab_pin.sym} 7340 10240 0 0 {name=l32826 lab=BL37}
N 7360 10200 7340 10200 {}
C {lab_pin.sym} 7340 10200 0 0 {name=l32827 lab=BLB37}
N 7360 10160 7340 10160 {}
C {lab_pin.sym} 7340 10160 0 0 {name=l32828 lab=WL51}
N 7440 10240 7460 10240 {}
C {lab_pin.sym} 7460 10240 0 0 {name=l32829 lab=VDD}
N 7440 10160 7460 10160 {}
C {lab_pin.sym} 7460 10160 0 0 {name=l32830 lab=VSS}
C {bitcell_6t.sym} 7600 10200 0 0 {name=Xr51c38}
N 7560 10240 7540 10240 {}
C {lab_pin.sym} 7540 10240 0 0 {name=l32831 lab=BL38}
N 7560 10200 7540 10200 {}
C {lab_pin.sym} 7540 10200 0 0 {name=l32832 lab=BLB38}
N 7560 10160 7540 10160 {}
C {lab_pin.sym} 7540 10160 0 0 {name=l32833 lab=WL51}
N 7640 10240 7660 10240 {}
C {lab_pin.sym} 7660 10240 0 0 {name=l32834 lab=VDD}
N 7640 10160 7660 10160 {}
C {lab_pin.sym} 7660 10160 0 0 {name=l32835 lab=VSS}
C {bitcell_6t.sym} 7800 10200 0 0 {name=Xr51c39}
N 7760 10240 7740 10240 {}
C {lab_pin.sym} 7740 10240 0 0 {name=l32836 lab=BL39}
N 7760 10200 7740 10200 {}
C {lab_pin.sym} 7740 10200 0 0 {name=l32837 lab=BLB39}
N 7760 10160 7740 10160 {}
C {lab_pin.sym} 7740 10160 0 0 {name=l32838 lab=WL51}
N 7840 10240 7860 10240 {}
C {lab_pin.sym} 7860 10240 0 0 {name=l32839 lab=VDD}
N 7840 10160 7860 10160 {}
C {lab_pin.sym} 7860 10160 0 0 {name=l32840 lab=VSS}
C {bitcell_6t.sym} 8000 10200 0 0 {name=Xr51c40}
N 7960 10240 7940 10240 {}
C {lab_pin.sym} 7940 10240 0 0 {name=l32841 lab=BL40}
N 7960 10200 7940 10200 {}
C {lab_pin.sym} 7940 10200 0 0 {name=l32842 lab=BLB40}
N 7960 10160 7940 10160 {}
C {lab_pin.sym} 7940 10160 0 0 {name=l32843 lab=WL51}
N 8040 10240 8060 10240 {}
C {lab_pin.sym} 8060 10240 0 0 {name=l32844 lab=VDD}
N 8040 10160 8060 10160 {}
C {lab_pin.sym} 8060 10160 0 0 {name=l32845 lab=VSS}
C {bitcell_6t.sym} 8200 10200 0 0 {name=Xr51c41}
N 8160 10240 8140 10240 {}
C {lab_pin.sym} 8140 10240 0 0 {name=l32846 lab=BL41}
N 8160 10200 8140 10200 {}
C {lab_pin.sym} 8140 10200 0 0 {name=l32847 lab=BLB41}
N 8160 10160 8140 10160 {}
C {lab_pin.sym} 8140 10160 0 0 {name=l32848 lab=WL51}
N 8240 10240 8260 10240 {}
C {lab_pin.sym} 8260 10240 0 0 {name=l32849 lab=VDD}
N 8240 10160 8260 10160 {}
C {lab_pin.sym} 8260 10160 0 0 {name=l32850 lab=VSS}
C {bitcell_6t.sym} 8400 10200 0 0 {name=Xr51c42}
N 8360 10240 8340 10240 {}
C {lab_pin.sym} 8340 10240 0 0 {name=l32851 lab=BL42}
N 8360 10200 8340 10200 {}
C {lab_pin.sym} 8340 10200 0 0 {name=l32852 lab=BLB42}
N 8360 10160 8340 10160 {}
C {lab_pin.sym} 8340 10160 0 0 {name=l32853 lab=WL51}
N 8440 10240 8460 10240 {}
C {lab_pin.sym} 8460 10240 0 0 {name=l32854 lab=VDD}
N 8440 10160 8460 10160 {}
C {lab_pin.sym} 8460 10160 0 0 {name=l32855 lab=VSS}
C {bitcell_6t.sym} 8600 10200 0 0 {name=Xr51c43}
N 8560 10240 8540 10240 {}
C {lab_pin.sym} 8540 10240 0 0 {name=l32856 lab=BL43}
N 8560 10200 8540 10200 {}
C {lab_pin.sym} 8540 10200 0 0 {name=l32857 lab=BLB43}
N 8560 10160 8540 10160 {}
C {lab_pin.sym} 8540 10160 0 0 {name=l32858 lab=WL51}
N 8640 10240 8660 10240 {}
C {lab_pin.sym} 8660 10240 0 0 {name=l32859 lab=VDD}
N 8640 10160 8660 10160 {}
C {lab_pin.sym} 8660 10160 0 0 {name=l32860 lab=VSS}
C {bitcell_6t.sym} 8800 10200 0 0 {name=Xr51c44}
N 8760 10240 8740 10240 {}
C {lab_pin.sym} 8740 10240 0 0 {name=l32861 lab=BL44}
N 8760 10200 8740 10200 {}
C {lab_pin.sym} 8740 10200 0 0 {name=l32862 lab=BLB44}
N 8760 10160 8740 10160 {}
C {lab_pin.sym} 8740 10160 0 0 {name=l32863 lab=WL51}
N 8840 10240 8860 10240 {}
C {lab_pin.sym} 8860 10240 0 0 {name=l32864 lab=VDD}
N 8840 10160 8860 10160 {}
C {lab_pin.sym} 8860 10160 0 0 {name=l32865 lab=VSS}
C {bitcell_6t.sym} 9000 10200 0 0 {name=Xr51c45}
N 8960 10240 8940 10240 {}
C {lab_pin.sym} 8940 10240 0 0 {name=l32866 lab=BL45}
N 8960 10200 8940 10200 {}
C {lab_pin.sym} 8940 10200 0 0 {name=l32867 lab=BLB45}
N 8960 10160 8940 10160 {}
C {lab_pin.sym} 8940 10160 0 0 {name=l32868 lab=WL51}
N 9040 10240 9060 10240 {}
C {lab_pin.sym} 9060 10240 0 0 {name=l32869 lab=VDD}
N 9040 10160 9060 10160 {}
C {lab_pin.sym} 9060 10160 0 0 {name=l32870 lab=VSS}
C {bitcell_6t.sym} 9200 10200 0 0 {name=Xr51c46}
N 9160 10240 9140 10240 {}
C {lab_pin.sym} 9140 10240 0 0 {name=l32871 lab=BL46}
N 9160 10200 9140 10200 {}
C {lab_pin.sym} 9140 10200 0 0 {name=l32872 lab=BLB46}
N 9160 10160 9140 10160 {}
C {lab_pin.sym} 9140 10160 0 0 {name=l32873 lab=WL51}
N 9240 10240 9260 10240 {}
C {lab_pin.sym} 9260 10240 0 0 {name=l32874 lab=VDD}
N 9240 10160 9260 10160 {}
C {lab_pin.sym} 9260 10160 0 0 {name=l32875 lab=VSS}
C {bitcell_6t.sym} 9400 10200 0 0 {name=Xr51c47}
N 9360 10240 9340 10240 {}
C {lab_pin.sym} 9340 10240 0 0 {name=l32876 lab=BL47}
N 9360 10200 9340 10200 {}
C {lab_pin.sym} 9340 10200 0 0 {name=l32877 lab=BLB47}
N 9360 10160 9340 10160 {}
C {lab_pin.sym} 9340 10160 0 0 {name=l32878 lab=WL51}
N 9440 10240 9460 10240 {}
C {lab_pin.sym} 9460 10240 0 0 {name=l32879 lab=VDD}
N 9440 10160 9460 10160 {}
C {lab_pin.sym} 9460 10160 0 0 {name=l32880 lab=VSS}
C {bitcell_6t.sym} 9600 10200 0 0 {name=Xr51c48}
N 9560 10240 9540 10240 {}
C {lab_pin.sym} 9540 10240 0 0 {name=l32881 lab=BL48}
N 9560 10200 9540 10200 {}
C {lab_pin.sym} 9540 10200 0 0 {name=l32882 lab=BLB48}
N 9560 10160 9540 10160 {}
C {lab_pin.sym} 9540 10160 0 0 {name=l32883 lab=WL51}
N 9640 10240 9660 10240 {}
C {lab_pin.sym} 9660 10240 0 0 {name=l32884 lab=VDD}
N 9640 10160 9660 10160 {}
C {lab_pin.sym} 9660 10160 0 0 {name=l32885 lab=VSS}
C {bitcell_6t.sym} 9800 10200 0 0 {name=Xr51c49}
N 9760 10240 9740 10240 {}
C {lab_pin.sym} 9740 10240 0 0 {name=l32886 lab=BL49}
N 9760 10200 9740 10200 {}
C {lab_pin.sym} 9740 10200 0 0 {name=l32887 lab=BLB49}
N 9760 10160 9740 10160 {}
C {lab_pin.sym} 9740 10160 0 0 {name=l32888 lab=WL51}
N 9840 10240 9860 10240 {}
C {lab_pin.sym} 9860 10240 0 0 {name=l32889 lab=VDD}
N 9840 10160 9860 10160 {}
C {lab_pin.sym} 9860 10160 0 0 {name=l32890 lab=VSS}
C {bitcell_6t.sym} 10000 10200 0 0 {name=Xr51c50}
N 9960 10240 9940 10240 {}
C {lab_pin.sym} 9940 10240 0 0 {name=l32891 lab=BL50}
N 9960 10200 9940 10200 {}
C {lab_pin.sym} 9940 10200 0 0 {name=l32892 lab=BLB50}
N 9960 10160 9940 10160 {}
C {lab_pin.sym} 9940 10160 0 0 {name=l32893 lab=WL51}
N 10040 10240 10060 10240 {}
C {lab_pin.sym} 10060 10240 0 0 {name=l32894 lab=VDD}
N 10040 10160 10060 10160 {}
C {lab_pin.sym} 10060 10160 0 0 {name=l32895 lab=VSS}
C {bitcell_6t.sym} 10200 10200 0 0 {name=Xr51c51}
N 10160 10240 10140 10240 {}
C {lab_pin.sym} 10140 10240 0 0 {name=l32896 lab=BL51}
N 10160 10200 10140 10200 {}
C {lab_pin.sym} 10140 10200 0 0 {name=l32897 lab=BLB51}
N 10160 10160 10140 10160 {}
C {lab_pin.sym} 10140 10160 0 0 {name=l32898 lab=WL51}
N 10240 10240 10260 10240 {}
C {lab_pin.sym} 10260 10240 0 0 {name=l32899 lab=VDD}
N 10240 10160 10260 10160 {}
C {lab_pin.sym} 10260 10160 0 0 {name=l32900 lab=VSS}
C {bitcell_6t.sym} 10400 10200 0 0 {name=Xr51c52}
N 10360 10240 10340 10240 {}
C {lab_pin.sym} 10340 10240 0 0 {name=l32901 lab=BL52}
N 10360 10200 10340 10200 {}
C {lab_pin.sym} 10340 10200 0 0 {name=l32902 lab=BLB52}
N 10360 10160 10340 10160 {}
C {lab_pin.sym} 10340 10160 0 0 {name=l32903 lab=WL51}
N 10440 10240 10460 10240 {}
C {lab_pin.sym} 10460 10240 0 0 {name=l32904 lab=VDD}
N 10440 10160 10460 10160 {}
C {lab_pin.sym} 10460 10160 0 0 {name=l32905 lab=VSS}
C {bitcell_6t.sym} 10600 10200 0 0 {name=Xr51c53}
N 10560 10240 10540 10240 {}
C {lab_pin.sym} 10540 10240 0 0 {name=l32906 lab=BL53}
N 10560 10200 10540 10200 {}
C {lab_pin.sym} 10540 10200 0 0 {name=l32907 lab=BLB53}
N 10560 10160 10540 10160 {}
C {lab_pin.sym} 10540 10160 0 0 {name=l32908 lab=WL51}
N 10640 10240 10660 10240 {}
C {lab_pin.sym} 10660 10240 0 0 {name=l32909 lab=VDD}
N 10640 10160 10660 10160 {}
C {lab_pin.sym} 10660 10160 0 0 {name=l32910 lab=VSS}
C {bitcell_6t.sym} 10800 10200 0 0 {name=Xr51c54}
N 10760 10240 10740 10240 {}
C {lab_pin.sym} 10740 10240 0 0 {name=l32911 lab=BL54}
N 10760 10200 10740 10200 {}
C {lab_pin.sym} 10740 10200 0 0 {name=l32912 lab=BLB54}
N 10760 10160 10740 10160 {}
C {lab_pin.sym} 10740 10160 0 0 {name=l32913 lab=WL51}
N 10840 10240 10860 10240 {}
C {lab_pin.sym} 10860 10240 0 0 {name=l32914 lab=VDD}
N 10840 10160 10860 10160 {}
C {lab_pin.sym} 10860 10160 0 0 {name=l32915 lab=VSS}
C {bitcell_6t.sym} 11000 10200 0 0 {name=Xr51c55}
N 10960 10240 10940 10240 {}
C {lab_pin.sym} 10940 10240 0 0 {name=l32916 lab=BL55}
N 10960 10200 10940 10200 {}
C {lab_pin.sym} 10940 10200 0 0 {name=l32917 lab=BLB55}
N 10960 10160 10940 10160 {}
C {lab_pin.sym} 10940 10160 0 0 {name=l32918 lab=WL51}
N 11040 10240 11060 10240 {}
C {lab_pin.sym} 11060 10240 0 0 {name=l32919 lab=VDD}
N 11040 10160 11060 10160 {}
C {lab_pin.sym} 11060 10160 0 0 {name=l32920 lab=VSS}
C {bitcell_6t.sym} 11200 10200 0 0 {name=Xr51c56}
N 11160 10240 11140 10240 {}
C {lab_pin.sym} 11140 10240 0 0 {name=l32921 lab=BL56}
N 11160 10200 11140 10200 {}
C {lab_pin.sym} 11140 10200 0 0 {name=l32922 lab=BLB56}
N 11160 10160 11140 10160 {}
C {lab_pin.sym} 11140 10160 0 0 {name=l32923 lab=WL51}
N 11240 10240 11260 10240 {}
C {lab_pin.sym} 11260 10240 0 0 {name=l32924 lab=VDD}
N 11240 10160 11260 10160 {}
C {lab_pin.sym} 11260 10160 0 0 {name=l32925 lab=VSS}
C {bitcell_6t.sym} 11400 10200 0 0 {name=Xr51c57}
N 11360 10240 11340 10240 {}
C {lab_pin.sym} 11340 10240 0 0 {name=l32926 lab=BL57}
N 11360 10200 11340 10200 {}
C {lab_pin.sym} 11340 10200 0 0 {name=l32927 lab=BLB57}
N 11360 10160 11340 10160 {}
C {lab_pin.sym} 11340 10160 0 0 {name=l32928 lab=WL51}
N 11440 10240 11460 10240 {}
C {lab_pin.sym} 11460 10240 0 0 {name=l32929 lab=VDD}
N 11440 10160 11460 10160 {}
C {lab_pin.sym} 11460 10160 0 0 {name=l32930 lab=VSS}
C {bitcell_6t.sym} 11600 10200 0 0 {name=Xr51c58}
N 11560 10240 11540 10240 {}
C {lab_pin.sym} 11540 10240 0 0 {name=l32931 lab=BL58}
N 11560 10200 11540 10200 {}
C {lab_pin.sym} 11540 10200 0 0 {name=l32932 lab=BLB58}
N 11560 10160 11540 10160 {}
C {lab_pin.sym} 11540 10160 0 0 {name=l32933 lab=WL51}
N 11640 10240 11660 10240 {}
C {lab_pin.sym} 11660 10240 0 0 {name=l32934 lab=VDD}
N 11640 10160 11660 10160 {}
C {lab_pin.sym} 11660 10160 0 0 {name=l32935 lab=VSS}
C {bitcell_6t.sym} 11800 10200 0 0 {name=Xr51c59}
N 11760 10240 11740 10240 {}
C {lab_pin.sym} 11740 10240 0 0 {name=l32936 lab=BL59}
N 11760 10200 11740 10200 {}
C {lab_pin.sym} 11740 10200 0 0 {name=l32937 lab=BLB59}
N 11760 10160 11740 10160 {}
C {lab_pin.sym} 11740 10160 0 0 {name=l32938 lab=WL51}
N 11840 10240 11860 10240 {}
C {lab_pin.sym} 11860 10240 0 0 {name=l32939 lab=VDD}
N 11840 10160 11860 10160 {}
C {lab_pin.sym} 11860 10160 0 0 {name=l32940 lab=VSS}
C {bitcell_6t.sym} 12000 10200 0 0 {name=Xr51c60}
N 11960 10240 11940 10240 {}
C {lab_pin.sym} 11940 10240 0 0 {name=l32941 lab=BL60}
N 11960 10200 11940 10200 {}
C {lab_pin.sym} 11940 10200 0 0 {name=l32942 lab=BLB60}
N 11960 10160 11940 10160 {}
C {lab_pin.sym} 11940 10160 0 0 {name=l32943 lab=WL51}
N 12040 10240 12060 10240 {}
C {lab_pin.sym} 12060 10240 0 0 {name=l32944 lab=VDD}
N 12040 10160 12060 10160 {}
C {lab_pin.sym} 12060 10160 0 0 {name=l32945 lab=VSS}
C {bitcell_6t.sym} 12200 10200 0 0 {name=Xr51c61}
N 12160 10240 12140 10240 {}
C {lab_pin.sym} 12140 10240 0 0 {name=l32946 lab=BL61}
N 12160 10200 12140 10200 {}
C {lab_pin.sym} 12140 10200 0 0 {name=l32947 lab=BLB61}
N 12160 10160 12140 10160 {}
C {lab_pin.sym} 12140 10160 0 0 {name=l32948 lab=WL51}
N 12240 10240 12260 10240 {}
C {lab_pin.sym} 12260 10240 0 0 {name=l32949 lab=VDD}
N 12240 10160 12260 10160 {}
C {lab_pin.sym} 12260 10160 0 0 {name=l32950 lab=VSS}
C {bitcell_6t.sym} 12400 10200 0 0 {name=Xr51c62}
N 12360 10240 12340 10240 {}
C {lab_pin.sym} 12340 10240 0 0 {name=l32951 lab=BL62}
N 12360 10200 12340 10200 {}
C {lab_pin.sym} 12340 10200 0 0 {name=l32952 lab=BLB62}
N 12360 10160 12340 10160 {}
C {lab_pin.sym} 12340 10160 0 0 {name=l32953 lab=WL51}
N 12440 10240 12460 10240 {}
C {lab_pin.sym} 12460 10240 0 0 {name=l32954 lab=VDD}
N 12440 10160 12460 10160 {}
C {lab_pin.sym} 12460 10160 0 0 {name=l32955 lab=VSS}
C {bitcell_6t.sym} 12600 10200 0 0 {name=Xr51c63}
N 12560 10240 12540 10240 {}
C {lab_pin.sym} 12540 10240 0 0 {name=l32956 lab=BL63}
N 12560 10200 12540 10200 {}
C {lab_pin.sym} 12540 10200 0 0 {name=l32957 lab=BLB63}
N 12560 10160 12540 10160 {}
C {lab_pin.sym} 12540 10160 0 0 {name=l32958 lab=WL51}
N 12640 10240 12660 10240 {}
C {lab_pin.sym} 12660 10240 0 0 {name=l32959 lab=VDD}
N 12640 10160 12660 10160 {}
C {lab_pin.sym} 12660 10160 0 0 {name=l32960 lab=VSS}
C {bitcell_6t.sym} 12800 10200 0 0 {name=Xr51c64}
N 12760 10240 12740 10240 {}
C {lab_pin.sym} 12740 10240 0 0 {name=l32961 lab=BL64}
N 12760 10200 12740 10200 {}
C {lab_pin.sym} 12740 10200 0 0 {name=l32962 lab=BLB64}
N 12760 10160 12740 10160 {}
C {lab_pin.sym} 12740 10160 0 0 {name=l32963 lab=WL51}
N 12840 10240 12860 10240 {}
C {lab_pin.sym} 12860 10240 0 0 {name=l32964 lab=VDD}
N 12840 10160 12860 10160 {}
C {lab_pin.sym} 12860 10160 0 0 {name=l32965 lab=VSS}
C {bitcell_6t.sym} 13000 10200 0 0 {name=Xr51c65}
N 12960 10240 12940 10240 {}
C {lab_pin.sym} 12940 10240 0 0 {name=l32966 lab=BL65}
N 12960 10200 12940 10200 {}
C {lab_pin.sym} 12940 10200 0 0 {name=l32967 lab=BLB65}
N 12960 10160 12940 10160 {}
C {lab_pin.sym} 12940 10160 0 0 {name=l32968 lab=WL51}
N 13040 10240 13060 10240 {}
C {lab_pin.sym} 13060 10240 0 0 {name=l32969 lab=VDD}
N 13040 10160 13060 10160 {}
C {lab_pin.sym} 13060 10160 0 0 {name=l32970 lab=VSS}
C {bitcell_6t.sym} 13200 10200 0 0 {name=Xr51c66}
N 13160 10240 13140 10240 {}
C {lab_pin.sym} 13140 10240 0 0 {name=l32971 lab=BL66}
N 13160 10200 13140 10200 {}
C {lab_pin.sym} 13140 10200 0 0 {name=l32972 lab=BLB66}
N 13160 10160 13140 10160 {}
C {lab_pin.sym} 13140 10160 0 0 {name=l32973 lab=WL51}
N 13240 10240 13260 10240 {}
C {lab_pin.sym} 13260 10240 0 0 {name=l32974 lab=VDD}
N 13240 10160 13260 10160 {}
C {lab_pin.sym} 13260 10160 0 0 {name=l32975 lab=VSS}
C {bitcell_6t.sym} 13400 10200 0 0 {name=Xr51c67}
N 13360 10240 13340 10240 {}
C {lab_pin.sym} 13340 10240 0 0 {name=l32976 lab=BL67}
N 13360 10200 13340 10200 {}
C {lab_pin.sym} 13340 10200 0 0 {name=l32977 lab=BLB67}
N 13360 10160 13340 10160 {}
C {lab_pin.sym} 13340 10160 0 0 {name=l32978 lab=WL51}
N 13440 10240 13460 10240 {}
C {lab_pin.sym} 13460 10240 0 0 {name=l32979 lab=VDD}
N 13440 10160 13460 10160 {}
C {lab_pin.sym} 13460 10160 0 0 {name=l32980 lab=VSS}
C {bitcell_6t.sym} 13600 10200 0 0 {name=Xr51c68}
N 13560 10240 13540 10240 {}
C {lab_pin.sym} 13540 10240 0 0 {name=l32981 lab=BL68}
N 13560 10200 13540 10200 {}
C {lab_pin.sym} 13540 10200 0 0 {name=l32982 lab=BLB68}
N 13560 10160 13540 10160 {}
C {lab_pin.sym} 13540 10160 0 0 {name=l32983 lab=WL51}
N 13640 10240 13660 10240 {}
C {lab_pin.sym} 13660 10240 0 0 {name=l32984 lab=VDD}
N 13640 10160 13660 10160 {}
C {lab_pin.sym} 13660 10160 0 0 {name=l32985 lab=VSS}
C {bitcell_6t.sym} 13800 10200 0 0 {name=Xr51c69}
N 13760 10240 13740 10240 {}
C {lab_pin.sym} 13740 10240 0 0 {name=l32986 lab=BL69}
N 13760 10200 13740 10200 {}
C {lab_pin.sym} 13740 10200 0 0 {name=l32987 lab=BLB69}
N 13760 10160 13740 10160 {}
C {lab_pin.sym} 13740 10160 0 0 {name=l32988 lab=WL51}
N 13840 10240 13860 10240 {}
C {lab_pin.sym} 13860 10240 0 0 {name=l32989 lab=VDD}
N 13840 10160 13860 10160 {}
C {lab_pin.sym} 13860 10160 0 0 {name=l32990 lab=VSS}
C {bitcell_6t.sym} 14000 10200 0 0 {name=Xr51c70}
N 13960 10240 13940 10240 {}
C {lab_pin.sym} 13940 10240 0 0 {name=l32991 lab=BL70}
N 13960 10200 13940 10200 {}
C {lab_pin.sym} 13940 10200 0 0 {name=l32992 lab=BLB70}
N 13960 10160 13940 10160 {}
C {lab_pin.sym} 13940 10160 0 0 {name=l32993 lab=WL51}
N 14040 10240 14060 10240 {}
C {lab_pin.sym} 14060 10240 0 0 {name=l32994 lab=VDD}
N 14040 10160 14060 10160 {}
C {lab_pin.sym} 14060 10160 0 0 {name=l32995 lab=VSS}
C {bitcell_6t.sym} 14200 10200 0 0 {name=Xr51c71}
N 14160 10240 14140 10240 {}
C {lab_pin.sym} 14140 10240 0 0 {name=l32996 lab=BL71}
N 14160 10200 14140 10200 {}
C {lab_pin.sym} 14140 10200 0 0 {name=l32997 lab=BLB71}
N 14160 10160 14140 10160 {}
C {lab_pin.sym} 14140 10160 0 0 {name=l32998 lab=WL51}
N 14240 10240 14260 10240 {}
C {lab_pin.sym} 14260 10240 0 0 {name=l32999 lab=VDD}
N 14240 10160 14260 10160 {}
C {lab_pin.sym} 14260 10160 0 0 {name=l33000 lab=VSS}
C {bitcell_6t.sym} 14400 10200 0 0 {name=Xr51c72}
N 14360 10240 14340 10240 {}
C {lab_pin.sym} 14340 10240 0 0 {name=l33001 lab=BL72}
N 14360 10200 14340 10200 {}
C {lab_pin.sym} 14340 10200 0 0 {name=l33002 lab=BLB72}
N 14360 10160 14340 10160 {}
C {lab_pin.sym} 14340 10160 0 0 {name=l33003 lab=WL51}
N 14440 10240 14460 10240 {}
C {lab_pin.sym} 14460 10240 0 0 {name=l33004 lab=VDD}
N 14440 10160 14460 10160 {}
C {lab_pin.sym} 14460 10160 0 0 {name=l33005 lab=VSS}
C {bitcell_6t.sym} 14600 10200 0 0 {name=Xr51c73}
N 14560 10240 14540 10240 {}
C {lab_pin.sym} 14540 10240 0 0 {name=l33006 lab=BL73}
N 14560 10200 14540 10200 {}
C {lab_pin.sym} 14540 10200 0 0 {name=l33007 lab=BLB73}
N 14560 10160 14540 10160 {}
C {lab_pin.sym} 14540 10160 0 0 {name=l33008 lab=WL51}
N 14640 10240 14660 10240 {}
C {lab_pin.sym} 14660 10240 0 0 {name=l33009 lab=VDD}
N 14640 10160 14660 10160 {}
C {lab_pin.sym} 14660 10160 0 0 {name=l33010 lab=VSS}
C {bitcell_6t.sym} 14800 10200 0 0 {name=Xr51c74}
N 14760 10240 14740 10240 {}
C {lab_pin.sym} 14740 10240 0 0 {name=l33011 lab=BL74}
N 14760 10200 14740 10200 {}
C {lab_pin.sym} 14740 10200 0 0 {name=l33012 lab=BLB74}
N 14760 10160 14740 10160 {}
C {lab_pin.sym} 14740 10160 0 0 {name=l33013 lab=WL51}
N 14840 10240 14860 10240 {}
C {lab_pin.sym} 14860 10240 0 0 {name=l33014 lab=VDD}
N 14840 10160 14860 10160 {}
C {lab_pin.sym} 14860 10160 0 0 {name=l33015 lab=VSS}
C {bitcell_6t.sym} 15000 10200 0 0 {name=Xr51c75}
N 14960 10240 14940 10240 {}
C {lab_pin.sym} 14940 10240 0 0 {name=l33016 lab=BL75}
N 14960 10200 14940 10200 {}
C {lab_pin.sym} 14940 10200 0 0 {name=l33017 lab=BLB75}
N 14960 10160 14940 10160 {}
C {lab_pin.sym} 14940 10160 0 0 {name=l33018 lab=WL51}
N 15040 10240 15060 10240 {}
C {lab_pin.sym} 15060 10240 0 0 {name=l33019 lab=VDD}
N 15040 10160 15060 10160 {}
C {lab_pin.sym} 15060 10160 0 0 {name=l33020 lab=VSS}
C {bitcell_6t.sym} 15200 10200 0 0 {name=Xr51c76}
N 15160 10240 15140 10240 {}
C {lab_pin.sym} 15140 10240 0 0 {name=l33021 lab=BL76}
N 15160 10200 15140 10200 {}
C {lab_pin.sym} 15140 10200 0 0 {name=l33022 lab=BLB76}
N 15160 10160 15140 10160 {}
C {lab_pin.sym} 15140 10160 0 0 {name=l33023 lab=WL51}
N 15240 10240 15260 10240 {}
C {lab_pin.sym} 15260 10240 0 0 {name=l33024 lab=VDD}
N 15240 10160 15260 10160 {}
C {lab_pin.sym} 15260 10160 0 0 {name=l33025 lab=VSS}
C {bitcell_6t.sym} 15400 10200 0 0 {name=Xr51c77}
N 15360 10240 15340 10240 {}
C {lab_pin.sym} 15340 10240 0 0 {name=l33026 lab=BL77}
N 15360 10200 15340 10200 {}
C {lab_pin.sym} 15340 10200 0 0 {name=l33027 lab=BLB77}
N 15360 10160 15340 10160 {}
C {lab_pin.sym} 15340 10160 0 0 {name=l33028 lab=WL51}
N 15440 10240 15460 10240 {}
C {lab_pin.sym} 15460 10240 0 0 {name=l33029 lab=VDD}
N 15440 10160 15460 10160 {}
C {lab_pin.sym} 15460 10160 0 0 {name=l33030 lab=VSS}
C {bitcell_6t.sym} 15600 10200 0 0 {name=Xr51c78}
N 15560 10240 15540 10240 {}
C {lab_pin.sym} 15540 10240 0 0 {name=l33031 lab=BL78}
N 15560 10200 15540 10200 {}
C {lab_pin.sym} 15540 10200 0 0 {name=l33032 lab=BLB78}
N 15560 10160 15540 10160 {}
C {lab_pin.sym} 15540 10160 0 0 {name=l33033 lab=WL51}
N 15640 10240 15660 10240 {}
C {lab_pin.sym} 15660 10240 0 0 {name=l33034 lab=VDD}
N 15640 10160 15660 10160 {}
C {lab_pin.sym} 15660 10160 0 0 {name=l33035 lab=VSS}
C {bitcell_6t.sym} 15800 10200 0 0 {name=Xr51c79}
N 15760 10240 15740 10240 {}
C {lab_pin.sym} 15740 10240 0 0 {name=l33036 lab=BL79}
N 15760 10200 15740 10200 {}
C {lab_pin.sym} 15740 10200 0 0 {name=l33037 lab=BLB79}
N 15760 10160 15740 10160 {}
C {lab_pin.sym} 15740 10160 0 0 {name=l33038 lab=WL51}
N 15840 10240 15860 10240 {}
C {lab_pin.sym} 15860 10240 0 0 {name=l33039 lab=VDD}
N 15840 10160 15860 10160 {}
C {lab_pin.sym} 15860 10160 0 0 {name=l33040 lab=VSS}
C {bitcell_6t.sym} 16000 10200 0 0 {name=Xr51c80}
N 15960 10240 15940 10240 {}
C {lab_pin.sym} 15940 10240 0 0 {name=l33041 lab=BL80}
N 15960 10200 15940 10200 {}
C {lab_pin.sym} 15940 10200 0 0 {name=l33042 lab=BLB80}
N 15960 10160 15940 10160 {}
C {lab_pin.sym} 15940 10160 0 0 {name=l33043 lab=WL51}
N 16040 10240 16060 10240 {}
C {lab_pin.sym} 16060 10240 0 0 {name=l33044 lab=VDD}
N 16040 10160 16060 10160 {}
C {lab_pin.sym} 16060 10160 0 0 {name=l33045 lab=VSS}
C {bitcell_6t.sym} 16200 10200 0 0 {name=Xr51c81}
N 16160 10240 16140 10240 {}
C {lab_pin.sym} 16140 10240 0 0 {name=l33046 lab=BL81}
N 16160 10200 16140 10200 {}
C {lab_pin.sym} 16140 10200 0 0 {name=l33047 lab=BLB81}
N 16160 10160 16140 10160 {}
C {lab_pin.sym} 16140 10160 0 0 {name=l33048 lab=WL51}
N 16240 10240 16260 10240 {}
C {lab_pin.sym} 16260 10240 0 0 {name=l33049 lab=VDD}
N 16240 10160 16260 10160 {}
C {lab_pin.sym} 16260 10160 0 0 {name=l33050 lab=VSS}
C {bitcell_6t.sym} 16400 10200 0 0 {name=Xr51c82}
N 16360 10240 16340 10240 {}
C {lab_pin.sym} 16340 10240 0 0 {name=l33051 lab=BL82}
N 16360 10200 16340 10200 {}
C {lab_pin.sym} 16340 10200 0 0 {name=l33052 lab=BLB82}
N 16360 10160 16340 10160 {}
C {lab_pin.sym} 16340 10160 0 0 {name=l33053 lab=WL51}
N 16440 10240 16460 10240 {}
C {lab_pin.sym} 16460 10240 0 0 {name=l33054 lab=VDD}
N 16440 10160 16460 10160 {}
C {lab_pin.sym} 16460 10160 0 0 {name=l33055 lab=VSS}
C {bitcell_6t.sym} 16600 10200 0 0 {name=Xr51c83}
N 16560 10240 16540 10240 {}
C {lab_pin.sym} 16540 10240 0 0 {name=l33056 lab=BL83}
N 16560 10200 16540 10200 {}
C {lab_pin.sym} 16540 10200 0 0 {name=l33057 lab=BLB83}
N 16560 10160 16540 10160 {}
C {lab_pin.sym} 16540 10160 0 0 {name=l33058 lab=WL51}
N 16640 10240 16660 10240 {}
C {lab_pin.sym} 16660 10240 0 0 {name=l33059 lab=VDD}
N 16640 10160 16660 10160 {}
C {lab_pin.sym} 16660 10160 0 0 {name=l33060 lab=VSS}
C {bitcell_6t.sym} 16800 10200 0 0 {name=Xr51c84}
N 16760 10240 16740 10240 {}
C {lab_pin.sym} 16740 10240 0 0 {name=l33061 lab=BL84}
N 16760 10200 16740 10200 {}
C {lab_pin.sym} 16740 10200 0 0 {name=l33062 lab=BLB84}
N 16760 10160 16740 10160 {}
C {lab_pin.sym} 16740 10160 0 0 {name=l33063 lab=WL51}
N 16840 10240 16860 10240 {}
C {lab_pin.sym} 16860 10240 0 0 {name=l33064 lab=VDD}
N 16840 10160 16860 10160 {}
C {lab_pin.sym} 16860 10160 0 0 {name=l33065 lab=VSS}
C {bitcell_6t.sym} 17000 10200 0 0 {name=Xr51c85}
N 16960 10240 16940 10240 {}
C {lab_pin.sym} 16940 10240 0 0 {name=l33066 lab=BL85}
N 16960 10200 16940 10200 {}
C {lab_pin.sym} 16940 10200 0 0 {name=l33067 lab=BLB85}
N 16960 10160 16940 10160 {}
C {lab_pin.sym} 16940 10160 0 0 {name=l33068 lab=WL51}
N 17040 10240 17060 10240 {}
C {lab_pin.sym} 17060 10240 0 0 {name=l33069 lab=VDD}
N 17040 10160 17060 10160 {}
C {lab_pin.sym} 17060 10160 0 0 {name=l33070 lab=VSS}
C {bitcell_6t.sym} 17200 10200 0 0 {name=Xr51c86}
N 17160 10240 17140 10240 {}
C {lab_pin.sym} 17140 10240 0 0 {name=l33071 lab=BL86}
N 17160 10200 17140 10200 {}
C {lab_pin.sym} 17140 10200 0 0 {name=l33072 lab=BLB86}
N 17160 10160 17140 10160 {}
C {lab_pin.sym} 17140 10160 0 0 {name=l33073 lab=WL51}
N 17240 10240 17260 10240 {}
C {lab_pin.sym} 17260 10240 0 0 {name=l33074 lab=VDD}
N 17240 10160 17260 10160 {}
C {lab_pin.sym} 17260 10160 0 0 {name=l33075 lab=VSS}
C {bitcell_6t.sym} 17400 10200 0 0 {name=Xr51c87}
N 17360 10240 17340 10240 {}
C {lab_pin.sym} 17340 10240 0 0 {name=l33076 lab=BL87}
N 17360 10200 17340 10200 {}
C {lab_pin.sym} 17340 10200 0 0 {name=l33077 lab=BLB87}
N 17360 10160 17340 10160 {}
C {lab_pin.sym} 17340 10160 0 0 {name=l33078 lab=WL51}
N 17440 10240 17460 10240 {}
C {lab_pin.sym} 17460 10240 0 0 {name=l33079 lab=VDD}
N 17440 10160 17460 10160 {}
C {lab_pin.sym} 17460 10160 0 0 {name=l33080 lab=VSS}
C {bitcell_6t.sym} 17600 10200 0 0 {name=Xr51c88}
N 17560 10240 17540 10240 {}
C {lab_pin.sym} 17540 10240 0 0 {name=l33081 lab=BL88}
N 17560 10200 17540 10200 {}
C {lab_pin.sym} 17540 10200 0 0 {name=l33082 lab=BLB88}
N 17560 10160 17540 10160 {}
C {lab_pin.sym} 17540 10160 0 0 {name=l33083 lab=WL51}
N 17640 10240 17660 10240 {}
C {lab_pin.sym} 17660 10240 0 0 {name=l33084 lab=VDD}
N 17640 10160 17660 10160 {}
C {lab_pin.sym} 17660 10160 0 0 {name=l33085 lab=VSS}
C {bitcell_6t.sym} 17800 10200 0 0 {name=Xr51c89}
N 17760 10240 17740 10240 {}
C {lab_pin.sym} 17740 10240 0 0 {name=l33086 lab=BL89}
N 17760 10200 17740 10200 {}
C {lab_pin.sym} 17740 10200 0 0 {name=l33087 lab=BLB89}
N 17760 10160 17740 10160 {}
C {lab_pin.sym} 17740 10160 0 0 {name=l33088 lab=WL51}
N 17840 10240 17860 10240 {}
C {lab_pin.sym} 17860 10240 0 0 {name=l33089 lab=VDD}
N 17840 10160 17860 10160 {}
C {lab_pin.sym} 17860 10160 0 0 {name=l33090 lab=VSS}
C {bitcell_6t.sym} 18000 10200 0 0 {name=Xr51c90}
N 17960 10240 17940 10240 {}
C {lab_pin.sym} 17940 10240 0 0 {name=l33091 lab=BL90}
N 17960 10200 17940 10200 {}
C {lab_pin.sym} 17940 10200 0 0 {name=l33092 lab=BLB90}
N 17960 10160 17940 10160 {}
C {lab_pin.sym} 17940 10160 0 0 {name=l33093 lab=WL51}
N 18040 10240 18060 10240 {}
C {lab_pin.sym} 18060 10240 0 0 {name=l33094 lab=VDD}
N 18040 10160 18060 10160 {}
C {lab_pin.sym} 18060 10160 0 0 {name=l33095 lab=VSS}
C {bitcell_6t.sym} 18200 10200 0 0 {name=Xr51c91}
N 18160 10240 18140 10240 {}
C {lab_pin.sym} 18140 10240 0 0 {name=l33096 lab=BL91}
N 18160 10200 18140 10200 {}
C {lab_pin.sym} 18140 10200 0 0 {name=l33097 lab=BLB91}
N 18160 10160 18140 10160 {}
C {lab_pin.sym} 18140 10160 0 0 {name=l33098 lab=WL51}
N 18240 10240 18260 10240 {}
C {lab_pin.sym} 18260 10240 0 0 {name=l33099 lab=VDD}
N 18240 10160 18260 10160 {}
C {lab_pin.sym} 18260 10160 0 0 {name=l33100 lab=VSS}
C {bitcell_6t.sym} 18400 10200 0 0 {name=Xr51c92}
N 18360 10240 18340 10240 {}
C {lab_pin.sym} 18340 10240 0 0 {name=l33101 lab=BL92}
N 18360 10200 18340 10200 {}
C {lab_pin.sym} 18340 10200 0 0 {name=l33102 lab=BLB92}
N 18360 10160 18340 10160 {}
C {lab_pin.sym} 18340 10160 0 0 {name=l33103 lab=WL51}
N 18440 10240 18460 10240 {}
C {lab_pin.sym} 18460 10240 0 0 {name=l33104 lab=VDD}
N 18440 10160 18460 10160 {}
C {lab_pin.sym} 18460 10160 0 0 {name=l33105 lab=VSS}
C {bitcell_6t.sym} 18600 10200 0 0 {name=Xr51c93}
N 18560 10240 18540 10240 {}
C {lab_pin.sym} 18540 10240 0 0 {name=l33106 lab=BL93}
N 18560 10200 18540 10200 {}
C {lab_pin.sym} 18540 10200 0 0 {name=l33107 lab=BLB93}
N 18560 10160 18540 10160 {}
C {lab_pin.sym} 18540 10160 0 0 {name=l33108 lab=WL51}
N 18640 10240 18660 10240 {}
C {lab_pin.sym} 18660 10240 0 0 {name=l33109 lab=VDD}
N 18640 10160 18660 10160 {}
C {lab_pin.sym} 18660 10160 0 0 {name=l33110 lab=VSS}
C {bitcell_6t.sym} 18800 10200 0 0 {name=Xr51c94}
N 18760 10240 18740 10240 {}
C {lab_pin.sym} 18740 10240 0 0 {name=l33111 lab=BL94}
N 18760 10200 18740 10200 {}
C {lab_pin.sym} 18740 10200 0 0 {name=l33112 lab=BLB94}
N 18760 10160 18740 10160 {}
C {lab_pin.sym} 18740 10160 0 0 {name=l33113 lab=WL51}
N 18840 10240 18860 10240 {}
C {lab_pin.sym} 18860 10240 0 0 {name=l33114 lab=VDD}
N 18840 10160 18860 10160 {}
C {lab_pin.sym} 18860 10160 0 0 {name=l33115 lab=VSS}
C {bitcell_6t.sym} 19000 10200 0 0 {name=Xr51c95}
N 18960 10240 18940 10240 {}
C {lab_pin.sym} 18940 10240 0 0 {name=l33116 lab=BL95}
N 18960 10200 18940 10200 {}
C {lab_pin.sym} 18940 10200 0 0 {name=l33117 lab=BLB95}
N 18960 10160 18940 10160 {}
C {lab_pin.sym} 18940 10160 0 0 {name=l33118 lab=WL51}
N 19040 10240 19060 10240 {}
C {lab_pin.sym} 19060 10240 0 0 {name=l33119 lab=VDD}
N 19040 10160 19060 10160 {}
C {lab_pin.sym} 19060 10160 0 0 {name=l33120 lab=VSS}
C {bitcell_6t.sym} 19200 10200 0 0 {name=Xr51c96}
N 19160 10240 19140 10240 {}
C {lab_pin.sym} 19140 10240 0 0 {name=l33121 lab=BL96}
N 19160 10200 19140 10200 {}
C {lab_pin.sym} 19140 10200 0 0 {name=l33122 lab=BLB96}
N 19160 10160 19140 10160 {}
C {lab_pin.sym} 19140 10160 0 0 {name=l33123 lab=WL51}
N 19240 10240 19260 10240 {}
C {lab_pin.sym} 19260 10240 0 0 {name=l33124 lab=VDD}
N 19240 10160 19260 10160 {}
C {lab_pin.sym} 19260 10160 0 0 {name=l33125 lab=VSS}
C {bitcell_6t.sym} 19400 10200 0 0 {name=Xr51c97}
N 19360 10240 19340 10240 {}
C {lab_pin.sym} 19340 10240 0 0 {name=l33126 lab=BL97}
N 19360 10200 19340 10200 {}
C {lab_pin.sym} 19340 10200 0 0 {name=l33127 lab=BLB97}
N 19360 10160 19340 10160 {}
C {lab_pin.sym} 19340 10160 0 0 {name=l33128 lab=WL51}
N 19440 10240 19460 10240 {}
C {lab_pin.sym} 19460 10240 0 0 {name=l33129 lab=VDD}
N 19440 10160 19460 10160 {}
C {lab_pin.sym} 19460 10160 0 0 {name=l33130 lab=VSS}
C {bitcell_6t.sym} 19600 10200 0 0 {name=Xr51c98}
N 19560 10240 19540 10240 {}
C {lab_pin.sym} 19540 10240 0 0 {name=l33131 lab=BL98}
N 19560 10200 19540 10200 {}
C {lab_pin.sym} 19540 10200 0 0 {name=l33132 lab=BLB98}
N 19560 10160 19540 10160 {}
C {lab_pin.sym} 19540 10160 0 0 {name=l33133 lab=WL51}
N 19640 10240 19660 10240 {}
C {lab_pin.sym} 19660 10240 0 0 {name=l33134 lab=VDD}
N 19640 10160 19660 10160 {}
C {lab_pin.sym} 19660 10160 0 0 {name=l33135 lab=VSS}
C {bitcell_6t.sym} 19800 10200 0 0 {name=Xr51c99}
N 19760 10240 19740 10240 {}
C {lab_pin.sym} 19740 10240 0 0 {name=l33136 lab=BL99}
N 19760 10200 19740 10200 {}
C {lab_pin.sym} 19740 10200 0 0 {name=l33137 lab=BLB99}
N 19760 10160 19740 10160 {}
C {lab_pin.sym} 19740 10160 0 0 {name=l33138 lab=WL51}
N 19840 10240 19860 10240 {}
C {lab_pin.sym} 19860 10240 0 0 {name=l33139 lab=VDD}
N 19840 10160 19860 10160 {}
C {lab_pin.sym} 19860 10160 0 0 {name=l33140 lab=VSS}
C {bitcell_6t.sym} 20000 10200 0 0 {name=Xr51c100}
N 19960 10240 19940 10240 {}
C {lab_pin.sym} 19940 10240 0 0 {name=l33141 lab=BL100}
N 19960 10200 19940 10200 {}
C {lab_pin.sym} 19940 10200 0 0 {name=l33142 lab=BLB100}
N 19960 10160 19940 10160 {}
C {lab_pin.sym} 19940 10160 0 0 {name=l33143 lab=WL51}
N 20040 10240 20060 10240 {}
C {lab_pin.sym} 20060 10240 0 0 {name=l33144 lab=VDD}
N 20040 10160 20060 10160 {}
C {lab_pin.sym} 20060 10160 0 0 {name=l33145 lab=VSS}
C {bitcell_6t.sym} 20200 10200 0 0 {name=Xr51c101}
N 20160 10240 20140 10240 {}
C {lab_pin.sym} 20140 10240 0 0 {name=l33146 lab=BL101}
N 20160 10200 20140 10200 {}
C {lab_pin.sym} 20140 10200 0 0 {name=l33147 lab=BLB101}
N 20160 10160 20140 10160 {}
C {lab_pin.sym} 20140 10160 0 0 {name=l33148 lab=WL51}
N 20240 10240 20260 10240 {}
C {lab_pin.sym} 20260 10240 0 0 {name=l33149 lab=VDD}
N 20240 10160 20260 10160 {}
C {lab_pin.sym} 20260 10160 0 0 {name=l33150 lab=VSS}
C {bitcell_6t.sym} 20400 10200 0 0 {name=Xr51c102}
N 20360 10240 20340 10240 {}
C {lab_pin.sym} 20340 10240 0 0 {name=l33151 lab=BL102}
N 20360 10200 20340 10200 {}
C {lab_pin.sym} 20340 10200 0 0 {name=l33152 lab=BLB102}
N 20360 10160 20340 10160 {}
C {lab_pin.sym} 20340 10160 0 0 {name=l33153 lab=WL51}
N 20440 10240 20460 10240 {}
C {lab_pin.sym} 20460 10240 0 0 {name=l33154 lab=VDD}
N 20440 10160 20460 10160 {}
C {lab_pin.sym} 20460 10160 0 0 {name=l33155 lab=VSS}
C {bitcell_6t.sym} 20600 10200 0 0 {name=Xr51c103}
N 20560 10240 20540 10240 {}
C {lab_pin.sym} 20540 10240 0 0 {name=l33156 lab=BL103}
N 20560 10200 20540 10200 {}
C {lab_pin.sym} 20540 10200 0 0 {name=l33157 lab=BLB103}
N 20560 10160 20540 10160 {}
C {lab_pin.sym} 20540 10160 0 0 {name=l33158 lab=WL51}
N 20640 10240 20660 10240 {}
C {lab_pin.sym} 20660 10240 0 0 {name=l33159 lab=VDD}
N 20640 10160 20660 10160 {}
C {lab_pin.sym} 20660 10160 0 0 {name=l33160 lab=VSS}
C {bitcell_6t.sym} 20800 10200 0 0 {name=Xr51c104}
N 20760 10240 20740 10240 {}
C {lab_pin.sym} 20740 10240 0 0 {name=l33161 lab=BL104}
N 20760 10200 20740 10200 {}
C {lab_pin.sym} 20740 10200 0 0 {name=l33162 lab=BLB104}
N 20760 10160 20740 10160 {}
C {lab_pin.sym} 20740 10160 0 0 {name=l33163 lab=WL51}
N 20840 10240 20860 10240 {}
C {lab_pin.sym} 20860 10240 0 0 {name=l33164 lab=VDD}
N 20840 10160 20860 10160 {}
C {lab_pin.sym} 20860 10160 0 0 {name=l33165 lab=VSS}
C {bitcell_6t.sym} 21000 10200 0 0 {name=Xr51c105}
N 20960 10240 20940 10240 {}
C {lab_pin.sym} 20940 10240 0 0 {name=l33166 lab=BL105}
N 20960 10200 20940 10200 {}
C {lab_pin.sym} 20940 10200 0 0 {name=l33167 lab=BLB105}
N 20960 10160 20940 10160 {}
C {lab_pin.sym} 20940 10160 0 0 {name=l33168 lab=WL51}
N 21040 10240 21060 10240 {}
C {lab_pin.sym} 21060 10240 0 0 {name=l33169 lab=VDD}
N 21040 10160 21060 10160 {}
C {lab_pin.sym} 21060 10160 0 0 {name=l33170 lab=VSS}
C {bitcell_6t.sym} 21200 10200 0 0 {name=Xr51c106}
N 21160 10240 21140 10240 {}
C {lab_pin.sym} 21140 10240 0 0 {name=l33171 lab=BL106}
N 21160 10200 21140 10200 {}
C {lab_pin.sym} 21140 10200 0 0 {name=l33172 lab=BLB106}
N 21160 10160 21140 10160 {}
C {lab_pin.sym} 21140 10160 0 0 {name=l33173 lab=WL51}
N 21240 10240 21260 10240 {}
C {lab_pin.sym} 21260 10240 0 0 {name=l33174 lab=VDD}
N 21240 10160 21260 10160 {}
C {lab_pin.sym} 21260 10160 0 0 {name=l33175 lab=VSS}
C {bitcell_6t.sym} 21400 10200 0 0 {name=Xr51c107}
N 21360 10240 21340 10240 {}
C {lab_pin.sym} 21340 10240 0 0 {name=l33176 lab=BL107}
N 21360 10200 21340 10200 {}
C {lab_pin.sym} 21340 10200 0 0 {name=l33177 lab=BLB107}
N 21360 10160 21340 10160 {}
C {lab_pin.sym} 21340 10160 0 0 {name=l33178 lab=WL51}
N 21440 10240 21460 10240 {}
C {lab_pin.sym} 21460 10240 0 0 {name=l33179 lab=VDD}
N 21440 10160 21460 10160 {}
C {lab_pin.sym} 21460 10160 0 0 {name=l33180 lab=VSS}
C {bitcell_6t.sym} 21600 10200 0 0 {name=Xr51c108}
N 21560 10240 21540 10240 {}
C {lab_pin.sym} 21540 10240 0 0 {name=l33181 lab=BL108}
N 21560 10200 21540 10200 {}
C {lab_pin.sym} 21540 10200 0 0 {name=l33182 lab=BLB108}
N 21560 10160 21540 10160 {}
C {lab_pin.sym} 21540 10160 0 0 {name=l33183 lab=WL51}
N 21640 10240 21660 10240 {}
C {lab_pin.sym} 21660 10240 0 0 {name=l33184 lab=VDD}
N 21640 10160 21660 10160 {}
C {lab_pin.sym} 21660 10160 0 0 {name=l33185 lab=VSS}
C {bitcell_6t.sym} 21800 10200 0 0 {name=Xr51c109}
N 21760 10240 21740 10240 {}
C {lab_pin.sym} 21740 10240 0 0 {name=l33186 lab=BL109}
N 21760 10200 21740 10200 {}
C {lab_pin.sym} 21740 10200 0 0 {name=l33187 lab=BLB109}
N 21760 10160 21740 10160 {}
C {lab_pin.sym} 21740 10160 0 0 {name=l33188 lab=WL51}
N 21840 10240 21860 10240 {}
C {lab_pin.sym} 21860 10240 0 0 {name=l33189 lab=VDD}
N 21840 10160 21860 10160 {}
C {lab_pin.sym} 21860 10160 0 0 {name=l33190 lab=VSS}
C {bitcell_6t.sym} 22000 10200 0 0 {name=Xr51c110}
N 21960 10240 21940 10240 {}
C {lab_pin.sym} 21940 10240 0 0 {name=l33191 lab=BL110}
N 21960 10200 21940 10200 {}
C {lab_pin.sym} 21940 10200 0 0 {name=l33192 lab=BLB110}
N 21960 10160 21940 10160 {}
C {lab_pin.sym} 21940 10160 0 0 {name=l33193 lab=WL51}
N 22040 10240 22060 10240 {}
C {lab_pin.sym} 22060 10240 0 0 {name=l33194 lab=VDD}
N 22040 10160 22060 10160 {}
C {lab_pin.sym} 22060 10160 0 0 {name=l33195 lab=VSS}
C {bitcell_6t.sym} 22200 10200 0 0 {name=Xr51c111}
N 22160 10240 22140 10240 {}
C {lab_pin.sym} 22140 10240 0 0 {name=l33196 lab=BL111}
N 22160 10200 22140 10200 {}
C {lab_pin.sym} 22140 10200 0 0 {name=l33197 lab=BLB111}
N 22160 10160 22140 10160 {}
C {lab_pin.sym} 22140 10160 0 0 {name=l33198 lab=WL51}
N 22240 10240 22260 10240 {}
C {lab_pin.sym} 22260 10240 0 0 {name=l33199 lab=VDD}
N 22240 10160 22260 10160 {}
C {lab_pin.sym} 22260 10160 0 0 {name=l33200 lab=VSS}
C {bitcell_6t.sym} 22400 10200 0 0 {name=Xr51c112}
N 22360 10240 22340 10240 {}
C {lab_pin.sym} 22340 10240 0 0 {name=l33201 lab=BL112}
N 22360 10200 22340 10200 {}
C {lab_pin.sym} 22340 10200 0 0 {name=l33202 lab=BLB112}
N 22360 10160 22340 10160 {}
C {lab_pin.sym} 22340 10160 0 0 {name=l33203 lab=WL51}
N 22440 10240 22460 10240 {}
C {lab_pin.sym} 22460 10240 0 0 {name=l33204 lab=VDD}
N 22440 10160 22460 10160 {}
C {lab_pin.sym} 22460 10160 0 0 {name=l33205 lab=VSS}
C {bitcell_6t.sym} 22600 10200 0 0 {name=Xr51c113}
N 22560 10240 22540 10240 {}
C {lab_pin.sym} 22540 10240 0 0 {name=l33206 lab=BL113}
N 22560 10200 22540 10200 {}
C {lab_pin.sym} 22540 10200 0 0 {name=l33207 lab=BLB113}
N 22560 10160 22540 10160 {}
C {lab_pin.sym} 22540 10160 0 0 {name=l33208 lab=WL51}
N 22640 10240 22660 10240 {}
C {lab_pin.sym} 22660 10240 0 0 {name=l33209 lab=VDD}
N 22640 10160 22660 10160 {}
C {lab_pin.sym} 22660 10160 0 0 {name=l33210 lab=VSS}
C {bitcell_6t.sym} 22800 10200 0 0 {name=Xr51c114}
N 22760 10240 22740 10240 {}
C {lab_pin.sym} 22740 10240 0 0 {name=l33211 lab=BL114}
N 22760 10200 22740 10200 {}
C {lab_pin.sym} 22740 10200 0 0 {name=l33212 lab=BLB114}
N 22760 10160 22740 10160 {}
C {lab_pin.sym} 22740 10160 0 0 {name=l33213 lab=WL51}
N 22840 10240 22860 10240 {}
C {lab_pin.sym} 22860 10240 0 0 {name=l33214 lab=VDD}
N 22840 10160 22860 10160 {}
C {lab_pin.sym} 22860 10160 0 0 {name=l33215 lab=VSS}
C {bitcell_6t.sym} 23000 10200 0 0 {name=Xr51c115}
N 22960 10240 22940 10240 {}
C {lab_pin.sym} 22940 10240 0 0 {name=l33216 lab=BL115}
N 22960 10200 22940 10200 {}
C {lab_pin.sym} 22940 10200 0 0 {name=l33217 lab=BLB115}
N 22960 10160 22940 10160 {}
C {lab_pin.sym} 22940 10160 0 0 {name=l33218 lab=WL51}
N 23040 10240 23060 10240 {}
C {lab_pin.sym} 23060 10240 0 0 {name=l33219 lab=VDD}
N 23040 10160 23060 10160 {}
C {lab_pin.sym} 23060 10160 0 0 {name=l33220 lab=VSS}
C {bitcell_6t.sym} 23200 10200 0 0 {name=Xr51c116}
N 23160 10240 23140 10240 {}
C {lab_pin.sym} 23140 10240 0 0 {name=l33221 lab=BL116}
N 23160 10200 23140 10200 {}
C {lab_pin.sym} 23140 10200 0 0 {name=l33222 lab=BLB116}
N 23160 10160 23140 10160 {}
C {lab_pin.sym} 23140 10160 0 0 {name=l33223 lab=WL51}
N 23240 10240 23260 10240 {}
C {lab_pin.sym} 23260 10240 0 0 {name=l33224 lab=VDD}
N 23240 10160 23260 10160 {}
C {lab_pin.sym} 23260 10160 0 0 {name=l33225 lab=VSS}
C {bitcell_6t.sym} 23400 10200 0 0 {name=Xr51c117}
N 23360 10240 23340 10240 {}
C {lab_pin.sym} 23340 10240 0 0 {name=l33226 lab=BL117}
N 23360 10200 23340 10200 {}
C {lab_pin.sym} 23340 10200 0 0 {name=l33227 lab=BLB117}
N 23360 10160 23340 10160 {}
C {lab_pin.sym} 23340 10160 0 0 {name=l33228 lab=WL51}
N 23440 10240 23460 10240 {}
C {lab_pin.sym} 23460 10240 0 0 {name=l33229 lab=VDD}
N 23440 10160 23460 10160 {}
C {lab_pin.sym} 23460 10160 0 0 {name=l33230 lab=VSS}
C {bitcell_6t.sym} 23600 10200 0 0 {name=Xr51c118}
N 23560 10240 23540 10240 {}
C {lab_pin.sym} 23540 10240 0 0 {name=l33231 lab=BL118}
N 23560 10200 23540 10200 {}
C {lab_pin.sym} 23540 10200 0 0 {name=l33232 lab=BLB118}
N 23560 10160 23540 10160 {}
C {lab_pin.sym} 23540 10160 0 0 {name=l33233 lab=WL51}
N 23640 10240 23660 10240 {}
C {lab_pin.sym} 23660 10240 0 0 {name=l33234 lab=VDD}
N 23640 10160 23660 10160 {}
C {lab_pin.sym} 23660 10160 0 0 {name=l33235 lab=VSS}
C {bitcell_6t.sym} 23800 10200 0 0 {name=Xr51c119}
N 23760 10240 23740 10240 {}
C {lab_pin.sym} 23740 10240 0 0 {name=l33236 lab=BL119}
N 23760 10200 23740 10200 {}
C {lab_pin.sym} 23740 10200 0 0 {name=l33237 lab=BLB119}
N 23760 10160 23740 10160 {}
C {lab_pin.sym} 23740 10160 0 0 {name=l33238 lab=WL51}
N 23840 10240 23860 10240 {}
C {lab_pin.sym} 23860 10240 0 0 {name=l33239 lab=VDD}
N 23840 10160 23860 10160 {}
C {lab_pin.sym} 23860 10160 0 0 {name=l33240 lab=VSS}
C {bitcell_6t.sym} 24000 10200 0 0 {name=Xr51c120}
N 23960 10240 23940 10240 {}
C {lab_pin.sym} 23940 10240 0 0 {name=l33241 lab=BL120}
N 23960 10200 23940 10200 {}
C {lab_pin.sym} 23940 10200 0 0 {name=l33242 lab=BLB120}
N 23960 10160 23940 10160 {}
C {lab_pin.sym} 23940 10160 0 0 {name=l33243 lab=WL51}
N 24040 10240 24060 10240 {}
C {lab_pin.sym} 24060 10240 0 0 {name=l33244 lab=VDD}
N 24040 10160 24060 10160 {}
C {lab_pin.sym} 24060 10160 0 0 {name=l33245 lab=VSS}
C {bitcell_6t.sym} 24200 10200 0 0 {name=Xr51c121}
N 24160 10240 24140 10240 {}
C {lab_pin.sym} 24140 10240 0 0 {name=l33246 lab=BL121}
N 24160 10200 24140 10200 {}
C {lab_pin.sym} 24140 10200 0 0 {name=l33247 lab=BLB121}
N 24160 10160 24140 10160 {}
C {lab_pin.sym} 24140 10160 0 0 {name=l33248 lab=WL51}
N 24240 10240 24260 10240 {}
C {lab_pin.sym} 24260 10240 0 0 {name=l33249 lab=VDD}
N 24240 10160 24260 10160 {}
C {lab_pin.sym} 24260 10160 0 0 {name=l33250 lab=VSS}
C {bitcell_6t.sym} 24400 10200 0 0 {name=Xr51c122}
N 24360 10240 24340 10240 {}
C {lab_pin.sym} 24340 10240 0 0 {name=l33251 lab=BL122}
N 24360 10200 24340 10200 {}
C {lab_pin.sym} 24340 10200 0 0 {name=l33252 lab=BLB122}
N 24360 10160 24340 10160 {}
C {lab_pin.sym} 24340 10160 0 0 {name=l33253 lab=WL51}
N 24440 10240 24460 10240 {}
C {lab_pin.sym} 24460 10240 0 0 {name=l33254 lab=VDD}
N 24440 10160 24460 10160 {}
C {lab_pin.sym} 24460 10160 0 0 {name=l33255 lab=VSS}
C {bitcell_6t.sym} 24600 10200 0 0 {name=Xr51c123}
N 24560 10240 24540 10240 {}
C {lab_pin.sym} 24540 10240 0 0 {name=l33256 lab=BL123}
N 24560 10200 24540 10200 {}
C {lab_pin.sym} 24540 10200 0 0 {name=l33257 lab=BLB123}
N 24560 10160 24540 10160 {}
C {lab_pin.sym} 24540 10160 0 0 {name=l33258 lab=WL51}
N 24640 10240 24660 10240 {}
C {lab_pin.sym} 24660 10240 0 0 {name=l33259 lab=VDD}
N 24640 10160 24660 10160 {}
C {lab_pin.sym} 24660 10160 0 0 {name=l33260 lab=VSS}
C {bitcell_6t.sym} 24800 10200 0 0 {name=Xr51c124}
N 24760 10240 24740 10240 {}
C {lab_pin.sym} 24740 10240 0 0 {name=l33261 lab=BL124}
N 24760 10200 24740 10200 {}
C {lab_pin.sym} 24740 10200 0 0 {name=l33262 lab=BLB124}
N 24760 10160 24740 10160 {}
C {lab_pin.sym} 24740 10160 0 0 {name=l33263 lab=WL51}
N 24840 10240 24860 10240 {}
C {lab_pin.sym} 24860 10240 0 0 {name=l33264 lab=VDD}
N 24840 10160 24860 10160 {}
C {lab_pin.sym} 24860 10160 0 0 {name=l33265 lab=VSS}
C {bitcell_6t.sym} 25000 10200 0 0 {name=Xr51c125}
N 24960 10240 24940 10240 {}
C {lab_pin.sym} 24940 10240 0 0 {name=l33266 lab=BL125}
N 24960 10200 24940 10200 {}
C {lab_pin.sym} 24940 10200 0 0 {name=l33267 lab=BLB125}
N 24960 10160 24940 10160 {}
C {lab_pin.sym} 24940 10160 0 0 {name=l33268 lab=WL51}
N 25040 10240 25060 10240 {}
C {lab_pin.sym} 25060 10240 0 0 {name=l33269 lab=VDD}
N 25040 10160 25060 10160 {}
C {lab_pin.sym} 25060 10160 0 0 {name=l33270 lab=VSS}
C {bitcell_6t.sym} 25200 10200 0 0 {name=Xr51c126}
N 25160 10240 25140 10240 {}
C {lab_pin.sym} 25140 10240 0 0 {name=l33271 lab=BL126}
N 25160 10200 25140 10200 {}
C {lab_pin.sym} 25140 10200 0 0 {name=l33272 lab=BLB126}
N 25160 10160 25140 10160 {}
C {lab_pin.sym} 25140 10160 0 0 {name=l33273 lab=WL51}
N 25240 10240 25260 10240 {}
C {lab_pin.sym} 25260 10240 0 0 {name=l33274 lab=VDD}
N 25240 10160 25260 10160 {}
C {lab_pin.sym} 25260 10160 0 0 {name=l33275 lab=VSS}
C {bitcell_6t.sym} 25400 10200 0 0 {name=Xr51c127}
N 25360 10240 25340 10240 {}
C {lab_pin.sym} 25340 10240 0 0 {name=l33276 lab=BL127}
N 25360 10200 25340 10200 {}
C {lab_pin.sym} 25340 10200 0 0 {name=l33277 lab=BLB127}
N 25360 10160 25340 10160 {}
C {lab_pin.sym} 25340 10160 0 0 {name=l33278 lab=WL51}
N 25440 10240 25460 10240 {}
C {lab_pin.sym} 25460 10240 0 0 {name=l33279 lab=VDD}
N 25440 10160 25460 10160 {}
C {lab_pin.sym} 25460 10160 0 0 {name=l33280 lab=VSS}
C {bitcell_6t.sym} 0 10400 0 0 {name=Xr52c0}
N -40 10440 -60 10440 {}
C {lab_pin.sym} -60 10440 0 0 {name=l33281 lab=BL0}
N -40 10400 -60 10400 {}
C {lab_pin.sym} -60 10400 0 0 {name=l33282 lab=BLB0}
N -40 10360 -60 10360 {}
C {lab_pin.sym} -60 10360 0 0 {name=l33283 lab=WL52}
N 40 10440 60 10440 {}
C {lab_pin.sym} 60 10440 0 0 {name=l33284 lab=VDD}
N 40 10360 60 10360 {}
C {lab_pin.sym} 60 10360 0 0 {name=l33285 lab=VSS}
C {bitcell_6t.sym} 200 10400 0 0 {name=Xr52c1}
N 160 10440 140 10440 {}
C {lab_pin.sym} 140 10440 0 0 {name=l33286 lab=BL1}
N 160 10400 140 10400 {}
C {lab_pin.sym} 140 10400 0 0 {name=l33287 lab=BLB1}
N 160 10360 140 10360 {}
C {lab_pin.sym} 140 10360 0 0 {name=l33288 lab=WL52}
N 240 10440 260 10440 {}
C {lab_pin.sym} 260 10440 0 0 {name=l33289 lab=VDD}
N 240 10360 260 10360 {}
C {lab_pin.sym} 260 10360 0 0 {name=l33290 lab=VSS}
C {bitcell_6t.sym} 400 10400 0 0 {name=Xr52c2}
N 360 10440 340 10440 {}
C {lab_pin.sym} 340 10440 0 0 {name=l33291 lab=BL2}
N 360 10400 340 10400 {}
C {lab_pin.sym} 340 10400 0 0 {name=l33292 lab=BLB2}
N 360 10360 340 10360 {}
C {lab_pin.sym} 340 10360 0 0 {name=l33293 lab=WL52}
N 440 10440 460 10440 {}
C {lab_pin.sym} 460 10440 0 0 {name=l33294 lab=VDD}
N 440 10360 460 10360 {}
C {lab_pin.sym} 460 10360 0 0 {name=l33295 lab=VSS}
C {bitcell_6t.sym} 600 10400 0 0 {name=Xr52c3}
N 560 10440 540 10440 {}
C {lab_pin.sym} 540 10440 0 0 {name=l33296 lab=BL3}
N 560 10400 540 10400 {}
C {lab_pin.sym} 540 10400 0 0 {name=l33297 lab=BLB3}
N 560 10360 540 10360 {}
C {lab_pin.sym} 540 10360 0 0 {name=l33298 lab=WL52}
N 640 10440 660 10440 {}
C {lab_pin.sym} 660 10440 0 0 {name=l33299 lab=VDD}
N 640 10360 660 10360 {}
C {lab_pin.sym} 660 10360 0 0 {name=l33300 lab=VSS}
C {bitcell_6t.sym} 800 10400 0 0 {name=Xr52c4}
N 760 10440 740 10440 {}
C {lab_pin.sym} 740 10440 0 0 {name=l33301 lab=BL4}
N 760 10400 740 10400 {}
C {lab_pin.sym} 740 10400 0 0 {name=l33302 lab=BLB4}
N 760 10360 740 10360 {}
C {lab_pin.sym} 740 10360 0 0 {name=l33303 lab=WL52}
N 840 10440 860 10440 {}
C {lab_pin.sym} 860 10440 0 0 {name=l33304 lab=VDD}
N 840 10360 860 10360 {}
C {lab_pin.sym} 860 10360 0 0 {name=l33305 lab=VSS}
C {bitcell_6t.sym} 1000 10400 0 0 {name=Xr52c5}
N 960 10440 940 10440 {}
C {lab_pin.sym} 940 10440 0 0 {name=l33306 lab=BL5}
N 960 10400 940 10400 {}
C {lab_pin.sym} 940 10400 0 0 {name=l33307 lab=BLB5}
N 960 10360 940 10360 {}
C {lab_pin.sym} 940 10360 0 0 {name=l33308 lab=WL52}
N 1040 10440 1060 10440 {}
C {lab_pin.sym} 1060 10440 0 0 {name=l33309 lab=VDD}
N 1040 10360 1060 10360 {}
C {lab_pin.sym} 1060 10360 0 0 {name=l33310 lab=VSS}
C {bitcell_6t.sym} 1200 10400 0 0 {name=Xr52c6}
N 1160 10440 1140 10440 {}
C {lab_pin.sym} 1140 10440 0 0 {name=l33311 lab=BL6}
N 1160 10400 1140 10400 {}
C {lab_pin.sym} 1140 10400 0 0 {name=l33312 lab=BLB6}
N 1160 10360 1140 10360 {}
C {lab_pin.sym} 1140 10360 0 0 {name=l33313 lab=WL52}
N 1240 10440 1260 10440 {}
C {lab_pin.sym} 1260 10440 0 0 {name=l33314 lab=VDD}
N 1240 10360 1260 10360 {}
C {lab_pin.sym} 1260 10360 0 0 {name=l33315 lab=VSS}
C {bitcell_6t.sym} 1400 10400 0 0 {name=Xr52c7}
N 1360 10440 1340 10440 {}
C {lab_pin.sym} 1340 10440 0 0 {name=l33316 lab=BL7}
N 1360 10400 1340 10400 {}
C {lab_pin.sym} 1340 10400 0 0 {name=l33317 lab=BLB7}
N 1360 10360 1340 10360 {}
C {lab_pin.sym} 1340 10360 0 0 {name=l33318 lab=WL52}
N 1440 10440 1460 10440 {}
C {lab_pin.sym} 1460 10440 0 0 {name=l33319 lab=VDD}
N 1440 10360 1460 10360 {}
C {lab_pin.sym} 1460 10360 0 0 {name=l33320 lab=VSS}
C {bitcell_6t.sym} 1600 10400 0 0 {name=Xr52c8}
N 1560 10440 1540 10440 {}
C {lab_pin.sym} 1540 10440 0 0 {name=l33321 lab=BL8}
N 1560 10400 1540 10400 {}
C {lab_pin.sym} 1540 10400 0 0 {name=l33322 lab=BLB8}
N 1560 10360 1540 10360 {}
C {lab_pin.sym} 1540 10360 0 0 {name=l33323 lab=WL52}
N 1640 10440 1660 10440 {}
C {lab_pin.sym} 1660 10440 0 0 {name=l33324 lab=VDD}
N 1640 10360 1660 10360 {}
C {lab_pin.sym} 1660 10360 0 0 {name=l33325 lab=VSS}
C {bitcell_6t.sym} 1800 10400 0 0 {name=Xr52c9}
N 1760 10440 1740 10440 {}
C {lab_pin.sym} 1740 10440 0 0 {name=l33326 lab=BL9}
N 1760 10400 1740 10400 {}
C {lab_pin.sym} 1740 10400 0 0 {name=l33327 lab=BLB9}
N 1760 10360 1740 10360 {}
C {lab_pin.sym} 1740 10360 0 0 {name=l33328 lab=WL52}
N 1840 10440 1860 10440 {}
C {lab_pin.sym} 1860 10440 0 0 {name=l33329 lab=VDD}
N 1840 10360 1860 10360 {}
C {lab_pin.sym} 1860 10360 0 0 {name=l33330 lab=VSS}
C {bitcell_6t.sym} 2000 10400 0 0 {name=Xr52c10}
N 1960 10440 1940 10440 {}
C {lab_pin.sym} 1940 10440 0 0 {name=l33331 lab=BL10}
N 1960 10400 1940 10400 {}
C {lab_pin.sym} 1940 10400 0 0 {name=l33332 lab=BLB10}
N 1960 10360 1940 10360 {}
C {lab_pin.sym} 1940 10360 0 0 {name=l33333 lab=WL52}
N 2040 10440 2060 10440 {}
C {lab_pin.sym} 2060 10440 0 0 {name=l33334 lab=VDD}
N 2040 10360 2060 10360 {}
C {lab_pin.sym} 2060 10360 0 0 {name=l33335 lab=VSS}
C {bitcell_6t.sym} 2200 10400 0 0 {name=Xr52c11}
N 2160 10440 2140 10440 {}
C {lab_pin.sym} 2140 10440 0 0 {name=l33336 lab=BL11}
N 2160 10400 2140 10400 {}
C {lab_pin.sym} 2140 10400 0 0 {name=l33337 lab=BLB11}
N 2160 10360 2140 10360 {}
C {lab_pin.sym} 2140 10360 0 0 {name=l33338 lab=WL52}
N 2240 10440 2260 10440 {}
C {lab_pin.sym} 2260 10440 0 0 {name=l33339 lab=VDD}
N 2240 10360 2260 10360 {}
C {lab_pin.sym} 2260 10360 0 0 {name=l33340 lab=VSS}
C {bitcell_6t.sym} 2400 10400 0 0 {name=Xr52c12}
N 2360 10440 2340 10440 {}
C {lab_pin.sym} 2340 10440 0 0 {name=l33341 lab=BL12}
N 2360 10400 2340 10400 {}
C {lab_pin.sym} 2340 10400 0 0 {name=l33342 lab=BLB12}
N 2360 10360 2340 10360 {}
C {lab_pin.sym} 2340 10360 0 0 {name=l33343 lab=WL52}
N 2440 10440 2460 10440 {}
C {lab_pin.sym} 2460 10440 0 0 {name=l33344 lab=VDD}
N 2440 10360 2460 10360 {}
C {lab_pin.sym} 2460 10360 0 0 {name=l33345 lab=VSS}
C {bitcell_6t.sym} 2600 10400 0 0 {name=Xr52c13}
N 2560 10440 2540 10440 {}
C {lab_pin.sym} 2540 10440 0 0 {name=l33346 lab=BL13}
N 2560 10400 2540 10400 {}
C {lab_pin.sym} 2540 10400 0 0 {name=l33347 lab=BLB13}
N 2560 10360 2540 10360 {}
C {lab_pin.sym} 2540 10360 0 0 {name=l33348 lab=WL52}
N 2640 10440 2660 10440 {}
C {lab_pin.sym} 2660 10440 0 0 {name=l33349 lab=VDD}
N 2640 10360 2660 10360 {}
C {lab_pin.sym} 2660 10360 0 0 {name=l33350 lab=VSS}
C {bitcell_6t.sym} 2800 10400 0 0 {name=Xr52c14}
N 2760 10440 2740 10440 {}
C {lab_pin.sym} 2740 10440 0 0 {name=l33351 lab=BL14}
N 2760 10400 2740 10400 {}
C {lab_pin.sym} 2740 10400 0 0 {name=l33352 lab=BLB14}
N 2760 10360 2740 10360 {}
C {lab_pin.sym} 2740 10360 0 0 {name=l33353 lab=WL52}
N 2840 10440 2860 10440 {}
C {lab_pin.sym} 2860 10440 0 0 {name=l33354 lab=VDD}
N 2840 10360 2860 10360 {}
C {lab_pin.sym} 2860 10360 0 0 {name=l33355 lab=VSS}
C {bitcell_6t.sym} 3000 10400 0 0 {name=Xr52c15}
N 2960 10440 2940 10440 {}
C {lab_pin.sym} 2940 10440 0 0 {name=l33356 lab=BL15}
N 2960 10400 2940 10400 {}
C {lab_pin.sym} 2940 10400 0 0 {name=l33357 lab=BLB15}
N 2960 10360 2940 10360 {}
C {lab_pin.sym} 2940 10360 0 0 {name=l33358 lab=WL52}
N 3040 10440 3060 10440 {}
C {lab_pin.sym} 3060 10440 0 0 {name=l33359 lab=VDD}
N 3040 10360 3060 10360 {}
C {lab_pin.sym} 3060 10360 0 0 {name=l33360 lab=VSS}
C {bitcell_6t.sym} 3200 10400 0 0 {name=Xr52c16}
N 3160 10440 3140 10440 {}
C {lab_pin.sym} 3140 10440 0 0 {name=l33361 lab=BL16}
N 3160 10400 3140 10400 {}
C {lab_pin.sym} 3140 10400 0 0 {name=l33362 lab=BLB16}
N 3160 10360 3140 10360 {}
C {lab_pin.sym} 3140 10360 0 0 {name=l33363 lab=WL52}
N 3240 10440 3260 10440 {}
C {lab_pin.sym} 3260 10440 0 0 {name=l33364 lab=VDD}
N 3240 10360 3260 10360 {}
C {lab_pin.sym} 3260 10360 0 0 {name=l33365 lab=VSS}
C {bitcell_6t.sym} 3400 10400 0 0 {name=Xr52c17}
N 3360 10440 3340 10440 {}
C {lab_pin.sym} 3340 10440 0 0 {name=l33366 lab=BL17}
N 3360 10400 3340 10400 {}
C {lab_pin.sym} 3340 10400 0 0 {name=l33367 lab=BLB17}
N 3360 10360 3340 10360 {}
C {lab_pin.sym} 3340 10360 0 0 {name=l33368 lab=WL52}
N 3440 10440 3460 10440 {}
C {lab_pin.sym} 3460 10440 0 0 {name=l33369 lab=VDD}
N 3440 10360 3460 10360 {}
C {lab_pin.sym} 3460 10360 0 0 {name=l33370 lab=VSS}
C {bitcell_6t.sym} 3600 10400 0 0 {name=Xr52c18}
N 3560 10440 3540 10440 {}
C {lab_pin.sym} 3540 10440 0 0 {name=l33371 lab=BL18}
N 3560 10400 3540 10400 {}
C {lab_pin.sym} 3540 10400 0 0 {name=l33372 lab=BLB18}
N 3560 10360 3540 10360 {}
C {lab_pin.sym} 3540 10360 0 0 {name=l33373 lab=WL52}
N 3640 10440 3660 10440 {}
C {lab_pin.sym} 3660 10440 0 0 {name=l33374 lab=VDD}
N 3640 10360 3660 10360 {}
C {lab_pin.sym} 3660 10360 0 0 {name=l33375 lab=VSS}
C {bitcell_6t.sym} 3800 10400 0 0 {name=Xr52c19}
N 3760 10440 3740 10440 {}
C {lab_pin.sym} 3740 10440 0 0 {name=l33376 lab=BL19}
N 3760 10400 3740 10400 {}
C {lab_pin.sym} 3740 10400 0 0 {name=l33377 lab=BLB19}
N 3760 10360 3740 10360 {}
C {lab_pin.sym} 3740 10360 0 0 {name=l33378 lab=WL52}
N 3840 10440 3860 10440 {}
C {lab_pin.sym} 3860 10440 0 0 {name=l33379 lab=VDD}
N 3840 10360 3860 10360 {}
C {lab_pin.sym} 3860 10360 0 0 {name=l33380 lab=VSS}
C {bitcell_6t.sym} 4000 10400 0 0 {name=Xr52c20}
N 3960 10440 3940 10440 {}
C {lab_pin.sym} 3940 10440 0 0 {name=l33381 lab=BL20}
N 3960 10400 3940 10400 {}
C {lab_pin.sym} 3940 10400 0 0 {name=l33382 lab=BLB20}
N 3960 10360 3940 10360 {}
C {lab_pin.sym} 3940 10360 0 0 {name=l33383 lab=WL52}
N 4040 10440 4060 10440 {}
C {lab_pin.sym} 4060 10440 0 0 {name=l33384 lab=VDD}
N 4040 10360 4060 10360 {}
C {lab_pin.sym} 4060 10360 0 0 {name=l33385 lab=VSS}
C {bitcell_6t.sym} 4200 10400 0 0 {name=Xr52c21}
N 4160 10440 4140 10440 {}
C {lab_pin.sym} 4140 10440 0 0 {name=l33386 lab=BL21}
N 4160 10400 4140 10400 {}
C {lab_pin.sym} 4140 10400 0 0 {name=l33387 lab=BLB21}
N 4160 10360 4140 10360 {}
C {lab_pin.sym} 4140 10360 0 0 {name=l33388 lab=WL52}
N 4240 10440 4260 10440 {}
C {lab_pin.sym} 4260 10440 0 0 {name=l33389 lab=VDD}
N 4240 10360 4260 10360 {}
C {lab_pin.sym} 4260 10360 0 0 {name=l33390 lab=VSS}
C {bitcell_6t.sym} 4400 10400 0 0 {name=Xr52c22}
N 4360 10440 4340 10440 {}
C {lab_pin.sym} 4340 10440 0 0 {name=l33391 lab=BL22}
N 4360 10400 4340 10400 {}
C {lab_pin.sym} 4340 10400 0 0 {name=l33392 lab=BLB22}
N 4360 10360 4340 10360 {}
C {lab_pin.sym} 4340 10360 0 0 {name=l33393 lab=WL52}
N 4440 10440 4460 10440 {}
C {lab_pin.sym} 4460 10440 0 0 {name=l33394 lab=VDD}
N 4440 10360 4460 10360 {}
C {lab_pin.sym} 4460 10360 0 0 {name=l33395 lab=VSS}
C {bitcell_6t.sym} 4600 10400 0 0 {name=Xr52c23}
N 4560 10440 4540 10440 {}
C {lab_pin.sym} 4540 10440 0 0 {name=l33396 lab=BL23}
N 4560 10400 4540 10400 {}
C {lab_pin.sym} 4540 10400 0 0 {name=l33397 lab=BLB23}
N 4560 10360 4540 10360 {}
C {lab_pin.sym} 4540 10360 0 0 {name=l33398 lab=WL52}
N 4640 10440 4660 10440 {}
C {lab_pin.sym} 4660 10440 0 0 {name=l33399 lab=VDD}
N 4640 10360 4660 10360 {}
C {lab_pin.sym} 4660 10360 0 0 {name=l33400 lab=VSS}
C {bitcell_6t.sym} 4800 10400 0 0 {name=Xr52c24}
N 4760 10440 4740 10440 {}
C {lab_pin.sym} 4740 10440 0 0 {name=l33401 lab=BL24}
N 4760 10400 4740 10400 {}
C {lab_pin.sym} 4740 10400 0 0 {name=l33402 lab=BLB24}
N 4760 10360 4740 10360 {}
C {lab_pin.sym} 4740 10360 0 0 {name=l33403 lab=WL52}
N 4840 10440 4860 10440 {}
C {lab_pin.sym} 4860 10440 0 0 {name=l33404 lab=VDD}
N 4840 10360 4860 10360 {}
C {lab_pin.sym} 4860 10360 0 0 {name=l33405 lab=VSS}
C {bitcell_6t.sym} 5000 10400 0 0 {name=Xr52c25}
N 4960 10440 4940 10440 {}
C {lab_pin.sym} 4940 10440 0 0 {name=l33406 lab=BL25}
N 4960 10400 4940 10400 {}
C {lab_pin.sym} 4940 10400 0 0 {name=l33407 lab=BLB25}
N 4960 10360 4940 10360 {}
C {lab_pin.sym} 4940 10360 0 0 {name=l33408 lab=WL52}
N 5040 10440 5060 10440 {}
C {lab_pin.sym} 5060 10440 0 0 {name=l33409 lab=VDD}
N 5040 10360 5060 10360 {}
C {lab_pin.sym} 5060 10360 0 0 {name=l33410 lab=VSS}
C {bitcell_6t.sym} 5200 10400 0 0 {name=Xr52c26}
N 5160 10440 5140 10440 {}
C {lab_pin.sym} 5140 10440 0 0 {name=l33411 lab=BL26}
N 5160 10400 5140 10400 {}
C {lab_pin.sym} 5140 10400 0 0 {name=l33412 lab=BLB26}
N 5160 10360 5140 10360 {}
C {lab_pin.sym} 5140 10360 0 0 {name=l33413 lab=WL52}
N 5240 10440 5260 10440 {}
C {lab_pin.sym} 5260 10440 0 0 {name=l33414 lab=VDD}
N 5240 10360 5260 10360 {}
C {lab_pin.sym} 5260 10360 0 0 {name=l33415 lab=VSS}
C {bitcell_6t.sym} 5400 10400 0 0 {name=Xr52c27}
N 5360 10440 5340 10440 {}
C {lab_pin.sym} 5340 10440 0 0 {name=l33416 lab=BL27}
N 5360 10400 5340 10400 {}
C {lab_pin.sym} 5340 10400 0 0 {name=l33417 lab=BLB27}
N 5360 10360 5340 10360 {}
C {lab_pin.sym} 5340 10360 0 0 {name=l33418 lab=WL52}
N 5440 10440 5460 10440 {}
C {lab_pin.sym} 5460 10440 0 0 {name=l33419 lab=VDD}
N 5440 10360 5460 10360 {}
C {lab_pin.sym} 5460 10360 0 0 {name=l33420 lab=VSS}
C {bitcell_6t.sym} 5600 10400 0 0 {name=Xr52c28}
N 5560 10440 5540 10440 {}
C {lab_pin.sym} 5540 10440 0 0 {name=l33421 lab=BL28}
N 5560 10400 5540 10400 {}
C {lab_pin.sym} 5540 10400 0 0 {name=l33422 lab=BLB28}
N 5560 10360 5540 10360 {}
C {lab_pin.sym} 5540 10360 0 0 {name=l33423 lab=WL52}
N 5640 10440 5660 10440 {}
C {lab_pin.sym} 5660 10440 0 0 {name=l33424 lab=VDD}
N 5640 10360 5660 10360 {}
C {lab_pin.sym} 5660 10360 0 0 {name=l33425 lab=VSS}
C {bitcell_6t.sym} 5800 10400 0 0 {name=Xr52c29}
N 5760 10440 5740 10440 {}
C {lab_pin.sym} 5740 10440 0 0 {name=l33426 lab=BL29}
N 5760 10400 5740 10400 {}
C {lab_pin.sym} 5740 10400 0 0 {name=l33427 lab=BLB29}
N 5760 10360 5740 10360 {}
C {lab_pin.sym} 5740 10360 0 0 {name=l33428 lab=WL52}
N 5840 10440 5860 10440 {}
C {lab_pin.sym} 5860 10440 0 0 {name=l33429 lab=VDD}
N 5840 10360 5860 10360 {}
C {lab_pin.sym} 5860 10360 0 0 {name=l33430 lab=VSS}
C {bitcell_6t.sym} 6000 10400 0 0 {name=Xr52c30}
N 5960 10440 5940 10440 {}
C {lab_pin.sym} 5940 10440 0 0 {name=l33431 lab=BL30}
N 5960 10400 5940 10400 {}
C {lab_pin.sym} 5940 10400 0 0 {name=l33432 lab=BLB30}
N 5960 10360 5940 10360 {}
C {lab_pin.sym} 5940 10360 0 0 {name=l33433 lab=WL52}
N 6040 10440 6060 10440 {}
C {lab_pin.sym} 6060 10440 0 0 {name=l33434 lab=VDD}
N 6040 10360 6060 10360 {}
C {lab_pin.sym} 6060 10360 0 0 {name=l33435 lab=VSS}
C {bitcell_6t.sym} 6200 10400 0 0 {name=Xr52c31}
N 6160 10440 6140 10440 {}
C {lab_pin.sym} 6140 10440 0 0 {name=l33436 lab=BL31}
N 6160 10400 6140 10400 {}
C {lab_pin.sym} 6140 10400 0 0 {name=l33437 lab=BLB31}
N 6160 10360 6140 10360 {}
C {lab_pin.sym} 6140 10360 0 0 {name=l33438 lab=WL52}
N 6240 10440 6260 10440 {}
C {lab_pin.sym} 6260 10440 0 0 {name=l33439 lab=VDD}
N 6240 10360 6260 10360 {}
C {lab_pin.sym} 6260 10360 0 0 {name=l33440 lab=VSS}
C {bitcell_6t.sym} 6400 10400 0 0 {name=Xr52c32}
N 6360 10440 6340 10440 {}
C {lab_pin.sym} 6340 10440 0 0 {name=l33441 lab=BL32}
N 6360 10400 6340 10400 {}
C {lab_pin.sym} 6340 10400 0 0 {name=l33442 lab=BLB32}
N 6360 10360 6340 10360 {}
C {lab_pin.sym} 6340 10360 0 0 {name=l33443 lab=WL52}
N 6440 10440 6460 10440 {}
C {lab_pin.sym} 6460 10440 0 0 {name=l33444 lab=VDD}
N 6440 10360 6460 10360 {}
C {lab_pin.sym} 6460 10360 0 0 {name=l33445 lab=VSS}
C {bitcell_6t.sym} 6600 10400 0 0 {name=Xr52c33}
N 6560 10440 6540 10440 {}
C {lab_pin.sym} 6540 10440 0 0 {name=l33446 lab=BL33}
N 6560 10400 6540 10400 {}
C {lab_pin.sym} 6540 10400 0 0 {name=l33447 lab=BLB33}
N 6560 10360 6540 10360 {}
C {lab_pin.sym} 6540 10360 0 0 {name=l33448 lab=WL52}
N 6640 10440 6660 10440 {}
C {lab_pin.sym} 6660 10440 0 0 {name=l33449 lab=VDD}
N 6640 10360 6660 10360 {}
C {lab_pin.sym} 6660 10360 0 0 {name=l33450 lab=VSS}
C {bitcell_6t.sym} 6800 10400 0 0 {name=Xr52c34}
N 6760 10440 6740 10440 {}
C {lab_pin.sym} 6740 10440 0 0 {name=l33451 lab=BL34}
N 6760 10400 6740 10400 {}
C {lab_pin.sym} 6740 10400 0 0 {name=l33452 lab=BLB34}
N 6760 10360 6740 10360 {}
C {lab_pin.sym} 6740 10360 0 0 {name=l33453 lab=WL52}
N 6840 10440 6860 10440 {}
C {lab_pin.sym} 6860 10440 0 0 {name=l33454 lab=VDD}
N 6840 10360 6860 10360 {}
C {lab_pin.sym} 6860 10360 0 0 {name=l33455 lab=VSS}
C {bitcell_6t.sym} 7000 10400 0 0 {name=Xr52c35}
N 6960 10440 6940 10440 {}
C {lab_pin.sym} 6940 10440 0 0 {name=l33456 lab=BL35}
N 6960 10400 6940 10400 {}
C {lab_pin.sym} 6940 10400 0 0 {name=l33457 lab=BLB35}
N 6960 10360 6940 10360 {}
C {lab_pin.sym} 6940 10360 0 0 {name=l33458 lab=WL52}
N 7040 10440 7060 10440 {}
C {lab_pin.sym} 7060 10440 0 0 {name=l33459 lab=VDD}
N 7040 10360 7060 10360 {}
C {lab_pin.sym} 7060 10360 0 0 {name=l33460 lab=VSS}
C {bitcell_6t.sym} 7200 10400 0 0 {name=Xr52c36}
N 7160 10440 7140 10440 {}
C {lab_pin.sym} 7140 10440 0 0 {name=l33461 lab=BL36}
N 7160 10400 7140 10400 {}
C {lab_pin.sym} 7140 10400 0 0 {name=l33462 lab=BLB36}
N 7160 10360 7140 10360 {}
C {lab_pin.sym} 7140 10360 0 0 {name=l33463 lab=WL52}
N 7240 10440 7260 10440 {}
C {lab_pin.sym} 7260 10440 0 0 {name=l33464 lab=VDD}
N 7240 10360 7260 10360 {}
C {lab_pin.sym} 7260 10360 0 0 {name=l33465 lab=VSS}
C {bitcell_6t.sym} 7400 10400 0 0 {name=Xr52c37}
N 7360 10440 7340 10440 {}
C {lab_pin.sym} 7340 10440 0 0 {name=l33466 lab=BL37}
N 7360 10400 7340 10400 {}
C {lab_pin.sym} 7340 10400 0 0 {name=l33467 lab=BLB37}
N 7360 10360 7340 10360 {}
C {lab_pin.sym} 7340 10360 0 0 {name=l33468 lab=WL52}
N 7440 10440 7460 10440 {}
C {lab_pin.sym} 7460 10440 0 0 {name=l33469 lab=VDD}
N 7440 10360 7460 10360 {}
C {lab_pin.sym} 7460 10360 0 0 {name=l33470 lab=VSS}
C {bitcell_6t.sym} 7600 10400 0 0 {name=Xr52c38}
N 7560 10440 7540 10440 {}
C {lab_pin.sym} 7540 10440 0 0 {name=l33471 lab=BL38}
N 7560 10400 7540 10400 {}
C {lab_pin.sym} 7540 10400 0 0 {name=l33472 lab=BLB38}
N 7560 10360 7540 10360 {}
C {lab_pin.sym} 7540 10360 0 0 {name=l33473 lab=WL52}
N 7640 10440 7660 10440 {}
C {lab_pin.sym} 7660 10440 0 0 {name=l33474 lab=VDD}
N 7640 10360 7660 10360 {}
C {lab_pin.sym} 7660 10360 0 0 {name=l33475 lab=VSS}
C {bitcell_6t.sym} 7800 10400 0 0 {name=Xr52c39}
N 7760 10440 7740 10440 {}
C {lab_pin.sym} 7740 10440 0 0 {name=l33476 lab=BL39}
N 7760 10400 7740 10400 {}
C {lab_pin.sym} 7740 10400 0 0 {name=l33477 lab=BLB39}
N 7760 10360 7740 10360 {}
C {lab_pin.sym} 7740 10360 0 0 {name=l33478 lab=WL52}
N 7840 10440 7860 10440 {}
C {lab_pin.sym} 7860 10440 0 0 {name=l33479 lab=VDD}
N 7840 10360 7860 10360 {}
C {lab_pin.sym} 7860 10360 0 0 {name=l33480 lab=VSS}
C {bitcell_6t.sym} 8000 10400 0 0 {name=Xr52c40}
N 7960 10440 7940 10440 {}
C {lab_pin.sym} 7940 10440 0 0 {name=l33481 lab=BL40}
N 7960 10400 7940 10400 {}
C {lab_pin.sym} 7940 10400 0 0 {name=l33482 lab=BLB40}
N 7960 10360 7940 10360 {}
C {lab_pin.sym} 7940 10360 0 0 {name=l33483 lab=WL52}
N 8040 10440 8060 10440 {}
C {lab_pin.sym} 8060 10440 0 0 {name=l33484 lab=VDD}
N 8040 10360 8060 10360 {}
C {lab_pin.sym} 8060 10360 0 0 {name=l33485 lab=VSS}
C {bitcell_6t.sym} 8200 10400 0 0 {name=Xr52c41}
N 8160 10440 8140 10440 {}
C {lab_pin.sym} 8140 10440 0 0 {name=l33486 lab=BL41}
N 8160 10400 8140 10400 {}
C {lab_pin.sym} 8140 10400 0 0 {name=l33487 lab=BLB41}
N 8160 10360 8140 10360 {}
C {lab_pin.sym} 8140 10360 0 0 {name=l33488 lab=WL52}
N 8240 10440 8260 10440 {}
C {lab_pin.sym} 8260 10440 0 0 {name=l33489 lab=VDD}
N 8240 10360 8260 10360 {}
C {lab_pin.sym} 8260 10360 0 0 {name=l33490 lab=VSS}
C {bitcell_6t.sym} 8400 10400 0 0 {name=Xr52c42}
N 8360 10440 8340 10440 {}
C {lab_pin.sym} 8340 10440 0 0 {name=l33491 lab=BL42}
N 8360 10400 8340 10400 {}
C {lab_pin.sym} 8340 10400 0 0 {name=l33492 lab=BLB42}
N 8360 10360 8340 10360 {}
C {lab_pin.sym} 8340 10360 0 0 {name=l33493 lab=WL52}
N 8440 10440 8460 10440 {}
C {lab_pin.sym} 8460 10440 0 0 {name=l33494 lab=VDD}
N 8440 10360 8460 10360 {}
C {lab_pin.sym} 8460 10360 0 0 {name=l33495 lab=VSS}
C {bitcell_6t.sym} 8600 10400 0 0 {name=Xr52c43}
N 8560 10440 8540 10440 {}
C {lab_pin.sym} 8540 10440 0 0 {name=l33496 lab=BL43}
N 8560 10400 8540 10400 {}
C {lab_pin.sym} 8540 10400 0 0 {name=l33497 lab=BLB43}
N 8560 10360 8540 10360 {}
C {lab_pin.sym} 8540 10360 0 0 {name=l33498 lab=WL52}
N 8640 10440 8660 10440 {}
C {lab_pin.sym} 8660 10440 0 0 {name=l33499 lab=VDD}
N 8640 10360 8660 10360 {}
C {lab_pin.sym} 8660 10360 0 0 {name=l33500 lab=VSS}
C {bitcell_6t.sym} 8800 10400 0 0 {name=Xr52c44}
N 8760 10440 8740 10440 {}
C {lab_pin.sym} 8740 10440 0 0 {name=l33501 lab=BL44}
N 8760 10400 8740 10400 {}
C {lab_pin.sym} 8740 10400 0 0 {name=l33502 lab=BLB44}
N 8760 10360 8740 10360 {}
C {lab_pin.sym} 8740 10360 0 0 {name=l33503 lab=WL52}
N 8840 10440 8860 10440 {}
C {lab_pin.sym} 8860 10440 0 0 {name=l33504 lab=VDD}
N 8840 10360 8860 10360 {}
C {lab_pin.sym} 8860 10360 0 0 {name=l33505 lab=VSS}
C {bitcell_6t.sym} 9000 10400 0 0 {name=Xr52c45}
N 8960 10440 8940 10440 {}
C {lab_pin.sym} 8940 10440 0 0 {name=l33506 lab=BL45}
N 8960 10400 8940 10400 {}
C {lab_pin.sym} 8940 10400 0 0 {name=l33507 lab=BLB45}
N 8960 10360 8940 10360 {}
C {lab_pin.sym} 8940 10360 0 0 {name=l33508 lab=WL52}
N 9040 10440 9060 10440 {}
C {lab_pin.sym} 9060 10440 0 0 {name=l33509 lab=VDD}
N 9040 10360 9060 10360 {}
C {lab_pin.sym} 9060 10360 0 0 {name=l33510 lab=VSS}
C {bitcell_6t.sym} 9200 10400 0 0 {name=Xr52c46}
N 9160 10440 9140 10440 {}
C {lab_pin.sym} 9140 10440 0 0 {name=l33511 lab=BL46}
N 9160 10400 9140 10400 {}
C {lab_pin.sym} 9140 10400 0 0 {name=l33512 lab=BLB46}
N 9160 10360 9140 10360 {}
C {lab_pin.sym} 9140 10360 0 0 {name=l33513 lab=WL52}
N 9240 10440 9260 10440 {}
C {lab_pin.sym} 9260 10440 0 0 {name=l33514 lab=VDD}
N 9240 10360 9260 10360 {}
C {lab_pin.sym} 9260 10360 0 0 {name=l33515 lab=VSS}
C {bitcell_6t.sym} 9400 10400 0 0 {name=Xr52c47}
N 9360 10440 9340 10440 {}
C {lab_pin.sym} 9340 10440 0 0 {name=l33516 lab=BL47}
N 9360 10400 9340 10400 {}
C {lab_pin.sym} 9340 10400 0 0 {name=l33517 lab=BLB47}
N 9360 10360 9340 10360 {}
C {lab_pin.sym} 9340 10360 0 0 {name=l33518 lab=WL52}
N 9440 10440 9460 10440 {}
C {lab_pin.sym} 9460 10440 0 0 {name=l33519 lab=VDD}
N 9440 10360 9460 10360 {}
C {lab_pin.sym} 9460 10360 0 0 {name=l33520 lab=VSS}
C {bitcell_6t.sym} 9600 10400 0 0 {name=Xr52c48}
N 9560 10440 9540 10440 {}
C {lab_pin.sym} 9540 10440 0 0 {name=l33521 lab=BL48}
N 9560 10400 9540 10400 {}
C {lab_pin.sym} 9540 10400 0 0 {name=l33522 lab=BLB48}
N 9560 10360 9540 10360 {}
C {lab_pin.sym} 9540 10360 0 0 {name=l33523 lab=WL52}
N 9640 10440 9660 10440 {}
C {lab_pin.sym} 9660 10440 0 0 {name=l33524 lab=VDD}
N 9640 10360 9660 10360 {}
C {lab_pin.sym} 9660 10360 0 0 {name=l33525 lab=VSS}
C {bitcell_6t.sym} 9800 10400 0 0 {name=Xr52c49}
N 9760 10440 9740 10440 {}
C {lab_pin.sym} 9740 10440 0 0 {name=l33526 lab=BL49}
N 9760 10400 9740 10400 {}
C {lab_pin.sym} 9740 10400 0 0 {name=l33527 lab=BLB49}
N 9760 10360 9740 10360 {}
C {lab_pin.sym} 9740 10360 0 0 {name=l33528 lab=WL52}
N 9840 10440 9860 10440 {}
C {lab_pin.sym} 9860 10440 0 0 {name=l33529 lab=VDD}
N 9840 10360 9860 10360 {}
C {lab_pin.sym} 9860 10360 0 0 {name=l33530 lab=VSS}
C {bitcell_6t.sym} 10000 10400 0 0 {name=Xr52c50}
N 9960 10440 9940 10440 {}
C {lab_pin.sym} 9940 10440 0 0 {name=l33531 lab=BL50}
N 9960 10400 9940 10400 {}
C {lab_pin.sym} 9940 10400 0 0 {name=l33532 lab=BLB50}
N 9960 10360 9940 10360 {}
C {lab_pin.sym} 9940 10360 0 0 {name=l33533 lab=WL52}
N 10040 10440 10060 10440 {}
C {lab_pin.sym} 10060 10440 0 0 {name=l33534 lab=VDD}
N 10040 10360 10060 10360 {}
C {lab_pin.sym} 10060 10360 0 0 {name=l33535 lab=VSS}
C {bitcell_6t.sym} 10200 10400 0 0 {name=Xr52c51}
N 10160 10440 10140 10440 {}
C {lab_pin.sym} 10140 10440 0 0 {name=l33536 lab=BL51}
N 10160 10400 10140 10400 {}
C {lab_pin.sym} 10140 10400 0 0 {name=l33537 lab=BLB51}
N 10160 10360 10140 10360 {}
C {lab_pin.sym} 10140 10360 0 0 {name=l33538 lab=WL52}
N 10240 10440 10260 10440 {}
C {lab_pin.sym} 10260 10440 0 0 {name=l33539 lab=VDD}
N 10240 10360 10260 10360 {}
C {lab_pin.sym} 10260 10360 0 0 {name=l33540 lab=VSS}
C {bitcell_6t.sym} 10400 10400 0 0 {name=Xr52c52}
N 10360 10440 10340 10440 {}
C {lab_pin.sym} 10340 10440 0 0 {name=l33541 lab=BL52}
N 10360 10400 10340 10400 {}
C {lab_pin.sym} 10340 10400 0 0 {name=l33542 lab=BLB52}
N 10360 10360 10340 10360 {}
C {lab_pin.sym} 10340 10360 0 0 {name=l33543 lab=WL52}
N 10440 10440 10460 10440 {}
C {lab_pin.sym} 10460 10440 0 0 {name=l33544 lab=VDD}
N 10440 10360 10460 10360 {}
C {lab_pin.sym} 10460 10360 0 0 {name=l33545 lab=VSS}
C {bitcell_6t.sym} 10600 10400 0 0 {name=Xr52c53}
N 10560 10440 10540 10440 {}
C {lab_pin.sym} 10540 10440 0 0 {name=l33546 lab=BL53}
N 10560 10400 10540 10400 {}
C {lab_pin.sym} 10540 10400 0 0 {name=l33547 lab=BLB53}
N 10560 10360 10540 10360 {}
C {lab_pin.sym} 10540 10360 0 0 {name=l33548 lab=WL52}
N 10640 10440 10660 10440 {}
C {lab_pin.sym} 10660 10440 0 0 {name=l33549 lab=VDD}
N 10640 10360 10660 10360 {}
C {lab_pin.sym} 10660 10360 0 0 {name=l33550 lab=VSS}
C {bitcell_6t.sym} 10800 10400 0 0 {name=Xr52c54}
N 10760 10440 10740 10440 {}
C {lab_pin.sym} 10740 10440 0 0 {name=l33551 lab=BL54}
N 10760 10400 10740 10400 {}
C {lab_pin.sym} 10740 10400 0 0 {name=l33552 lab=BLB54}
N 10760 10360 10740 10360 {}
C {lab_pin.sym} 10740 10360 0 0 {name=l33553 lab=WL52}
N 10840 10440 10860 10440 {}
C {lab_pin.sym} 10860 10440 0 0 {name=l33554 lab=VDD}
N 10840 10360 10860 10360 {}
C {lab_pin.sym} 10860 10360 0 0 {name=l33555 lab=VSS}
C {bitcell_6t.sym} 11000 10400 0 0 {name=Xr52c55}
N 10960 10440 10940 10440 {}
C {lab_pin.sym} 10940 10440 0 0 {name=l33556 lab=BL55}
N 10960 10400 10940 10400 {}
C {lab_pin.sym} 10940 10400 0 0 {name=l33557 lab=BLB55}
N 10960 10360 10940 10360 {}
C {lab_pin.sym} 10940 10360 0 0 {name=l33558 lab=WL52}
N 11040 10440 11060 10440 {}
C {lab_pin.sym} 11060 10440 0 0 {name=l33559 lab=VDD}
N 11040 10360 11060 10360 {}
C {lab_pin.sym} 11060 10360 0 0 {name=l33560 lab=VSS}
C {bitcell_6t.sym} 11200 10400 0 0 {name=Xr52c56}
N 11160 10440 11140 10440 {}
C {lab_pin.sym} 11140 10440 0 0 {name=l33561 lab=BL56}
N 11160 10400 11140 10400 {}
C {lab_pin.sym} 11140 10400 0 0 {name=l33562 lab=BLB56}
N 11160 10360 11140 10360 {}
C {lab_pin.sym} 11140 10360 0 0 {name=l33563 lab=WL52}
N 11240 10440 11260 10440 {}
C {lab_pin.sym} 11260 10440 0 0 {name=l33564 lab=VDD}
N 11240 10360 11260 10360 {}
C {lab_pin.sym} 11260 10360 0 0 {name=l33565 lab=VSS}
C {bitcell_6t.sym} 11400 10400 0 0 {name=Xr52c57}
N 11360 10440 11340 10440 {}
C {lab_pin.sym} 11340 10440 0 0 {name=l33566 lab=BL57}
N 11360 10400 11340 10400 {}
C {lab_pin.sym} 11340 10400 0 0 {name=l33567 lab=BLB57}
N 11360 10360 11340 10360 {}
C {lab_pin.sym} 11340 10360 0 0 {name=l33568 lab=WL52}
N 11440 10440 11460 10440 {}
C {lab_pin.sym} 11460 10440 0 0 {name=l33569 lab=VDD}
N 11440 10360 11460 10360 {}
C {lab_pin.sym} 11460 10360 0 0 {name=l33570 lab=VSS}
C {bitcell_6t.sym} 11600 10400 0 0 {name=Xr52c58}
N 11560 10440 11540 10440 {}
C {lab_pin.sym} 11540 10440 0 0 {name=l33571 lab=BL58}
N 11560 10400 11540 10400 {}
C {lab_pin.sym} 11540 10400 0 0 {name=l33572 lab=BLB58}
N 11560 10360 11540 10360 {}
C {lab_pin.sym} 11540 10360 0 0 {name=l33573 lab=WL52}
N 11640 10440 11660 10440 {}
C {lab_pin.sym} 11660 10440 0 0 {name=l33574 lab=VDD}
N 11640 10360 11660 10360 {}
C {lab_pin.sym} 11660 10360 0 0 {name=l33575 lab=VSS}
C {bitcell_6t.sym} 11800 10400 0 0 {name=Xr52c59}
N 11760 10440 11740 10440 {}
C {lab_pin.sym} 11740 10440 0 0 {name=l33576 lab=BL59}
N 11760 10400 11740 10400 {}
C {lab_pin.sym} 11740 10400 0 0 {name=l33577 lab=BLB59}
N 11760 10360 11740 10360 {}
C {lab_pin.sym} 11740 10360 0 0 {name=l33578 lab=WL52}
N 11840 10440 11860 10440 {}
C {lab_pin.sym} 11860 10440 0 0 {name=l33579 lab=VDD}
N 11840 10360 11860 10360 {}
C {lab_pin.sym} 11860 10360 0 0 {name=l33580 lab=VSS}
C {bitcell_6t.sym} 12000 10400 0 0 {name=Xr52c60}
N 11960 10440 11940 10440 {}
C {lab_pin.sym} 11940 10440 0 0 {name=l33581 lab=BL60}
N 11960 10400 11940 10400 {}
C {lab_pin.sym} 11940 10400 0 0 {name=l33582 lab=BLB60}
N 11960 10360 11940 10360 {}
C {lab_pin.sym} 11940 10360 0 0 {name=l33583 lab=WL52}
N 12040 10440 12060 10440 {}
C {lab_pin.sym} 12060 10440 0 0 {name=l33584 lab=VDD}
N 12040 10360 12060 10360 {}
C {lab_pin.sym} 12060 10360 0 0 {name=l33585 lab=VSS}
C {bitcell_6t.sym} 12200 10400 0 0 {name=Xr52c61}
N 12160 10440 12140 10440 {}
C {lab_pin.sym} 12140 10440 0 0 {name=l33586 lab=BL61}
N 12160 10400 12140 10400 {}
C {lab_pin.sym} 12140 10400 0 0 {name=l33587 lab=BLB61}
N 12160 10360 12140 10360 {}
C {lab_pin.sym} 12140 10360 0 0 {name=l33588 lab=WL52}
N 12240 10440 12260 10440 {}
C {lab_pin.sym} 12260 10440 0 0 {name=l33589 lab=VDD}
N 12240 10360 12260 10360 {}
C {lab_pin.sym} 12260 10360 0 0 {name=l33590 lab=VSS}
C {bitcell_6t.sym} 12400 10400 0 0 {name=Xr52c62}
N 12360 10440 12340 10440 {}
C {lab_pin.sym} 12340 10440 0 0 {name=l33591 lab=BL62}
N 12360 10400 12340 10400 {}
C {lab_pin.sym} 12340 10400 0 0 {name=l33592 lab=BLB62}
N 12360 10360 12340 10360 {}
C {lab_pin.sym} 12340 10360 0 0 {name=l33593 lab=WL52}
N 12440 10440 12460 10440 {}
C {lab_pin.sym} 12460 10440 0 0 {name=l33594 lab=VDD}
N 12440 10360 12460 10360 {}
C {lab_pin.sym} 12460 10360 0 0 {name=l33595 lab=VSS}
C {bitcell_6t.sym} 12600 10400 0 0 {name=Xr52c63}
N 12560 10440 12540 10440 {}
C {lab_pin.sym} 12540 10440 0 0 {name=l33596 lab=BL63}
N 12560 10400 12540 10400 {}
C {lab_pin.sym} 12540 10400 0 0 {name=l33597 lab=BLB63}
N 12560 10360 12540 10360 {}
C {lab_pin.sym} 12540 10360 0 0 {name=l33598 lab=WL52}
N 12640 10440 12660 10440 {}
C {lab_pin.sym} 12660 10440 0 0 {name=l33599 lab=VDD}
N 12640 10360 12660 10360 {}
C {lab_pin.sym} 12660 10360 0 0 {name=l33600 lab=VSS}
C {bitcell_6t.sym} 12800 10400 0 0 {name=Xr52c64}
N 12760 10440 12740 10440 {}
C {lab_pin.sym} 12740 10440 0 0 {name=l33601 lab=BL64}
N 12760 10400 12740 10400 {}
C {lab_pin.sym} 12740 10400 0 0 {name=l33602 lab=BLB64}
N 12760 10360 12740 10360 {}
C {lab_pin.sym} 12740 10360 0 0 {name=l33603 lab=WL52}
N 12840 10440 12860 10440 {}
C {lab_pin.sym} 12860 10440 0 0 {name=l33604 lab=VDD}
N 12840 10360 12860 10360 {}
C {lab_pin.sym} 12860 10360 0 0 {name=l33605 lab=VSS}
C {bitcell_6t.sym} 13000 10400 0 0 {name=Xr52c65}
N 12960 10440 12940 10440 {}
C {lab_pin.sym} 12940 10440 0 0 {name=l33606 lab=BL65}
N 12960 10400 12940 10400 {}
C {lab_pin.sym} 12940 10400 0 0 {name=l33607 lab=BLB65}
N 12960 10360 12940 10360 {}
C {lab_pin.sym} 12940 10360 0 0 {name=l33608 lab=WL52}
N 13040 10440 13060 10440 {}
C {lab_pin.sym} 13060 10440 0 0 {name=l33609 lab=VDD}
N 13040 10360 13060 10360 {}
C {lab_pin.sym} 13060 10360 0 0 {name=l33610 lab=VSS}
C {bitcell_6t.sym} 13200 10400 0 0 {name=Xr52c66}
N 13160 10440 13140 10440 {}
C {lab_pin.sym} 13140 10440 0 0 {name=l33611 lab=BL66}
N 13160 10400 13140 10400 {}
C {lab_pin.sym} 13140 10400 0 0 {name=l33612 lab=BLB66}
N 13160 10360 13140 10360 {}
C {lab_pin.sym} 13140 10360 0 0 {name=l33613 lab=WL52}
N 13240 10440 13260 10440 {}
C {lab_pin.sym} 13260 10440 0 0 {name=l33614 lab=VDD}
N 13240 10360 13260 10360 {}
C {lab_pin.sym} 13260 10360 0 0 {name=l33615 lab=VSS}
C {bitcell_6t.sym} 13400 10400 0 0 {name=Xr52c67}
N 13360 10440 13340 10440 {}
C {lab_pin.sym} 13340 10440 0 0 {name=l33616 lab=BL67}
N 13360 10400 13340 10400 {}
C {lab_pin.sym} 13340 10400 0 0 {name=l33617 lab=BLB67}
N 13360 10360 13340 10360 {}
C {lab_pin.sym} 13340 10360 0 0 {name=l33618 lab=WL52}
N 13440 10440 13460 10440 {}
C {lab_pin.sym} 13460 10440 0 0 {name=l33619 lab=VDD}
N 13440 10360 13460 10360 {}
C {lab_pin.sym} 13460 10360 0 0 {name=l33620 lab=VSS}
C {bitcell_6t.sym} 13600 10400 0 0 {name=Xr52c68}
N 13560 10440 13540 10440 {}
C {lab_pin.sym} 13540 10440 0 0 {name=l33621 lab=BL68}
N 13560 10400 13540 10400 {}
C {lab_pin.sym} 13540 10400 0 0 {name=l33622 lab=BLB68}
N 13560 10360 13540 10360 {}
C {lab_pin.sym} 13540 10360 0 0 {name=l33623 lab=WL52}
N 13640 10440 13660 10440 {}
C {lab_pin.sym} 13660 10440 0 0 {name=l33624 lab=VDD}
N 13640 10360 13660 10360 {}
C {lab_pin.sym} 13660 10360 0 0 {name=l33625 lab=VSS}
C {bitcell_6t.sym} 13800 10400 0 0 {name=Xr52c69}
N 13760 10440 13740 10440 {}
C {lab_pin.sym} 13740 10440 0 0 {name=l33626 lab=BL69}
N 13760 10400 13740 10400 {}
C {lab_pin.sym} 13740 10400 0 0 {name=l33627 lab=BLB69}
N 13760 10360 13740 10360 {}
C {lab_pin.sym} 13740 10360 0 0 {name=l33628 lab=WL52}
N 13840 10440 13860 10440 {}
C {lab_pin.sym} 13860 10440 0 0 {name=l33629 lab=VDD}
N 13840 10360 13860 10360 {}
C {lab_pin.sym} 13860 10360 0 0 {name=l33630 lab=VSS}
C {bitcell_6t.sym} 14000 10400 0 0 {name=Xr52c70}
N 13960 10440 13940 10440 {}
C {lab_pin.sym} 13940 10440 0 0 {name=l33631 lab=BL70}
N 13960 10400 13940 10400 {}
C {lab_pin.sym} 13940 10400 0 0 {name=l33632 lab=BLB70}
N 13960 10360 13940 10360 {}
C {lab_pin.sym} 13940 10360 0 0 {name=l33633 lab=WL52}
N 14040 10440 14060 10440 {}
C {lab_pin.sym} 14060 10440 0 0 {name=l33634 lab=VDD}
N 14040 10360 14060 10360 {}
C {lab_pin.sym} 14060 10360 0 0 {name=l33635 lab=VSS}
C {bitcell_6t.sym} 14200 10400 0 0 {name=Xr52c71}
N 14160 10440 14140 10440 {}
C {lab_pin.sym} 14140 10440 0 0 {name=l33636 lab=BL71}
N 14160 10400 14140 10400 {}
C {lab_pin.sym} 14140 10400 0 0 {name=l33637 lab=BLB71}
N 14160 10360 14140 10360 {}
C {lab_pin.sym} 14140 10360 0 0 {name=l33638 lab=WL52}
N 14240 10440 14260 10440 {}
C {lab_pin.sym} 14260 10440 0 0 {name=l33639 lab=VDD}
N 14240 10360 14260 10360 {}
C {lab_pin.sym} 14260 10360 0 0 {name=l33640 lab=VSS}
C {bitcell_6t.sym} 14400 10400 0 0 {name=Xr52c72}
N 14360 10440 14340 10440 {}
C {lab_pin.sym} 14340 10440 0 0 {name=l33641 lab=BL72}
N 14360 10400 14340 10400 {}
C {lab_pin.sym} 14340 10400 0 0 {name=l33642 lab=BLB72}
N 14360 10360 14340 10360 {}
C {lab_pin.sym} 14340 10360 0 0 {name=l33643 lab=WL52}
N 14440 10440 14460 10440 {}
C {lab_pin.sym} 14460 10440 0 0 {name=l33644 lab=VDD}
N 14440 10360 14460 10360 {}
C {lab_pin.sym} 14460 10360 0 0 {name=l33645 lab=VSS}
C {bitcell_6t.sym} 14600 10400 0 0 {name=Xr52c73}
N 14560 10440 14540 10440 {}
C {lab_pin.sym} 14540 10440 0 0 {name=l33646 lab=BL73}
N 14560 10400 14540 10400 {}
C {lab_pin.sym} 14540 10400 0 0 {name=l33647 lab=BLB73}
N 14560 10360 14540 10360 {}
C {lab_pin.sym} 14540 10360 0 0 {name=l33648 lab=WL52}
N 14640 10440 14660 10440 {}
C {lab_pin.sym} 14660 10440 0 0 {name=l33649 lab=VDD}
N 14640 10360 14660 10360 {}
C {lab_pin.sym} 14660 10360 0 0 {name=l33650 lab=VSS}
C {bitcell_6t.sym} 14800 10400 0 0 {name=Xr52c74}
N 14760 10440 14740 10440 {}
C {lab_pin.sym} 14740 10440 0 0 {name=l33651 lab=BL74}
N 14760 10400 14740 10400 {}
C {lab_pin.sym} 14740 10400 0 0 {name=l33652 lab=BLB74}
N 14760 10360 14740 10360 {}
C {lab_pin.sym} 14740 10360 0 0 {name=l33653 lab=WL52}
N 14840 10440 14860 10440 {}
C {lab_pin.sym} 14860 10440 0 0 {name=l33654 lab=VDD}
N 14840 10360 14860 10360 {}
C {lab_pin.sym} 14860 10360 0 0 {name=l33655 lab=VSS}
C {bitcell_6t.sym} 15000 10400 0 0 {name=Xr52c75}
N 14960 10440 14940 10440 {}
C {lab_pin.sym} 14940 10440 0 0 {name=l33656 lab=BL75}
N 14960 10400 14940 10400 {}
C {lab_pin.sym} 14940 10400 0 0 {name=l33657 lab=BLB75}
N 14960 10360 14940 10360 {}
C {lab_pin.sym} 14940 10360 0 0 {name=l33658 lab=WL52}
N 15040 10440 15060 10440 {}
C {lab_pin.sym} 15060 10440 0 0 {name=l33659 lab=VDD}
N 15040 10360 15060 10360 {}
C {lab_pin.sym} 15060 10360 0 0 {name=l33660 lab=VSS}
C {bitcell_6t.sym} 15200 10400 0 0 {name=Xr52c76}
N 15160 10440 15140 10440 {}
C {lab_pin.sym} 15140 10440 0 0 {name=l33661 lab=BL76}
N 15160 10400 15140 10400 {}
C {lab_pin.sym} 15140 10400 0 0 {name=l33662 lab=BLB76}
N 15160 10360 15140 10360 {}
C {lab_pin.sym} 15140 10360 0 0 {name=l33663 lab=WL52}
N 15240 10440 15260 10440 {}
C {lab_pin.sym} 15260 10440 0 0 {name=l33664 lab=VDD}
N 15240 10360 15260 10360 {}
C {lab_pin.sym} 15260 10360 0 0 {name=l33665 lab=VSS}
C {bitcell_6t.sym} 15400 10400 0 0 {name=Xr52c77}
N 15360 10440 15340 10440 {}
C {lab_pin.sym} 15340 10440 0 0 {name=l33666 lab=BL77}
N 15360 10400 15340 10400 {}
C {lab_pin.sym} 15340 10400 0 0 {name=l33667 lab=BLB77}
N 15360 10360 15340 10360 {}
C {lab_pin.sym} 15340 10360 0 0 {name=l33668 lab=WL52}
N 15440 10440 15460 10440 {}
C {lab_pin.sym} 15460 10440 0 0 {name=l33669 lab=VDD}
N 15440 10360 15460 10360 {}
C {lab_pin.sym} 15460 10360 0 0 {name=l33670 lab=VSS}
C {bitcell_6t.sym} 15600 10400 0 0 {name=Xr52c78}
N 15560 10440 15540 10440 {}
C {lab_pin.sym} 15540 10440 0 0 {name=l33671 lab=BL78}
N 15560 10400 15540 10400 {}
C {lab_pin.sym} 15540 10400 0 0 {name=l33672 lab=BLB78}
N 15560 10360 15540 10360 {}
C {lab_pin.sym} 15540 10360 0 0 {name=l33673 lab=WL52}
N 15640 10440 15660 10440 {}
C {lab_pin.sym} 15660 10440 0 0 {name=l33674 lab=VDD}
N 15640 10360 15660 10360 {}
C {lab_pin.sym} 15660 10360 0 0 {name=l33675 lab=VSS}
C {bitcell_6t.sym} 15800 10400 0 0 {name=Xr52c79}
N 15760 10440 15740 10440 {}
C {lab_pin.sym} 15740 10440 0 0 {name=l33676 lab=BL79}
N 15760 10400 15740 10400 {}
C {lab_pin.sym} 15740 10400 0 0 {name=l33677 lab=BLB79}
N 15760 10360 15740 10360 {}
C {lab_pin.sym} 15740 10360 0 0 {name=l33678 lab=WL52}
N 15840 10440 15860 10440 {}
C {lab_pin.sym} 15860 10440 0 0 {name=l33679 lab=VDD}
N 15840 10360 15860 10360 {}
C {lab_pin.sym} 15860 10360 0 0 {name=l33680 lab=VSS}
C {bitcell_6t.sym} 16000 10400 0 0 {name=Xr52c80}
N 15960 10440 15940 10440 {}
C {lab_pin.sym} 15940 10440 0 0 {name=l33681 lab=BL80}
N 15960 10400 15940 10400 {}
C {lab_pin.sym} 15940 10400 0 0 {name=l33682 lab=BLB80}
N 15960 10360 15940 10360 {}
C {lab_pin.sym} 15940 10360 0 0 {name=l33683 lab=WL52}
N 16040 10440 16060 10440 {}
C {lab_pin.sym} 16060 10440 0 0 {name=l33684 lab=VDD}
N 16040 10360 16060 10360 {}
C {lab_pin.sym} 16060 10360 0 0 {name=l33685 lab=VSS}
C {bitcell_6t.sym} 16200 10400 0 0 {name=Xr52c81}
N 16160 10440 16140 10440 {}
C {lab_pin.sym} 16140 10440 0 0 {name=l33686 lab=BL81}
N 16160 10400 16140 10400 {}
C {lab_pin.sym} 16140 10400 0 0 {name=l33687 lab=BLB81}
N 16160 10360 16140 10360 {}
C {lab_pin.sym} 16140 10360 0 0 {name=l33688 lab=WL52}
N 16240 10440 16260 10440 {}
C {lab_pin.sym} 16260 10440 0 0 {name=l33689 lab=VDD}
N 16240 10360 16260 10360 {}
C {lab_pin.sym} 16260 10360 0 0 {name=l33690 lab=VSS}
C {bitcell_6t.sym} 16400 10400 0 0 {name=Xr52c82}
N 16360 10440 16340 10440 {}
C {lab_pin.sym} 16340 10440 0 0 {name=l33691 lab=BL82}
N 16360 10400 16340 10400 {}
C {lab_pin.sym} 16340 10400 0 0 {name=l33692 lab=BLB82}
N 16360 10360 16340 10360 {}
C {lab_pin.sym} 16340 10360 0 0 {name=l33693 lab=WL52}
N 16440 10440 16460 10440 {}
C {lab_pin.sym} 16460 10440 0 0 {name=l33694 lab=VDD}
N 16440 10360 16460 10360 {}
C {lab_pin.sym} 16460 10360 0 0 {name=l33695 lab=VSS}
C {bitcell_6t.sym} 16600 10400 0 0 {name=Xr52c83}
N 16560 10440 16540 10440 {}
C {lab_pin.sym} 16540 10440 0 0 {name=l33696 lab=BL83}
N 16560 10400 16540 10400 {}
C {lab_pin.sym} 16540 10400 0 0 {name=l33697 lab=BLB83}
N 16560 10360 16540 10360 {}
C {lab_pin.sym} 16540 10360 0 0 {name=l33698 lab=WL52}
N 16640 10440 16660 10440 {}
C {lab_pin.sym} 16660 10440 0 0 {name=l33699 lab=VDD}
N 16640 10360 16660 10360 {}
C {lab_pin.sym} 16660 10360 0 0 {name=l33700 lab=VSS}
C {bitcell_6t.sym} 16800 10400 0 0 {name=Xr52c84}
N 16760 10440 16740 10440 {}
C {lab_pin.sym} 16740 10440 0 0 {name=l33701 lab=BL84}
N 16760 10400 16740 10400 {}
C {lab_pin.sym} 16740 10400 0 0 {name=l33702 lab=BLB84}
N 16760 10360 16740 10360 {}
C {lab_pin.sym} 16740 10360 0 0 {name=l33703 lab=WL52}
N 16840 10440 16860 10440 {}
C {lab_pin.sym} 16860 10440 0 0 {name=l33704 lab=VDD}
N 16840 10360 16860 10360 {}
C {lab_pin.sym} 16860 10360 0 0 {name=l33705 lab=VSS}
C {bitcell_6t.sym} 17000 10400 0 0 {name=Xr52c85}
N 16960 10440 16940 10440 {}
C {lab_pin.sym} 16940 10440 0 0 {name=l33706 lab=BL85}
N 16960 10400 16940 10400 {}
C {lab_pin.sym} 16940 10400 0 0 {name=l33707 lab=BLB85}
N 16960 10360 16940 10360 {}
C {lab_pin.sym} 16940 10360 0 0 {name=l33708 lab=WL52}
N 17040 10440 17060 10440 {}
C {lab_pin.sym} 17060 10440 0 0 {name=l33709 lab=VDD}
N 17040 10360 17060 10360 {}
C {lab_pin.sym} 17060 10360 0 0 {name=l33710 lab=VSS}
C {bitcell_6t.sym} 17200 10400 0 0 {name=Xr52c86}
N 17160 10440 17140 10440 {}
C {lab_pin.sym} 17140 10440 0 0 {name=l33711 lab=BL86}
N 17160 10400 17140 10400 {}
C {lab_pin.sym} 17140 10400 0 0 {name=l33712 lab=BLB86}
N 17160 10360 17140 10360 {}
C {lab_pin.sym} 17140 10360 0 0 {name=l33713 lab=WL52}
N 17240 10440 17260 10440 {}
C {lab_pin.sym} 17260 10440 0 0 {name=l33714 lab=VDD}
N 17240 10360 17260 10360 {}
C {lab_pin.sym} 17260 10360 0 0 {name=l33715 lab=VSS}
C {bitcell_6t.sym} 17400 10400 0 0 {name=Xr52c87}
N 17360 10440 17340 10440 {}
C {lab_pin.sym} 17340 10440 0 0 {name=l33716 lab=BL87}
N 17360 10400 17340 10400 {}
C {lab_pin.sym} 17340 10400 0 0 {name=l33717 lab=BLB87}
N 17360 10360 17340 10360 {}
C {lab_pin.sym} 17340 10360 0 0 {name=l33718 lab=WL52}
N 17440 10440 17460 10440 {}
C {lab_pin.sym} 17460 10440 0 0 {name=l33719 lab=VDD}
N 17440 10360 17460 10360 {}
C {lab_pin.sym} 17460 10360 0 0 {name=l33720 lab=VSS}
C {bitcell_6t.sym} 17600 10400 0 0 {name=Xr52c88}
N 17560 10440 17540 10440 {}
C {lab_pin.sym} 17540 10440 0 0 {name=l33721 lab=BL88}
N 17560 10400 17540 10400 {}
C {lab_pin.sym} 17540 10400 0 0 {name=l33722 lab=BLB88}
N 17560 10360 17540 10360 {}
C {lab_pin.sym} 17540 10360 0 0 {name=l33723 lab=WL52}
N 17640 10440 17660 10440 {}
C {lab_pin.sym} 17660 10440 0 0 {name=l33724 lab=VDD}
N 17640 10360 17660 10360 {}
C {lab_pin.sym} 17660 10360 0 0 {name=l33725 lab=VSS}
C {bitcell_6t.sym} 17800 10400 0 0 {name=Xr52c89}
N 17760 10440 17740 10440 {}
C {lab_pin.sym} 17740 10440 0 0 {name=l33726 lab=BL89}
N 17760 10400 17740 10400 {}
C {lab_pin.sym} 17740 10400 0 0 {name=l33727 lab=BLB89}
N 17760 10360 17740 10360 {}
C {lab_pin.sym} 17740 10360 0 0 {name=l33728 lab=WL52}
N 17840 10440 17860 10440 {}
C {lab_pin.sym} 17860 10440 0 0 {name=l33729 lab=VDD}
N 17840 10360 17860 10360 {}
C {lab_pin.sym} 17860 10360 0 0 {name=l33730 lab=VSS}
C {bitcell_6t.sym} 18000 10400 0 0 {name=Xr52c90}
N 17960 10440 17940 10440 {}
C {lab_pin.sym} 17940 10440 0 0 {name=l33731 lab=BL90}
N 17960 10400 17940 10400 {}
C {lab_pin.sym} 17940 10400 0 0 {name=l33732 lab=BLB90}
N 17960 10360 17940 10360 {}
C {lab_pin.sym} 17940 10360 0 0 {name=l33733 lab=WL52}
N 18040 10440 18060 10440 {}
C {lab_pin.sym} 18060 10440 0 0 {name=l33734 lab=VDD}
N 18040 10360 18060 10360 {}
C {lab_pin.sym} 18060 10360 0 0 {name=l33735 lab=VSS}
C {bitcell_6t.sym} 18200 10400 0 0 {name=Xr52c91}
N 18160 10440 18140 10440 {}
C {lab_pin.sym} 18140 10440 0 0 {name=l33736 lab=BL91}
N 18160 10400 18140 10400 {}
C {lab_pin.sym} 18140 10400 0 0 {name=l33737 lab=BLB91}
N 18160 10360 18140 10360 {}
C {lab_pin.sym} 18140 10360 0 0 {name=l33738 lab=WL52}
N 18240 10440 18260 10440 {}
C {lab_pin.sym} 18260 10440 0 0 {name=l33739 lab=VDD}
N 18240 10360 18260 10360 {}
C {lab_pin.sym} 18260 10360 0 0 {name=l33740 lab=VSS}
C {bitcell_6t.sym} 18400 10400 0 0 {name=Xr52c92}
N 18360 10440 18340 10440 {}
C {lab_pin.sym} 18340 10440 0 0 {name=l33741 lab=BL92}
N 18360 10400 18340 10400 {}
C {lab_pin.sym} 18340 10400 0 0 {name=l33742 lab=BLB92}
N 18360 10360 18340 10360 {}
C {lab_pin.sym} 18340 10360 0 0 {name=l33743 lab=WL52}
N 18440 10440 18460 10440 {}
C {lab_pin.sym} 18460 10440 0 0 {name=l33744 lab=VDD}
N 18440 10360 18460 10360 {}
C {lab_pin.sym} 18460 10360 0 0 {name=l33745 lab=VSS}
C {bitcell_6t.sym} 18600 10400 0 0 {name=Xr52c93}
N 18560 10440 18540 10440 {}
C {lab_pin.sym} 18540 10440 0 0 {name=l33746 lab=BL93}
N 18560 10400 18540 10400 {}
C {lab_pin.sym} 18540 10400 0 0 {name=l33747 lab=BLB93}
N 18560 10360 18540 10360 {}
C {lab_pin.sym} 18540 10360 0 0 {name=l33748 lab=WL52}
N 18640 10440 18660 10440 {}
C {lab_pin.sym} 18660 10440 0 0 {name=l33749 lab=VDD}
N 18640 10360 18660 10360 {}
C {lab_pin.sym} 18660 10360 0 0 {name=l33750 lab=VSS}
C {bitcell_6t.sym} 18800 10400 0 0 {name=Xr52c94}
N 18760 10440 18740 10440 {}
C {lab_pin.sym} 18740 10440 0 0 {name=l33751 lab=BL94}
N 18760 10400 18740 10400 {}
C {lab_pin.sym} 18740 10400 0 0 {name=l33752 lab=BLB94}
N 18760 10360 18740 10360 {}
C {lab_pin.sym} 18740 10360 0 0 {name=l33753 lab=WL52}
N 18840 10440 18860 10440 {}
C {lab_pin.sym} 18860 10440 0 0 {name=l33754 lab=VDD}
N 18840 10360 18860 10360 {}
C {lab_pin.sym} 18860 10360 0 0 {name=l33755 lab=VSS}
C {bitcell_6t.sym} 19000 10400 0 0 {name=Xr52c95}
N 18960 10440 18940 10440 {}
C {lab_pin.sym} 18940 10440 0 0 {name=l33756 lab=BL95}
N 18960 10400 18940 10400 {}
C {lab_pin.sym} 18940 10400 0 0 {name=l33757 lab=BLB95}
N 18960 10360 18940 10360 {}
C {lab_pin.sym} 18940 10360 0 0 {name=l33758 lab=WL52}
N 19040 10440 19060 10440 {}
C {lab_pin.sym} 19060 10440 0 0 {name=l33759 lab=VDD}
N 19040 10360 19060 10360 {}
C {lab_pin.sym} 19060 10360 0 0 {name=l33760 lab=VSS}
C {bitcell_6t.sym} 19200 10400 0 0 {name=Xr52c96}
N 19160 10440 19140 10440 {}
C {lab_pin.sym} 19140 10440 0 0 {name=l33761 lab=BL96}
N 19160 10400 19140 10400 {}
C {lab_pin.sym} 19140 10400 0 0 {name=l33762 lab=BLB96}
N 19160 10360 19140 10360 {}
C {lab_pin.sym} 19140 10360 0 0 {name=l33763 lab=WL52}
N 19240 10440 19260 10440 {}
C {lab_pin.sym} 19260 10440 0 0 {name=l33764 lab=VDD}
N 19240 10360 19260 10360 {}
C {lab_pin.sym} 19260 10360 0 0 {name=l33765 lab=VSS}
C {bitcell_6t.sym} 19400 10400 0 0 {name=Xr52c97}
N 19360 10440 19340 10440 {}
C {lab_pin.sym} 19340 10440 0 0 {name=l33766 lab=BL97}
N 19360 10400 19340 10400 {}
C {lab_pin.sym} 19340 10400 0 0 {name=l33767 lab=BLB97}
N 19360 10360 19340 10360 {}
C {lab_pin.sym} 19340 10360 0 0 {name=l33768 lab=WL52}
N 19440 10440 19460 10440 {}
C {lab_pin.sym} 19460 10440 0 0 {name=l33769 lab=VDD}
N 19440 10360 19460 10360 {}
C {lab_pin.sym} 19460 10360 0 0 {name=l33770 lab=VSS}
C {bitcell_6t.sym} 19600 10400 0 0 {name=Xr52c98}
N 19560 10440 19540 10440 {}
C {lab_pin.sym} 19540 10440 0 0 {name=l33771 lab=BL98}
N 19560 10400 19540 10400 {}
C {lab_pin.sym} 19540 10400 0 0 {name=l33772 lab=BLB98}
N 19560 10360 19540 10360 {}
C {lab_pin.sym} 19540 10360 0 0 {name=l33773 lab=WL52}
N 19640 10440 19660 10440 {}
C {lab_pin.sym} 19660 10440 0 0 {name=l33774 lab=VDD}
N 19640 10360 19660 10360 {}
C {lab_pin.sym} 19660 10360 0 0 {name=l33775 lab=VSS}
C {bitcell_6t.sym} 19800 10400 0 0 {name=Xr52c99}
N 19760 10440 19740 10440 {}
C {lab_pin.sym} 19740 10440 0 0 {name=l33776 lab=BL99}
N 19760 10400 19740 10400 {}
C {lab_pin.sym} 19740 10400 0 0 {name=l33777 lab=BLB99}
N 19760 10360 19740 10360 {}
C {lab_pin.sym} 19740 10360 0 0 {name=l33778 lab=WL52}
N 19840 10440 19860 10440 {}
C {lab_pin.sym} 19860 10440 0 0 {name=l33779 lab=VDD}
N 19840 10360 19860 10360 {}
C {lab_pin.sym} 19860 10360 0 0 {name=l33780 lab=VSS}
C {bitcell_6t.sym} 20000 10400 0 0 {name=Xr52c100}
N 19960 10440 19940 10440 {}
C {lab_pin.sym} 19940 10440 0 0 {name=l33781 lab=BL100}
N 19960 10400 19940 10400 {}
C {lab_pin.sym} 19940 10400 0 0 {name=l33782 lab=BLB100}
N 19960 10360 19940 10360 {}
C {lab_pin.sym} 19940 10360 0 0 {name=l33783 lab=WL52}
N 20040 10440 20060 10440 {}
C {lab_pin.sym} 20060 10440 0 0 {name=l33784 lab=VDD}
N 20040 10360 20060 10360 {}
C {lab_pin.sym} 20060 10360 0 0 {name=l33785 lab=VSS}
C {bitcell_6t.sym} 20200 10400 0 0 {name=Xr52c101}
N 20160 10440 20140 10440 {}
C {lab_pin.sym} 20140 10440 0 0 {name=l33786 lab=BL101}
N 20160 10400 20140 10400 {}
C {lab_pin.sym} 20140 10400 0 0 {name=l33787 lab=BLB101}
N 20160 10360 20140 10360 {}
C {lab_pin.sym} 20140 10360 0 0 {name=l33788 lab=WL52}
N 20240 10440 20260 10440 {}
C {lab_pin.sym} 20260 10440 0 0 {name=l33789 lab=VDD}
N 20240 10360 20260 10360 {}
C {lab_pin.sym} 20260 10360 0 0 {name=l33790 lab=VSS}
C {bitcell_6t.sym} 20400 10400 0 0 {name=Xr52c102}
N 20360 10440 20340 10440 {}
C {lab_pin.sym} 20340 10440 0 0 {name=l33791 lab=BL102}
N 20360 10400 20340 10400 {}
C {lab_pin.sym} 20340 10400 0 0 {name=l33792 lab=BLB102}
N 20360 10360 20340 10360 {}
C {lab_pin.sym} 20340 10360 0 0 {name=l33793 lab=WL52}
N 20440 10440 20460 10440 {}
C {lab_pin.sym} 20460 10440 0 0 {name=l33794 lab=VDD}
N 20440 10360 20460 10360 {}
C {lab_pin.sym} 20460 10360 0 0 {name=l33795 lab=VSS}
C {bitcell_6t.sym} 20600 10400 0 0 {name=Xr52c103}
N 20560 10440 20540 10440 {}
C {lab_pin.sym} 20540 10440 0 0 {name=l33796 lab=BL103}
N 20560 10400 20540 10400 {}
C {lab_pin.sym} 20540 10400 0 0 {name=l33797 lab=BLB103}
N 20560 10360 20540 10360 {}
C {lab_pin.sym} 20540 10360 0 0 {name=l33798 lab=WL52}
N 20640 10440 20660 10440 {}
C {lab_pin.sym} 20660 10440 0 0 {name=l33799 lab=VDD}
N 20640 10360 20660 10360 {}
C {lab_pin.sym} 20660 10360 0 0 {name=l33800 lab=VSS}
C {bitcell_6t.sym} 20800 10400 0 0 {name=Xr52c104}
N 20760 10440 20740 10440 {}
C {lab_pin.sym} 20740 10440 0 0 {name=l33801 lab=BL104}
N 20760 10400 20740 10400 {}
C {lab_pin.sym} 20740 10400 0 0 {name=l33802 lab=BLB104}
N 20760 10360 20740 10360 {}
C {lab_pin.sym} 20740 10360 0 0 {name=l33803 lab=WL52}
N 20840 10440 20860 10440 {}
C {lab_pin.sym} 20860 10440 0 0 {name=l33804 lab=VDD}
N 20840 10360 20860 10360 {}
C {lab_pin.sym} 20860 10360 0 0 {name=l33805 lab=VSS}
C {bitcell_6t.sym} 21000 10400 0 0 {name=Xr52c105}
N 20960 10440 20940 10440 {}
C {lab_pin.sym} 20940 10440 0 0 {name=l33806 lab=BL105}
N 20960 10400 20940 10400 {}
C {lab_pin.sym} 20940 10400 0 0 {name=l33807 lab=BLB105}
N 20960 10360 20940 10360 {}
C {lab_pin.sym} 20940 10360 0 0 {name=l33808 lab=WL52}
N 21040 10440 21060 10440 {}
C {lab_pin.sym} 21060 10440 0 0 {name=l33809 lab=VDD}
N 21040 10360 21060 10360 {}
C {lab_pin.sym} 21060 10360 0 0 {name=l33810 lab=VSS}
C {bitcell_6t.sym} 21200 10400 0 0 {name=Xr52c106}
N 21160 10440 21140 10440 {}
C {lab_pin.sym} 21140 10440 0 0 {name=l33811 lab=BL106}
N 21160 10400 21140 10400 {}
C {lab_pin.sym} 21140 10400 0 0 {name=l33812 lab=BLB106}
N 21160 10360 21140 10360 {}
C {lab_pin.sym} 21140 10360 0 0 {name=l33813 lab=WL52}
N 21240 10440 21260 10440 {}
C {lab_pin.sym} 21260 10440 0 0 {name=l33814 lab=VDD}
N 21240 10360 21260 10360 {}
C {lab_pin.sym} 21260 10360 0 0 {name=l33815 lab=VSS}
C {bitcell_6t.sym} 21400 10400 0 0 {name=Xr52c107}
N 21360 10440 21340 10440 {}
C {lab_pin.sym} 21340 10440 0 0 {name=l33816 lab=BL107}
N 21360 10400 21340 10400 {}
C {lab_pin.sym} 21340 10400 0 0 {name=l33817 lab=BLB107}
N 21360 10360 21340 10360 {}
C {lab_pin.sym} 21340 10360 0 0 {name=l33818 lab=WL52}
N 21440 10440 21460 10440 {}
C {lab_pin.sym} 21460 10440 0 0 {name=l33819 lab=VDD}
N 21440 10360 21460 10360 {}
C {lab_pin.sym} 21460 10360 0 0 {name=l33820 lab=VSS}
C {bitcell_6t.sym} 21600 10400 0 0 {name=Xr52c108}
N 21560 10440 21540 10440 {}
C {lab_pin.sym} 21540 10440 0 0 {name=l33821 lab=BL108}
N 21560 10400 21540 10400 {}
C {lab_pin.sym} 21540 10400 0 0 {name=l33822 lab=BLB108}
N 21560 10360 21540 10360 {}
C {lab_pin.sym} 21540 10360 0 0 {name=l33823 lab=WL52}
N 21640 10440 21660 10440 {}
C {lab_pin.sym} 21660 10440 0 0 {name=l33824 lab=VDD}
N 21640 10360 21660 10360 {}
C {lab_pin.sym} 21660 10360 0 0 {name=l33825 lab=VSS}
C {bitcell_6t.sym} 21800 10400 0 0 {name=Xr52c109}
N 21760 10440 21740 10440 {}
C {lab_pin.sym} 21740 10440 0 0 {name=l33826 lab=BL109}
N 21760 10400 21740 10400 {}
C {lab_pin.sym} 21740 10400 0 0 {name=l33827 lab=BLB109}
N 21760 10360 21740 10360 {}
C {lab_pin.sym} 21740 10360 0 0 {name=l33828 lab=WL52}
N 21840 10440 21860 10440 {}
C {lab_pin.sym} 21860 10440 0 0 {name=l33829 lab=VDD}
N 21840 10360 21860 10360 {}
C {lab_pin.sym} 21860 10360 0 0 {name=l33830 lab=VSS}
C {bitcell_6t.sym} 22000 10400 0 0 {name=Xr52c110}
N 21960 10440 21940 10440 {}
C {lab_pin.sym} 21940 10440 0 0 {name=l33831 lab=BL110}
N 21960 10400 21940 10400 {}
C {lab_pin.sym} 21940 10400 0 0 {name=l33832 lab=BLB110}
N 21960 10360 21940 10360 {}
C {lab_pin.sym} 21940 10360 0 0 {name=l33833 lab=WL52}
N 22040 10440 22060 10440 {}
C {lab_pin.sym} 22060 10440 0 0 {name=l33834 lab=VDD}
N 22040 10360 22060 10360 {}
C {lab_pin.sym} 22060 10360 0 0 {name=l33835 lab=VSS}
C {bitcell_6t.sym} 22200 10400 0 0 {name=Xr52c111}
N 22160 10440 22140 10440 {}
C {lab_pin.sym} 22140 10440 0 0 {name=l33836 lab=BL111}
N 22160 10400 22140 10400 {}
C {lab_pin.sym} 22140 10400 0 0 {name=l33837 lab=BLB111}
N 22160 10360 22140 10360 {}
C {lab_pin.sym} 22140 10360 0 0 {name=l33838 lab=WL52}
N 22240 10440 22260 10440 {}
C {lab_pin.sym} 22260 10440 0 0 {name=l33839 lab=VDD}
N 22240 10360 22260 10360 {}
C {lab_pin.sym} 22260 10360 0 0 {name=l33840 lab=VSS}
C {bitcell_6t.sym} 22400 10400 0 0 {name=Xr52c112}
N 22360 10440 22340 10440 {}
C {lab_pin.sym} 22340 10440 0 0 {name=l33841 lab=BL112}
N 22360 10400 22340 10400 {}
C {lab_pin.sym} 22340 10400 0 0 {name=l33842 lab=BLB112}
N 22360 10360 22340 10360 {}
C {lab_pin.sym} 22340 10360 0 0 {name=l33843 lab=WL52}
N 22440 10440 22460 10440 {}
C {lab_pin.sym} 22460 10440 0 0 {name=l33844 lab=VDD}
N 22440 10360 22460 10360 {}
C {lab_pin.sym} 22460 10360 0 0 {name=l33845 lab=VSS}
C {bitcell_6t.sym} 22600 10400 0 0 {name=Xr52c113}
N 22560 10440 22540 10440 {}
C {lab_pin.sym} 22540 10440 0 0 {name=l33846 lab=BL113}
N 22560 10400 22540 10400 {}
C {lab_pin.sym} 22540 10400 0 0 {name=l33847 lab=BLB113}
N 22560 10360 22540 10360 {}
C {lab_pin.sym} 22540 10360 0 0 {name=l33848 lab=WL52}
N 22640 10440 22660 10440 {}
C {lab_pin.sym} 22660 10440 0 0 {name=l33849 lab=VDD}
N 22640 10360 22660 10360 {}
C {lab_pin.sym} 22660 10360 0 0 {name=l33850 lab=VSS}
C {bitcell_6t.sym} 22800 10400 0 0 {name=Xr52c114}
N 22760 10440 22740 10440 {}
C {lab_pin.sym} 22740 10440 0 0 {name=l33851 lab=BL114}
N 22760 10400 22740 10400 {}
C {lab_pin.sym} 22740 10400 0 0 {name=l33852 lab=BLB114}
N 22760 10360 22740 10360 {}
C {lab_pin.sym} 22740 10360 0 0 {name=l33853 lab=WL52}
N 22840 10440 22860 10440 {}
C {lab_pin.sym} 22860 10440 0 0 {name=l33854 lab=VDD}
N 22840 10360 22860 10360 {}
C {lab_pin.sym} 22860 10360 0 0 {name=l33855 lab=VSS}
C {bitcell_6t.sym} 23000 10400 0 0 {name=Xr52c115}
N 22960 10440 22940 10440 {}
C {lab_pin.sym} 22940 10440 0 0 {name=l33856 lab=BL115}
N 22960 10400 22940 10400 {}
C {lab_pin.sym} 22940 10400 0 0 {name=l33857 lab=BLB115}
N 22960 10360 22940 10360 {}
C {lab_pin.sym} 22940 10360 0 0 {name=l33858 lab=WL52}
N 23040 10440 23060 10440 {}
C {lab_pin.sym} 23060 10440 0 0 {name=l33859 lab=VDD}
N 23040 10360 23060 10360 {}
C {lab_pin.sym} 23060 10360 0 0 {name=l33860 lab=VSS}
C {bitcell_6t.sym} 23200 10400 0 0 {name=Xr52c116}
N 23160 10440 23140 10440 {}
C {lab_pin.sym} 23140 10440 0 0 {name=l33861 lab=BL116}
N 23160 10400 23140 10400 {}
C {lab_pin.sym} 23140 10400 0 0 {name=l33862 lab=BLB116}
N 23160 10360 23140 10360 {}
C {lab_pin.sym} 23140 10360 0 0 {name=l33863 lab=WL52}
N 23240 10440 23260 10440 {}
C {lab_pin.sym} 23260 10440 0 0 {name=l33864 lab=VDD}
N 23240 10360 23260 10360 {}
C {lab_pin.sym} 23260 10360 0 0 {name=l33865 lab=VSS}
C {bitcell_6t.sym} 23400 10400 0 0 {name=Xr52c117}
N 23360 10440 23340 10440 {}
C {lab_pin.sym} 23340 10440 0 0 {name=l33866 lab=BL117}
N 23360 10400 23340 10400 {}
C {lab_pin.sym} 23340 10400 0 0 {name=l33867 lab=BLB117}
N 23360 10360 23340 10360 {}
C {lab_pin.sym} 23340 10360 0 0 {name=l33868 lab=WL52}
N 23440 10440 23460 10440 {}
C {lab_pin.sym} 23460 10440 0 0 {name=l33869 lab=VDD}
N 23440 10360 23460 10360 {}
C {lab_pin.sym} 23460 10360 0 0 {name=l33870 lab=VSS}
C {bitcell_6t.sym} 23600 10400 0 0 {name=Xr52c118}
N 23560 10440 23540 10440 {}
C {lab_pin.sym} 23540 10440 0 0 {name=l33871 lab=BL118}
N 23560 10400 23540 10400 {}
C {lab_pin.sym} 23540 10400 0 0 {name=l33872 lab=BLB118}
N 23560 10360 23540 10360 {}
C {lab_pin.sym} 23540 10360 0 0 {name=l33873 lab=WL52}
N 23640 10440 23660 10440 {}
C {lab_pin.sym} 23660 10440 0 0 {name=l33874 lab=VDD}
N 23640 10360 23660 10360 {}
C {lab_pin.sym} 23660 10360 0 0 {name=l33875 lab=VSS}
C {bitcell_6t.sym} 23800 10400 0 0 {name=Xr52c119}
N 23760 10440 23740 10440 {}
C {lab_pin.sym} 23740 10440 0 0 {name=l33876 lab=BL119}
N 23760 10400 23740 10400 {}
C {lab_pin.sym} 23740 10400 0 0 {name=l33877 lab=BLB119}
N 23760 10360 23740 10360 {}
C {lab_pin.sym} 23740 10360 0 0 {name=l33878 lab=WL52}
N 23840 10440 23860 10440 {}
C {lab_pin.sym} 23860 10440 0 0 {name=l33879 lab=VDD}
N 23840 10360 23860 10360 {}
C {lab_pin.sym} 23860 10360 0 0 {name=l33880 lab=VSS}
C {bitcell_6t.sym} 24000 10400 0 0 {name=Xr52c120}
N 23960 10440 23940 10440 {}
C {lab_pin.sym} 23940 10440 0 0 {name=l33881 lab=BL120}
N 23960 10400 23940 10400 {}
C {lab_pin.sym} 23940 10400 0 0 {name=l33882 lab=BLB120}
N 23960 10360 23940 10360 {}
C {lab_pin.sym} 23940 10360 0 0 {name=l33883 lab=WL52}
N 24040 10440 24060 10440 {}
C {lab_pin.sym} 24060 10440 0 0 {name=l33884 lab=VDD}
N 24040 10360 24060 10360 {}
C {lab_pin.sym} 24060 10360 0 0 {name=l33885 lab=VSS}
C {bitcell_6t.sym} 24200 10400 0 0 {name=Xr52c121}
N 24160 10440 24140 10440 {}
C {lab_pin.sym} 24140 10440 0 0 {name=l33886 lab=BL121}
N 24160 10400 24140 10400 {}
C {lab_pin.sym} 24140 10400 0 0 {name=l33887 lab=BLB121}
N 24160 10360 24140 10360 {}
C {lab_pin.sym} 24140 10360 0 0 {name=l33888 lab=WL52}
N 24240 10440 24260 10440 {}
C {lab_pin.sym} 24260 10440 0 0 {name=l33889 lab=VDD}
N 24240 10360 24260 10360 {}
C {lab_pin.sym} 24260 10360 0 0 {name=l33890 lab=VSS}
C {bitcell_6t.sym} 24400 10400 0 0 {name=Xr52c122}
N 24360 10440 24340 10440 {}
C {lab_pin.sym} 24340 10440 0 0 {name=l33891 lab=BL122}
N 24360 10400 24340 10400 {}
C {lab_pin.sym} 24340 10400 0 0 {name=l33892 lab=BLB122}
N 24360 10360 24340 10360 {}
C {lab_pin.sym} 24340 10360 0 0 {name=l33893 lab=WL52}
N 24440 10440 24460 10440 {}
C {lab_pin.sym} 24460 10440 0 0 {name=l33894 lab=VDD}
N 24440 10360 24460 10360 {}
C {lab_pin.sym} 24460 10360 0 0 {name=l33895 lab=VSS}
C {bitcell_6t.sym} 24600 10400 0 0 {name=Xr52c123}
N 24560 10440 24540 10440 {}
C {lab_pin.sym} 24540 10440 0 0 {name=l33896 lab=BL123}
N 24560 10400 24540 10400 {}
C {lab_pin.sym} 24540 10400 0 0 {name=l33897 lab=BLB123}
N 24560 10360 24540 10360 {}
C {lab_pin.sym} 24540 10360 0 0 {name=l33898 lab=WL52}
N 24640 10440 24660 10440 {}
C {lab_pin.sym} 24660 10440 0 0 {name=l33899 lab=VDD}
N 24640 10360 24660 10360 {}
C {lab_pin.sym} 24660 10360 0 0 {name=l33900 lab=VSS}
C {bitcell_6t.sym} 24800 10400 0 0 {name=Xr52c124}
N 24760 10440 24740 10440 {}
C {lab_pin.sym} 24740 10440 0 0 {name=l33901 lab=BL124}
N 24760 10400 24740 10400 {}
C {lab_pin.sym} 24740 10400 0 0 {name=l33902 lab=BLB124}
N 24760 10360 24740 10360 {}
C {lab_pin.sym} 24740 10360 0 0 {name=l33903 lab=WL52}
N 24840 10440 24860 10440 {}
C {lab_pin.sym} 24860 10440 0 0 {name=l33904 lab=VDD}
N 24840 10360 24860 10360 {}
C {lab_pin.sym} 24860 10360 0 0 {name=l33905 lab=VSS}
C {bitcell_6t.sym} 25000 10400 0 0 {name=Xr52c125}
N 24960 10440 24940 10440 {}
C {lab_pin.sym} 24940 10440 0 0 {name=l33906 lab=BL125}
N 24960 10400 24940 10400 {}
C {lab_pin.sym} 24940 10400 0 0 {name=l33907 lab=BLB125}
N 24960 10360 24940 10360 {}
C {lab_pin.sym} 24940 10360 0 0 {name=l33908 lab=WL52}
N 25040 10440 25060 10440 {}
C {lab_pin.sym} 25060 10440 0 0 {name=l33909 lab=VDD}
N 25040 10360 25060 10360 {}
C {lab_pin.sym} 25060 10360 0 0 {name=l33910 lab=VSS}
C {bitcell_6t.sym} 25200 10400 0 0 {name=Xr52c126}
N 25160 10440 25140 10440 {}
C {lab_pin.sym} 25140 10440 0 0 {name=l33911 lab=BL126}
N 25160 10400 25140 10400 {}
C {lab_pin.sym} 25140 10400 0 0 {name=l33912 lab=BLB126}
N 25160 10360 25140 10360 {}
C {lab_pin.sym} 25140 10360 0 0 {name=l33913 lab=WL52}
N 25240 10440 25260 10440 {}
C {lab_pin.sym} 25260 10440 0 0 {name=l33914 lab=VDD}
N 25240 10360 25260 10360 {}
C {lab_pin.sym} 25260 10360 0 0 {name=l33915 lab=VSS}
C {bitcell_6t.sym} 25400 10400 0 0 {name=Xr52c127}
N 25360 10440 25340 10440 {}
C {lab_pin.sym} 25340 10440 0 0 {name=l33916 lab=BL127}
N 25360 10400 25340 10400 {}
C {lab_pin.sym} 25340 10400 0 0 {name=l33917 lab=BLB127}
N 25360 10360 25340 10360 {}
C {lab_pin.sym} 25340 10360 0 0 {name=l33918 lab=WL52}
N 25440 10440 25460 10440 {}
C {lab_pin.sym} 25460 10440 0 0 {name=l33919 lab=VDD}
N 25440 10360 25460 10360 {}
C {lab_pin.sym} 25460 10360 0 0 {name=l33920 lab=VSS}
C {bitcell_6t.sym} 0 10600 0 0 {name=Xr53c0}
N -40 10640 -60 10640 {}
C {lab_pin.sym} -60 10640 0 0 {name=l33921 lab=BL0}
N -40 10600 -60 10600 {}
C {lab_pin.sym} -60 10600 0 0 {name=l33922 lab=BLB0}
N -40 10560 -60 10560 {}
C {lab_pin.sym} -60 10560 0 0 {name=l33923 lab=WL53}
N 40 10640 60 10640 {}
C {lab_pin.sym} 60 10640 0 0 {name=l33924 lab=VDD}
N 40 10560 60 10560 {}
C {lab_pin.sym} 60 10560 0 0 {name=l33925 lab=VSS}
C {bitcell_6t.sym} 200 10600 0 0 {name=Xr53c1}
N 160 10640 140 10640 {}
C {lab_pin.sym} 140 10640 0 0 {name=l33926 lab=BL1}
N 160 10600 140 10600 {}
C {lab_pin.sym} 140 10600 0 0 {name=l33927 lab=BLB1}
N 160 10560 140 10560 {}
C {lab_pin.sym} 140 10560 0 0 {name=l33928 lab=WL53}
N 240 10640 260 10640 {}
C {lab_pin.sym} 260 10640 0 0 {name=l33929 lab=VDD}
N 240 10560 260 10560 {}
C {lab_pin.sym} 260 10560 0 0 {name=l33930 lab=VSS}
C {bitcell_6t.sym} 400 10600 0 0 {name=Xr53c2}
N 360 10640 340 10640 {}
C {lab_pin.sym} 340 10640 0 0 {name=l33931 lab=BL2}
N 360 10600 340 10600 {}
C {lab_pin.sym} 340 10600 0 0 {name=l33932 lab=BLB2}
N 360 10560 340 10560 {}
C {lab_pin.sym} 340 10560 0 0 {name=l33933 lab=WL53}
N 440 10640 460 10640 {}
C {lab_pin.sym} 460 10640 0 0 {name=l33934 lab=VDD}
N 440 10560 460 10560 {}
C {lab_pin.sym} 460 10560 0 0 {name=l33935 lab=VSS}
C {bitcell_6t.sym} 600 10600 0 0 {name=Xr53c3}
N 560 10640 540 10640 {}
C {lab_pin.sym} 540 10640 0 0 {name=l33936 lab=BL3}
N 560 10600 540 10600 {}
C {lab_pin.sym} 540 10600 0 0 {name=l33937 lab=BLB3}
N 560 10560 540 10560 {}
C {lab_pin.sym} 540 10560 0 0 {name=l33938 lab=WL53}
N 640 10640 660 10640 {}
C {lab_pin.sym} 660 10640 0 0 {name=l33939 lab=VDD}
N 640 10560 660 10560 {}
C {lab_pin.sym} 660 10560 0 0 {name=l33940 lab=VSS}
C {bitcell_6t.sym} 800 10600 0 0 {name=Xr53c4}
N 760 10640 740 10640 {}
C {lab_pin.sym} 740 10640 0 0 {name=l33941 lab=BL4}
N 760 10600 740 10600 {}
C {lab_pin.sym} 740 10600 0 0 {name=l33942 lab=BLB4}
N 760 10560 740 10560 {}
C {lab_pin.sym} 740 10560 0 0 {name=l33943 lab=WL53}
N 840 10640 860 10640 {}
C {lab_pin.sym} 860 10640 0 0 {name=l33944 lab=VDD}
N 840 10560 860 10560 {}
C {lab_pin.sym} 860 10560 0 0 {name=l33945 lab=VSS}
C {bitcell_6t.sym} 1000 10600 0 0 {name=Xr53c5}
N 960 10640 940 10640 {}
C {lab_pin.sym} 940 10640 0 0 {name=l33946 lab=BL5}
N 960 10600 940 10600 {}
C {lab_pin.sym} 940 10600 0 0 {name=l33947 lab=BLB5}
N 960 10560 940 10560 {}
C {lab_pin.sym} 940 10560 0 0 {name=l33948 lab=WL53}
N 1040 10640 1060 10640 {}
C {lab_pin.sym} 1060 10640 0 0 {name=l33949 lab=VDD}
N 1040 10560 1060 10560 {}
C {lab_pin.sym} 1060 10560 0 0 {name=l33950 lab=VSS}
C {bitcell_6t.sym} 1200 10600 0 0 {name=Xr53c6}
N 1160 10640 1140 10640 {}
C {lab_pin.sym} 1140 10640 0 0 {name=l33951 lab=BL6}
N 1160 10600 1140 10600 {}
C {lab_pin.sym} 1140 10600 0 0 {name=l33952 lab=BLB6}
N 1160 10560 1140 10560 {}
C {lab_pin.sym} 1140 10560 0 0 {name=l33953 lab=WL53}
N 1240 10640 1260 10640 {}
C {lab_pin.sym} 1260 10640 0 0 {name=l33954 lab=VDD}
N 1240 10560 1260 10560 {}
C {lab_pin.sym} 1260 10560 0 0 {name=l33955 lab=VSS}
C {bitcell_6t.sym} 1400 10600 0 0 {name=Xr53c7}
N 1360 10640 1340 10640 {}
C {lab_pin.sym} 1340 10640 0 0 {name=l33956 lab=BL7}
N 1360 10600 1340 10600 {}
C {lab_pin.sym} 1340 10600 0 0 {name=l33957 lab=BLB7}
N 1360 10560 1340 10560 {}
C {lab_pin.sym} 1340 10560 0 0 {name=l33958 lab=WL53}
N 1440 10640 1460 10640 {}
C {lab_pin.sym} 1460 10640 0 0 {name=l33959 lab=VDD}
N 1440 10560 1460 10560 {}
C {lab_pin.sym} 1460 10560 0 0 {name=l33960 lab=VSS}
C {bitcell_6t.sym} 1600 10600 0 0 {name=Xr53c8}
N 1560 10640 1540 10640 {}
C {lab_pin.sym} 1540 10640 0 0 {name=l33961 lab=BL8}
N 1560 10600 1540 10600 {}
C {lab_pin.sym} 1540 10600 0 0 {name=l33962 lab=BLB8}
N 1560 10560 1540 10560 {}
C {lab_pin.sym} 1540 10560 0 0 {name=l33963 lab=WL53}
N 1640 10640 1660 10640 {}
C {lab_pin.sym} 1660 10640 0 0 {name=l33964 lab=VDD}
N 1640 10560 1660 10560 {}
C {lab_pin.sym} 1660 10560 0 0 {name=l33965 lab=VSS}
C {bitcell_6t.sym} 1800 10600 0 0 {name=Xr53c9}
N 1760 10640 1740 10640 {}
C {lab_pin.sym} 1740 10640 0 0 {name=l33966 lab=BL9}
N 1760 10600 1740 10600 {}
C {lab_pin.sym} 1740 10600 0 0 {name=l33967 lab=BLB9}
N 1760 10560 1740 10560 {}
C {lab_pin.sym} 1740 10560 0 0 {name=l33968 lab=WL53}
N 1840 10640 1860 10640 {}
C {lab_pin.sym} 1860 10640 0 0 {name=l33969 lab=VDD}
N 1840 10560 1860 10560 {}
C {lab_pin.sym} 1860 10560 0 0 {name=l33970 lab=VSS}
C {bitcell_6t.sym} 2000 10600 0 0 {name=Xr53c10}
N 1960 10640 1940 10640 {}
C {lab_pin.sym} 1940 10640 0 0 {name=l33971 lab=BL10}
N 1960 10600 1940 10600 {}
C {lab_pin.sym} 1940 10600 0 0 {name=l33972 lab=BLB10}
N 1960 10560 1940 10560 {}
C {lab_pin.sym} 1940 10560 0 0 {name=l33973 lab=WL53}
N 2040 10640 2060 10640 {}
C {lab_pin.sym} 2060 10640 0 0 {name=l33974 lab=VDD}
N 2040 10560 2060 10560 {}
C {lab_pin.sym} 2060 10560 0 0 {name=l33975 lab=VSS}
C {bitcell_6t.sym} 2200 10600 0 0 {name=Xr53c11}
N 2160 10640 2140 10640 {}
C {lab_pin.sym} 2140 10640 0 0 {name=l33976 lab=BL11}
N 2160 10600 2140 10600 {}
C {lab_pin.sym} 2140 10600 0 0 {name=l33977 lab=BLB11}
N 2160 10560 2140 10560 {}
C {lab_pin.sym} 2140 10560 0 0 {name=l33978 lab=WL53}
N 2240 10640 2260 10640 {}
C {lab_pin.sym} 2260 10640 0 0 {name=l33979 lab=VDD}
N 2240 10560 2260 10560 {}
C {lab_pin.sym} 2260 10560 0 0 {name=l33980 lab=VSS}
C {bitcell_6t.sym} 2400 10600 0 0 {name=Xr53c12}
N 2360 10640 2340 10640 {}
C {lab_pin.sym} 2340 10640 0 0 {name=l33981 lab=BL12}
N 2360 10600 2340 10600 {}
C {lab_pin.sym} 2340 10600 0 0 {name=l33982 lab=BLB12}
N 2360 10560 2340 10560 {}
C {lab_pin.sym} 2340 10560 0 0 {name=l33983 lab=WL53}
N 2440 10640 2460 10640 {}
C {lab_pin.sym} 2460 10640 0 0 {name=l33984 lab=VDD}
N 2440 10560 2460 10560 {}
C {lab_pin.sym} 2460 10560 0 0 {name=l33985 lab=VSS}
C {bitcell_6t.sym} 2600 10600 0 0 {name=Xr53c13}
N 2560 10640 2540 10640 {}
C {lab_pin.sym} 2540 10640 0 0 {name=l33986 lab=BL13}
N 2560 10600 2540 10600 {}
C {lab_pin.sym} 2540 10600 0 0 {name=l33987 lab=BLB13}
N 2560 10560 2540 10560 {}
C {lab_pin.sym} 2540 10560 0 0 {name=l33988 lab=WL53}
N 2640 10640 2660 10640 {}
C {lab_pin.sym} 2660 10640 0 0 {name=l33989 lab=VDD}
N 2640 10560 2660 10560 {}
C {lab_pin.sym} 2660 10560 0 0 {name=l33990 lab=VSS}
C {bitcell_6t.sym} 2800 10600 0 0 {name=Xr53c14}
N 2760 10640 2740 10640 {}
C {lab_pin.sym} 2740 10640 0 0 {name=l33991 lab=BL14}
N 2760 10600 2740 10600 {}
C {lab_pin.sym} 2740 10600 0 0 {name=l33992 lab=BLB14}
N 2760 10560 2740 10560 {}
C {lab_pin.sym} 2740 10560 0 0 {name=l33993 lab=WL53}
N 2840 10640 2860 10640 {}
C {lab_pin.sym} 2860 10640 0 0 {name=l33994 lab=VDD}
N 2840 10560 2860 10560 {}
C {lab_pin.sym} 2860 10560 0 0 {name=l33995 lab=VSS}
C {bitcell_6t.sym} 3000 10600 0 0 {name=Xr53c15}
N 2960 10640 2940 10640 {}
C {lab_pin.sym} 2940 10640 0 0 {name=l33996 lab=BL15}
N 2960 10600 2940 10600 {}
C {lab_pin.sym} 2940 10600 0 0 {name=l33997 lab=BLB15}
N 2960 10560 2940 10560 {}
C {lab_pin.sym} 2940 10560 0 0 {name=l33998 lab=WL53}
N 3040 10640 3060 10640 {}
C {lab_pin.sym} 3060 10640 0 0 {name=l33999 lab=VDD}
N 3040 10560 3060 10560 {}
C {lab_pin.sym} 3060 10560 0 0 {name=l34000 lab=VSS}
C {bitcell_6t.sym} 3200 10600 0 0 {name=Xr53c16}
N 3160 10640 3140 10640 {}
C {lab_pin.sym} 3140 10640 0 0 {name=l34001 lab=BL16}
N 3160 10600 3140 10600 {}
C {lab_pin.sym} 3140 10600 0 0 {name=l34002 lab=BLB16}
N 3160 10560 3140 10560 {}
C {lab_pin.sym} 3140 10560 0 0 {name=l34003 lab=WL53}
N 3240 10640 3260 10640 {}
C {lab_pin.sym} 3260 10640 0 0 {name=l34004 lab=VDD}
N 3240 10560 3260 10560 {}
C {lab_pin.sym} 3260 10560 0 0 {name=l34005 lab=VSS}
C {bitcell_6t.sym} 3400 10600 0 0 {name=Xr53c17}
N 3360 10640 3340 10640 {}
C {lab_pin.sym} 3340 10640 0 0 {name=l34006 lab=BL17}
N 3360 10600 3340 10600 {}
C {lab_pin.sym} 3340 10600 0 0 {name=l34007 lab=BLB17}
N 3360 10560 3340 10560 {}
C {lab_pin.sym} 3340 10560 0 0 {name=l34008 lab=WL53}
N 3440 10640 3460 10640 {}
C {lab_pin.sym} 3460 10640 0 0 {name=l34009 lab=VDD}
N 3440 10560 3460 10560 {}
C {lab_pin.sym} 3460 10560 0 0 {name=l34010 lab=VSS}
C {bitcell_6t.sym} 3600 10600 0 0 {name=Xr53c18}
N 3560 10640 3540 10640 {}
C {lab_pin.sym} 3540 10640 0 0 {name=l34011 lab=BL18}
N 3560 10600 3540 10600 {}
C {lab_pin.sym} 3540 10600 0 0 {name=l34012 lab=BLB18}
N 3560 10560 3540 10560 {}
C {lab_pin.sym} 3540 10560 0 0 {name=l34013 lab=WL53}
N 3640 10640 3660 10640 {}
C {lab_pin.sym} 3660 10640 0 0 {name=l34014 lab=VDD}
N 3640 10560 3660 10560 {}
C {lab_pin.sym} 3660 10560 0 0 {name=l34015 lab=VSS}
C {bitcell_6t.sym} 3800 10600 0 0 {name=Xr53c19}
N 3760 10640 3740 10640 {}
C {lab_pin.sym} 3740 10640 0 0 {name=l34016 lab=BL19}
N 3760 10600 3740 10600 {}
C {lab_pin.sym} 3740 10600 0 0 {name=l34017 lab=BLB19}
N 3760 10560 3740 10560 {}
C {lab_pin.sym} 3740 10560 0 0 {name=l34018 lab=WL53}
N 3840 10640 3860 10640 {}
C {lab_pin.sym} 3860 10640 0 0 {name=l34019 lab=VDD}
N 3840 10560 3860 10560 {}
C {lab_pin.sym} 3860 10560 0 0 {name=l34020 lab=VSS}
C {bitcell_6t.sym} 4000 10600 0 0 {name=Xr53c20}
N 3960 10640 3940 10640 {}
C {lab_pin.sym} 3940 10640 0 0 {name=l34021 lab=BL20}
N 3960 10600 3940 10600 {}
C {lab_pin.sym} 3940 10600 0 0 {name=l34022 lab=BLB20}
N 3960 10560 3940 10560 {}
C {lab_pin.sym} 3940 10560 0 0 {name=l34023 lab=WL53}
N 4040 10640 4060 10640 {}
C {lab_pin.sym} 4060 10640 0 0 {name=l34024 lab=VDD}
N 4040 10560 4060 10560 {}
C {lab_pin.sym} 4060 10560 0 0 {name=l34025 lab=VSS}
C {bitcell_6t.sym} 4200 10600 0 0 {name=Xr53c21}
N 4160 10640 4140 10640 {}
C {lab_pin.sym} 4140 10640 0 0 {name=l34026 lab=BL21}
N 4160 10600 4140 10600 {}
C {lab_pin.sym} 4140 10600 0 0 {name=l34027 lab=BLB21}
N 4160 10560 4140 10560 {}
C {lab_pin.sym} 4140 10560 0 0 {name=l34028 lab=WL53}
N 4240 10640 4260 10640 {}
C {lab_pin.sym} 4260 10640 0 0 {name=l34029 lab=VDD}
N 4240 10560 4260 10560 {}
C {lab_pin.sym} 4260 10560 0 0 {name=l34030 lab=VSS}
C {bitcell_6t.sym} 4400 10600 0 0 {name=Xr53c22}
N 4360 10640 4340 10640 {}
C {lab_pin.sym} 4340 10640 0 0 {name=l34031 lab=BL22}
N 4360 10600 4340 10600 {}
C {lab_pin.sym} 4340 10600 0 0 {name=l34032 lab=BLB22}
N 4360 10560 4340 10560 {}
C {lab_pin.sym} 4340 10560 0 0 {name=l34033 lab=WL53}
N 4440 10640 4460 10640 {}
C {lab_pin.sym} 4460 10640 0 0 {name=l34034 lab=VDD}
N 4440 10560 4460 10560 {}
C {lab_pin.sym} 4460 10560 0 0 {name=l34035 lab=VSS}
C {bitcell_6t.sym} 4600 10600 0 0 {name=Xr53c23}
N 4560 10640 4540 10640 {}
C {lab_pin.sym} 4540 10640 0 0 {name=l34036 lab=BL23}
N 4560 10600 4540 10600 {}
C {lab_pin.sym} 4540 10600 0 0 {name=l34037 lab=BLB23}
N 4560 10560 4540 10560 {}
C {lab_pin.sym} 4540 10560 0 0 {name=l34038 lab=WL53}
N 4640 10640 4660 10640 {}
C {lab_pin.sym} 4660 10640 0 0 {name=l34039 lab=VDD}
N 4640 10560 4660 10560 {}
C {lab_pin.sym} 4660 10560 0 0 {name=l34040 lab=VSS}
C {bitcell_6t.sym} 4800 10600 0 0 {name=Xr53c24}
N 4760 10640 4740 10640 {}
C {lab_pin.sym} 4740 10640 0 0 {name=l34041 lab=BL24}
N 4760 10600 4740 10600 {}
C {lab_pin.sym} 4740 10600 0 0 {name=l34042 lab=BLB24}
N 4760 10560 4740 10560 {}
C {lab_pin.sym} 4740 10560 0 0 {name=l34043 lab=WL53}
N 4840 10640 4860 10640 {}
C {lab_pin.sym} 4860 10640 0 0 {name=l34044 lab=VDD}
N 4840 10560 4860 10560 {}
C {lab_pin.sym} 4860 10560 0 0 {name=l34045 lab=VSS}
C {bitcell_6t.sym} 5000 10600 0 0 {name=Xr53c25}
N 4960 10640 4940 10640 {}
C {lab_pin.sym} 4940 10640 0 0 {name=l34046 lab=BL25}
N 4960 10600 4940 10600 {}
C {lab_pin.sym} 4940 10600 0 0 {name=l34047 lab=BLB25}
N 4960 10560 4940 10560 {}
C {lab_pin.sym} 4940 10560 0 0 {name=l34048 lab=WL53}
N 5040 10640 5060 10640 {}
C {lab_pin.sym} 5060 10640 0 0 {name=l34049 lab=VDD}
N 5040 10560 5060 10560 {}
C {lab_pin.sym} 5060 10560 0 0 {name=l34050 lab=VSS}
C {bitcell_6t.sym} 5200 10600 0 0 {name=Xr53c26}
N 5160 10640 5140 10640 {}
C {lab_pin.sym} 5140 10640 0 0 {name=l34051 lab=BL26}
N 5160 10600 5140 10600 {}
C {lab_pin.sym} 5140 10600 0 0 {name=l34052 lab=BLB26}
N 5160 10560 5140 10560 {}
C {lab_pin.sym} 5140 10560 0 0 {name=l34053 lab=WL53}
N 5240 10640 5260 10640 {}
C {lab_pin.sym} 5260 10640 0 0 {name=l34054 lab=VDD}
N 5240 10560 5260 10560 {}
C {lab_pin.sym} 5260 10560 0 0 {name=l34055 lab=VSS}
C {bitcell_6t.sym} 5400 10600 0 0 {name=Xr53c27}
N 5360 10640 5340 10640 {}
C {lab_pin.sym} 5340 10640 0 0 {name=l34056 lab=BL27}
N 5360 10600 5340 10600 {}
C {lab_pin.sym} 5340 10600 0 0 {name=l34057 lab=BLB27}
N 5360 10560 5340 10560 {}
C {lab_pin.sym} 5340 10560 0 0 {name=l34058 lab=WL53}
N 5440 10640 5460 10640 {}
C {lab_pin.sym} 5460 10640 0 0 {name=l34059 lab=VDD}
N 5440 10560 5460 10560 {}
C {lab_pin.sym} 5460 10560 0 0 {name=l34060 lab=VSS}
C {bitcell_6t.sym} 5600 10600 0 0 {name=Xr53c28}
N 5560 10640 5540 10640 {}
C {lab_pin.sym} 5540 10640 0 0 {name=l34061 lab=BL28}
N 5560 10600 5540 10600 {}
C {lab_pin.sym} 5540 10600 0 0 {name=l34062 lab=BLB28}
N 5560 10560 5540 10560 {}
C {lab_pin.sym} 5540 10560 0 0 {name=l34063 lab=WL53}
N 5640 10640 5660 10640 {}
C {lab_pin.sym} 5660 10640 0 0 {name=l34064 lab=VDD}
N 5640 10560 5660 10560 {}
C {lab_pin.sym} 5660 10560 0 0 {name=l34065 lab=VSS}
C {bitcell_6t.sym} 5800 10600 0 0 {name=Xr53c29}
N 5760 10640 5740 10640 {}
C {lab_pin.sym} 5740 10640 0 0 {name=l34066 lab=BL29}
N 5760 10600 5740 10600 {}
C {lab_pin.sym} 5740 10600 0 0 {name=l34067 lab=BLB29}
N 5760 10560 5740 10560 {}
C {lab_pin.sym} 5740 10560 0 0 {name=l34068 lab=WL53}
N 5840 10640 5860 10640 {}
C {lab_pin.sym} 5860 10640 0 0 {name=l34069 lab=VDD}
N 5840 10560 5860 10560 {}
C {lab_pin.sym} 5860 10560 0 0 {name=l34070 lab=VSS}
C {bitcell_6t.sym} 6000 10600 0 0 {name=Xr53c30}
N 5960 10640 5940 10640 {}
C {lab_pin.sym} 5940 10640 0 0 {name=l34071 lab=BL30}
N 5960 10600 5940 10600 {}
C {lab_pin.sym} 5940 10600 0 0 {name=l34072 lab=BLB30}
N 5960 10560 5940 10560 {}
C {lab_pin.sym} 5940 10560 0 0 {name=l34073 lab=WL53}
N 6040 10640 6060 10640 {}
C {lab_pin.sym} 6060 10640 0 0 {name=l34074 lab=VDD}
N 6040 10560 6060 10560 {}
C {lab_pin.sym} 6060 10560 0 0 {name=l34075 lab=VSS}
C {bitcell_6t.sym} 6200 10600 0 0 {name=Xr53c31}
N 6160 10640 6140 10640 {}
C {lab_pin.sym} 6140 10640 0 0 {name=l34076 lab=BL31}
N 6160 10600 6140 10600 {}
C {lab_pin.sym} 6140 10600 0 0 {name=l34077 lab=BLB31}
N 6160 10560 6140 10560 {}
C {lab_pin.sym} 6140 10560 0 0 {name=l34078 lab=WL53}
N 6240 10640 6260 10640 {}
C {lab_pin.sym} 6260 10640 0 0 {name=l34079 lab=VDD}
N 6240 10560 6260 10560 {}
C {lab_pin.sym} 6260 10560 0 0 {name=l34080 lab=VSS}
C {bitcell_6t.sym} 6400 10600 0 0 {name=Xr53c32}
N 6360 10640 6340 10640 {}
C {lab_pin.sym} 6340 10640 0 0 {name=l34081 lab=BL32}
N 6360 10600 6340 10600 {}
C {lab_pin.sym} 6340 10600 0 0 {name=l34082 lab=BLB32}
N 6360 10560 6340 10560 {}
C {lab_pin.sym} 6340 10560 0 0 {name=l34083 lab=WL53}
N 6440 10640 6460 10640 {}
C {lab_pin.sym} 6460 10640 0 0 {name=l34084 lab=VDD}
N 6440 10560 6460 10560 {}
C {lab_pin.sym} 6460 10560 0 0 {name=l34085 lab=VSS}
C {bitcell_6t.sym} 6600 10600 0 0 {name=Xr53c33}
N 6560 10640 6540 10640 {}
C {lab_pin.sym} 6540 10640 0 0 {name=l34086 lab=BL33}
N 6560 10600 6540 10600 {}
C {lab_pin.sym} 6540 10600 0 0 {name=l34087 lab=BLB33}
N 6560 10560 6540 10560 {}
C {lab_pin.sym} 6540 10560 0 0 {name=l34088 lab=WL53}
N 6640 10640 6660 10640 {}
C {lab_pin.sym} 6660 10640 0 0 {name=l34089 lab=VDD}
N 6640 10560 6660 10560 {}
C {lab_pin.sym} 6660 10560 0 0 {name=l34090 lab=VSS}
C {bitcell_6t.sym} 6800 10600 0 0 {name=Xr53c34}
N 6760 10640 6740 10640 {}
C {lab_pin.sym} 6740 10640 0 0 {name=l34091 lab=BL34}
N 6760 10600 6740 10600 {}
C {lab_pin.sym} 6740 10600 0 0 {name=l34092 lab=BLB34}
N 6760 10560 6740 10560 {}
C {lab_pin.sym} 6740 10560 0 0 {name=l34093 lab=WL53}
N 6840 10640 6860 10640 {}
C {lab_pin.sym} 6860 10640 0 0 {name=l34094 lab=VDD}
N 6840 10560 6860 10560 {}
C {lab_pin.sym} 6860 10560 0 0 {name=l34095 lab=VSS}
C {bitcell_6t.sym} 7000 10600 0 0 {name=Xr53c35}
N 6960 10640 6940 10640 {}
C {lab_pin.sym} 6940 10640 0 0 {name=l34096 lab=BL35}
N 6960 10600 6940 10600 {}
C {lab_pin.sym} 6940 10600 0 0 {name=l34097 lab=BLB35}
N 6960 10560 6940 10560 {}
C {lab_pin.sym} 6940 10560 0 0 {name=l34098 lab=WL53}
N 7040 10640 7060 10640 {}
C {lab_pin.sym} 7060 10640 0 0 {name=l34099 lab=VDD}
N 7040 10560 7060 10560 {}
C {lab_pin.sym} 7060 10560 0 0 {name=l34100 lab=VSS}
C {bitcell_6t.sym} 7200 10600 0 0 {name=Xr53c36}
N 7160 10640 7140 10640 {}
C {lab_pin.sym} 7140 10640 0 0 {name=l34101 lab=BL36}
N 7160 10600 7140 10600 {}
C {lab_pin.sym} 7140 10600 0 0 {name=l34102 lab=BLB36}
N 7160 10560 7140 10560 {}
C {lab_pin.sym} 7140 10560 0 0 {name=l34103 lab=WL53}
N 7240 10640 7260 10640 {}
C {lab_pin.sym} 7260 10640 0 0 {name=l34104 lab=VDD}
N 7240 10560 7260 10560 {}
C {lab_pin.sym} 7260 10560 0 0 {name=l34105 lab=VSS}
C {bitcell_6t.sym} 7400 10600 0 0 {name=Xr53c37}
N 7360 10640 7340 10640 {}
C {lab_pin.sym} 7340 10640 0 0 {name=l34106 lab=BL37}
N 7360 10600 7340 10600 {}
C {lab_pin.sym} 7340 10600 0 0 {name=l34107 lab=BLB37}
N 7360 10560 7340 10560 {}
C {lab_pin.sym} 7340 10560 0 0 {name=l34108 lab=WL53}
N 7440 10640 7460 10640 {}
C {lab_pin.sym} 7460 10640 0 0 {name=l34109 lab=VDD}
N 7440 10560 7460 10560 {}
C {lab_pin.sym} 7460 10560 0 0 {name=l34110 lab=VSS}
C {bitcell_6t.sym} 7600 10600 0 0 {name=Xr53c38}
N 7560 10640 7540 10640 {}
C {lab_pin.sym} 7540 10640 0 0 {name=l34111 lab=BL38}
N 7560 10600 7540 10600 {}
C {lab_pin.sym} 7540 10600 0 0 {name=l34112 lab=BLB38}
N 7560 10560 7540 10560 {}
C {lab_pin.sym} 7540 10560 0 0 {name=l34113 lab=WL53}
N 7640 10640 7660 10640 {}
C {lab_pin.sym} 7660 10640 0 0 {name=l34114 lab=VDD}
N 7640 10560 7660 10560 {}
C {lab_pin.sym} 7660 10560 0 0 {name=l34115 lab=VSS}
C {bitcell_6t.sym} 7800 10600 0 0 {name=Xr53c39}
N 7760 10640 7740 10640 {}
C {lab_pin.sym} 7740 10640 0 0 {name=l34116 lab=BL39}
N 7760 10600 7740 10600 {}
C {lab_pin.sym} 7740 10600 0 0 {name=l34117 lab=BLB39}
N 7760 10560 7740 10560 {}
C {lab_pin.sym} 7740 10560 0 0 {name=l34118 lab=WL53}
N 7840 10640 7860 10640 {}
C {lab_pin.sym} 7860 10640 0 0 {name=l34119 lab=VDD}
N 7840 10560 7860 10560 {}
C {lab_pin.sym} 7860 10560 0 0 {name=l34120 lab=VSS}
C {bitcell_6t.sym} 8000 10600 0 0 {name=Xr53c40}
N 7960 10640 7940 10640 {}
C {lab_pin.sym} 7940 10640 0 0 {name=l34121 lab=BL40}
N 7960 10600 7940 10600 {}
C {lab_pin.sym} 7940 10600 0 0 {name=l34122 lab=BLB40}
N 7960 10560 7940 10560 {}
C {lab_pin.sym} 7940 10560 0 0 {name=l34123 lab=WL53}
N 8040 10640 8060 10640 {}
C {lab_pin.sym} 8060 10640 0 0 {name=l34124 lab=VDD}
N 8040 10560 8060 10560 {}
C {lab_pin.sym} 8060 10560 0 0 {name=l34125 lab=VSS}
C {bitcell_6t.sym} 8200 10600 0 0 {name=Xr53c41}
N 8160 10640 8140 10640 {}
C {lab_pin.sym} 8140 10640 0 0 {name=l34126 lab=BL41}
N 8160 10600 8140 10600 {}
C {lab_pin.sym} 8140 10600 0 0 {name=l34127 lab=BLB41}
N 8160 10560 8140 10560 {}
C {lab_pin.sym} 8140 10560 0 0 {name=l34128 lab=WL53}
N 8240 10640 8260 10640 {}
C {lab_pin.sym} 8260 10640 0 0 {name=l34129 lab=VDD}
N 8240 10560 8260 10560 {}
C {lab_pin.sym} 8260 10560 0 0 {name=l34130 lab=VSS}
C {bitcell_6t.sym} 8400 10600 0 0 {name=Xr53c42}
N 8360 10640 8340 10640 {}
C {lab_pin.sym} 8340 10640 0 0 {name=l34131 lab=BL42}
N 8360 10600 8340 10600 {}
C {lab_pin.sym} 8340 10600 0 0 {name=l34132 lab=BLB42}
N 8360 10560 8340 10560 {}
C {lab_pin.sym} 8340 10560 0 0 {name=l34133 lab=WL53}
N 8440 10640 8460 10640 {}
C {lab_pin.sym} 8460 10640 0 0 {name=l34134 lab=VDD}
N 8440 10560 8460 10560 {}
C {lab_pin.sym} 8460 10560 0 0 {name=l34135 lab=VSS}
C {bitcell_6t.sym} 8600 10600 0 0 {name=Xr53c43}
N 8560 10640 8540 10640 {}
C {lab_pin.sym} 8540 10640 0 0 {name=l34136 lab=BL43}
N 8560 10600 8540 10600 {}
C {lab_pin.sym} 8540 10600 0 0 {name=l34137 lab=BLB43}
N 8560 10560 8540 10560 {}
C {lab_pin.sym} 8540 10560 0 0 {name=l34138 lab=WL53}
N 8640 10640 8660 10640 {}
C {lab_pin.sym} 8660 10640 0 0 {name=l34139 lab=VDD}
N 8640 10560 8660 10560 {}
C {lab_pin.sym} 8660 10560 0 0 {name=l34140 lab=VSS}
C {bitcell_6t.sym} 8800 10600 0 0 {name=Xr53c44}
N 8760 10640 8740 10640 {}
C {lab_pin.sym} 8740 10640 0 0 {name=l34141 lab=BL44}
N 8760 10600 8740 10600 {}
C {lab_pin.sym} 8740 10600 0 0 {name=l34142 lab=BLB44}
N 8760 10560 8740 10560 {}
C {lab_pin.sym} 8740 10560 0 0 {name=l34143 lab=WL53}
N 8840 10640 8860 10640 {}
C {lab_pin.sym} 8860 10640 0 0 {name=l34144 lab=VDD}
N 8840 10560 8860 10560 {}
C {lab_pin.sym} 8860 10560 0 0 {name=l34145 lab=VSS}
C {bitcell_6t.sym} 9000 10600 0 0 {name=Xr53c45}
N 8960 10640 8940 10640 {}
C {lab_pin.sym} 8940 10640 0 0 {name=l34146 lab=BL45}
N 8960 10600 8940 10600 {}
C {lab_pin.sym} 8940 10600 0 0 {name=l34147 lab=BLB45}
N 8960 10560 8940 10560 {}
C {lab_pin.sym} 8940 10560 0 0 {name=l34148 lab=WL53}
N 9040 10640 9060 10640 {}
C {lab_pin.sym} 9060 10640 0 0 {name=l34149 lab=VDD}
N 9040 10560 9060 10560 {}
C {lab_pin.sym} 9060 10560 0 0 {name=l34150 lab=VSS}
C {bitcell_6t.sym} 9200 10600 0 0 {name=Xr53c46}
N 9160 10640 9140 10640 {}
C {lab_pin.sym} 9140 10640 0 0 {name=l34151 lab=BL46}
N 9160 10600 9140 10600 {}
C {lab_pin.sym} 9140 10600 0 0 {name=l34152 lab=BLB46}
N 9160 10560 9140 10560 {}
C {lab_pin.sym} 9140 10560 0 0 {name=l34153 lab=WL53}
N 9240 10640 9260 10640 {}
C {lab_pin.sym} 9260 10640 0 0 {name=l34154 lab=VDD}
N 9240 10560 9260 10560 {}
C {lab_pin.sym} 9260 10560 0 0 {name=l34155 lab=VSS}
C {bitcell_6t.sym} 9400 10600 0 0 {name=Xr53c47}
N 9360 10640 9340 10640 {}
C {lab_pin.sym} 9340 10640 0 0 {name=l34156 lab=BL47}
N 9360 10600 9340 10600 {}
C {lab_pin.sym} 9340 10600 0 0 {name=l34157 lab=BLB47}
N 9360 10560 9340 10560 {}
C {lab_pin.sym} 9340 10560 0 0 {name=l34158 lab=WL53}
N 9440 10640 9460 10640 {}
C {lab_pin.sym} 9460 10640 0 0 {name=l34159 lab=VDD}
N 9440 10560 9460 10560 {}
C {lab_pin.sym} 9460 10560 0 0 {name=l34160 lab=VSS}
C {bitcell_6t.sym} 9600 10600 0 0 {name=Xr53c48}
N 9560 10640 9540 10640 {}
C {lab_pin.sym} 9540 10640 0 0 {name=l34161 lab=BL48}
N 9560 10600 9540 10600 {}
C {lab_pin.sym} 9540 10600 0 0 {name=l34162 lab=BLB48}
N 9560 10560 9540 10560 {}
C {lab_pin.sym} 9540 10560 0 0 {name=l34163 lab=WL53}
N 9640 10640 9660 10640 {}
C {lab_pin.sym} 9660 10640 0 0 {name=l34164 lab=VDD}
N 9640 10560 9660 10560 {}
C {lab_pin.sym} 9660 10560 0 0 {name=l34165 lab=VSS}
C {bitcell_6t.sym} 9800 10600 0 0 {name=Xr53c49}
N 9760 10640 9740 10640 {}
C {lab_pin.sym} 9740 10640 0 0 {name=l34166 lab=BL49}
N 9760 10600 9740 10600 {}
C {lab_pin.sym} 9740 10600 0 0 {name=l34167 lab=BLB49}
N 9760 10560 9740 10560 {}
C {lab_pin.sym} 9740 10560 0 0 {name=l34168 lab=WL53}
N 9840 10640 9860 10640 {}
C {lab_pin.sym} 9860 10640 0 0 {name=l34169 lab=VDD}
N 9840 10560 9860 10560 {}
C {lab_pin.sym} 9860 10560 0 0 {name=l34170 lab=VSS}
C {bitcell_6t.sym} 10000 10600 0 0 {name=Xr53c50}
N 9960 10640 9940 10640 {}
C {lab_pin.sym} 9940 10640 0 0 {name=l34171 lab=BL50}
N 9960 10600 9940 10600 {}
C {lab_pin.sym} 9940 10600 0 0 {name=l34172 lab=BLB50}
N 9960 10560 9940 10560 {}
C {lab_pin.sym} 9940 10560 0 0 {name=l34173 lab=WL53}
N 10040 10640 10060 10640 {}
C {lab_pin.sym} 10060 10640 0 0 {name=l34174 lab=VDD}
N 10040 10560 10060 10560 {}
C {lab_pin.sym} 10060 10560 0 0 {name=l34175 lab=VSS}
C {bitcell_6t.sym} 10200 10600 0 0 {name=Xr53c51}
N 10160 10640 10140 10640 {}
C {lab_pin.sym} 10140 10640 0 0 {name=l34176 lab=BL51}
N 10160 10600 10140 10600 {}
C {lab_pin.sym} 10140 10600 0 0 {name=l34177 lab=BLB51}
N 10160 10560 10140 10560 {}
C {lab_pin.sym} 10140 10560 0 0 {name=l34178 lab=WL53}
N 10240 10640 10260 10640 {}
C {lab_pin.sym} 10260 10640 0 0 {name=l34179 lab=VDD}
N 10240 10560 10260 10560 {}
C {lab_pin.sym} 10260 10560 0 0 {name=l34180 lab=VSS}
C {bitcell_6t.sym} 10400 10600 0 0 {name=Xr53c52}
N 10360 10640 10340 10640 {}
C {lab_pin.sym} 10340 10640 0 0 {name=l34181 lab=BL52}
N 10360 10600 10340 10600 {}
C {lab_pin.sym} 10340 10600 0 0 {name=l34182 lab=BLB52}
N 10360 10560 10340 10560 {}
C {lab_pin.sym} 10340 10560 0 0 {name=l34183 lab=WL53}
N 10440 10640 10460 10640 {}
C {lab_pin.sym} 10460 10640 0 0 {name=l34184 lab=VDD}
N 10440 10560 10460 10560 {}
C {lab_pin.sym} 10460 10560 0 0 {name=l34185 lab=VSS}
C {bitcell_6t.sym} 10600 10600 0 0 {name=Xr53c53}
N 10560 10640 10540 10640 {}
C {lab_pin.sym} 10540 10640 0 0 {name=l34186 lab=BL53}
N 10560 10600 10540 10600 {}
C {lab_pin.sym} 10540 10600 0 0 {name=l34187 lab=BLB53}
N 10560 10560 10540 10560 {}
C {lab_pin.sym} 10540 10560 0 0 {name=l34188 lab=WL53}
N 10640 10640 10660 10640 {}
C {lab_pin.sym} 10660 10640 0 0 {name=l34189 lab=VDD}
N 10640 10560 10660 10560 {}
C {lab_pin.sym} 10660 10560 0 0 {name=l34190 lab=VSS}
C {bitcell_6t.sym} 10800 10600 0 0 {name=Xr53c54}
N 10760 10640 10740 10640 {}
C {lab_pin.sym} 10740 10640 0 0 {name=l34191 lab=BL54}
N 10760 10600 10740 10600 {}
C {lab_pin.sym} 10740 10600 0 0 {name=l34192 lab=BLB54}
N 10760 10560 10740 10560 {}
C {lab_pin.sym} 10740 10560 0 0 {name=l34193 lab=WL53}
N 10840 10640 10860 10640 {}
C {lab_pin.sym} 10860 10640 0 0 {name=l34194 lab=VDD}
N 10840 10560 10860 10560 {}
C {lab_pin.sym} 10860 10560 0 0 {name=l34195 lab=VSS}
C {bitcell_6t.sym} 11000 10600 0 0 {name=Xr53c55}
N 10960 10640 10940 10640 {}
C {lab_pin.sym} 10940 10640 0 0 {name=l34196 lab=BL55}
N 10960 10600 10940 10600 {}
C {lab_pin.sym} 10940 10600 0 0 {name=l34197 lab=BLB55}
N 10960 10560 10940 10560 {}
C {lab_pin.sym} 10940 10560 0 0 {name=l34198 lab=WL53}
N 11040 10640 11060 10640 {}
C {lab_pin.sym} 11060 10640 0 0 {name=l34199 lab=VDD}
N 11040 10560 11060 10560 {}
C {lab_pin.sym} 11060 10560 0 0 {name=l34200 lab=VSS}
C {bitcell_6t.sym} 11200 10600 0 0 {name=Xr53c56}
N 11160 10640 11140 10640 {}
C {lab_pin.sym} 11140 10640 0 0 {name=l34201 lab=BL56}
N 11160 10600 11140 10600 {}
C {lab_pin.sym} 11140 10600 0 0 {name=l34202 lab=BLB56}
N 11160 10560 11140 10560 {}
C {lab_pin.sym} 11140 10560 0 0 {name=l34203 lab=WL53}
N 11240 10640 11260 10640 {}
C {lab_pin.sym} 11260 10640 0 0 {name=l34204 lab=VDD}
N 11240 10560 11260 10560 {}
C {lab_pin.sym} 11260 10560 0 0 {name=l34205 lab=VSS}
C {bitcell_6t.sym} 11400 10600 0 0 {name=Xr53c57}
N 11360 10640 11340 10640 {}
C {lab_pin.sym} 11340 10640 0 0 {name=l34206 lab=BL57}
N 11360 10600 11340 10600 {}
C {lab_pin.sym} 11340 10600 0 0 {name=l34207 lab=BLB57}
N 11360 10560 11340 10560 {}
C {lab_pin.sym} 11340 10560 0 0 {name=l34208 lab=WL53}
N 11440 10640 11460 10640 {}
C {lab_pin.sym} 11460 10640 0 0 {name=l34209 lab=VDD}
N 11440 10560 11460 10560 {}
C {lab_pin.sym} 11460 10560 0 0 {name=l34210 lab=VSS}
C {bitcell_6t.sym} 11600 10600 0 0 {name=Xr53c58}
N 11560 10640 11540 10640 {}
C {lab_pin.sym} 11540 10640 0 0 {name=l34211 lab=BL58}
N 11560 10600 11540 10600 {}
C {lab_pin.sym} 11540 10600 0 0 {name=l34212 lab=BLB58}
N 11560 10560 11540 10560 {}
C {lab_pin.sym} 11540 10560 0 0 {name=l34213 lab=WL53}
N 11640 10640 11660 10640 {}
C {lab_pin.sym} 11660 10640 0 0 {name=l34214 lab=VDD}
N 11640 10560 11660 10560 {}
C {lab_pin.sym} 11660 10560 0 0 {name=l34215 lab=VSS}
C {bitcell_6t.sym} 11800 10600 0 0 {name=Xr53c59}
N 11760 10640 11740 10640 {}
C {lab_pin.sym} 11740 10640 0 0 {name=l34216 lab=BL59}
N 11760 10600 11740 10600 {}
C {lab_pin.sym} 11740 10600 0 0 {name=l34217 lab=BLB59}
N 11760 10560 11740 10560 {}
C {lab_pin.sym} 11740 10560 0 0 {name=l34218 lab=WL53}
N 11840 10640 11860 10640 {}
C {lab_pin.sym} 11860 10640 0 0 {name=l34219 lab=VDD}
N 11840 10560 11860 10560 {}
C {lab_pin.sym} 11860 10560 0 0 {name=l34220 lab=VSS}
C {bitcell_6t.sym} 12000 10600 0 0 {name=Xr53c60}
N 11960 10640 11940 10640 {}
C {lab_pin.sym} 11940 10640 0 0 {name=l34221 lab=BL60}
N 11960 10600 11940 10600 {}
C {lab_pin.sym} 11940 10600 0 0 {name=l34222 lab=BLB60}
N 11960 10560 11940 10560 {}
C {lab_pin.sym} 11940 10560 0 0 {name=l34223 lab=WL53}
N 12040 10640 12060 10640 {}
C {lab_pin.sym} 12060 10640 0 0 {name=l34224 lab=VDD}
N 12040 10560 12060 10560 {}
C {lab_pin.sym} 12060 10560 0 0 {name=l34225 lab=VSS}
C {bitcell_6t.sym} 12200 10600 0 0 {name=Xr53c61}
N 12160 10640 12140 10640 {}
C {lab_pin.sym} 12140 10640 0 0 {name=l34226 lab=BL61}
N 12160 10600 12140 10600 {}
C {lab_pin.sym} 12140 10600 0 0 {name=l34227 lab=BLB61}
N 12160 10560 12140 10560 {}
C {lab_pin.sym} 12140 10560 0 0 {name=l34228 lab=WL53}
N 12240 10640 12260 10640 {}
C {lab_pin.sym} 12260 10640 0 0 {name=l34229 lab=VDD}
N 12240 10560 12260 10560 {}
C {lab_pin.sym} 12260 10560 0 0 {name=l34230 lab=VSS}
C {bitcell_6t.sym} 12400 10600 0 0 {name=Xr53c62}
N 12360 10640 12340 10640 {}
C {lab_pin.sym} 12340 10640 0 0 {name=l34231 lab=BL62}
N 12360 10600 12340 10600 {}
C {lab_pin.sym} 12340 10600 0 0 {name=l34232 lab=BLB62}
N 12360 10560 12340 10560 {}
C {lab_pin.sym} 12340 10560 0 0 {name=l34233 lab=WL53}
N 12440 10640 12460 10640 {}
C {lab_pin.sym} 12460 10640 0 0 {name=l34234 lab=VDD}
N 12440 10560 12460 10560 {}
C {lab_pin.sym} 12460 10560 0 0 {name=l34235 lab=VSS}
C {bitcell_6t.sym} 12600 10600 0 0 {name=Xr53c63}
N 12560 10640 12540 10640 {}
C {lab_pin.sym} 12540 10640 0 0 {name=l34236 lab=BL63}
N 12560 10600 12540 10600 {}
C {lab_pin.sym} 12540 10600 0 0 {name=l34237 lab=BLB63}
N 12560 10560 12540 10560 {}
C {lab_pin.sym} 12540 10560 0 0 {name=l34238 lab=WL53}
N 12640 10640 12660 10640 {}
C {lab_pin.sym} 12660 10640 0 0 {name=l34239 lab=VDD}
N 12640 10560 12660 10560 {}
C {lab_pin.sym} 12660 10560 0 0 {name=l34240 lab=VSS}
C {bitcell_6t.sym} 12800 10600 0 0 {name=Xr53c64}
N 12760 10640 12740 10640 {}
C {lab_pin.sym} 12740 10640 0 0 {name=l34241 lab=BL64}
N 12760 10600 12740 10600 {}
C {lab_pin.sym} 12740 10600 0 0 {name=l34242 lab=BLB64}
N 12760 10560 12740 10560 {}
C {lab_pin.sym} 12740 10560 0 0 {name=l34243 lab=WL53}
N 12840 10640 12860 10640 {}
C {lab_pin.sym} 12860 10640 0 0 {name=l34244 lab=VDD}
N 12840 10560 12860 10560 {}
C {lab_pin.sym} 12860 10560 0 0 {name=l34245 lab=VSS}
C {bitcell_6t.sym} 13000 10600 0 0 {name=Xr53c65}
N 12960 10640 12940 10640 {}
C {lab_pin.sym} 12940 10640 0 0 {name=l34246 lab=BL65}
N 12960 10600 12940 10600 {}
C {lab_pin.sym} 12940 10600 0 0 {name=l34247 lab=BLB65}
N 12960 10560 12940 10560 {}
C {lab_pin.sym} 12940 10560 0 0 {name=l34248 lab=WL53}
N 13040 10640 13060 10640 {}
C {lab_pin.sym} 13060 10640 0 0 {name=l34249 lab=VDD}
N 13040 10560 13060 10560 {}
C {lab_pin.sym} 13060 10560 0 0 {name=l34250 lab=VSS}
C {bitcell_6t.sym} 13200 10600 0 0 {name=Xr53c66}
N 13160 10640 13140 10640 {}
C {lab_pin.sym} 13140 10640 0 0 {name=l34251 lab=BL66}
N 13160 10600 13140 10600 {}
C {lab_pin.sym} 13140 10600 0 0 {name=l34252 lab=BLB66}
N 13160 10560 13140 10560 {}
C {lab_pin.sym} 13140 10560 0 0 {name=l34253 lab=WL53}
N 13240 10640 13260 10640 {}
C {lab_pin.sym} 13260 10640 0 0 {name=l34254 lab=VDD}
N 13240 10560 13260 10560 {}
C {lab_pin.sym} 13260 10560 0 0 {name=l34255 lab=VSS}
C {bitcell_6t.sym} 13400 10600 0 0 {name=Xr53c67}
N 13360 10640 13340 10640 {}
C {lab_pin.sym} 13340 10640 0 0 {name=l34256 lab=BL67}
N 13360 10600 13340 10600 {}
C {lab_pin.sym} 13340 10600 0 0 {name=l34257 lab=BLB67}
N 13360 10560 13340 10560 {}
C {lab_pin.sym} 13340 10560 0 0 {name=l34258 lab=WL53}
N 13440 10640 13460 10640 {}
C {lab_pin.sym} 13460 10640 0 0 {name=l34259 lab=VDD}
N 13440 10560 13460 10560 {}
C {lab_pin.sym} 13460 10560 0 0 {name=l34260 lab=VSS}
C {bitcell_6t.sym} 13600 10600 0 0 {name=Xr53c68}
N 13560 10640 13540 10640 {}
C {lab_pin.sym} 13540 10640 0 0 {name=l34261 lab=BL68}
N 13560 10600 13540 10600 {}
C {lab_pin.sym} 13540 10600 0 0 {name=l34262 lab=BLB68}
N 13560 10560 13540 10560 {}
C {lab_pin.sym} 13540 10560 0 0 {name=l34263 lab=WL53}
N 13640 10640 13660 10640 {}
C {lab_pin.sym} 13660 10640 0 0 {name=l34264 lab=VDD}
N 13640 10560 13660 10560 {}
C {lab_pin.sym} 13660 10560 0 0 {name=l34265 lab=VSS}
C {bitcell_6t.sym} 13800 10600 0 0 {name=Xr53c69}
N 13760 10640 13740 10640 {}
C {lab_pin.sym} 13740 10640 0 0 {name=l34266 lab=BL69}
N 13760 10600 13740 10600 {}
C {lab_pin.sym} 13740 10600 0 0 {name=l34267 lab=BLB69}
N 13760 10560 13740 10560 {}
C {lab_pin.sym} 13740 10560 0 0 {name=l34268 lab=WL53}
N 13840 10640 13860 10640 {}
C {lab_pin.sym} 13860 10640 0 0 {name=l34269 lab=VDD}
N 13840 10560 13860 10560 {}
C {lab_pin.sym} 13860 10560 0 0 {name=l34270 lab=VSS}
C {bitcell_6t.sym} 14000 10600 0 0 {name=Xr53c70}
N 13960 10640 13940 10640 {}
C {lab_pin.sym} 13940 10640 0 0 {name=l34271 lab=BL70}
N 13960 10600 13940 10600 {}
C {lab_pin.sym} 13940 10600 0 0 {name=l34272 lab=BLB70}
N 13960 10560 13940 10560 {}
C {lab_pin.sym} 13940 10560 0 0 {name=l34273 lab=WL53}
N 14040 10640 14060 10640 {}
C {lab_pin.sym} 14060 10640 0 0 {name=l34274 lab=VDD}
N 14040 10560 14060 10560 {}
C {lab_pin.sym} 14060 10560 0 0 {name=l34275 lab=VSS}
C {bitcell_6t.sym} 14200 10600 0 0 {name=Xr53c71}
N 14160 10640 14140 10640 {}
C {lab_pin.sym} 14140 10640 0 0 {name=l34276 lab=BL71}
N 14160 10600 14140 10600 {}
C {lab_pin.sym} 14140 10600 0 0 {name=l34277 lab=BLB71}
N 14160 10560 14140 10560 {}
C {lab_pin.sym} 14140 10560 0 0 {name=l34278 lab=WL53}
N 14240 10640 14260 10640 {}
C {lab_pin.sym} 14260 10640 0 0 {name=l34279 lab=VDD}
N 14240 10560 14260 10560 {}
C {lab_pin.sym} 14260 10560 0 0 {name=l34280 lab=VSS}
C {bitcell_6t.sym} 14400 10600 0 0 {name=Xr53c72}
N 14360 10640 14340 10640 {}
C {lab_pin.sym} 14340 10640 0 0 {name=l34281 lab=BL72}
N 14360 10600 14340 10600 {}
C {lab_pin.sym} 14340 10600 0 0 {name=l34282 lab=BLB72}
N 14360 10560 14340 10560 {}
C {lab_pin.sym} 14340 10560 0 0 {name=l34283 lab=WL53}
N 14440 10640 14460 10640 {}
C {lab_pin.sym} 14460 10640 0 0 {name=l34284 lab=VDD}
N 14440 10560 14460 10560 {}
C {lab_pin.sym} 14460 10560 0 0 {name=l34285 lab=VSS}
C {bitcell_6t.sym} 14600 10600 0 0 {name=Xr53c73}
N 14560 10640 14540 10640 {}
C {lab_pin.sym} 14540 10640 0 0 {name=l34286 lab=BL73}
N 14560 10600 14540 10600 {}
C {lab_pin.sym} 14540 10600 0 0 {name=l34287 lab=BLB73}
N 14560 10560 14540 10560 {}
C {lab_pin.sym} 14540 10560 0 0 {name=l34288 lab=WL53}
N 14640 10640 14660 10640 {}
C {lab_pin.sym} 14660 10640 0 0 {name=l34289 lab=VDD}
N 14640 10560 14660 10560 {}
C {lab_pin.sym} 14660 10560 0 0 {name=l34290 lab=VSS}
C {bitcell_6t.sym} 14800 10600 0 0 {name=Xr53c74}
N 14760 10640 14740 10640 {}
C {lab_pin.sym} 14740 10640 0 0 {name=l34291 lab=BL74}
N 14760 10600 14740 10600 {}
C {lab_pin.sym} 14740 10600 0 0 {name=l34292 lab=BLB74}
N 14760 10560 14740 10560 {}
C {lab_pin.sym} 14740 10560 0 0 {name=l34293 lab=WL53}
N 14840 10640 14860 10640 {}
C {lab_pin.sym} 14860 10640 0 0 {name=l34294 lab=VDD}
N 14840 10560 14860 10560 {}
C {lab_pin.sym} 14860 10560 0 0 {name=l34295 lab=VSS}
C {bitcell_6t.sym} 15000 10600 0 0 {name=Xr53c75}
N 14960 10640 14940 10640 {}
C {lab_pin.sym} 14940 10640 0 0 {name=l34296 lab=BL75}
N 14960 10600 14940 10600 {}
C {lab_pin.sym} 14940 10600 0 0 {name=l34297 lab=BLB75}
N 14960 10560 14940 10560 {}
C {lab_pin.sym} 14940 10560 0 0 {name=l34298 lab=WL53}
N 15040 10640 15060 10640 {}
C {lab_pin.sym} 15060 10640 0 0 {name=l34299 lab=VDD}
N 15040 10560 15060 10560 {}
C {lab_pin.sym} 15060 10560 0 0 {name=l34300 lab=VSS}
C {bitcell_6t.sym} 15200 10600 0 0 {name=Xr53c76}
N 15160 10640 15140 10640 {}
C {lab_pin.sym} 15140 10640 0 0 {name=l34301 lab=BL76}
N 15160 10600 15140 10600 {}
C {lab_pin.sym} 15140 10600 0 0 {name=l34302 lab=BLB76}
N 15160 10560 15140 10560 {}
C {lab_pin.sym} 15140 10560 0 0 {name=l34303 lab=WL53}
N 15240 10640 15260 10640 {}
C {lab_pin.sym} 15260 10640 0 0 {name=l34304 lab=VDD}
N 15240 10560 15260 10560 {}
C {lab_pin.sym} 15260 10560 0 0 {name=l34305 lab=VSS}
C {bitcell_6t.sym} 15400 10600 0 0 {name=Xr53c77}
N 15360 10640 15340 10640 {}
C {lab_pin.sym} 15340 10640 0 0 {name=l34306 lab=BL77}
N 15360 10600 15340 10600 {}
C {lab_pin.sym} 15340 10600 0 0 {name=l34307 lab=BLB77}
N 15360 10560 15340 10560 {}
C {lab_pin.sym} 15340 10560 0 0 {name=l34308 lab=WL53}
N 15440 10640 15460 10640 {}
C {lab_pin.sym} 15460 10640 0 0 {name=l34309 lab=VDD}
N 15440 10560 15460 10560 {}
C {lab_pin.sym} 15460 10560 0 0 {name=l34310 lab=VSS}
C {bitcell_6t.sym} 15600 10600 0 0 {name=Xr53c78}
N 15560 10640 15540 10640 {}
C {lab_pin.sym} 15540 10640 0 0 {name=l34311 lab=BL78}
N 15560 10600 15540 10600 {}
C {lab_pin.sym} 15540 10600 0 0 {name=l34312 lab=BLB78}
N 15560 10560 15540 10560 {}
C {lab_pin.sym} 15540 10560 0 0 {name=l34313 lab=WL53}
N 15640 10640 15660 10640 {}
C {lab_pin.sym} 15660 10640 0 0 {name=l34314 lab=VDD}
N 15640 10560 15660 10560 {}
C {lab_pin.sym} 15660 10560 0 0 {name=l34315 lab=VSS}
C {bitcell_6t.sym} 15800 10600 0 0 {name=Xr53c79}
N 15760 10640 15740 10640 {}
C {lab_pin.sym} 15740 10640 0 0 {name=l34316 lab=BL79}
N 15760 10600 15740 10600 {}
C {lab_pin.sym} 15740 10600 0 0 {name=l34317 lab=BLB79}
N 15760 10560 15740 10560 {}
C {lab_pin.sym} 15740 10560 0 0 {name=l34318 lab=WL53}
N 15840 10640 15860 10640 {}
C {lab_pin.sym} 15860 10640 0 0 {name=l34319 lab=VDD}
N 15840 10560 15860 10560 {}
C {lab_pin.sym} 15860 10560 0 0 {name=l34320 lab=VSS}
C {bitcell_6t.sym} 16000 10600 0 0 {name=Xr53c80}
N 15960 10640 15940 10640 {}
C {lab_pin.sym} 15940 10640 0 0 {name=l34321 lab=BL80}
N 15960 10600 15940 10600 {}
C {lab_pin.sym} 15940 10600 0 0 {name=l34322 lab=BLB80}
N 15960 10560 15940 10560 {}
C {lab_pin.sym} 15940 10560 0 0 {name=l34323 lab=WL53}
N 16040 10640 16060 10640 {}
C {lab_pin.sym} 16060 10640 0 0 {name=l34324 lab=VDD}
N 16040 10560 16060 10560 {}
C {lab_pin.sym} 16060 10560 0 0 {name=l34325 lab=VSS}
C {bitcell_6t.sym} 16200 10600 0 0 {name=Xr53c81}
N 16160 10640 16140 10640 {}
C {lab_pin.sym} 16140 10640 0 0 {name=l34326 lab=BL81}
N 16160 10600 16140 10600 {}
C {lab_pin.sym} 16140 10600 0 0 {name=l34327 lab=BLB81}
N 16160 10560 16140 10560 {}
C {lab_pin.sym} 16140 10560 0 0 {name=l34328 lab=WL53}
N 16240 10640 16260 10640 {}
C {lab_pin.sym} 16260 10640 0 0 {name=l34329 lab=VDD}
N 16240 10560 16260 10560 {}
C {lab_pin.sym} 16260 10560 0 0 {name=l34330 lab=VSS}
C {bitcell_6t.sym} 16400 10600 0 0 {name=Xr53c82}
N 16360 10640 16340 10640 {}
C {lab_pin.sym} 16340 10640 0 0 {name=l34331 lab=BL82}
N 16360 10600 16340 10600 {}
C {lab_pin.sym} 16340 10600 0 0 {name=l34332 lab=BLB82}
N 16360 10560 16340 10560 {}
C {lab_pin.sym} 16340 10560 0 0 {name=l34333 lab=WL53}
N 16440 10640 16460 10640 {}
C {lab_pin.sym} 16460 10640 0 0 {name=l34334 lab=VDD}
N 16440 10560 16460 10560 {}
C {lab_pin.sym} 16460 10560 0 0 {name=l34335 lab=VSS}
C {bitcell_6t.sym} 16600 10600 0 0 {name=Xr53c83}
N 16560 10640 16540 10640 {}
C {lab_pin.sym} 16540 10640 0 0 {name=l34336 lab=BL83}
N 16560 10600 16540 10600 {}
C {lab_pin.sym} 16540 10600 0 0 {name=l34337 lab=BLB83}
N 16560 10560 16540 10560 {}
C {lab_pin.sym} 16540 10560 0 0 {name=l34338 lab=WL53}
N 16640 10640 16660 10640 {}
C {lab_pin.sym} 16660 10640 0 0 {name=l34339 lab=VDD}
N 16640 10560 16660 10560 {}
C {lab_pin.sym} 16660 10560 0 0 {name=l34340 lab=VSS}
C {bitcell_6t.sym} 16800 10600 0 0 {name=Xr53c84}
N 16760 10640 16740 10640 {}
C {lab_pin.sym} 16740 10640 0 0 {name=l34341 lab=BL84}
N 16760 10600 16740 10600 {}
C {lab_pin.sym} 16740 10600 0 0 {name=l34342 lab=BLB84}
N 16760 10560 16740 10560 {}
C {lab_pin.sym} 16740 10560 0 0 {name=l34343 lab=WL53}
N 16840 10640 16860 10640 {}
C {lab_pin.sym} 16860 10640 0 0 {name=l34344 lab=VDD}
N 16840 10560 16860 10560 {}
C {lab_pin.sym} 16860 10560 0 0 {name=l34345 lab=VSS}
C {bitcell_6t.sym} 17000 10600 0 0 {name=Xr53c85}
N 16960 10640 16940 10640 {}
C {lab_pin.sym} 16940 10640 0 0 {name=l34346 lab=BL85}
N 16960 10600 16940 10600 {}
C {lab_pin.sym} 16940 10600 0 0 {name=l34347 lab=BLB85}
N 16960 10560 16940 10560 {}
C {lab_pin.sym} 16940 10560 0 0 {name=l34348 lab=WL53}
N 17040 10640 17060 10640 {}
C {lab_pin.sym} 17060 10640 0 0 {name=l34349 lab=VDD}
N 17040 10560 17060 10560 {}
C {lab_pin.sym} 17060 10560 0 0 {name=l34350 lab=VSS}
C {bitcell_6t.sym} 17200 10600 0 0 {name=Xr53c86}
N 17160 10640 17140 10640 {}
C {lab_pin.sym} 17140 10640 0 0 {name=l34351 lab=BL86}
N 17160 10600 17140 10600 {}
C {lab_pin.sym} 17140 10600 0 0 {name=l34352 lab=BLB86}
N 17160 10560 17140 10560 {}
C {lab_pin.sym} 17140 10560 0 0 {name=l34353 lab=WL53}
N 17240 10640 17260 10640 {}
C {lab_pin.sym} 17260 10640 0 0 {name=l34354 lab=VDD}
N 17240 10560 17260 10560 {}
C {lab_pin.sym} 17260 10560 0 0 {name=l34355 lab=VSS}
C {bitcell_6t.sym} 17400 10600 0 0 {name=Xr53c87}
N 17360 10640 17340 10640 {}
C {lab_pin.sym} 17340 10640 0 0 {name=l34356 lab=BL87}
N 17360 10600 17340 10600 {}
C {lab_pin.sym} 17340 10600 0 0 {name=l34357 lab=BLB87}
N 17360 10560 17340 10560 {}
C {lab_pin.sym} 17340 10560 0 0 {name=l34358 lab=WL53}
N 17440 10640 17460 10640 {}
C {lab_pin.sym} 17460 10640 0 0 {name=l34359 lab=VDD}
N 17440 10560 17460 10560 {}
C {lab_pin.sym} 17460 10560 0 0 {name=l34360 lab=VSS}
C {bitcell_6t.sym} 17600 10600 0 0 {name=Xr53c88}
N 17560 10640 17540 10640 {}
C {lab_pin.sym} 17540 10640 0 0 {name=l34361 lab=BL88}
N 17560 10600 17540 10600 {}
C {lab_pin.sym} 17540 10600 0 0 {name=l34362 lab=BLB88}
N 17560 10560 17540 10560 {}
C {lab_pin.sym} 17540 10560 0 0 {name=l34363 lab=WL53}
N 17640 10640 17660 10640 {}
C {lab_pin.sym} 17660 10640 0 0 {name=l34364 lab=VDD}
N 17640 10560 17660 10560 {}
C {lab_pin.sym} 17660 10560 0 0 {name=l34365 lab=VSS}
C {bitcell_6t.sym} 17800 10600 0 0 {name=Xr53c89}
N 17760 10640 17740 10640 {}
C {lab_pin.sym} 17740 10640 0 0 {name=l34366 lab=BL89}
N 17760 10600 17740 10600 {}
C {lab_pin.sym} 17740 10600 0 0 {name=l34367 lab=BLB89}
N 17760 10560 17740 10560 {}
C {lab_pin.sym} 17740 10560 0 0 {name=l34368 lab=WL53}
N 17840 10640 17860 10640 {}
C {lab_pin.sym} 17860 10640 0 0 {name=l34369 lab=VDD}
N 17840 10560 17860 10560 {}
C {lab_pin.sym} 17860 10560 0 0 {name=l34370 lab=VSS}
C {bitcell_6t.sym} 18000 10600 0 0 {name=Xr53c90}
N 17960 10640 17940 10640 {}
C {lab_pin.sym} 17940 10640 0 0 {name=l34371 lab=BL90}
N 17960 10600 17940 10600 {}
C {lab_pin.sym} 17940 10600 0 0 {name=l34372 lab=BLB90}
N 17960 10560 17940 10560 {}
C {lab_pin.sym} 17940 10560 0 0 {name=l34373 lab=WL53}
N 18040 10640 18060 10640 {}
C {lab_pin.sym} 18060 10640 0 0 {name=l34374 lab=VDD}
N 18040 10560 18060 10560 {}
C {lab_pin.sym} 18060 10560 0 0 {name=l34375 lab=VSS}
C {bitcell_6t.sym} 18200 10600 0 0 {name=Xr53c91}
N 18160 10640 18140 10640 {}
C {lab_pin.sym} 18140 10640 0 0 {name=l34376 lab=BL91}
N 18160 10600 18140 10600 {}
C {lab_pin.sym} 18140 10600 0 0 {name=l34377 lab=BLB91}
N 18160 10560 18140 10560 {}
C {lab_pin.sym} 18140 10560 0 0 {name=l34378 lab=WL53}
N 18240 10640 18260 10640 {}
C {lab_pin.sym} 18260 10640 0 0 {name=l34379 lab=VDD}
N 18240 10560 18260 10560 {}
C {lab_pin.sym} 18260 10560 0 0 {name=l34380 lab=VSS}
C {bitcell_6t.sym} 18400 10600 0 0 {name=Xr53c92}
N 18360 10640 18340 10640 {}
C {lab_pin.sym} 18340 10640 0 0 {name=l34381 lab=BL92}
N 18360 10600 18340 10600 {}
C {lab_pin.sym} 18340 10600 0 0 {name=l34382 lab=BLB92}
N 18360 10560 18340 10560 {}
C {lab_pin.sym} 18340 10560 0 0 {name=l34383 lab=WL53}
N 18440 10640 18460 10640 {}
C {lab_pin.sym} 18460 10640 0 0 {name=l34384 lab=VDD}
N 18440 10560 18460 10560 {}
C {lab_pin.sym} 18460 10560 0 0 {name=l34385 lab=VSS}
C {bitcell_6t.sym} 18600 10600 0 0 {name=Xr53c93}
N 18560 10640 18540 10640 {}
C {lab_pin.sym} 18540 10640 0 0 {name=l34386 lab=BL93}
N 18560 10600 18540 10600 {}
C {lab_pin.sym} 18540 10600 0 0 {name=l34387 lab=BLB93}
N 18560 10560 18540 10560 {}
C {lab_pin.sym} 18540 10560 0 0 {name=l34388 lab=WL53}
N 18640 10640 18660 10640 {}
C {lab_pin.sym} 18660 10640 0 0 {name=l34389 lab=VDD}
N 18640 10560 18660 10560 {}
C {lab_pin.sym} 18660 10560 0 0 {name=l34390 lab=VSS}
C {bitcell_6t.sym} 18800 10600 0 0 {name=Xr53c94}
N 18760 10640 18740 10640 {}
C {lab_pin.sym} 18740 10640 0 0 {name=l34391 lab=BL94}
N 18760 10600 18740 10600 {}
C {lab_pin.sym} 18740 10600 0 0 {name=l34392 lab=BLB94}
N 18760 10560 18740 10560 {}
C {lab_pin.sym} 18740 10560 0 0 {name=l34393 lab=WL53}
N 18840 10640 18860 10640 {}
C {lab_pin.sym} 18860 10640 0 0 {name=l34394 lab=VDD}
N 18840 10560 18860 10560 {}
C {lab_pin.sym} 18860 10560 0 0 {name=l34395 lab=VSS}
C {bitcell_6t.sym} 19000 10600 0 0 {name=Xr53c95}
N 18960 10640 18940 10640 {}
C {lab_pin.sym} 18940 10640 0 0 {name=l34396 lab=BL95}
N 18960 10600 18940 10600 {}
C {lab_pin.sym} 18940 10600 0 0 {name=l34397 lab=BLB95}
N 18960 10560 18940 10560 {}
C {lab_pin.sym} 18940 10560 0 0 {name=l34398 lab=WL53}
N 19040 10640 19060 10640 {}
C {lab_pin.sym} 19060 10640 0 0 {name=l34399 lab=VDD}
N 19040 10560 19060 10560 {}
C {lab_pin.sym} 19060 10560 0 0 {name=l34400 lab=VSS}
C {bitcell_6t.sym} 19200 10600 0 0 {name=Xr53c96}
N 19160 10640 19140 10640 {}
C {lab_pin.sym} 19140 10640 0 0 {name=l34401 lab=BL96}
N 19160 10600 19140 10600 {}
C {lab_pin.sym} 19140 10600 0 0 {name=l34402 lab=BLB96}
N 19160 10560 19140 10560 {}
C {lab_pin.sym} 19140 10560 0 0 {name=l34403 lab=WL53}
N 19240 10640 19260 10640 {}
C {lab_pin.sym} 19260 10640 0 0 {name=l34404 lab=VDD}
N 19240 10560 19260 10560 {}
C {lab_pin.sym} 19260 10560 0 0 {name=l34405 lab=VSS}
C {bitcell_6t.sym} 19400 10600 0 0 {name=Xr53c97}
N 19360 10640 19340 10640 {}
C {lab_pin.sym} 19340 10640 0 0 {name=l34406 lab=BL97}
N 19360 10600 19340 10600 {}
C {lab_pin.sym} 19340 10600 0 0 {name=l34407 lab=BLB97}
N 19360 10560 19340 10560 {}
C {lab_pin.sym} 19340 10560 0 0 {name=l34408 lab=WL53}
N 19440 10640 19460 10640 {}
C {lab_pin.sym} 19460 10640 0 0 {name=l34409 lab=VDD}
N 19440 10560 19460 10560 {}
C {lab_pin.sym} 19460 10560 0 0 {name=l34410 lab=VSS}
C {bitcell_6t.sym} 19600 10600 0 0 {name=Xr53c98}
N 19560 10640 19540 10640 {}
C {lab_pin.sym} 19540 10640 0 0 {name=l34411 lab=BL98}
N 19560 10600 19540 10600 {}
C {lab_pin.sym} 19540 10600 0 0 {name=l34412 lab=BLB98}
N 19560 10560 19540 10560 {}
C {lab_pin.sym} 19540 10560 0 0 {name=l34413 lab=WL53}
N 19640 10640 19660 10640 {}
C {lab_pin.sym} 19660 10640 0 0 {name=l34414 lab=VDD}
N 19640 10560 19660 10560 {}
C {lab_pin.sym} 19660 10560 0 0 {name=l34415 lab=VSS}
C {bitcell_6t.sym} 19800 10600 0 0 {name=Xr53c99}
N 19760 10640 19740 10640 {}
C {lab_pin.sym} 19740 10640 0 0 {name=l34416 lab=BL99}
N 19760 10600 19740 10600 {}
C {lab_pin.sym} 19740 10600 0 0 {name=l34417 lab=BLB99}
N 19760 10560 19740 10560 {}
C {lab_pin.sym} 19740 10560 0 0 {name=l34418 lab=WL53}
N 19840 10640 19860 10640 {}
C {lab_pin.sym} 19860 10640 0 0 {name=l34419 lab=VDD}
N 19840 10560 19860 10560 {}
C {lab_pin.sym} 19860 10560 0 0 {name=l34420 lab=VSS}
C {bitcell_6t.sym} 20000 10600 0 0 {name=Xr53c100}
N 19960 10640 19940 10640 {}
C {lab_pin.sym} 19940 10640 0 0 {name=l34421 lab=BL100}
N 19960 10600 19940 10600 {}
C {lab_pin.sym} 19940 10600 0 0 {name=l34422 lab=BLB100}
N 19960 10560 19940 10560 {}
C {lab_pin.sym} 19940 10560 0 0 {name=l34423 lab=WL53}
N 20040 10640 20060 10640 {}
C {lab_pin.sym} 20060 10640 0 0 {name=l34424 lab=VDD}
N 20040 10560 20060 10560 {}
C {lab_pin.sym} 20060 10560 0 0 {name=l34425 lab=VSS}
C {bitcell_6t.sym} 20200 10600 0 0 {name=Xr53c101}
N 20160 10640 20140 10640 {}
C {lab_pin.sym} 20140 10640 0 0 {name=l34426 lab=BL101}
N 20160 10600 20140 10600 {}
C {lab_pin.sym} 20140 10600 0 0 {name=l34427 lab=BLB101}
N 20160 10560 20140 10560 {}
C {lab_pin.sym} 20140 10560 0 0 {name=l34428 lab=WL53}
N 20240 10640 20260 10640 {}
C {lab_pin.sym} 20260 10640 0 0 {name=l34429 lab=VDD}
N 20240 10560 20260 10560 {}
C {lab_pin.sym} 20260 10560 0 0 {name=l34430 lab=VSS}
C {bitcell_6t.sym} 20400 10600 0 0 {name=Xr53c102}
N 20360 10640 20340 10640 {}
C {lab_pin.sym} 20340 10640 0 0 {name=l34431 lab=BL102}
N 20360 10600 20340 10600 {}
C {lab_pin.sym} 20340 10600 0 0 {name=l34432 lab=BLB102}
N 20360 10560 20340 10560 {}
C {lab_pin.sym} 20340 10560 0 0 {name=l34433 lab=WL53}
N 20440 10640 20460 10640 {}
C {lab_pin.sym} 20460 10640 0 0 {name=l34434 lab=VDD}
N 20440 10560 20460 10560 {}
C {lab_pin.sym} 20460 10560 0 0 {name=l34435 lab=VSS}
C {bitcell_6t.sym} 20600 10600 0 0 {name=Xr53c103}
N 20560 10640 20540 10640 {}
C {lab_pin.sym} 20540 10640 0 0 {name=l34436 lab=BL103}
N 20560 10600 20540 10600 {}
C {lab_pin.sym} 20540 10600 0 0 {name=l34437 lab=BLB103}
N 20560 10560 20540 10560 {}
C {lab_pin.sym} 20540 10560 0 0 {name=l34438 lab=WL53}
N 20640 10640 20660 10640 {}
C {lab_pin.sym} 20660 10640 0 0 {name=l34439 lab=VDD}
N 20640 10560 20660 10560 {}
C {lab_pin.sym} 20660 10560 0 0 {name=l34440 lab=VSS}
C {bitcell_6t.sym} 20800 10600 0 0 {name=Xr53c104}
N 20760 10640 20740 10640 {}
C {lab_pin.sym} 20740 10640 0 0 {name=l34441 lab=BL104}
N 20760 10600 20740 10600 {}
C {lab_pin.sym} 20740 10600 0 0 {name=l34442 lab=BLB104}
N 20760 10560 20740 10560 {}
C {lab_pin.sym} 20740 10560 0 0 {name=l34443 lab=WL53}
N 20840 10640 20860 10640 {}
C {lab_pin.sym} 20860 10640 0 0 {name=l34444 lab=VDD}
N 20840 10560 20860 10560 {}
C {lab_pin.sym} 20860 10560 0 0 {name=l34445 lab=VSS}
C {bitcell_6t.sym} 21000 10600 0 0 {name=Xr53c105}
N 20960 10640 20940 10640 {}
C {lab_pin.sym} 20940 10640 0 0 {name=l34446 lab=BL105}
N 20960 10600 20940 10600 {}
C {lab_pin.sym} 20940 10600 0 0 {name=l34447 lab=BLB105}
N 20960 10560 20940 10560 {}
C {lab_pin.sym} 20940 10560 0 0 {name=l34448 lab=WL53}
N 21040 10640 21060 10640 {}
C {lab_pin.sym} 21060 10640 0 0 {name=l34449 lab=VDD}
N 21040 10560 21060 10560 {}
C {lab_pin.sym} 21060 10560 0 0 {name=l34450 lab=VSS}
C {bitcell_6t.sym} 21200 10600 0 0 {name=Xr53c106}
N 21160 10640 21140 10640 {}
C {lab_pin.sym} 21140 10640 0 0 {name=l34451 lab=BL106}
N 21160 10600 21140 10600 {}
C {lab_pin.sym} 21140 10600 0 0 {name=l34452 lab=BLB106}
N 21160 10560 21140 10560 {}
C {lab_pin.sym} 21140 10560 0 0 {name=l34453 lab=WL53}
N 21240 10640 21260 10640 {}
C {lab_pin.sym} 21260 10640 0 0 {name=l34454 lab=VDD}
N 21240 10560 21260 10560 {}
C {lab_pin.sym} 21260 10560 0 0 {name=l34455 lab=VSS}
C {bitcell_6t.sym} 21400 10600 0 0 {name=Xr53c107}
N 21360 10640 21340 10640 {}
C {lab_pin.sym} 21340 10640 0 0 {name=l34456 lab=BL107}
N 21360 10600 21340 10600 {}
C {lab_pin.sym} 21340 10600 0 0 {name=l34457 lab=BLB107}
N 21360 10560 21340 10560 {}
C {lab_pin.sym} 21340 10560 0 0 {name=l34458 lab=WL53}
N 21440 10640 21460 10640 {}
C {lab_pin.sym} 21460 10640 0 0 {name=l34459 lab=VDD}
N 21440 10560 21460 10560 {}
C {lab_pin.sym} 21460 10560 0 0 {name=l34460 lab=VSS}
C {bitcell_6t.sym} 21600 10600 0 0 {name=Xr53c108}
N 21560 10640 21540 10640 {}
C {lab_pin.sym} 21540 10640 0 0 {name=l34461 lab=BL108}
N 21560 10600 21540 10600 {}
C {lab_pin.sym} 21540 10600 0 0 {name=l34462 lab=BLB108}
N 21560 10560 21540 10560 {}
C {lab_pin.sym} 21540 10560 0 0 {name=l34463 lab=WL53}
N 21640 10640 21660 10640 {}
C {lab_pin.sym} 21660 10640 0 0 {name=l34464 lab=VDD}
N 21640 10560 21660 10560 {}
C {lab_pin.sym} 21660 10560 0 0 {name=l34465 lab=VSS}
C {bitcell_6t.sym} 21800 10600 0 0 {name=Xr53c109}
N 21760 10640 21740 10640 {}
C {lab_pin.sym} 21740 10640 0 0 {name=l34466 lab=BL109}
N 21760 10600 21740 10600 {}
C {lab_pin.sym} 21740 10600 0 0 {name=l34467 lab=BLB109}
N 21760 10560 21740 10560 {}
C {lab_pin.sym} 21740 10560 0 0 {name=l34468 lab=WL53}
N 21840 10640 21860 10640 {}
C {lab_pin.sym} 21860 10640 0 0 {name=l34469 lab=VDD}
N 21840 10560 21860 10560 {}
C {lab_pin.sym} 21860 10560 0 0 {name=l34470 lab=VSS}
C {bitcell_6t.sym} 22000 10600 0 0 {name=Xr53c110}
N 21960 10640 21940 10640 {}
C {lab_pin.sym} 21940 10640 0 0 {name=l34471 lab=BL110}
N 21960 10600 21940 10600 {}
C {lab_pin.sym} 21940 10600 0 0 {name=l34472 lab=BLB110}
N 21960 10560 21940 10560 {}
C {lab_pin.sym} 21940 10560 0 0 {name=l34473 lab=WL53}
N 22040 10640 22060 10640 {}
C {lab_pin.sym} 22060 10640 0 0 {name=l34474 lab=VDD}
N 22040 10560 22060 10560 {}
C {lab_pin.sym} 22060 10560 0 0 {name=l34475 lab=VSS}
C {bitcell_6t.sym} 22200 10600 0 0 {name=Xr53c111}
N 22160 10640 22140 10640 {}
C {lab_pin.sym} 22140 10640 0 0 {name=l34476 lab=BL111}
N 22160 10600 22140 10600 {}
C {lab_pin.sym} 22140 10600 0 0 {name=l34477 lab=BLB111}
N 22160 10560 22140 10560 {}
C {lab_pin.sym} 22140 10560 0 0 {name=l34478 lab=WL53}
N 22240 10640 22260 10640 {}
C {lab_pin.sym} 22260 10640 0 0 {name=l34479 lab=VDD}
N 22240 10560 22260 10560 {}
C {lab_pin.sym} 22260 10560 0 0 {name=l34480 lab=VSS}
C {bitcell_6t.sym} 22400 10600 0 0 {name=Xr53c112}
N 22360 10640 22340 10640 {}
C {lab_pin.sym} 22340 10640 0 0 {name=l34481 lab=BL112}
N 22360 10600 22340 10600 {}
C {lab_pin.sym} 22340 10600 0 0 {name=l34482 lab=BLB112}
N 22360 10560 22340 10560 {}
C {lab_pin.sym} 22340 10560 0 0 {name=l34483 lab=WL53}
N 22440 10640 22460 10640 {}
C {lab_pin.sym} 22460 10640 0 0 {name=l34484 lab=VDD}
N 22440 10560 22460 10560 {}
C {lab_pin.sym} 22460 10560 0 0 {name=l34485 lab=VSS}
C {bitcell_6t.sym} 22600 10600 0 0 {name=Xr53c113}
N 22560 10640 22540 10640 {}
C {lab_pin.sym} 22540 10640 0 0 {name=l34486 lab=BL113}
N 22560 10600 22540 10600 {}
C {lab_pin.sym} 22540 10600 0 0 {name=l34487 lab=BLB113}
N 22560 10560 22540 10560 {}
C {lab_pin.sym} 22540 10560 0 0 {name=l34488 lab=WL53}
N 22640 10640 22660 10640 {}
C {lab_pin.sym} 22660 10640 0 0 {name=l34489 lab=VDD}
N 22640 10560 22660 10560 {}
C {lab_pin.sym} 22660 10560 0 0 {name=l34490 lab=VSS}
C {bitcell_6t.sym} 22800 10600 0 0 {name=Xr53c114}
N 22760 10640 22740 10640 {}
C {lab_pin.sym} 22740 10640 0 0 {name=l34491 lab=BL114}
N 22760 10600 22740 10600 {}
C {lab_pin.sym} 22740 10600 0 0 {name=l34492 lab=BLB114}
N 22760 10560 22740 10560 {}
C {lab_pin.sym} 22740 10560 0 0 {name=l34493 lab=WL53}
N 22840 10640 22860 10640 {}
C {lab_pin.sym} 22860 10640 0 0 {name=l34494 lab=VDD}
N 22840 10560 22860 10560 {}
C {lab_pin.sym} 22860 10560 0 0 {name=l34495 lab=VSS}
C {bitcell_6t.sym} 23000 10600 0 0 {name=Xr53c115}
N 22960 10640 22940 10640 {}
C {lab_pin.sym} 22940 10640 0 0 {name=l34496 lab=BL115}
N 22960 10600 22940 10600 {}
C {lab_pin.sym} 22940 10600 0 0 {name=l34497 lab=BLB115}
N 22960 10560 22940 10560 {}
C {lab_pin.sym} 22940 10560 0 0 {name=l34498 lab=WL53}
N 23040 10640 23060 10640 {}
C {lab_pin.sym} 23060 10640 0 0 {name=l34499 lab=VDD}
N 23040 10560 23060 10560 {}
C {lab_pin.sym} 23060 10560 0 0 {name=l34500 lab=VSS}
C {bitcell_6t.sym} 23200 10600 0 0 {name=Xr53c116}
N 23160 10640 23140 10640 {}
C {lab_pin.sym} 23140 10640 0 0 {name=l34501 lab=BL116}
N 23160 10600 23140 10600 {}
C {lab_pin.sym} 23140 10600 0 0 {name=l34502 lab=BLB116}
N 23160 10560 23140 10560 {}
C {lab_pin.sym} 23140 10560 0 0 {name=l34503 lab=WL53}
N 23240 10640 23260 10640 {}
C {lab_pin.sym} 23260 10640 0 0 {name=l34504 lab=VDD}
N 23240 10560 23260 10560 {}
C {lab_pin.sym} 23260 10560 0 0 {name=l34505 lab=VSS}
C {bitcell_6t.sym} 23400 10600 0 0 {name=Xr53c117}
N 23360 10640 23340 10640 {}
C {lab_pin.sym} 23340 10640 0 0 {name=l34506 lab=BL117}
N 23360 10600 23340 10600 {}
C {lab_pin.sym} 23340 10600 0 0 {name=l34507 lab=BLB117}
N 23360 10560 23340 10560 {}
C {lab_pin.sym} 23340 10560 0 0 {name=l34508 lab=WL53}
N 23440 10640 23460 10640 {}
C {lab_pin.sym} 23460 10640 0 0 {name=l34509 lab=VDD}
N 23440 10560 23460 10560 {}
C {lab_pin.sym} 23460 10560 0 0 {name=l34510 lab=VSS}
C {bitcell_6t.sym} 23600 10600 0 0 {name=Xr53c118}
N 23560 10640 23540 10640 {}
C {lab_pin.sym} 23540 10640 0 0 {name=l34511 lab=BL118}
N 23560 10600 23540 10600 {}
C {lab_pin.sym} 23540 10600 0 0 {name=l34512 lab=BLB118}
N 23560 10560 23540 10560 {}
C {lab_pin.sym} 23540 10560 0 0 {name=l34513 lab=WL53}
N 23640 10640 23660 10640 {}
C {lab_pin.sym} 23660 10640 0 0 {name=l34514 lab=VDD}
N 23640 10560 23660 10560 {}
C {lab_pin.sym} 23660 10560 0 0 {name=l34515 lab=VSS}
C {bitcell_6t.sym} 23800 10600 0 0 {name=Xr53c119}
N 23760 10640 23740 10640 {}
C {lab_pin.sym} 23740 10640 0 0 {name=l34516 lab=BL119}
N 23760 10600 23740 10600 {}
C {lab_pin.sym} 23740 10600 0 0 {name=l34517 lab=BLB119}
N 23760 10560 23740 10560 {}
C {lab_pin.sym} 23740 10560 0 0 {name=l34518 lab=WL53}
N 23840 10640 23860 10640 {}
C {lab_pin.sym} 23860 10640 0 0 {name=l34519 lab=VDD}
N 23840 10560 23860 10560 {}
C {lab_pin.sym} 23860 10560 0 0 {name=l34520 lab=VSS}
C {bitcell_6t.sym} 24000 10600 0 0 {name=Xr53c120}
N 23960 10640 23940 10640 {}
C {lab_pin.sym} 23940 10640 0 0 {name=l34521 lab=BL120}
N 23960 10600 23940 10600 {}
C {lab_pin.sym} 23940 10600 0 0 {name=l34522 lab=BLB120}
N 23960 10560 23940 10560 {}
C {lab_pin.sym} 23940 10560 0 0 {name=l34523 lab=WL53}
N 24040 10640 24060 10640 {}
C {lab_pin.sym} 24060 10640 0 0 {name=l34524 lab=VDD}
N 24040 10560 24060 10560 {}
C {lab_pin.sym} 24060 10560 0 0 {name=l34525 lab=VSS}
C {bitcell_6t.sym} 24200 10600 0 0 {name=Xr53c121}
N 24160 10640 24140 10640 {}
C {lab_pin.sym} 24140 10640 0 0 {name=l34526 lab=BL121}
N 24160 10600 24140 10600 {}
C {lab_pin.sym} 24140 10600 0 0 {name=l34527 lab=BLB121}
N 24160 10560 24140 10560 {}
C {lab_pin.sym} 24140 10560 0 0 {name=l34528 lab=WL53}
N 24240 10640 24260 10640 {}
C {lab_pin.sym} 24260 10640 0 0 {name=l34529 lab=VDD}
N 24240 10560 24260 10560 {}
C {lab_pin.sym} 24260 10560 0 0 {name=l34530 lab=VSS}
C {bitcell_6t.sym} 24400 10600 0 0 {name=Xr53c122}
N 24360 10640 24340 10640 {}
C {lab_pin.sym} 24340 10640 0 0 {name=l34531 lab=BL122}
N 24360 10600 24340 10600 {}
C {lab_pin.sym} 24340 10600 0 0 {name=l34532 lab=BLB122}
N 24360 10560 24340 10560 {}
C {lab_pin.sym} 24340 10560 0 0 {name=l34533 lab=WL53}
N 24440 10640 24460 10640 {}
C {lab_pin.sym} 24460 10640 0 0 {name=l34534 lab=VDD}
N 24440 10560 24460 10560 {}
C {lab_pin.sym} 24460 10560 0 0 {name=l34535 lab=VSS}
C {bitcell_6t.sym} 24600 10600 0 0 {name=Xr53c123}
N 24560 10640 24540 10640 {}
C {lab_pin.sym} 24540 10640 0 0 {name=l34536 lab=BL123}
N 24560 10600 24540 10600 {}
C {lab_pin.sym} 24540 10600 0 0 {name=l34537 lab=BLB123}
N 24560 10560 24540 10560 {}
C {lab_pin.sym} 24540 10560 0 0 {name=l34538 lab=WL53}
N 24640 10640 24660 10640 {}
C {lab_pin.sym} 24660 10640 0 0 {name=l34539 lab=VDD}
N 24640 10560 24660 10560 {}
C {lab_pin.sym} 24660 10560 0 0 {name=l34540 lab=VSS}
C {bitcell_6t.sym} 24800 10600 0 0 {name=Xr53c124}
N 24760 10640 24740 10640 {}
C {lab_pin.sym} 24740 10640 0 0 {name=l34541 lab=BL124}
N 24760 10600 24740 10600 {}
C {lab_pin.sym} 24740 10600 0 0 {name=l34542 lab=BLB124}
N 24760 10560 24740 10560 {}
C {lab_pin.sym} 24740 10560 0 0 {name=l34543 lab=WL53}
N 24840 10640 24860 10640 {}
C {lab_pin.sym} 24860 10640 0 0 {name=l34544 lab=VDD}
N 24840 10560 24860 10560 {}
C {lab_pin.sym} 24860 10560 0 0 {name=l34545 lab=VSS}
C {bitcell_6t.sym} 25000 10600 0 0 {name=Xr53c125}
N 24960 10640 24940 10640 {}
C {lab_pin.sym} 24940 10640 0 0 {name=l34546 lab=BL125}
N 24960 10600 24940 10600 {}
C {lab_pin.sym} 24940 10600 0 0 {name=l34547 lab=BLB125}
N 24960 10560 24940 10560 {}
C {lab_pin.sym} 24940 10560 0 0 {name=l34548 lab=WL53}
N 25040 10640 25060 10640 {}
C {lab_pin.sym} 25060 10640 0 0 {name=l34549 lab=VDD}
N 25040 10560 25060 10560 {}
C {lab_pin.sym} 25060 10560 0 0 {name=l34550 lab=VSS}
C {bitcell_6t.sym} 25200 10600 0 0 {name=Xr53c126}
N 25160 10640 25140 10640 {}
C {lab_pin.sym} 25140 10640 0 0 {name=l34551 lab=BL126}
N 25160 10600 25140 10600 {}
C {lab_pin.sym} 25140 10600 0 0 {name=l34552 lab=BLB126}
N 25160 10560 25140 10560 {}
C {lab_pin.sym} 25140 10560 0 0 {name=l34553 lab=WL53}
N 25240 10640 25260 10640 {}
C {lab_pin.sym} 25260 10640 0 0 {name=l34554 lab=VDD}
N 25240 10560 25260 10560 {}
C {lab_pin.sym} 25260 10560 0 0 {name=l34555 lab=VSS}
C {bitcell_6t.sym} 25400 10600 0 0 {name=Xr53c127}
N 25360 10640 25340 10640 {}
C {lab_pin.sym} 25340 10640 0 0 {name=l34556 lab=BL127}
N 25360 10600 25340 10600 {}
C {lab_pin.sym} 25340 10600 0 0 {name=l34557 lab=BLB127}
N 25360 10560 25340 10560 {}
C {lab_pin.sym} 25340 10560 0 0 {name=l34558 lab=WL53}
N 25440 10640 25460 10640 {}
C {lab_pin.sym} 25460 10640 0 0 {name=l34559 lab=VDD}
N 25440 10560 25460 10560 {}
C {lab_pin.sym} 25460 10560 0 0 {name=l34560 lab=VSS}
C {bitcell_6t.sym} 0 10800 0 0 {name=Xr54c0}
N -40 10840 -60 10840 {}
C {lab_pin.sym} -60 10840 0 0 {name=l34561 lab=BL0}
N -40 10800 -60 10800 {}
C {lab_pin.sym} -60 10800 0 0 {name=l34562 lab=BLB0}
N -40 10760 -60 10760 {}
C {lab_pin.sym} -60 10760 0 0 {name=l34563 lab=WL54}
N 40 10840 60 10840 {}
C {lab_pin.sym} 60 10840 0 0 {name=l34564 lab=VDD}
N 40 10760 60 10760 {}
C {lab_pin.sym} 60 10760 0 0 {name=l34565 lab=VSS}
C {bitcell_6t.sym} 200 10800 0 0 {name=Xr54c1}
N 160 10840 140 10840 {}
C {lab_pin.sym} 140 10840 0 0 {name=l34566 lab=BL1}
N 160 10800 140 10800 {}
C {lab_pin.sym} 140 10800 0 0 {name=l34567 lab=BLB1}
N 160 10760 140 10760 {}
C {lab_pin.sym} 140 10760 0 0 {name=l34568 lab=WL54}
N 240 10840 260 10840 {}
C {lab_pin.sym} 260 10840 0 0 {name=l34569 lab=VDD}
N 240 10760 260 10760 {}
C {lab_pin.sym} 260 10760 0 0 {name=l34570 lab=VSS}
C {bitcell_6t.sym} 400 10800 0 0 {name=Xr54c2}
N 360 10840 340 10840 {}
C {lab_pin.sym} 340 10840 0 0 {name=l34571 lab=BL2}
N 360 10800 340 10800 {}
C {lab_pin.sym} 340 10800 0 0 {name=l34572 lab=BLB2}
N 360 10760 340 10760 {}
C {lab_pin.sym} 340 10760 0 0 {name=l34573 lab=WL54}
N 440 10840 460 10840 {}
C {lab_pin.sym} 460 10840 0 0 {name=l34574 lab=VDD}
N 440 10760 460 10760 {}
C {lab_pin.sym} 460 10760 0 0 {name=l34575 lab=VSS}
C {bitcell_6t.sym} 600 10800 0 0 {name=Xr54c3}
N 560 10840 540 10840 {}
C {lab_pin.sym} 540 10840 0 0 {name=l34576 lab=BL3}
N 560 10800 540 10800 {}
C {lab_pin.sym} 540 10800 0 0 {name=l34577 lab=BLB3}
N 560 10760 540 10760 {}
C {lab_pin.sym} 540 10760 0 0 {name=l34578 lab=WL54}
N 640 10840 660 10840 {}
C {lab_pin.sym} 660 10840 0 0 {name=l34579 lab=VDD}
N 640 10760 660 10760 {}
C {lab_pin.sym} 660 10760 0 0 {name=l34580 lab=VSS}
C {bitcell_6t.sym} 800 10800 0 0 {name=Xr54c4}
N 760 10840 740 10840 {}
C {lab_pin.sym} 740 10840 0 0 {name=l34581 lab=BL4}
N 760 10800 740 10800 {}
C {lab_pin.sym} 740 10800 0 0 {name=l34582 lab=BLB4}
N 760 10760 740 10760 {}
C {lab_pin.sym} 740 10760 0 0 {name=l34583 lab=WL54}
N 840 10840 860 10840 {}
C {lab_pin.sym} 860 10840 0 0 {name=l34584 lab=VDD}
N 840 10760 860 10760 {}
C {lab_pin.sym} 860 10760 0 0 {name=l34585 lab=VSS}
C {bitcell_6t.sym} 1000 10800 0 0 {name=Xr54c5}
N 960 10840 940 10840 {}
C {lab_pin.sym} 940 10840 0 0 {name=l34586 lab=BL5}
N 960 10800 940 10800 {}
C {lab_pin.sym} 940 10800 0 0 {name=l34587 lab=BLB5}
N 960 10760 940 10760 {}
C {lab_pin.sym} 940 10760 0 0 {name=l34588 lab=WL54}
N 1040 10840 1060 10840 {}
C {lab_pin.sym} 1060 10840 0 0 {name=l34589 lab=VDD}
N 1040 10760 1060 10760 {}
C {lab_pin.sym} 1060 10760 0 0 {name=l34590 lab=VSS}
C {bitcell_6t.sym} 1200 10800 0 0 {name=Xr54c6}
N 1160 10840 1140 10840 {}
C {lab_pin.sym} 1140 10840 0 0 {name=l34591 lab=BL6}
N 1160 10800 1140 10800 {}
C {lab_pin.sym} 1140 10800 0 0 {name=l34592 lab=BLB6}
N 1160 10760 1140 10760 {}
C {lab_pin.sym} 1140 10760 0 0 {name=l34593 lab=WL54}
N 1240 10840 1260 10840 {}
C {lab_pin.sym} 1260 10840 0 0 {name=l34594 lab=VDD}
N 1240 10760 1260 10760 {}
C {lab_pin.sym} 1260 10760 0 0 {name=l34595 lab=VSS}
C {bitcell_6t.sym} 1400 10800 0 0 {name=Xr54c7}
N 1360 10840 1340 10840 {}
C {lab_pin.sym} 1340 10840 0 0 {name=l34596 lab=BL7}
N 1360 10800 1340 10800 {}
C {lab_pin.sym} 1340 10800 0 0 {name=l34597 lab=BLB7}
N 1360 10760 1340 10760 {}
C {lab_pin.sym} 1340 10760 0 0 {name=l34598 lab=WL54}
N 1440 10840 1460 10840 {}
C {lab_pin.sym} 1460 10840 0 0 {name=l34599 lab=VDD}
N 1440 10760 1460 10760 {}
C {lab_pin.sym} 1460 10760 0 0 {name=l34600 lab=VSS}
C {bitcell_6t.sym} 1600 10800 0 0 {name=Xr54c8}
N 1560 10840 1540 10840 {}
C {lab_pin.sym} 1540 10840 0 0 {name=l34601 lab=BL8}
N 1560 10800 1540 10800 {}
C {lab_pin.sym} 1540 10800 0 0 {name=l34602 lab=BLB8}
N 1560 10760 1540 10760 {}
C {lab_pin.sym} 1540 10760 0 0 {name=l34603 lab=WL54}
N 1640 10840 1660 10840 {}
C {lab_pin.sym} 1660 10840 0 0 {name=l34604 lab=VDD}
N 1640 10760 1660 10760 {}
C {lab_pin.sym} 1660 10760 0 0 {name=l34605 lab=VSS}
C {bitcell_6t.sym} 1800 10800 0 0 {name=Xr54c9}
N 1760 10840 1740 10840 {}
C {lab_pin.sym} 1740 10840 0 0 {name=l34606 lab=BL9}
N 1760 10800 1740 10800 {}
C {lab_pin.sym} 1740 10800 0 0 {name=l34607 lab=BLB9}
N 1760 10760 1740 10760 {}
C {lab_pin.sym} 1740 10760 0 0 {name=l34608 lab=WL54}
N 1840 10840 1860 10840 {}
C {lab_pin.sym} 1860 10840 0 0 {name=l34609 lab=VDD}
N 1840 10760 1860 10760 {}
C {lab_pin.sym} 1860 10760 0 0 {name=l34610 lab=VSS}
C {bitcell_6t.sym} 2000 10800 0 0 {name=Xr54c10}
N 1960 10840 1940 10840 {}
C {lab_pin.sym} 1940 10840 0 0 {name=l34611 lab=BL10}
N 1960 10800 1940 10800 {}
C {lab_pin.sym} 1940 10800 0 0 {name=l34612 lab=BLB10}
N 1960 10760 1940 10760 {}
C {lab_pin.sym} 1940 10760 0 0 {name=l34613 lab=WL54}
N 2040 10840 2060 10840 {}
C {lab_pin.sym} 2060 10840 0 0 {name=l34614 lab=VDD}
N 2040 10760 2060 10760 {}
C {lab_pin.sym} 2060 10760 0 0 {name=l34615 lab=VSS}
C {bitcell_6t.sym} 2200 10800 0 0 {name=Xr54c11}
N 2160 10840 2140 10840 {}
C {lab_pin.sym} 2140 10840 0 0 {name=l34616 lab=BL11}
N 2160 10800 2140 10800 {}
C {lab_pin.sym} 2140 10800 0 0 {name=l34617 lab=BLB11}
N 2160 10760 2140 10760 {}
C {lab_pin.sym} 2140 10760 0 0 {name=l34618 lab=WL54}
N 2240 10840 2260 10840 {}
C {lab_pin.sym} 2260 10840 0 0 {name=l34619 lab=VDD}
N 2240 10760 2260 10760 {}
C {lab_pin.sym} 2260 10760 0 0 {name=l34620 lab=VSS}
C {bitcell_6t.sym} 2400 10800 0 0 {name=Xr54c12}
N 2360 10840 2340 10840 {}
C {lab_pin.sym} 2340 10840 0 0 {name=l34621 lab=BL12}
N 2360 10800 2340 10800 {}
C {lab_pin.sym} 2340 10800 0 0 {name=l34622 lab=BLB12}
N 2360 10760 2340 10760 {}
C {lab_pin.sym} 2340 10760 0 0 {name=l34623 lab=WL54}
N 2440 10840 2460 10840 {}
C {lab_pin.sym} 2460 10840 0 0 {name=l34624 lab=VDD}
N 2440 10760 2460 10760 {}
C {lab_pin.sym} 2460 10760 0 0 {name=l34625 lab=VSS}
C {bitcell_6t.sym} 2600 10800 0 0 {name=Xr54c13}
N 2560 10840 2540 10840 {}
C {lab_pin.sym} 2540 10840 0 0 {name=l34626 lab=BL13}
N 2560 10800 2540 10800 {}
C {lab_pin.sym} 2540 10800 0 0 {name=l34627 lab=BLB13}
N 2560 10760 2540 10760 {}
C {lab_pin.sym} 2540 10760 0 0 {name=l34628 lab=WL54}
N 2640 10840 2660 10840 {}
C {lab_pin.sym} 2660 10840 0 0 {name=l34629 lab=VDD}
N 2640 10760 2660 10760 {}
C {lab_pin.sym} 2660 10760 0 0 {name=l34630 lab=VSS}
C {bitcell_6t.sym} 2800 10800 0 0 {name=Xr54c14}
N 2760 10840 2740 10840 {}
C {lab_pin.sym} 2740 10840 0 0 {name=l34631 lab=BL14}
N 2760 10800 2740 10800 {}
C {lab_pin.sym} 2740 10800 0 0 {name=l34632 lab=BLB14}
N 2760 10760 2740 10760 {}
C {lab_pin.sym} 2740 10760 0 0 {name=l34633 lab=WL54}
N 2840 10840 2860 10840 {}
C {lab_pin.sym} 2860 10840 0 0 {name=l34634 lab=VDD}
N 2840 10760 2860 10760 {}
C {lab_pin.sym} 2860 10760 0 0 {name=l34635 lab=VSS}
C {bitcell_6t.sym} 3000 10800 0 0 {name=Xr54c15}
N 2960 10840 2940 10840 {}
C {lab_pin.sym} 2940 10840 0 0 {name=l34636 lab=BL15}
N 2960 10800 2940 10800 {}
C {lab_pin.sym} 2940 10800 0 0 {name=l34637 lab=BLB15}
N 2960 10760 2940 10760 {}
C {lab_pin.sym} 2940 10760 0 0 {name=l34638 lab=WL54}
N 3040 10840 3060 10840 {}
C {lab_pin.sym} 3060 10840 0 0 {name=l34639 lab=VDD}
N 3040 10760 3060 10760 {}
C {lab_pin.sym} 3060 10760 0 0 {name=l34640 lab=VSS}
C {bitcell_6t.sym} 3200 10800 0 0 {name=Xr54c16}
N 3160 10840 3140 10840 {}
C {lab_pin.sym} 3140 10840 0 0 {name=l34641 lab=BL16}
N 3160 10800 3140 10800 {}
C {lab_pin.sym} 3140 10800 0 0 {name=l34642 lab=BLB16}
N 3160 10760 3140 10760 {}
C {lab_pin.sym} 3140 10760 0 0 {name=l34643 lab=WL54}
N 3240 10840 3260 10840 {}
C {lab_pin.sym} 3260 10840 0 0 {name=l34644 lab=VDD}
N 3240 10760 3260 10760 {}
C {lab_pin.sym} 3260 10760 0 0 {name=l34645 lab=VSS}
C {bitcell_6t.sym} 3400 10800 0 0 {name=Xr54c17}
N 3360 10840 3340 10840 {}
C {lab_pin.sym} 3340 10840 0 0 {name=l34646 lab=BL17}
N 3360 10800 3340 10800 {}
C {lab_pin.sym} 3340 10800 0 0 {name=l34647 lab=BLB17}
N 3360 10760 3340 10760 {}
C {lab_pin.sym} 3340 10760 0 0 {name=l34648 lab=WL54}
N 3440 10840 3460 10840 {}
C {lab_pin.sym} 3460 10840 0 0 {name=l34649 lab=VDD}
N 3440 10760 3460 10760 {}
C {lab_pin.sym} 3460 10760 0 0 {name=l34650 lab=VSS}
C {bitcell_6t.sym} 3600 10800 0 0 {name=Xr54c18}
N 3560 10840 3540 10840 {}
C {lab_pin.sym} 3540 10840 0 0 {name=l34651 lab=BL18}
N 3560 10800 3540 10800 {}
C {lab_pin.sym} 3540 10800 0 0 {name=l34652 lab=BLB18}
N 3560 10760 3540 10760 {}
C {lab_pin.sym} 3540 10760 0 0 {name=l34653 lab=WL54}
N 3640 10840 3660 10840 {}
C {lab_pin.sym} 3660 10840 0 0 {name=l34654 lab=VDD}
N 3640 10760 3660 10760 {}
C {lab_pin.sym} 3660 10760 0 0 {name=l34655 lab=VSS}
C {bitcell_6t.sym} 3800 10800 0 0 {name=Xr54c19}
N 3760 10840 3740 10840 {}
C {lab_pin.sym} 3740 10840 0 0 {name=l34656 lab=BL19}
N 3760 10800 3740 10800 {}
C {lab_pin.sym} 3740 10800 0 0 {name=l34657 lab=BLB19}
N 3760 10760 3740 10760 {}
C {lab_pin.sym} 3740 10760 0 0 {name=l34658 lab=WL54}
N 3840 10840 3860 10840 {}
C {lab_pin.sym} 3860 10840 0 0 {name=l34659 lab=VDD}
N 3840 10760 3860 10760 {}
C {lab_pin.sym} 3860 10760 0 0 {name=l34660 lab=VSS}
C {bitcell_6t.sym} 4000 10800 0 0 {name=Xr54c20}
N 3960 10840 3940 10840 {}
C {lab_pin.sym} 3940 10840 0 0 {name=l34661 lab=BL20}
N 3960 10800 3940 10800 {}
C {lab_pin.sym} 3940 10800 0 0 {name=l34662 lab=BLB20}
N 3960 10760 3940 10760 {}
C {lab_pin.sym} 3940 10760 0 0 {name=l34663 lab=WL54}
N 4040 10840 4060 10840 {}
C {lab_pin.sym} 4060 10840 0 0 {name=l34664 lab=VDD}
N 4040 10760 4060 10760 {}
C {lab_pin.sym} 4060 10760 0 0 {name=l34665 lab=VSS}
C {bitcell_6t.sym} 4200 10800 0 0 {name=Xr54c21}
N 4160 10840 4140 10840 {}
C {lab_pin.sym} 4140 10840 0 0 {name=l34666 lab=BL21}
N 4160 10800 4140 10800 {}
C {lab_pin.sym} 4140 10800 0 0 {name=l34667 lab=BLB21}
N 4160 10760 4140 10760 {}
C {lab_pin.sym} 4140 10760 0 0 {name=l34668 lab=WL54}
N 4240 10840 4260 10840 {}
C {lab_pin.sym} 4260 10840 0 0 {name=l34669 lab=VDD}
N 4240 10760 4260 10760 {}
C {lab_pin.sym} 4260 10760 0 0 {name=l34670 lab=VSS}
C {bitcell_6t.sym} 4400 10800 0 0 {name=Xr54c22}
N 4360 10840 4340 10840 {}
C {lab_pin.sym} 4340 10840 0 0 {name=l34671 lab=BL22}
N 4360 10800 4340 10800 {}
C {lab_pin.sym} 4340 10800 0 0 {name=l34672 lab=BLB22}
N 4360 10760 4340 10760 {}
C {lab_pin.sym} 4340 10760 0 0 {name=l34673 lab=WL54}
N 4440 10840 4460 10840 {}
C {lab_pin.sym} 4460 10840 0 0 {name=l34674 lab=VDD}
N 4440 10760 4460 10760 {}
C {lab_pin.sym} 4460 10760 0 0 {name=l34675 lab=VSS}
C {bitcell_6t.sym} 4600 10800 0 0 {name=Xr54c23}
N 4560 10840 4540 10840 {}
C {lab_pin.sym} 4540 10840 0 0 {name=l34676 lab=BL23}
N 4560 10800 4540 10800 {}
C {lab_pin.sym} 4540 10800 0 0 {name=l34677 lab=BLB23}
N 4560 10760 4540 10760 {}
C {lab_pin.sym} 4540 10760 0 0 {name=l34678 lab=WL54}
N 4640 10840 4660 10840 {}
C {lab_pin.sym} 4660 10840 0 0 {name=l34679 lab=VDD}
N 4640 10760 4660 10760 {}
C {lab_pin.sym} 4660 10760 0 0 {name=l34680 lab=VSS}
C {bitcell_6t.sym} 4800 10800 0 0 {name=Xr54c24}
N 4760 10840 4740 10840 {}
C {lab_pin.sym} 4740 10840 0 0 {name=l34681 lab=BL24}
N 4760 10800 4740 10800 {}
C {lab_pin.sym} 4740 10800 0 0 {name=l34682 lab=BLB24}
N 4760 10760 4740 10760 {}
C {lab_pin.sym} 4740 10760 0 0 {name=l34683 lab=WL54}
N 4840 10840 4860 10840 {}
C {lab_pin.sym} 4860 10840 0 0 {name=l34684 lab=VDD}
N 4840 10760 4860 10760 {}
C {lab_pin.sym} 4860 10760 0 0 {name=l34685 lab=VSS}
C {bitcell_6t.sym} 5000 10800 0 0 {name=Xr54c25}
N 4960 10840 4940 10840 {}
C {lab_pin.sym} 4940 10840 0 0 {name=l34686 lab=BL25}
N 4960 10800 4940 10800 {}
C {lab_pin.sym} 4940 10800 0 0 {name=l34687 lab=BLB25}
N 4960 10760 4940 10760 {}
C {lab_pin.sym} 4940 10760 0 0 {name=l34688 lab=WL54}
N 5040 10840 5060 10840 {}
C {lab_pin.sym} 5060 10840 0 0 {name=l34689 lab=VDD}
N 5040 10760 5060 10760 {}
C {lab_pin.sym} 5060 10760 0 0 {name=l34690 lab=VSS}
C {bitcell_6t.sym} 5200 10800 0 0 {name=Xr54c26}
N 5160 10840 5140 10840 {}
C {lab_pin.sym} 5140 10840 0 0 {name=l34691 lab=BL26}
N 5160 10800 5140 10800 {}
C {lab_pin.sym} 5140 10800 0 0 {name=l34692 lab=BLB26}
N 5160 10760 5140 10760 {}
C {lab_pin.sym} 5140 10760 0 0 {name=l34693 lab=WL54}
N 5240 10840 5260 10840 {}
C {lab_pin.sym} 5260 10840 0 0 {name=l34694 lab=VDD}
N 5240 10760 5260 10760 {}
C {lab_pin.sym} 5260 10760 0 0 {name=l34695 lab=VSS}
C {bitcell_6t.sym} 5400 10800 0 0 {name=Xr54c27}
N 5360 10840 5340 10840 {}
C {lab_pin.sym} 5340 10840 0 0 {name=l34696 lab=BL27}
N 5360 10800 5340 10800 {}
C {lab_pin.sym} 5340 10800 0 0 {name=l34697 lab=BLB27}
N 5360 10760 5340 10760 {}
C {lab_pin.sym} 5340 10760 0 0 {name=l34698 lab=WL54}
N 5440 10840 5460 10840 {}
C {lab_pin.sym} 5460 10840 0 0 {name=l34699 lab=VDD}
N 5440 10760 5460 10760 {}
C {lab_pin.sym} 5460 10760 0 0 {name=l34700 lab=VSS}
C {bitcell_6t.sym} 5600 10800 0 0 {name=Xr54c28}
N 5560 10840 5540 10840 {}
C {lab_pin.sym} 5540 10840 0 0 {name=l34701 lab=BL28}
N 5560 10800 5540 10800 {}
C {lab_pin.sym} 5540 10800 0 0 {name=l34702 lab=BLB28}
N 5560 10760 5540 10760 {}
C {lab_pin.sym} 5540 10760 0 0 {name=l34703 lab=WL54}
N 5640 10840 5660 10840 {}
C {lab_pin.sym} 5660 10840 0 0 {name=l34704 lab=VDD}
N 5640 10760 5660 10760 {}
C {lab_pin.sym} 5660 10760 0 0 {name=l34705 lab=VSS}
C {bitcell_6t.sym} 5800 10800 0 0 {name=Xr54c29}
N 5760 10840 5740 10840 {}
C {lab_pin.sym} 5740 10840 0 0 {name=l34706 lab=BL29}
N 5760 10800 5740 10800 {}
C {lab_pin.sym} 5740 10800 0 0 {name=l34707 lab=BLB29}
N 5760 10760 5740 10760 {}
C {lab_pin.sym} 5740 10760 0 0 {name=l34708 lab=WL54}
N 5840 10840 5860 10840 {}
C {lab_pin.sym} 5860 10840 0 0 {name=l34709 lab=VDD}
N 5840 10760 5860 10760 {}
C {lab_pin.sym} 5860 10760 0 0 {name=l34710 lab=VSS}
C {bitcell_6t.sym} 6000 10800 0 0 {name=Xr54c30}
N 5960 10840 5940 10840 {}
C {lab_pin.sym} 5940 10840 0 0 {name=l34711 lab=BL30}
N 5960 10800 5940 10800 {}
C {lab_pin.sym} 5940 10800 0 0 {name=l34712 lab=BLB30}
N 5960 10760 5940 10760 {}
C {lab_pin.sym} 5940 10760 0 0 {name=l34713 lab=WL54}
N 6040 10840 6060 10840 {}
C {lab_pin.sym} 6060 10840 0 0 {name=l34714 lab=VDD}
N 6040 10760 6060 10760 {}
C {lab_pin.sym} 6060 10760 0 0 {name=l34715 lab=VSS}
C {bitcell_6t.sym} 6200 10800 0 0 {name=Xr54c31}
N 6160 10840 6140 10840 {}
C {lab_pin.sym} 6140 10840 0 0 {name=l34716 lab=BL31}
N 6160 10800 6140 10800 {}
C {lab_pin.sym} 6140 10800 0 0 {name=l34717 lab=BLB31}
N 6160 10760 6140 10760 {}
C {lab_pin.sym} 6140 10760 0 0 {name=l34718 lab=WL54}
N 6240 10840 6260 10840 {}
C {lab_pin.sym} 6260 10840 0 0 {name=l34719 lab=VDD}
N 6240 10760 6260 10760 {}
C {lab_pin.sym} 6260 10760 0 0 {name=l34720 lab=VSS}
C {bitcell_6t.sym} 6400 10800 0 0 {name=Xr54c32}
N 6360 10840 6340 10840 {}
C {lab_pin.sym} 6340 10840 0 0 {name=l34721 lab=BL32}
N 6360 10800 6340 10800 {}
C {lab_pin.sym} 6340 10800 0 0 {name=l34722 lab=BLB32}
N 6360 10760 6340 10760 {}
C {lab_pin.sym} 6340 10760 0 0 {name=l34723 lab=WL54}
N 6440 10840 6460 10840 {}
C {lab_pin.sym} 6460 10840 0 0 {name=l34724 lab=VDD}
N 6440 10760 6460 10760 {}
C {lab_pin.sym} 6460 10760 0 0 {name=l34725 lab=VSS}
C {bitcell_6t.sym} 6600 10800 0 0 {name=Xr54c33}
N 6560 10840 6540 10840 {}
C {lab_pin.sym} 6540 10840 0 0 {name=l34726 lab=BL33}
N 6560 10800 6540 10800 {}
C {lab_pin.sym} 6540 10800 0 0 {name=l34727 lab=BLB33}
N 6560 10760 6540 10760 {}
C {lab_pin.sym} 6540 10760 0 0 {name=l34728 lab=WL54}
N 6640 10840 6660 10840 {}
C {lab_pin.sym} 6660 10840 0 0 {name=l34729 lab=VDD}
N 6640 10760 6660 10760 {}
C {lab_pin.sym} 6660 10760 0 0 {name=l34730 lab=VSS}
C {bitcell_6t.sym} 6800 10800 0 0 {name=Xr54c34}
N 6760 10840 6740 10840 {}
C {lab_pin.sym} 6740 10840 0 0 {name=l34731 lab=BL34}
N 6760 10800 6740 10800 {}
C {lab_pin.sym} 6740 10800 0 0 {name=l34732 lab=BLB34}
N 6760 10760 6740 10760 {}
C {lab_pin.sym} 6740 10760 0 0 {name=l34733 lab=WL54}
N 6840 10840 6860 10840 {}
C {lab_pin.sym} 6860 10840 0 0 {name=l34734 lab=VDD}
N 6840 10760 6860 10760 {}
C {lab_pin.sym} 6860 10760 0 0 {name=l34735 lab=VSS}
C {bitcell_6t.sym} 7000 10800 0 0 {name=Xr54c35}
N 6960 10840 6940 10840 {}
C {lab_pin.sym} 6940 10840 0 0 {name=l34736 lab=BL35}
N 6960 10800 6940 10800 {}
C {lab_pin.sym} 6940 10800 0 0 {name=l34737 lab=BLB35}
N 6960 10760 6940 10760 {}
C {lab_pin.sym} 6940 10760 0 0 {name=l34738 lab=WL54}
N 7040 10840 7060 10840 {}
C {lab_pin.sym} 7060 10840 0 0 {name=l34739 lab=VDD}
N 7040 10760 7060 10760 {}
C {lab_pin.sym} 7060 10760 0 0 {name=l34740 lab=VSS}
C {bitcell_6t.sym} 7200 10800 0 0 {name=Xr54c36}
N 7160 10840 7140 10840 {}
C {lab_pin.sym} 7140 10840 0 0 {name=l34741 lab=BL36}
N 7160 10800 7140 10800 {}
C {lab_pin.sym} 7140 10800 0 0 {name=l34742 lab=BLB36}
N 7160 10760 7140 10760 {}
C {lab_pin.sym} 7140 10760 0 0 {name=l34743 lab=WL54}
N 7240 10840 7260 10840 {}
C {lab_pin.sym} 7260 10840 0 0 {name=l34744 lab=VDD}
N 7240 10760 7260 10760 {}
C {lab_pin.sym} 7260 10760 0 0 {name=l34745 lab=VSS}
C {bitcell_6t.sym} 7400 10800 0 0 {name=Xr54c37}
N 7360 10840 7340 10840 {}
C {lab_pin.sym} 7340 10840 0 0 {name=l34746 lab=BL37}
N 7360 10800 7340 10800 {}
C {lab_pin.sym} 7340 10800 0 0 {name=l34747 lab=BLB37}
N 7360 10760 7340 10760 {}
C {lab_pin.sym} 7340 10760 0 0 {name=l34748 lab=WL54}
N 7440 10840 7460 10840 {}
C {lab_pin.sym} 7460 10840 0 0 {name=l34749 lab=VDD}
N 7440 10760 7460 10760 {}
C {lab_pin.sym} 7460 10760 0 0 {name=l34750 lab=VSS}
C {bitcell_6t.sym} 7600 10800 0 0 {name=Xr54c38}
N 7560 10840 7540 10840 {}
C {lab_pin.sym} 7540 10840 0 0 {name=l34751 lab=BL38}
N 7560 10800 7540 10800 {}
C {lab_pin.sym} 7540 10800 0 0 {name=l34752 lab=BLB38}
N 7560 10760 7540 10760 {}
C {lab_pin.sym} 7540 10760 0 0 {name=l34753 lab=WL54}
N 7640 10840 7660 10840 {}
C {lab_pin.sym} 7660 10840 0 0 {name=l34754 lab=VDD}
N 7640 10760 7660 10760 {}
C {lab_pin.sym} 7660 10760 0 0 {name=l34755 lab=VSS}
C {bitcell_6t.sym} 7800 10800 0 0 {name=Xr54c39}
N 7760 10840 7740 10840 {}
C {lab_pin.sym} 7740 10840 0 0 {name=l34756 lab=BL39}
N 7760 10800 7740 10800 {}
C {lab_pin.sym} 7740 10800 0 0 {name=l34757 lab=BLB39}
N 7760 10760 7740 10760 {}
C {lab_pin.sym} 7740 10760 0 0 {name=l34758 lab=WL54}
N 7840 10840 7860 10840 {}
C {lab_pin.sym} 7860 10840 0 0 {name=l34759 lab=VDD}
N 7840 10760 7860 10760 {}
C {lab_pin.sym} 7860 10760 0 0 {name=l34760 lab=VSS}
C {bitcell_6t.sym} 8000 10800 0 0 {name=Xr54c40}
N 7960 10840 7940 10840 {}
C {lab_pin.sym} 7940 10840 0 0 {name=l34761 lab=BL40}
N 7960 10800 7940 10800 {}
C {lab_pin.sym} 7940 10800 0 0 {name=l34762 lab=BLB40}
N 7960 10760 7940 10760 {}
C {lab_pin.sym} 7940 10760 0 0 {name=l34763 lab=WL54}
N 8040 10840 8060 10840 {}
C {lab_pin.sym} 8060 10840 0 0 {name=l34764 lab=VDD}
N 8040 10760 8060 10760 {}
C {lab_pin.sym} 8060 10760 0 0 {name=l34765 lab=VSS}
C {bitcell_6t.sym} 8200 10800 0 0 {name=Xr54c41}
N 8160 10840 8140 10840 {}
C {lab_pin.sym} 8140 10840 0 0 {name=l34766 lab=BL41}
N 8160 10800 8140 10800 {}
C {lab_pin.sym} 8140 10800 0 0 {name=l34767 lab=BLB41}
N 8160 10760 8140 10760 {}
C {lab_pin.sym} 8140 10760 0 0 {name=l34768 lab=WL54}
N 8240 10840 8260 10840 {}
C {lab_pin.sym} 8260 10840 0 0 {name=l34769 lab=VDD}
N 8240 10760 8260 10760 {}
C {lab_pin.sym} 8260 10760 0 0 {name=l34770 lab=VSS}
C {bitcell_6t.sym} 8400 10800 0 0 {name=Xr54c42}
N 8360 10840 8340 10840 {}
C {lab_pin.sym} 8340 10840 0 0 {name=l34771 lab=BL42}
N 8360 10800 8340 10800 {}
C {lab_pin.sym} 8340 10800 0 0 {name=l34772 lab=BLB42}
N 8360 10760 8340 10760 {}
C {lab_pin.sym} 8340 10760 0 0 {name=l34773 lab=WL54}
N 8440 10840 8460 10840 {}
C {lab_pin.sym} 8460 10840 0 0 {name=l34774 lab=VDD}
N 8440 10760 8460 10760 {}
C {lab_pin.sym} 8460 10760 0 0 {name=l34775 lab=VSS}
C {bitcell_6t.sym} 8600 10800 0 0 {name=Xr54c43}
N 8560 10840 8540 10840 {}
C {lab_pin.sym} 8540 10840 0 0 {name=l34776 lab=BL43}
N 8560 10800 8540 10800 {}
C {lab_pin.sym} 8540 10800 0 0 {name=l34777 lab=BLB43}
N 8560 10760 8540 10760 {}
C {lab_pin.sym} 8540 10760 0 0 {name=l34778 lab=WL54}
N 8640 10840 8660 10840 {}
C {lab_pin.sym} 8660 10840 0 0 {name=l34779 lab=VDD}
N 8640 10760 8660 10760 {}
C {lab_pin.sym} 8660 10760 0 0 {name=l34780 lab=VSS}
C {bitcell_6t.sym} 8800 10800 0 0 {name=Xr54c44}
N 8760 10840 8740 10840 {}
C {lab_pin.sym} 8740 10840 0 0 {name=l34781 lab=BL44}
N 8760 10800 8740 10800 {}
C {lab_pin.sym} 8740 10800 0 0 {name=l34782 lab=BLB44}
N 8760 10760 8740 10760 {}
C {lab_pin.sym} 8740 10760 0 0 {name=l34783 lab=WL54}
N 8840 10840 8860 10840 {}
C {lab_pin.sym} 8860 10840 0 0 {name=l34784 lab=VDD}
N 8840 10760 8860 10760 {}
C {lab_pin.sym} 8860 10760 0 0 {name=l34785 lab=VSS}
C {bitcell_6t.sym} 9000 10800 0 0 {name=Xr54c45}
N 8960 10840 8940 10840 {}
C {lab_pin.sym} 8940 10840 0 0 {name=l34786 lab=BL45}
N 8960 10800 8940 10800 {}
C {lab_pin.sym} 8940 10800 0 0 {name=l34787 lab=BLB45}
N 8960 10760 8940 10760 {}
C {lab_pin.sym} 8940 10760 0 0 {name=l34788 lab=WL54}
N 9040 10840 9060 10840 {}
C {lab_pin.sym} 9060 10840 0 0 {name=l34789 lab=VDD}
N 9040 10760 9060 10760 {}
C {lab_pin.sym} 9060 10760 0 0 {name=l34790 lab=VSS}
C {bitcell_6t.sym} 9200 10800 0 0 {name=Xr54c46}
N 9160 10840 9140 10840 {}
C {lab_pin.sym} 9140 10840 0 0 {name=l34791 lab=BL46}
N 9160 10800 9140 10800 {}
C {lab_pin.sym} 9140 10800 0 0 {name=l34792 lab=BLB46}
N 9160 10760 9140 10760 {}
C {lab_pin.sym} 9140 10760 0 0 {name=l34793 lab=WL54}
N 9240 10840 9260 10840 {}
C {lab_pin.sym} 9260 10840 0 0 {name=l34794 lab=VDD}
N 9240 10760 9260 10760 {}
C {lab_pin.sym} 9260 10760 0 0 {name=l34795 lab=VSS}
C {bitcell_6t.sym} 9400 10800 0 0 {name=Xr54c47}
N 9360 10840 9340 10840 {}
C {lab_pin.sym} 9340 10840 0 0 {name=l34796 lab=BL47}
N 9360 10800 9340 10800 {}
C {lab_pin.sym} 9340 10800 0 0 {name=l34797 lab=BLB47}
N 9360 10760 9340 10760 {}
C {lab_pin.sym} 9340 10760 0 0 {name=l34798 lab=WL54}
N 9440 10840 9460 10840 {}
C {lab_pin.sym} 9460 10840 0 0 {name=l34799 lab=VDD}
N 9440 10760 9460 10760 {}
C {lab_pin.sym} 9460 10760 0 0 {name=l34800 lab=VSS}
C {bitcell_6t.sym} 9600 10800 0 0 {name=Xr54c48}
N 9560 10840 9540 10840 {}
C {lab_pin.sym} 9540 10840 0 0 {name=l34801 lab=BL48}
N 9560 10800 9540 10800 {}
C {lab_pin.sym} 9540 10800 0 0 {name=l34802 lab=BLB48}
N 9560 10760 9540 10760 {}
C {lab_pin.sym} 9540 10760 0 0 {name=l34803 lab=WL54}
N 9640 10840 9660 10840 {}
C {lab_pin.sym} 9660 10840 0 0 {name=l34804 lab=VDD}
N 9640 10760 9660 10760 {}
C {lab_pin.sym} 9660 10760 0 0 {name=l34805 lab=VSS}
C {bitcell_6t.sym} 9800 10800 0 0 {name=Xr54c49}
N 9760 10840 9740 10840 {}
C {lab_pin.sym} 9740 10840 0 0 {name=l34806 lab=BL49}
N 9760 10800 9740 10800 {}
C {lab_pin.sym} 9740 10800 0 0 {name=l34807 lab=BLB49}
N 9760 10760 9740 10760 {}
C {lab_pin.sym} 9740 10760 0 0 {name=l34808 lab=WL54}
N 9840 10840 9860 10840 {}
C {lab_pin.sym} 9860 10840 0 0 {name=l34809 lab=VDD}
N 9840 10760 9860 10760 {}
C {lab_pin.sym} 9860 10760 0 0 {name=l34810 lab=VSS}
C {bitcell_6t.sym} 10000 10800 0 0 {name=Xr54c50}
N 9960 10840 9940 10840 {}
C {lab_pin.sym} 9940 10840 0 0 {name=l34811 lab=BL50}
N 9960 10800 9940 10800 {}
C {lab_pin.sym} 9940 10800 0 0 {name=l34812 lab=BLB50}
N 9960 10760 9940 10760 {}
C {lab_pin.sym} 9940 10760 0 0 {name=l34813 lab=WL54}
N 10040 10840 10060 10840 {}
C {lab_pin.sym} 10060 10840 0 0 {name=l34814 lab=VDD}
N 10040 10760 10060 10760 {}
C {lab_pin.sym} 10060 10760 0 0 {name=l34815 lab=VSS}
C {bitcell_6t.sym} 10200 10800 0 0 {name=Xr54c51}
N 10160 10840 10140 10840 {}
C {lab_pin.sym} 10140 10840 0 0 {name=l34816 lab=BL51}
N 10160 10800 10140 10800 {}
C {lab_pin.sym} 10140 10800 0 0 {name=l34817 lab=BLB51}
N 10160 10760 10140 10760 {}
C {lab_pin.sym} 10140 10760 0 0 {name=l34818 lab=WL54}
N 10240 10840 10260 10840 {}
C {lab_pin.sym} 10260 10840 0 0 {name=l34819 lab=VDD}
N 10240 10760 10260 10760 {}
C {lab_pin.sym} 10260 10760 0 0 {name=l34820 lab=VSS}
C {bitcell_6t.sym} 10400 10800 0 0 {name=Xr54c52}
N 10360 10840 10340 10840 {}
C {lab_pin.sym} 10340 10840 0 0 {name=l34821 lab=BL52}
N 10360 10800 10340 10800 {}
C {lab_pin.sym} 10340 10800 0 0 {name=l34822 lab=BLB52}
N 10360 10760 10340 10760 {}
C {lab_pin.sym} 10340 10760 0 0 {name=l34823 lab=WL54}
N 10440 10840 10460 10840 {}
C {lab_pin.sym} 10460 10840 0 0 {name=l34824 lab=VDD}
N 10440 10760 10460 10760 {}
C {lab_pin.sym} 10460 10760 0 0 {name=l34825 lab=VSS}
C {bitcell_6t.sym} 10600 10800 0 0 {name=Xr54c53}
N 10560 10840 10540 10840 {}
C {lab_pin.sym} 10540 10840 0 0 {name=l34826 lab=BL53}
N 10560 10800 10540 10800 {}
C {lab_pin.sym} 10540 10800 0 0 {name=l34827 lab=BLB53}
N 10560 10760 10540 10760 {}
C {lab_pin.sym} 10540 10760 0 0 {name=l34828 lab=WL54}
N 10640 10840 10660 10840 {}
C {lab_pin.sym} 10660 10840 0 0 {name=l34829 lab=VDD}
N 10640 10760 10660 10760 {}
C {lab_pin.sym} 10660 10760 0 0 {name=l34830 lab=VSS}
C {bitcell_6t.sym} 10800 10800 0 0 {name=Xr54c54}
N 10760 10840 10740 10840 {}
C {lab_pin.sym} 10740 10840 0 0 {name=l34831 lab=BL54}
N 10760 10800 10740 10800 {}
C {lab_pin.sym} 10740 10800 0 0 {name=l34832 lab=BLB54}
N 10760 10760 10740 10760 {}
C {lab_pin.sym} 10740 10760 0 0 {name=l34833 lab=WL54}
N 10840 10840 10860 10840 {}
C {lab_pin.sym} 10860 10840 0 0 {name=l34834 lab=VDD}
N 10840 10760 10860 10760 {}
C {lab_pin.sym} 10860 10760 0 0 {name=l34835 lab=VSS}
C {bitcell_6t.sym} 11000 10800 0 0 {name=Xr54c55}
N 10960 10840 10940 10840 {}
C {lab_pin.sym} 10940 10840 0 0 {name=l34836 lab=BL55}
N 10960 10800 10940 10800 {}
C {lab_pin.sym} 10940 10800 0 0 {name=l34837 lab=BLB55}
N 10960 10760 10940 10760 {}
C {lab_pin.sym} 10940 10760 0 0 {name=l34838 lab=WL54}
N 11040 10840 11060 10840 {}
C {lab_pin.sym} 11060 10840 0 0 {name=l34839 lab=VDD}
N 11040 10760 11060 10760 {}
C {lab_pin.sym} 11060 10760 0 0 {name=l34840 lab=VSS}
C {bitcell_6t.sym} 11200 10800 0 0 {name=Xr54c56}
N 11160 10840 11140 10840 {}
C {lab_pin.sym} 11140 10840 0 0 {name=l34841 lab=BL56}
N 11160 10800 11140 10800 {}
C {lab_pin.sym} 11140 10800 0 0 {name=l34842 lab=BLB56}
N 11160 10760 11140 10760 {}
C {lab_pin.sym} 11140 10760 0 0 {name=l34843 lab=WL54}
N 11240 10840 11260 10840 {}
C {lab_pin.sym} 11260 10840 0 0 {name=l34844 lab=VDD}
N 11240 10760 11260 10760 {}
C {lab_pin.sym} 11260 10760 0 0 {name=l34845 lab=VSS}
C {bitcell_6t.sym} 11400 10800 0 0 {name=Xr54c57}
N 11360 10840 11340 10840 {}
C {lab_pin.sym} 11340 10840 0 0 {name=l34846 lab=BL57}
N 11360 10800 11340 10800 {}
C {lab_pin.sym} 11340 10800 0 0 {name=l34847 lab=BLB57}
N 11360 10760 11340 10760 {}
C {lab_pin.sym} 11340 10760 0 0 {name=l34848 lab=WL54}
N 11440 10840 11460 10840 {}
C {lab_pin.sym} 11460 10840 0 0 {name=l34849 lab=VDD}
N 11440 10760 11460 10760 {}
C {lab_pin.sym} 11460 10760 0 0 {name=l34850 lab=VSS}
C {bitcell_6t.sym} 11600 10800 0 0 {name=Xr54c58}
N 11560 10840 11540 10840 {}
C {lab_pin.sym} 11540 10840 0 0 {name=l34851 lab=BL58}
N 11560 10800 11540 10800 {}
C {lab_pin.sym} 11540 10800 0 0 {name=l34852 lab=BLB58}
N 11560 10760 11540 10760 {}
C {lab_pin.sym} 11540 10760 0 0 {name=l34853 lab=WL54}
N 11640 10840 11660 10840 {}
C {lab_pin.sym} 11660 10840 0 0 {name=l34854 lab=VDD}
N 11640 10760 11660 10760 {}
C {lab_pin.sym} 11660 10760 0 0 {name=l34855 lab=VSS}
C {bitcell_6t.sym} 11800 10800 0 0 {name=Xr54c59}
N 11760 10840 11740 10840 {}
C {lab_pin.sym} 11740 10840 0 0 {name=l34856 lab=BL59}
N 11760 10800 11740 10800 {}
C {lab_pin.sym} 11740 10800 0 0 {name=l34857 lab=BLB59}
N 11760 10760 11740 10760 {}
C {lab_pin.sym} 11740 10760 0 0 {name=l34858 lab=WL54}
N 11840 10840 11860 10840 {}
C {lab_pin.sym} 11860 10840 0 0 {name=l34859 lab=VDD}
N 11840 10760 11860 10760 {}
C {lab_pin.sym} 11860 10760 0 0 {name=l34860 lab=VSS}
C {bitcell_6t.sym} 12000 10800 0 0 {name=Xr54c60}
N 11960 10840 11940 10840 {}
C {lab_pin.sym} 11940 10840 0 0 {name=l34861 lab=BL60}
N 11960 10800 11940 10800 {}
C {lab_pin.sym} 11940 10800 0 0 {name=l34862 lab=BLB60}
N 11960 10760 11940 10760 {}
C {lab_pin.sym} 11940 10760 0 0 {name=l34863 lab=WL54}
N 12040 10840 12060 10840 {}
C {lab_pin.sym} 12060 10840 0 0 {name=l34864 lab=VDD}
N 12040 10760 12060 10760 {}
C {lab_pin.sym} 12060 10760 0 0 {name=l34865 lab=VSS}
C {bitcell_6t.sym} 12200 10800 0 0 {name=Xr54c61}
N 12160 10840 12140 10840 {}
C {lab_pin.sym} 12140 10840 0 0 {name=l34866 lab=BL61}
N 12160 10800 12140 10800 {}
C {lab_pin.sym} 12140 10800 0 0 {name=l34867 lab=BLB61}
N 12160 10760 12140 10760 {}
C {lab_pin.sym} 12140 10760 0 0 {name=l34868 lab=WL54}
N 12240 10840 12260 10840 {}
C {lab_pin.sym} 12260 10840 0 0 {name=l34869 lab=VDD}
N 12240 10760 12260 10760 {}
C {lab_pin.sym} 12260 10760 0 0 {name=l34870 lab=VSS}
C {bitcell_6t.sym} 12400 10800 0 0 {name=Xr54c62}
N 12360 10840 12340 10840 {}
C {lab_pin.sym} 12340 10840 0 0 {name=l34871 lab=BL62}
N 12360 10800 12340 10800 {}
C {lab_pin.sym} 12340 10800 0 0 {name=l34872 lab=BLB62}
N 12360 10760 12340 10760 {}
C {lab_pin.sym} 12340 10760 0 0 {name=l34873 lab=WL54}
N 12440 10840 12460 10840 {}
C {lab_pin.sym} 12460 10840 0 0 {name=l34874 lab=VDD}
N 12440 10760 12460 10760 {}
C {lab_pin.sym} 12460 10760 0 0 {name=l34875 lab=VSS}
C {bitcell_6t.sym} 12600 10800 0 0 {name=Xr54c63}
N 12560 10840 12540 10840 {}
C {lab_pin.sym} 12540 10840 0 0 {name=l34876 lab=BL63}
N 12560 10800 12540 10800 {}
C {lab_pin.sym} 12540 10800 0 0 {name=l34877 lab=BLB63}
N 12560 10760 12540 10760 {}
C {lab_pin.sym} 12540 10760 0 0 {name=l34878 lab=WL54}
N 12640 10840 12660 10840 {}
C {lab_pin.sym} 12660 10840 0 0 {name=l34879 lab=VDD}
N 12640 10760 12660 10760 {}
C {lab_pin.sym} 12660 10760 0 0 {name=l34880 lab=VSS}
C {bitcell_6t.sym} 12800 10800 0 0 {name=Xr54c64}
N 12760 10840 12740 10840 {}
C {lab_pin.sym} 12740 10840 0 0 {name=l34881 lab=BL64}
N 12760 10800 12740 10800 {}
C {lab_pin.sym} 12740 10800 0 0 {name=l34882 lab=BLB64}
N 12760 10760 12740 10760 {}
C {lab_pin.sym} 12740 10760 0 0 {name=l34883 lab=WL54}
N 12840 10840 12860 10840 {}
C {lab_pin.sym} 12860 10840 0 0 {name=l34884 lab=VDD}
N 12840 10760 12860 10760 {}
C {lab_pin.sym} 12860 10760 0 0 {name=l34885 lab=VSS}
C {bitcell_6t.sym} 13000 10800 0 0 {name=Xr54c65}
N 12960 10840 12940 10840 {}
C {lab_pin.sym} 12940 10840 0 0 {name=l34886 lab=BL65}
N 12960 10800 12940 10800 {}
C {lab_pin.sym} 12940 10800 0 0 {name=l34887 lab=BLB65}
N 12960 10760 12940 10760 {}
C {lab_pin.sym} 12940 10760 0 0 {name=l34888 lab=WL54}
N 13040 10840 13060 10840 {}
C {lab_pin.sym} 13060 10840 0 0 {name=l34889 lab=VDD}
N 13040 10760 13060 10760 {}
C {lab_pin.sym} 13060 10760 0 0 {name=l34890 lab=VSS}
C {bitcell_6t.sym} 13200 10800 0 0 {name=Xr54c66}
N 13160 10840 13140 10840 {}
C {lab_pin.sym} 13140 10840 0 0 {name=l34891 lab=BL66}
N 13160 10800 13140 10800 {}
C {lab_pin.sym} 13140 10800 0 0 {name=l34892 lab=BLB66}
N 13160 10760 13140 10760 {}
C {lab_pin.sym} 13140 10760 0 0 {name=l34893 lab=WL54}
N 13240 10840 13260 10840 {}
C {lab_pin.sym} 13260 10840 0 0 {name=l34894 lab=VDD}
N 13240 10760 13260 10760 {}
C {lab_pin.sym} 13260 10760 0 0 {name=l34895 lab=VSS}
C {bitcell_6t.sym} 13400 10800 0 0 {name=Xr54c67}
N 13360 10840 13340 10840 {}
C {lab_pin.sym} 13340 10840 0 0 {name=l34896 lab=BL67}
N 13360 10800 13340 10800 {}
C {lab_pin.sym} 13340 10800 0 0 {name=l34897 lab=BLB67}
N 13360 10760 13340 10760 {}
C {lab_pin.sym} 13340 10760 0 0 {name=l34898 lab=WL54}
N 13440 10840 13460 10840 {}
C {lab_pin.sym} 13460 10840 0 0 {name=l34899 lab=VDD}
N 13440 10760 13460 10760 {}
C {lab_pin.sym} 13460 10760 0 0 {name=l34900 lab=VSS}
C {bitcell_6t.sym} 13600 10800 0 0 {name=Xr54c68}
N 13560 10840 13540 10840 {}
C {lab_pin.sym} 13540 10840 0 0 {name=l34901 lab=BL68}
N 13560 10800 13540 10800 {}
C {lab_pin.sym} 13540 10800 0 0 {name=l34902 lab=BLB68}
N 13560 10760 13540 10760 {}
C {lab_pin.sym} 13540 10760 0 0 {name=l34903 lab=WL54}
N 13640 10840 13660 10840 {}
C {lab_pin.sym} 13660 10840 0 0 {name=l34904 lab=VDD}
N 13640 10760 13660 10760 {}
C {lab_pin.sym} 13660 10760 0 0 {name=l34905 lab=VSS}
C {bitcell_6t.sym} 13800 10800 0 0 {name=Xr54c69}
N 13760 10840 13740 10840 {}
C {lab_pin.sym} 13740 10840 0 0 {name=l34906 lab=BL69}
N 13760 10800 13740 10800 {}
C {lab_pin.sym} 13740 10800 0 0 {name=l34907 lab=BLB69}
N 13760 10760 13740 10760 {}
C {lab_pin.sym} 13740 10760 0 0 {name=l34908 lab=WL54}
N 13840 10840 13860 10840 {}
C {lab_pin.sym} 13860 10840 0 0 {name=l34909 lab=VDD}
N 13840 10760 13860 10760 {}
C {lab_pin.sym} 13860 10760 0 0 {name=l34910 lab=VSS}
C {bitcell_6t.sym} 14000 10800 0 0 {name=Xr54c70}
N 13960 10840 13940 10840 {}
C {lab_pin.sym} 13940 10840 0 0 {name=l34911 lab=BL70}
N 13960 10800 13940 10800 {}
C {lab_pin.sym} 13940 10800 0 0 {name=l34912 lab=BLB70}
N 13960 10760 13940 10760 {}
C {lab_pin.sym} 13940 10760 0 0 {name=l34913 lab=WL54}
N 14040 10840 14060 10840 {}
C {lab_pin.sym} 14060 10840 0 0 {name=l34914 lab=VDD}
N 14040 10760 14060 10760 {}
C {lab_pin.sym} 14060 10760 0 0 {name=l34915 lab=VSS}
C {bitcell_6t.sym} 14200 10800 0 0 {name=Xr54c71}
N 14160 10840 14140 10840 {}
C {lab_pin.sym} 14140 10840 0 0 {name=l34916 lab=BL71}
N 14160 10800 14140 10800 {}
C {lab_pin.sym} 14140 10800 0 0 {name=l34917 lab=BLB71}
N 14160 10760 14140 10760 {}
C {lab_pin.sym} 14140 10760 0 0 {name=l34918 lab=WL54}
N 14240 10840 14260 10840 {}
C {lab_pin.sym} 14260 10840 0 0 {name=l34919 lab=VDD}
N 14240 10760 14260 10760 {}
C {lab_pin.sym} 14260 10760 0 0 {name=l34920 lab=VSS}
C {bitcell_6t.sym} 14400 10800 0 0 {name=Xr54c72}
N 14360 10840 14340 10840 {}
C {lab_pin.sym} 14340 10840 0 0 {name=l34921 lab=BL72}
N 14360 10800 14340 10800 {}
C {lab_pin.sym} 14340 10800 0 0 {name=l34922 lab=BLB72}
N 14360 10760 14340 10760 {}
C {lab_pin.sym} 14340 10760 0 0 {name=l34923 lab=WL54}
N 14440 10840 14460 10840 {}
C {lab_pin.sym} 14460 10840 0 0 {name=l34924 lab=VDD}
N 14440 10760 14460 10760 {}
C {lab_pin.sym} 14460 10760 0 0 {name=l34925 lab=VSS}
C {bitcell_6t.sym} 14600 10800 0 0 {name=Xr54c73}
N 14560 10840 14540 10840 {}
C {lab_pin.sym} 14540 10840 0 0 {name=l34926 lab=BL73}
N 14560 10800 14540 10800 {}
C {lab_pin.sym} 14540 10800 0 0 {name=l34927 lab=BLB73}
N 14560 10760 14540 10760 {}
C {lab_pin.sym} 14540 10760 0 0 {name=l34928 lab=WL54}
N 14640 10840 14660 10840 {}
C {lab_pin.sym} 14660 10840 0 0 {name=l34929 lab=VDD}
N 14640 10760 14660 10760 {}
C {lab_pin.sym} 14660 10760 0 0 {name=l34930 lab=VSS}
C {bitcell_6t.sym} 14800 10800 0 0 {name=Xr54c74}
N 14760 10840 14740 10840 {}
C {lab_pin.sym} 14740 10840 0 0 {name=l34931 lab=BL74}
N 14760 10800 14740 10800 {}
C {lab_pin.sym} 14740 10800 0 0 {name=l34932 lab=BLB74}
N 14760 10760 14740 10760 {}
C {lab_pin.sym} 14740 10760 0 0 {name=l34933 lab=WL54}
N 14840 10840 14860 10840 {}
C {lab_pin.sym} 14860 10840 0 0 {name=l34934 lab=VDD}
N 14840 10760 14860 10760 {}
C {lab_pin.sym} 14860 10760 0 0 {name=l34935 lab=VSS}
C {bitcell_6t.sym} 15000 10800 0 0 {name=Xr54c75}
N 14960 10840 14940 10840 {}
C {lab_pin.sym} 14940 10840 0 0 {name=l34936 lab=BL75}
N 14960 10800 14940 10800 {}
C {lab_pin.sym} 14940 10800 0 0 {name=l34937 lab=BLB75}
N 14960 10760 14940 10760 {}
C {lab_pin.sym} 14940 10760 0 0 {name=l34938 lab=WL54}
N 15040 10840 15060 10840 {}
C {lab_pin.sym} 15060 10840 0 0 {name=l34939 lab=VDD}
N 15040 10760 15060 10760 {}
C {lab_pin.sym} 15060 10760 0 0 {name=l34940 lab=VSS}
C {bitcell_6t.sym} 15200 10800 0 0 {name=Xr54c76}
N 15160 10840 15140 10840 {}
C {lab_pin.sym} 15140 10840 0 0 {name=l34941 lab=BL76}
N 15160 10800 15140 10800 {}
C {lab_pin.sym} 15140 10800 0 0 {name=l34942 lab=BLB76}
N 15160 10760 15140 10760 {}
C {lab_pin.sym} 15140 10760 0 0 {name=l34943 lab=WL54}
N 15240 10840 15260 10840 {}
C {lab_pin.sym} 15260 10840 0 0 {name=l34944 lab=VDD}
N 15240 10760 15260 10760 {}
C {lab_pin.sym} 15260 10760 0 0 {name=l34945 lab=VSS}
C {bitcell_6t.sym} 15400 10800 0 0 {name=Xr54c77}
N 15360 10840 15340 10840 {}
C {lab_pin.sym} 15340 10840 0 0 {name=l34946 lab=BL77}
N 15360 10800 15340 10800 {}
C {lab_pin.sym} 15340 10800 0 0 {name=l34947 lab=BLB77}
N 15360 10760 15340 10760 {}
C {lab_pin.sym} 15340 10760 0 0 {name=l34948 lab=WL54}
N 15440 10840 15460 10840 {}
C {lab_pin.sym} 15460 10840 0 0 {name=l34949 lab=VDD}
N 15440 10760 15460 10760 {}
C {lab_pin.sym} 15460 10760 0 0 {name=l34950 lab=VSS}
C {bitcell_6t.sym} 15600 10800 0 0 {name=Xr54c78}
N 15560 10840 15540 10840 {}
C {lab_pin.sym} 15540 10840 0 0 {name=l34951 lab=BL78}
N 15560 10800 15540 10800 {}
C {lab_pin.sym} 15540 10800 0 0 {name=l34952 lab=BLB78}
N 15560 10760 15540 10760 {}
C {lab_pin.sym} 15540 10760 0 0 {name=l34953 lab=WL54}
N 15640 10840 15660 10840 {}
C {lab_pin.sym} 15660 10840 0 0 {name=l34954 lab=VDD}
N 15640 10760 15660 10760 {}
C {lab_pin.sym} 15660 10760 0 0 {name=l34955 lab=VSS}
C {bitcell_6t.sym} 15800 10800 0 0 {name=Xr54c79}
N 15760 10840 15740 10840 {}
C {lab_pin.sym} 15740 10840 0 0 {name=l34956 lab=BL79}
N 15760 10800 15740 10800 {}
C {lab_pin.sym} 15740 10800 0 0 {name=l34957 lab=BLB79}
N 15760 10760 15740 10760 {}
C {lab_pin.sym} 15740 10760 0 0 {name=l34958 lab=WL54}
N 15840 10840 15860 10840 {}
C {lab_pin.sym} 15860 10840 0 0 {name=l34959 lab=VDD}
N 15840 10760 15860 10760 {}
C {lab_pin.sym} 15860 10760 0 0 {name=l34960 lab=VSS}
C {bitcell_6t.sym} 16000 10800 0 0 {name=Xr54c80}
N 15960 10840 15940 10840 {}
C {lab_pin.sym} 15940 10840 0 0 {name=l34961 lab=BL80}
N 15960 10800 15940 10800 {}
C {lab_pin.sym} 15940 10800 0 0 {name=l34962 lab=BLB80}
N 15960 10760 15940 10760 {}
C {lab_pin.sym} 15940 10760 0 0 {name=l34963 lab=WL54}
N 16040 10840 16060 10840 {}
C {lab_pin.sym} 16060 10840 0 0 {name=l34964 lab=VDD}
N 16040 10760 16060 10760 {}
C {lab_pin.sym} 16060 10760 0 0 {name=l34965 lab=VSS}
C {bitcell_6t.sym} 16200 10800 0 0 {name=Xr54c81}
N 16160 10840 16140 10840 {}
C {lab_pin.sym} 16140 10840 0 0 {name=l34966 lab=BL81}
N 16160 10800 16140 10800 {}
C {lab_pin.sym} 16140 10800 0 0 {name=l34967 lab=BLB81}
N 16160 10760 16140 10760 {}
C {lab_pin.sym} 16140 10760 0 0 {name=l34968 lab=WL54}
N 16240 10840 16260 10840 {}
C {lab_pin.sym} 16260 10840 0 0 {name=l34969 lab=VDD}
N 16240 10760 16260 10760 {}
C {lab_pin.sym} 16260 10760 0 0 {name=l34970 lab=VSS}
C {bitcell_6t.sym} 16400 10800 0 0 {name=Xr54c82}
N 16360 10840 16340 10840 {}
C {lab_pin.sym} 16340 10840 0 0 {name=l34971 lab=BL82}
N 16360 10800 16340 10800 {}
C {lab_pin.sym} 16340 10800 0 0 {name=l34972 lab=BLB82}
N 16360 10760 16340 10760 {}
C {lab_pin.sym} 16340 10760 0 0 {name=l34973 lab=WL54}
N 16440 10840 16460 10840 {}
C {lab_pin.sym} 16460 10840 0 0 {name=l34974 lab=VDD}
N 16440 10760 16460 10760 {}
C {lab_pin.sym} 16460 10760 0 0 {name=l34975 lab=VSS}
C {bitcell_6t.sym} 16600 10800 0 0 {name=Xr54c83}
N 16560 10840 16540 10840 {}
C {lab_pin.sym} 16540 10840 0 0 {name=l34976 lab=BL83}
N 16560 10800 16540 10800 {}
C {lab_pin.sym} 16540 10800 0 0 {name=l34977 lab=BLB83}
N 16560 10760 16540 10760 {}
C {lab_pin.sym} 16540 10760 0 0 {name=l34978 lab=WL54}
N 16640 10840 16660 10840 {}
C {lab_pin.sym} 16660 10840 0 0 {name=l34979 lab=VDD}
N 16640 10760 16660 10760 {}
C {lab_pin.sym} 16660 10760 0 0 {name=l34980 lab=VSS}
C {bitcell_6t.sym} 16800 10800 0 0 {name=Xr54c84}
N 16760 10840 16740 10840 {}
C {lab_pin.sym} 16740 10840 0 0 {name=l34981 lab=BL84}
N 16760 10800 16740 10800 {}
C {lab_pin.sym} 16740 10800 0 0 {name=l34982 lab=BLB84}
N 16760 10760 16740 10760 {}
C {lab_pin.sym} 16740 10760 0 0 {name=l34983 lab=WL54}
N 16840 10840 16860 10840 {}
C {lab_pin.sym} 16860 10840 0 0 {name=l34984 lab=VDD}
N 16840 10760 16860 10760 {}
C {lab_pin.sym} 16860 10760 0 0 {name=l34985 lab=VSS}
C {bitcell_6t.sym} 17000 10800 0 0 {name=Xr54c85}
N 16960 10840 16940 10840 {}
C {lab_pin.sym} 16940 10840 0 0 {name=l34986 lab=BL85}
N 16960 10800 16940 10800 {}
C {lab_pin.sym} 16940 10800 0 0 {name=l34987 lab=BLB85}
N 16960 10760 16940 10760 {}
C {lab_pin.sym} 16940 10760 0 0 {name=l34988 lab=WL54}
N 17040 10840 17060 10840 {}
C {lab_pin.sym} 17060 10840 0 0 {name=l34989 lab=VDD}
N 17040 10760 17060 10760 {}
C {lab_pin.sym} 17060 10760 0 0 {name=l34990 lab=VSS}
C {bitcell_6t.sym} 17200 10800 0 0 {name=Xr54c86}
N 17160 10840 17140 10840 {}
C {lab_pin.sym} 17140 10840 0 0 {name=l34991 lab=BL86}
N 17160 10800 17140 10800 {}
C {lab_pin.sym} 17140 10800 0 0 {name=l34992 lab=BLB86}
N 17160 10760 17140 10760 {}
C {lab_pin.sym} 17140 10760 0 0 {name=l34993 lab=WL54}
N 17240 10840 17260 10840 {}
C {lab_pin.sym} 17260 10840 0 0 {name=l34994 lab=VDD}
N 17240 10760 17260 10760 {}
C {lab_pin.sym} 17260 10760 0 0 {name=l34995 lab=VSS}
C {bitcell_6t.sym} 17400 10800 0 0 {name=Xr54c87}
N 17360 10840 17340 10840 {}
C {lab_pin.sym} 17340 10840 0 0 {name=l34996 lab=BL87}
N 17360 10800 17340 10800 {}
C {lab_pin.sym} 17340 10800 0 0 {name=l34997 lab=BLB87}
N 17360 10760 17340 10760 {}
C {lab_pin.sym} 17340 10760 0 0 {name=l34998 lab=WL54}
N 17440 10840 17460 10840 {}
C {lab_pin.sym} 17460 10840 0 0 {name=l34999 lab=VDD}
N 17440 10760 17460 10760 {}
C {lab_pin.sym} 17460 10760 0 0 {name=l35000 lab=VSS}
C {bitcell_6t.sym} 17600 10800 0 0 {name=Xr54c88}
N 17560 10840 17540 10840 {}
C {lab_pin.sym} 17540 10840 0 0 {name=l35001 lab=BL88}
N 17560 10800 17540 10800 {}
C {lab_pin.sym} 17540 10800 0 0 {name=l35002 lab=BLB88}
N 17560 10760 17540 10760 {}
C {lab_pin.sym} 17540 10760 0 0 {name=l35003 lab=WL54}
N 17640 10840 17660 10840 {}
C {lab_pin.sym} 17660 10840 0 0 {name=l35004 lab=VDD}
N 17640 10760 17660 10760 {}
C {lab_pin.sym} 17660 10760 0 0 {name=l35005 lab=VSS}
C {bitcell_6t.sym} 17800 10800 0 0 {name=Xr54c89}
N 17760 10840 17740 10840 {}
C {lab_pin.sym} 17740 10840 0 0 {name=l35006 lab=BL89}
N 17760 10800 17740 10800 {}
C {lab_pin.sym} 17740 10800 0 0 {name=l35007 lab=BLB89}
N 17760 10760 17740 10760 {}
C {lab_pin.sym} 17740 10760 0 0 {name=l35008 lab=WL54}
N 17840 10840 17860 10840 {}
C {lab_pin.sym} 17860 10840 0 0 {name=l35009 lab=VDD}
N 17840 10760 17860 10760 {}
C {lab_pin.sym} 17860 10760 0 0 {name=l35010 lab=VSS}
C {bitcell_6t.sym} 18000 10800 0 0 {name=Xr54c90}
N 17960 10840 17940 10840 {}
C {lab_pin.sym} 17940 10840 0 0 {name=l35011 lab=BL90}
N 17960 10800 17940 10800 {}
C {lab_pin.sym} 17940 10800 0 0 {name=l35012 lab=BLB90}
N 17960 10760 17940 10760 {}
C {lab_pin.sym} 17940 10760 0 0 {name=l35013 lab=WL54}
N 18040 10840 18060 10840 {}
C {lab_pin.sym} 18060 10840 0 0 {name=l35014 lab=VDD}
N 18040 10760 18060 10760 {}
C {lab_pin.sym} 18060 10760 0 0 {name=l35015 lab=VSS}
C {bitcell_6t.sym} 18200 10800 0 0 {name=Xr54c91}
N 18160 10840 18140 10840 {}
C {lab_pin.sym} 18140 10840 0 0 {name=l35016 lab=BL91}
N 18160 10800 18140 10800 {}
C {lab_pin.sym} 18140 10800 0 0 {name=l35017 lab=BLB91}
N 18160 10760 18140 10760 {}
C {lab_pin.sym} 18140 10760 0 0 {name=l35018 lab=WL54}
N 18240 10840 18260 10840 {}
C {lab_pin.sym} 18260 10840 0 0 {name=l35019 lab=VDD}
N 18240 10760 18260 10760 {}
C {lab_pin.sym} 18260 10760 0 0 {name=l35020 lab=VSS}
C {bitcell_6t.sym} 18400 10800 0 0 {name=Xr54c92}
N 18360 10840 18340 10840 {}
C {lab_pin.sym} 18340 10840 0 0 {name=l35021 lab=BL92}
N 18360 10800 18340 10800 {}
C {lab_pin.sym} 18340 10800 0 0 {name=l35022 lab=BLB92}
N 18360 10760 18340 10760 {}
C {lab_pin.sym} 18340 10760 0 0 {name=l35023 lab=WL54}
N 18440 10840 18460 10840 {}
C {lab_pin.sym} 18460 10840 0 0 {name=l35024 lab=VDD}
N 18440 10760 18460 10760 {}
C {lab_pin.sym} 18460 10760 0 0 {name=l35025 lab=VSS}
C {bitcell_6t.sym} 18600 10800 0 0 {name=Xr54c93}
N 18560 10840 18540 10840 {}
C {lab_pin.sym} 18540 10840 0 0 {name=l35026 lab=BL93}
N 18560 10800 18540 10800 {}
C {lab_pin.sym} 18540 10800 0 0 {name=l35027 lab=BLB93}
N 18560 10760 18540 10760 {}
C {lab_pin.sym} 18540 10760 0 0 {name=l35028 lab=WL54}
N 18640 10840 18660 10840 {}
C {lab_pin.sym} 18660 10840 0 0 {name=l35029 lab=VDD}
N 18640 10760 18660 10760 {}
C {lab_pin.sym} 18660 10760 0 0 {name=l35030 lab=VSS}
C {bitcell_6t.sym} 18800 10800 0 0 {name=Xr54c94}
N 18760 10840 18740 10840 {}
C {lab_pin.sym} 18740 10840 0 0 {name=l35031 lab=BL94}
N 18760 10800 18740 10800 {}
C {lab_pin.sym} 18740 10800 0 0 {name=l35032 lab=BLB94}
N 18760 10760 18740 10760 {}
C {lab_pin.sym} 18740 10760 0 0 {name=l35033 lab=WL54}
N 18840 10840 18860 10840 {}
C {lab_pin.sym} 18860 10840 0 0 {name=l35034 lab=VDD}
N 18840 10760 18860 10760 {}
C {lab_pin.sym} 18860 10760 0 0 {name=l35035 lab=VSS}
C {bitcell_6t.sym} 19000 10800 0 0 {name=Xr54c95}
N 18960 10840 18940 10840 {}
C {lab_pin.sym} 18940 10840 0 0 {name=l35036 lab=BL95}
N 18960 10800 18940 10800 {}
C {lab_pin.sym} 18940 10800 0 0 {name=l35037 lab=BLB95}
N 18960 10760 18940 10760 {}
C {lab_pin.sym} 18940 10760 0 0 {name=l35038 lab=WL54}
N 19040 10840 19060 10840 {}
C {lab_pin.sym} 19060 10840 0 0 {name=l35039 lab=VDD}
N 19040 10760 19060 10760 {}
C {lab_pin.sym} 19060 10760 0 0 {name=l35040 lab=VSS}
C {bitcell_6t.sym} 19200 10800 0 0 {name=Xr54c96}
N 19160 10840 19140 10840 {}
C {lab_pin.sym} 19140 10840 0 0 {name=l35041 lab=BL96}
N 19160 10800 19140 10800 {}
C {lab_pin.sym} 19140 10800 0 0 {name=l35042 lab=BLB96}
N 19160 10760 19140 10760 {}
C {lab_pin.sym} 19140 10760 0 0 {name=l35043 lab=WL54}
N 19240 10840 19260 10840 {}
C {lab_pin.sym} 19260 10840 0 0 {name=l35044 lab=VDD}
N 19240 10760 19260 10760 {}
C {lab_pin.sym} 19260 10760 0 0 {name=l35045 lab=VSS}
C {bitcell_6t.sym} 19400 10800 0 0 {name=Xr54c97}
N 19360 10840 19340 10840 {}
C {lab_pin.sym} 19340 10840 0 0 {name=l35046 lab=BL97}
N 19360 10800 19340 10800 {}
C {lab_pin.sym} 19340 10800 0 0 {name=l35047 lab=BLB97}
N 19360 10760 19340 10760 {}
C {lab_pin.sym} 19340 10760 0 0 {name=l35048 lab=WL54}
N 19440 10840 19460 10840 {}
C {lab_pin.sym} 19460 10840 0 0 {name=l35049 lab=VDD}
N 19440 10760 19460 10760 {}
C {lab_pin.sym} 19460 10760 0 0 {name=l35050 lab=VSS}
C {bitcell_6t.sym} 19600 10800 0 0 {name=Xr54c98}
N 19560 10840 19540 10840 {}
C {lab_pin.sym} 19540 10840 0 0 {name=l35051 lab=BL98}
N 19560 10800 19540 10800 {}
C {lab_pin.sym} 19540 10800 0 0 {name=l35052 lab=BLB98}
N 19560 10760 19540 10760 {}
C {lab_pin.sym} 19540 10760 0 0 {name=l35053 lab=WL54}
N 19640 10840 19660 10840 {}
C {lab_pin.sym} 19660 10840 0 0 {name=l35054 lab=VDD}
N 19640 10760 19660 10760 {}
C {lab_pin.sym} 19660 10760 0 0 {name=l35055 lab=VSS}
C {bitcell_6t.sym} 19800 10800 0 0 {name=Xr54c99}
N 19760 10840 19740 10840 {}
C {lab_pin.sym} 19740 10840 0 0 {name=l35056 lab=BL99}
N 19760 10800 19740 10800 {}
C {lab_pin.sym} 19740 10800 0 0 {name=l35057 lab=BLB99}
N 19760 10760 19740 10760 {}
C {lab_pin.sym} 19740 10760 0 0 {name=l35058 lab=WL54}
N 19840 10840 19860 10840 {}
C {lab_pin.sym} 19860 10840 0 0 {name=l35059 lab=VDD}
N 19840 10760 19860 10760 {}
C {lab_pin.sym} 19860 10760 0 0 {name=l35060 lab=VSS}
C {bitcell_6t.sym} 20000 10800 0 0 {name=Xr54c100}
N 19960 10840 19940 10840 {}
C {lab_pin.sym} 19940 10840 0 0 {name=l35061 lab=BL100}
N 19960 10800 19940 10800 {}
C {lab_pin.sym} 19940 10800 0 0 {name=l35062 lab=BLB100}
N 19960 10760 19940 10760 {}
C {lab_pin.sym} 19940 10760 0 0 {name=l35063 lab=WL54}
N 20040 10840 20060 10840 {}
C {lab_pin.sym} 20060 10840 0 0 {name=l35064 lab=VDD}
N 20040 10760 20060 10760 {}
C {lab_pin.sym} 20060 10760 0 0 {name=l35065 lab=VSS}
C {bitcell_6t.sym} 20200 10800 0 0 {name=Xr54c101}
N 20160 10840 20140 10840 {}
C {lab_pin.sym} 20140 10840 0 0 {name=l35066 lab=BL101}
N 20160 10800 20140 10800 {}
C {lab_pin.sym} 20140 10800 0 0 {name=l35067 lab=BLB101}
N 20160 10760 20140 10760 {}
C {lab_pin.sym} 20140 10760 0 0 {name=l35068 lab=WL54}
N 20240 10840 20260 10840 {}
C {lab_pin.sym} 20260 10840 0 0 {name=l35069 lab=VDD}
N 20240 10760 20260 10760 {}
C {lab_pin.sym} 20260 10760 0 0 {name=l35070 lab=VSS}
C {bitcell_6t.sym} 20400 10800 0 0 {name=Xr54c102}
N 20360 10840 20340 10840 {}
C {lab_pin.sym} 20340 10840 0 0 {name=l35071 lab=BL102}
N 20360 10800 20340 10800 {}
C {lab_pin.sym} 20340 10800 0 0 {name=l35072 lab=BLB102}
N 20360 10760 20340 10760 {}
C {lab_pin.sym} 20340 10760 0 0 {name=l35073 lab=WL54}
N 20440 10840 20460 10840 {}
C {lab_pin.sym} 20460 10840 0 0 {name=l35074 lab=VDD}
N 20440 10760 20460 10760 {}
C {lab_pin.sym} 20460 10760 0 0 {name=l35075 lab=VSS}
C {bitcell_6t.sym} 20600 10800 0 0 {name=Xr54c103}
N 20560 10840 20540 10840 {}
C {lab_pin.sym} 20540 10840 0 0 {name=l35076 lab=BL103}
N 20560 10800 20540 10800 {}
C {lab_pin.sym} 20540 10800 0 0 {name=l35077 lab=BLB103}
N 20560 10760 20540 10760 {}
C {lab_pin.sym} 20540 10760 0 0 {name=l35078 lab=WL54}
N 20640 10840 20660 10840 {}
C {lab_pin.sym} 20660 10840 0 0 {name=l35079 lab=VDD}
N 20640 10760 20660 10760 {}
C {lab_pin.sym} 20660 10760 0 0 {name=l35080 lab=VSS}
C {bitcell_6t.sym} 20800 10800 0 0 {name=Xr54c104}
N 20760 10840 20740 10840 {}
C {lab_pin.sym} 20740 10840 0 0 {name=l35081 lab=BL104}
N 20760 10800 20740 10800 {}
C {lab_pin.sym} 20740 10800 0 0 {name=l35082 lab=BLB104}
N 20760 10760 20740 10760 {}
C {lab_pin.sym} 20740 10760 0 0 {name=l35083 lab=WL54}
N 20840 10840 20860 10840 {}
C {lab_pin.sym} 20860 10840 0 0 {name=l35084 lab=VDD}
N 20840 10760 20860 10760 {}
C {lab_pin.sym} 20860 10760 0 0 {name=l35085 lab=VSS}
C {bitcell_6t.sym} 21000 10800 0 0 {name=Xr54c105}
N 20960 10840 20940 10840 {}
C {lab_pin.sym} 20940 10840 0 0 {name=l35086 lab=BL105}
N 20960 10800 20940 10800 {}
C {lab_pin.sym} 20940 10800 0 0 {name=l35087 lab=BLB105}
N 20960 10760 20940 10760 {}
C {lab_pin.sym} 20940 10760 0 0 {name=l35088 lab=WL54}
N 21040 10840 21060 10840 {}
C {lab_pin.sym} 21060 10840 0 0 {name=l35089 lab=VDD}
N 21040 10760 21060 10760 {}
C {lab_pin.sym} 21060 10760 0 0 {name=l35090 lab=VSS}
C {bitcell_6t.sym} 21200 10800 0 0 {name=Xr54c106}
N 21160 10840 21140 10840 {}
C {lab_pin.sym} 21140 10840 0 0 {name=l35091 lab=BL106}
N 21160 10800 21140 10800 {}
C {lab_pin.sym} 21140 10800 0 0 {name=l35092 lab=BLB106}
N 21160 10760 21140 10760 {}
C {lab_pin.sym} 21140 10760 0 0 {name=l35093 lab=WL54}
N 21240 10840 21260 10840 {}
C {lab_pin.sym} 21260 10840 0 0 {name=l35094 lab=VDD}
N 21240 10760 21260 10760 {}
C {lab_pin.sym} 21260 10760 0 0 {name=l35095 lab=VSS}
C {bitcell_6t.sym} 21400 10800 0 0 {name=Xr54c107}
N 21360 10840 21340 10840 {}
C {lab_pin.sym} 21340 10840 0 0 {name=l35096 lab=BL107}
N 21360 10800 21340 10800 {}
C {lab_pin.sym} 21340 10800 0 0 {name=l35097 lab=BLB107}
N 21360 10760 21340 10760 {}
C {lab_pin.sym} 21340 10760 0 0 {name=l35098 lab=WL54}
N 21440 10840 21460 10840 {}
C {lab_pin.sym} 21460 10840 0 0 {name=l35099 lab=VDD}
N 21440 10760 21460 10760 {}
C {lab_pin.sym} 21460 10760 0 0 {name=l35100 lab=VSS}
C {bitcell_6t.sym} 21600 10800 0 0 {name=Xr54c108}
N 21560 10840 21540 10840 {}
C {lab_pin.sym} 21540 10840 0 0 {name=l35101 lab=BL108}
N 21560 10800 21540 10800 {}
C {lab_pin.sym} 21540 10800 0 0 {name=l35102 lab=BLB108}
N 21560 10760 21540 10760 {}
C {lab_pin.sym} 21540 10760 0 0 {name=l35103 lab=WL54}
N 21640 10840 21660 10840 {}
C {lab_pin.sym} 21660 10840 0 0 {name=l35104 lab=VDD}
N 21640 10760 21660 10760 {}
C {lab_pin.sym} 21660 10760 0 0 {name=l35105 lab=VSS}
C {bitcell_6t.sym} 21800 10800 0 0 {name=Xr54c109}
N 21760 10840 21740 10840 {}
C {lab_pin.sym} 21740 10840 0 0 {name=l35106 lab=BL109}
N 21760 10800 21740 10800 {}
C {lab_pin.sym} 21740 10800 0 0 {name=l35107 lab=BLB109}
N 21760 10760 21740 10760 {}
C {lab_pin.sym} 21740 10760 0 0 {name=l35108 lab=WL54}
N 21840 10840 21860 10840 {}
C {lab_pin.sym} 21860 10840 0 0 {name=l35109 lab=VDD}
N 21840 10760 21860 10760 {}
C {lab_pin.sym} 21860 10760 0 0 {name=l35110 lab=VSS}
C {bitcell_6t.sym} 22000 10800 0 0 {name=Xr54c110}
N 21960 10840 21940 10840 {}
C {lab_pin.sym} 21940 10840 0 0 {name=l35111 lab=BL110}
N 21960 10800 21940 10800 {}
C {lab_pin.sym} 21940 10800 0 0 {name=l35112 lab=BLB110}
N 21960 10760 21940 10760 {}
C {lab_pin.sym} 21940 10760 0 0 {name=l35113 lab=WL54}
N 22040 10840 22060 10840 {}
C {lab_pin.sym} 22060 10840 0 0 {name=l35114 lab=VDD}
N 22040 10760 22060 10760 {}
C {lab_pin.sym} 22060 10760 0 0 {name=l35115 lab=VSS}
C {bitcell_6t.sym} 22200 10800 0 0 {name=Xr54c111}
N 22160 10840 22140 10840 {}
C {lab_pin.sym} 22140 10840 0 0 {name=l35116 lab=BL111}
N 22160 10800 22140 10800 {}
C {lab_pin.sym} 22140 10800 0 0 {name=l35117 lab=BLB111}
N 22160 10760 22140 10760 {}
C {lab_pin.sym} 22140 10760 0 0 {name=l35118 lab=WL54}
N 22240 10840 22260 10840 {}
C {lab_pin.sym} 22260 10840 0 0 {name=l35119 lab=VDD}
N 22240 10760 22260 10760 {}
C {lab_pin.sym} 22260 10760 0 0 {name=l35120 lab=VSS}
C {bitcell_6t.sym} 22400 10800 0 0 {name=Xr54c112}
N 22360 10840 22340 10840 {}
C {lab_pin.sym} 22340 10840 0 0 {name=l35121 lab=BL112}
N 22360 10800 22340 10800 {}
C {lab_pin.sym} 22340 10800 0 0 {name=l35122 lab=BLB112}
N 22360 10760 22340 10760 {}
C {lab_pin.sym} 22340 10760 0 0 {name=l35123 lab=WL54}
N 22440 10840 22460 10840 {}
C {lab_pin.sym} 22460 10840 0 0 {name=l35124 lab=VDD}
N 22440 10760 22460 10760 {}
C {lab_pin.sym} 22460 10760 0 0 {name=l35125 lab=VSS}
C {bitcell_6t.sym} 22600 10800 0 0 {name=Xr54c113}
N 22560 10840 22540 10840 {}
C {lab_pin.sym} 22540 10840 0 0 {name=l35126 lab=BL113}
N 22560 10800 22540 10800 {}
C {lab_pin.sym} 22540 10800 0 0 {name=l35127 lab=BLB113}
N 22560 10760 22540 10760 {}
C {lab_pin.sym} 22540 10760 0 0 {name=l35128 lab=WL54}
N 22640 10840 22660 10840 {}
C {lab_pin.sym} 22660 10840 0 0 {name=l35129 lab=VDD}
N 22640 10760 22660 10760 {}
C {lab_pin.sym} 22660 10760 0 0 {name=l35130 lab=VSS}
C {bitcell_6t.sym} 22800 10800 0 0 {name=Xr54c114}
N 22760 10840 22740 10840 {}
C {lab_pin.sym} 22740 10840 0 0 {name=l35131 lab=BL114}
N 22760 10800 22740 10800 {}
C {lab_pin.sym} 22740 10800 0 0 {name=l35132 lab=BLB114}
N 22760 10760 22740 10760 {}
C {lab_pin.sym} 22740 10760 0 0 {name=l35133 lab=WL54}
N 22840 10840 22860 10840 {}
C {lab_pin.sym} 22860 10840 0 0 {name=l35134 lab=VDD}
N 22840 10760 22860 10760 {}
C {lab_pin.sym} 22860 10760 0 0 {name=l35135 lab=VSS}
C {bitcell_6t.sym} 23000 10800 0 0 {name=Xr54c115}
N 22960 10840 22940 10840 {}
C {lab_pin.sym} 22940 10840 0 0 {name=l35136 lab=BL115}
N 22960 10800 22940 10800 {}
C {lab_pin.sym} 22940 10800 0 0 {name=l35137 lab=BLB115}
N 22960 10760 22940 10760 {}
C {lab_pin.sym} 22940 10760 0 0 {name=l35138 lab=WL54}
N 23040 10840 23060 10840 {}
C {lab_pin.sym} 23060 10840 0 0 {name=l35139 lab=VDD}
N 23040 10760 23060 10760 {}
C {lab_pin.sym} 23060 10760 0 0 {name=l35140 lab=VSS}
C {bitcell_6t.sym} 23200 10800 0 0 {name=Xr54c116}
N 23160 10840 23140 10840 {}
C {lab_pin.sym} 23140 10840 0 0 {name=l35141 lab=BL116}
N 23160 10800 23140 10800 {}
C {lab_pin.sym} 23140 10800 0 0 {name=l35142 lab=BLB116}
N 23160 10760 23140 10760 {}
C {lab_pin.sym} 23140 10760 0 0 {name=l35143 lab=WL54}
N 23240 10840 23260 10840 {}
C {lab_pin.sym} 23260 10840 0 0 {name=l35144 lab=VDD}
N 23240 10760 23260 10760 {}
C {lab_pin.sym} 23260 10760 0 0 {name=l35145 lab=VSS}
C {bitcell_6t.sym} 23400 10800 0 0 {name=Xr54c117}
N 23360 10840 23340 10840 {}
C {lab_pin.sym} 23340 10840 0 0 {name=l35146 lab=BL117}
N 23360 10800 23340 10800 {}
C {lab_pin.sym} 23340 10800 0 0 {name=l35147 lab=BLB117}
N 23360 10760 23340 10760 {}
C {lab_pin.sym} 23340 10760 0 0 {name=l35148 lab=WL54}
N 23440 10840 23460 10840 {}
C {lab_pin.sym} 23460 10840 0 0 {name=l35149 lab=VDD}
N 23440 10760 23460 10760 {}
C {lab_pin.sym} 23460 10760 0 0 {name=l35150 lab=VSS}
C {bitcell_6t.sym} 23600 10800 0 0 {name=Xr54c118}
N 23560 10840 23540 10840 {}
C {lab_pin.sym} 23540 10840 0 0 {name=l35151 lab=BL118}
N 23560 10800 23540 10800 {}
C {lab_pin.sym} 23540 10800 0 0 {name=l35152 lab=BLB118}
N 23560 10760 23540 10760 {}
C {lab_pin.sym} 23540 10760 0 0 {name=l35153 lab=WL54}
N 23640 10840 23660 10840 {}
C {lab_pin.sym} 23660 10840 0 0 {name=l35154 lab=VDD}
N 23640 10760 23660 10760 {}
C {lab_pin.sym} 23660 10760 0 0 {name=l35155 lab=VSS}
C {bitcell_6t.sym} 23800 10800 0 0 {name=Xr54c119}
N 23760 10840 23740 10840 {}
C {lab_pin.sym} 23740 10840 0 0 {name=l35156 lab=BL119}
N 23760 10800 23740 10800 {}
C {lab_pin.sym} 23740 10800 0 0 {name=l35157 lab=BLB119}
N 23760 10760 23740 10760 {}
C {lab_pin.sym} 23740 10760 0 0 {name=l35158 lab=WL54}
N 23840 10840 23860 10840 {}
C {lab_pin.sym} 23860 10840 0 0 {name=l35159 lab=VDD}
N 23840 10760 23860 10760 {}
C {lab_pin.sym} 23860 10760 0 0 {name=l35160 lab=VSS}
C {bitcell_6t.sym} 24000 10800 0 0 {name=Xr54c120}
N 23960 10840 23940 10840 {}
C {lab_pin.sym} 23940 10840 0 0 {name=l35161 lab=BL120}
N 23960 10800 23940 10800 {}
C {lab_pin.sym} 23940 10800 0 0 {name=l35162 lab=BLB120}
N 23960 10760 23940 10760 {}
C {lab_pin.sym} 23940 10760 0 0 {name=l35163 lab=WL54}
N 24040 10840 24060 10840 {}
C {lab_pin.sym} 24060 10840 0 0 {name=l35164 lab=VDD}
N 24040 10760 24060 10760 {}
C {lab_pin.sym} 24060 10760 0 0 {name=l35165 lab=VSS}
C {bitcell_6t.sym} 24200 10800 0 0 {name=Xr54c121}
N 24160 10840 24140 10840 {}
C {lab_pin.sym} 24140 10840 0 0 {name=l35166 lab=BL121}
N 24160 10800 24140 10800 {}
C {lab_pin.sym} 24140 10800 0 0 {name=l35167 lab=BLB121}
N 24160 10760 24140 10760 {}
C {lab_pin.sym} 24140 10760 0 0 {name=l35168 lab=WL54}
N 24240 10840 24260 10840 {}
C {lab_pin.sym} 24260 10840 0 0 {name=l35169 lab=VDD}
N 24240 10760 24260 10760 {}
C {lab_pin.sym} 24260 10760 0 0 {name=l35170 lab=VSS}
C {bitcell_6t.sym} 24400 10800 0 0 {name=Xr54c122}
N 24360 10840 24340 10840 {}
C {lab_pin.sym} 24340 10840 0 0 {name=l35171 lab=BL122}
N 24360 10800 24340 10800 {}
C {lab_pin.sym} 24340 10800 0 0 {name=l35172 lab=BLB122}
N 24360 10760 24340 10760 {}
C {lab_pin.sym} 24340 10760 0 0 {name=l35173 lab=WL54}
N 24440 10840 24460 10840 {}
C {lab_pin.sym} 24460 10840 0 0 {name=l35174 lab=VDD}
N 24440 10760 24460 10760 {}
C {lab_pin.sym} 24460 10760 0 0 {name=l35175 lab=VSS}
C {bitcell_6t.sym} 24600 10800 0 0 {name=Xr54c123}
N 24560 10840 24540 10840 {}
C {lab_pin.sym} 24540 10840 0 0 {name=l35176 lab=BL123}
N 24560 10800 24540 10800 {}
C {lab_pin.sym} 24540 10800 0 0 {name=l35177 lab=BLB123}
N 24560 10760 24540 10760 {}
C {lab_pin.sym} 24540 10760 0 0 {name=l35178 lab=WL54}
N 24640 10840 24660 10840 {}
C {lab_pin.sym} 24660 10840 0 0 {name=l35179 lab=VDD}
N 24640 10760 24660 10760 {}
C {lab_pin.sym} 24660 10760 0 0 {name=l35180 lab=VSS}
C {bitcell_6t.sym} 24800 10800 0 0 {name=Xr54c124}
N 24760 10840 24740 10840 {}
C {lab_pin.sym} 24740 10840 0 0 {name=l35181 lab=BL124}
N 24760 10800 24740 10800 {}
C {lab_pin.sym} 24740 10800 0 0 {name=l35182 lab=BLB124}
N 24760 10760 24740 10760 {}
C {lab_pin.sym} 24740 10760 0 0 {name=l35183 lab=WL54}
N 24840 10840 24860 10840 {}
C {lab_pin.sym} 24860 10840 0 0 {name=l35184 lab=VDD}
N 24840 10760 24860 10760 {}
C {lab_pin.sym} 24860 10760 0 0 {name=l35185 lab=VSS}
C {bitcell_6t.sym} 25000 10800 0 0 {name=Xr54c125}
N 24960 10840 24940 10840 {}
C {lab_pin.sym} 24940 10840 0 0 {name=l35186 lab=BL125}
N 24960 10800 24940 10800 {}
C {lab_pin.sym} 24940 10800 0 0 {name=l35187 lab=BLB125}
N 24960 10760 24940 10760 {}
C {lab_pin.sym} 24940 10760 0 0 {name=l35188 lab=WL54}
N 25040 10840 25060 10840 {}
C {lab_pin.sym} 25060 10840 0 0 {name=l35189 lab=VDD}
N 25040 10760 25060 10760 {}
C {lab_pin.sym} 25060 10760 0 0 {name=l35190 lab=VSS}
C {bitcell_6t.sym} 25200 10800 0 0 {name=Xr54c126}
N 25160 10840 25140 10840 {}
C {lab_pin.sym} 25140 10840 0 0 {name=l35191 lab=BL126}
N 25160 10800 25140 10800 {}
C {lab_pin.sym} 25140 10800 0 0 {name=l35192 lab=BLB126}
N 25160 10760 25140 10760 {}
C {lab_pin.sym} 25140 10760 0 0 {name=l35193 lab=WL54}
N 25240 10840 25260 10840 {}
C {lab_pin.sym} 25260 10840 0 0 {name=l35194 lab=VDD}
N 25240 10760 25260 10760 {}
C {lab_pin.sym} 25260 10760 0 0 {name=l35195 lab=VSS}
C {bitcell_6t.sym} 25400 10800 0 0 {name=Xr54c127}
N 25360 10840 25340 10840 {}
C {lab_pin.sym} 25340 10840 0 0 {name=l35196 lab=BL127}
N 25360 10800 25340 10800 {}
C {lab_pin.sym} 25340 10800 0 0 {name=l35197 lab=BLB127}
N 25360 10760 25340 10760 {}
C {lab_pin.sym} 25340 10760 0 0 {name=l35198 lab=WL54}
N 25440 10840 25460 10840 {}
C {lab_pin.sym} 25460 10840 0 0 {name=l35199 lab=VDD}
N 25440 10760 25460 10760 {}
C {lab_pin.sym} 25460 10760 0 0 {name=l35200 lab=VSS}
C {bitcell_6t.sym} 0 11000 0 0 {name=Xr55c0}
N -40 11040 -60 11040 {}
C {lab_pin.sym} -60 11040 0 0 {name=l35201 lab=BL0}
N -40 11000 -60 11000 {}
C {lab_pin.sym} -60 11000 0 0 {name=l35202 lab=BLB0}
N -40 10960 -60 10960 {}
C {lab_pin.sym} -60 10960 0 0 {name=l35203 lab=WL55}
N 40 11040 60 11040 {}
C {lab_pin.sym} 60 11040 0 0 {name=l35204 lab=VDD}
N 40 10960 60 10960 {}
C {lab_pin.sym} 60 10960 0 0 {name=l35205 lab=VSS}
C {bitcell_6t.sym} 200 11000 0 0 {name=Xr55c1}
N 160 11040 140 11040 {}
C {lab_pin.sym} 140 11040 0 0 {name=l35206 lab=BL1}
N 160 11000 140 11000 {}
C {lab_pin.sym} 140 11000 0 0 {name=l35207 lab=BLB1}
N 160 10960 140 10960 {}
C {lab_pin.sym} 140 10960 0 0 {name=l35208 lab=WL55}
N 240 11040 260 11040 {}
C {lab_pin.sym} 260 11040 0 0 {name=l35209 lab=VDD}
N 240 10960 260 10960 {}
C {lab_pin.sym} 260 10960 0 0 {name=l35210 lab=VSS}
C {bitcell_6t.sym} 400 11000 0 0 {name=Xr55c2}
N 360 11040 340 11040 {}
C {lab_pin.sym} 340 11040 0 0 {name=l35211 lab=BL2}
N 360 11000 340 11000 {}
C {lab_pin.sym} 340 11000 0 0 {name=l35212 lab=BLB2}
N 360 10960 340 10960 {}
C {lab_pin.sym} 340 10960 0 0 {name=l35213 lab=WL55}
N 440 11040 460 11040 {}
C {lab_pin.sym} 460 11040 0 0 {name=l35214 lab=VDD}
N 440 10960 460 10960 {}
C {lab_pin.sym} 460 10960 0 0 {name=l35215 lab=VSS}
C {bitcell_6t.sym} 600 11000 0 0 {name=Xr55c3}
N 560 11040 540 11040 {}
C {lab_pin.sym} 540 11040 0 0 {name=l35216 lab=BL3}
N 560 11000 540 11000 {}
C {lab_pin.sym} 540 11000 0 0 {name=l35217 lab=BLB3}
N 560 10960 540 10960 {}
C {lab_pin.sym} 540 10960 0 0 {name=l35218 lab=WL55}
N 640 11040 660 11040 {}
C {lab_pin.sym} 660 11040 0 0 {name=l35219 lab=VDD}
N 640 10960 660 10960 {}
C {lab_pin.sym} 660 10960 0 0 {name=l35220 lab=VSS}
C {bitcell_6t.sym} 800 11000 0 0 {name=Xr55c4}
N 760 11040 740 11040 {}
C {lab_pin.sym} 740 11040 0 0 {name=l35221 lab=BL4}
N 760 11000 740 11000 {}
C {lab_pin.sym} 740 11000 0 0 {name=l35222 lab=BLB4}
N 760 10960 740 10960 {}
C {lab_pin.sym} 740 10960 0 0 {name=l35223 lab=WL55}
N 840 11040 860 11040 {}
C {lab_pin.sym} 860 11040 0 0 {name=l35224 lab=VDD}
N 840 10960 860 10960 {}
C {lab_pin.sym} 860 10960 0 0 {name=l35225 lab=VSS}
C {bitcell_6t.sym} 1000 11000 0 0 {name=Xr55c5}
N 960 11040 940 11040 {}
C {lab_pin.sym} 940 11040 0 0 {name=l35226 lab=BL5}
N 960 11000 940 11000 {}
C {lab_pin.sym} 940 11000 0 0 {name=l35227 lab=BLB5}
N 960 10960 940 10960 {}
C {lab_pin.sym} 940 10960 0 0 {name=l35228 lab=WL55}
N 1040 11040 1060 11040 {}
C {lab_pin.sym} 1060 11040 0 0 {name=l35229 lab=VDD}
N 1040 10960 1060 10960 {}
C {lab_pin.sym} 1060 10960 0 0 {name=l35230 lab=VSS}
C {bitcell_6t.sym} 1200 11000 0 0 {name=Xr55c6}
N 1160 11040 1140 11040 {}
C {lab_pin.sym} 1140 11040 0 0 {name=l35231 lab=BL6}
N 1160 11000 1140 11000 {}
C {lab_pin.sym} 1140 11000 0 0 {name=l35232 lab=BLB6}
N 1160 10960 1140 10960 {}
C {lab_pin.sym} 1140 10960 0 0 {name=l35233 lab=WL55}
N 1240 11040 1260 11040 {}
C {lab_pin.sym} 1260 11040 0 0 {name=l35234 lab=VDD}
N 1240 10960 1260 10960 {}
C {lab_pin.sym} 1260 10960 0 0 {name=l35235 lab=VSS}
C {bitcell_6t.sym} 1400 11000 0 0 {name=Xr55c7}
N 1360 11040 1340 11040 {}
C {lab_pin.sym} 1340 11040 0 0 {name=l35236 lab=BL7}
N 1360 11000 1340 11000 {}
C {lab_pin.sym} 1340 11000 0 0 {name=l35237 lab=BLB7}
N 1360 10960 1340 10960 {}
C {lab_pin.sym} 1340 10960 0 0 {name=l35238 lab=WL55}
N 1440 11040 1460 11040 {}
C {lab_pin.sym} 1460 11040 0 0 {name=l35239 lab=VDD}
N 1440 10960 1460 10960 {}
C {lab_pin.sym} 1460 10960 0 0 {name=l35240 lab=VSS}
C {bitcell_6t.sym} 1600 11000 0 0 {name=Xr55c8}
N 1560 11040 1540 11040 {}
C {lab_pin.sym} 1540 11040 0 0 {name=l35241 lab=BL8}
N 1560 11000 1540 11000 {}
C {lab_pin.sym} 1540 11000 0 0 {name=l35242 lab=BLB8}
N 1560 10960 1540 10960 {}
C {lab_pin.sym} 1540 10960 0 0 {name=l35243 lab=WL55}
N 1640 11040 1660 11040 {}
C {lab_pin.sym} 1660 11040 0 0 {name=l35244 lab=VDD}
N 1640 10960 1660 10960 {}
C {lab_pin.sym} 1660 10960 0 0 {name=l35245 lab=VSS}
C {bitcell_6t.sym} 1800 11000 0 0 {name=Xr55c9}
N 1760 11040 1740 11040 {}
C {lab_pin.sym} 1740 11040 0 0 {name=l35246 lab=BL9}
N 1760 11000 1740 11000 {}
C {lab_pin.sym} 1740 11000 0 0 {name=l35247 lab=BLB9}
N 1760 10960 1740 10960 {}
C {lab_pin.sym} 1740 10960 0 0 {name=l35248 lab=WL55}
N 1840 11040 1860 11040 {}
C {lab_pin.sym} 1860 11040 0 0 {name=l35249 lab=VDD}
N 1840 10960 1860 10960 {}
C {lab_pin.sym} 1860 10960 0 0 {name=l35250 lab=VSS}
C {bitcell_6t.sym} 2000 11000 0 0 {name=Xr55c10}
N 1960 11040 1940 11040 {}
C {lab_pin.sym} 1940 11040 0 0 {name=l35251 lab=BL10}
N 1960 11000 1940 11000 {}
C {lab_pin.sym} 1940 11000 0 0 {name=l35252 lab=BLB10}
N 1960 10960 1940 10960 {}
C {lab_pin.sym} 1940 10960 0 0 {name=l35253 lab=WL55}
N 2040 11040 2060 11040 {}
C {lab_pin.sym} 2060 11040 0 0 {name=l35254 lab=VDD}
N 2040 10960 2060 10960 {}
C {lab_pin.sym} 2060 10960 0 0 {name=l35255 lab=VSS}
C {bitcell_6t.sym} 2200 11000 0 0 {name=Xr55c11}
N 2160 11040 2140 11040 {}
C {lab_pin.sym} 2140 11040 0 0 {name=l35256 lab=BL11}
N 2160 11000 2140 11000 {}
C {lab_pin.sym} 2140 11000 0 0 {name=l35257 lab=BLB11}
N 2160 10960 2140 10960 {}
C {lab_pin.sym} 2140 10960 0 0 {name=l35258 lab=WL55}
N 2240 11040 2260 11040 {}
C {lab_pin.sym} 2260 11040 0 0 {name=l35259 lab=VDD}
N 2240 10960 2260 10960 {}
C {lab_pin.sym} 2260 10960 0 0 {name=l35260 lab=VSS}
C {bitcell_6t.sym} 2400 11000 0 0 {name=Xr55c12}
N 2360 11040 2340 11040 {}
C {lab_pin.sym} 2340 11040 0 0 {name=l35261 lab=BL12}
N 2360 11000 2340 11000 {}
C {lab_pin.sym} 2340 11000 0 0 {name=l35262 lab=BLB12}
N 2360 10960 2340 10960 {}
C {lab_pin.sym} 2340 10960 0 0 {name=l35263 lab=WL55}
N 2440 11040 2460 11040 {}
C {lab_pin.sym} 2460 11040 0 0 {name=l35264 lab=VDD}
N 2440 10960 2460 10960 {}
C {lab_pin.sym} 2460 10960 0 0 {name=l35265 lab=VSS}
C {bitcell_6t.sym} 2600 11000 0 0 {name=Xr55c13}
N 2560 11040 2540 11040 {}
C {lab_pin.sym} 2540 11040 0 0 {name=l35266 lab=BL13}
N 2560 11000 2540 11000 {}
C {lab_pin.sym} 2540 11000 0 0 {name=l35267 lab=BLB13}
N 2560 10960 2540 10960 {}
C {lab_pin.sym} 2540 10960 0 0 {name=l35268 lab=WL55}
N 2640 11040 2660 11040 {}
C {lab_pin.sym} 2660 11040 0 0 {name=l35269 lab=VDD}
N 2640 10960 2660 10960 {}
C {lab_pin.sym} 2660 10960 0 0 {name=l35270 lab=VSS}
C {bitcell_6t.sym} 2800 11000 0 0 {name=Xr55c14}
N 2760 11040 2740 11040 {}
C {lab_pin.sym} 2740 11040 0 0 {name=l35271 lab=BL14}
N 2760 11000 2740 11000 {}
C {lab_pin.sym} 2740 11000 0 0 {name=l35272 lab=BLB14}
N 2760 10960 2740 10960 {}
C {lab_pin.sym} 2740 10960 0 0 {name=l35273 lab=WL55}
N 2840 11040 2860 11040 {}
C {lab_pin.sym} 2860 11040 0 0 {name=l35274 lab=VDD}
N 2840 10960 2860 10960 {}
C {lab_pin.sym} 2860 10960 0 0 {name=l35275 lab=VSS}
C {bitcell_6t.sym} 3000 11000 0 0 {name=Xr55c15}
N 2960 11040 2940 11040 {}
C {lab_pin.sym} 2940 11040 0 0 {name=l35276 lab=BL15}
N 2960 11000 2940 11000 {}
C {lab_pin.sym} 2940 11000 0 0 {name=l35277 lab=BLB15}
N 2960 10960 2940 10960 {}
C {lab_pin.sym} 2940 10960 0 0 {name=l35278 lab=WL55}
N 3040 11040 3060 11040 {}
C {lab_pin.sym} 3060 11040 0 0 {name=l35279 lab=VDD}
N 3040 10960 3060 10960 {}
C {lab_pin.sym} 3060 10960 0 0 {name=l35280 lab=VSS}
C {bitcell_6t.sym} 3200 11000 0 0 {name=Xr55c16}
N 3160 11040 3140 11040 {}
C {lab_pin.sym} 3140 11040 0 0 {name=l35281 lab=BL16}
N 3160 11000 3140 11000 {}
C {lab_pin.sym} 3140 11000 0 0 {name=l35282 lab=BLB16}
N 3160 10960 3140 10960 {}
C {lab_pin.sym} 3140 10960 0 0 {name=l35283 lab=WL55}
N 3240 11040 3260 11040 {}
C {lab_pin.sym} 3260 11040 0 0 {name=l35284 lab=VDD}
N 3240 10960 3260 10960 {}
C {lab_pin.sym} 3260 10960 0 0 {name=l35285 lab=VSS}
C {bitcell_6t.sym} 3400 11000 0 0 {name=Xr55c17}
N 3360 11040 3340 11040 {}
C {lab_pin.sym} 3340 11040 0 0 {name=l35286 lab=BL17}
N 3360 11000 3340 11000 {}
C {lab_pin.sym} 3340 11000 0 0 {name=l35287 lab=BLB17}
N 3360 10960 3340 10960 {}
C {lab_pin.sym} 3340 10960 0 0 {name=l35288 lab=WL55}
N 3440 11040 3460 11040 {}
C {lab_pin.sym} 3460 11040 0 0 {name=l35289 lab=VDD}
N 3440 10960 3460 10960 {}
C {lab_pin.sym} 3460 10960 0 0 {name=l35290 lab=VSS}
C {bitcell_6t.sym} 3600 11000 0 0 {name=Xr55c18}
N 3560 11040 3540 11040 {}
C {lab_pin.sym} 3540 11040 0 0 {name=l35291 lab=BL18}
N 3560 11000 3540 11000 {}
C {lab_pin.sym} 3540 11000 0 0 {name=l35292 lab=BLB18}
N 3560 10960 3540 10960 {}
C {lab_pin.sym} 3540 10960 0 0 {name=l35293 lab=WL55}
N 3640 11040 3660 11040 {}
C {lab_pin.sym} 3660 11040 0 0 {name=l35294 lab=VDD}
N 3640 10960 3660 10960 {}
C {lab_pin.sym} 3660 10960 0 0 {name=l35295 lab=VSS}
C {bitcell_6t.sym} 3800 11000 0 0 {name=Xr55c19}
N 3760 11040 3740 11040 {}
C {lab_pin.sym} 3740 11040 0 0 {name=l35296 lab=BL19}
N 3760 11000 3740 11000 {}
C {lab_pin.sym} 3740 11000 0 0 {name=l35297 lab=BLB19}
N 3760 10960 3740 10960 {}
C {lab_pin.sym} 3740 10960 0 0 {name=l35298 lab=WL55}
N 3840 11040 3860 11040 {}
C {lab_pin.sym} 3860 11040 0 0 {name=l35299 lab=VDD}
N 3840 10960 3860 10960 {}
C {lab_pin.sym} 3860 10960 0 0 {name=l35300 lab=VSS}
C {bitcell_6t.sym} 4000 11000 0 0 {name=Xr55c20}
N 3960 11040 3940 11040 {}
C {lab_pin.sym} 3940 11040 0 0 {name=l35301 lab=BL20}
N 3960 11000 3940 11000 {}
C {lab_pin.sym} 3940 11000 0 0 {name=l35302 lab=BLB20}
N 3960 10960 3940 10960 {}
C {lab_pin.sym} 3940 10960 0 0 {name=l35303 lab=WL55}
N 4040 11040 4060 11040 {}
C {lab_pin.sym} 4060 11040 0 0 {name=l35304 lab=VDD}
N 4040 10960 4060 10960 {}
C {lab_pin.sym} 4060 10960 0 0 {name=l35305 lab=VSS}
C {bitcell_6t.sym} 4200 11000 0 0 {name=Xr55c21}
N 4160 11040 4140 11040 {}
C {lab_pin.sym} 4140 11040 0 0 {name=l35306 lab=BL21}
N 4160 11000 4140 11000 {}
C {lab_pin.sym} 4140 11000 0 0 {name=l35307 lab=BLB21}
N 4160 10960 4140 10960 {}
C {lab_pin.sym} 4140 10960 0 0 {name=l35308 lab=WL55}
N 4240 11040 4260 11040 {}
C {lab_pin.sym} 4260 11040 0 0 {name=l35309 lab=VDD}
N 4240 10960 4260 10960 {}
C {lab_pin.sym} 4260 10960 0 0 {name=l35310 lab=VSS}
C {bitcell_6t.sym} 4400 11000 0 0 {name=Xr55c22}
N 4360 11040 4340 11040 {}
C {lab_pin.sym} 4340 11040 0 0 {name=l35311 lab=BL22}
N 4360 11000 4340 11000 {}
C {lab_pin.sym} 4340 11000 0 0 {name=l35312 lab=BLB22}
N 4360 10960 4340 10960 {}
C {lab_pin.sym} 4340 10960 0 0 {name=l35313 lab=WL55}
N 4440 11040 4460 11040 {}
C {lab_pin.sym} 4460 11040 0 0 {name=l35314 lab=VDD}
N 4440 10960 4460 10960 {}
C {lab_pin.sym} 4460 10960 0 0 {name=l35315 lab=VSS}
C {bitcell_6t.sym} 4600 11000 0 0 {name=Xr55c23}
N 4560 11040 4540 11040 {}
C {lab_pin.sym} 4540 11040 0 0 {name=l35316 lab=BL23}
N 4560 11000 4540 11000 {}
C {lab_pin.sym} 4540 11000 0 0 {name=l35317 lab=BLB23}
N 4560 10960 4540 10960 {}
C {lab_pin.sym} 4540 10960 0 0 {name=l35318 lab=WL55}
N 4640 11040 4660 11040 {}
C {lab_pin.sym} 4660 11040 0 0 {name=l35319 lab=VDD}
N 4640 10960 4660 10960 {}
C {lab_pin.sym} 4660 10960 0 0 {name=l35320 lab=VSS}
C {bitcell_6t.sym} 4800 11000 0 0 {name=Xr55c24}
N 4760 11040 4740 11040 {}
C {lab_pin.sym} 4740 11040 0 0 {name=l35321 lab=BL24}
N 4760 11000 4740 11000 {}
C {lab_pin.sym} 4740 11000 0 0 {name=l35322 lab=BLB24}
N 4760 10960 4740 10960 {}
C {lab_pin.sym} 4740 10960 0 0 {name=l35323 lab=WL55}
N 4840 11040 4860 11040 {}
C {lab_pin.sym} 4860 11040 0 0 {name=l35324 lab=VDD}
N 4840 10960 4860 10960 {}
C {lab_pin.sym} 4860 10960 0 0 {name=l35325 lab=VSS}
C {bitcell_6t.sym} 5000 11000 0 0 {name=Xr55c25}
N 4960 11040 4940 11040 {}
C {lab_pin.sym} 4940 11040 0 0 {name=l35326 lab=BL25}
N 4960 11000 4940 11000 {}
C {lab_pin.sym} 4940 11000 0 0 {name=l35327 lab=BLB25}
N 4960 10960 4940 10960 {}
C {lab_pin.sym} 4940 10960 0 0 {name=l35328 lab=WL55}
N 5040 11040 5060 11040 {}
C {lab_pin.sym} 5060 11040 0 0 {name=l35329 lab=VDD}
N 5040 10960 5060 10960 {}
C {lab_pin.sym} 5060 10960 0 0 {name=l35330 lab=VSS}
C {bitcell_6t.sym} 5200 11000 0 0 {name=Xr55c26}
N 5160 11040 5140 11040 {}
C {lab_pin.sym} 5140 11040 0 0 {name=l35331 lab=BL26}
N 5160 11000 5140 11000 {}
C {lab_pin.sym} 5140 11000 0 0 {name=l35332 lab=BLB26}
N 5160 10960 5140 10960 {}
C {lab_pin.sym} 5140 10960 0 0 {name=l35333 lab=WL55}
N 5240 11040 5260 11040 {}
C {lab_pin.sym} 5260 11040 0 0 {name=l35334 lab=VDD}
N 5240 10960 5260 10960 {}
C {lab_pin.sym} 5260 10960 0 0 {name=l35335 lab=VSS}
C {bitcell_6t.sym} 5400 11000 0 0 {name=Xr55c27}
N 5360 11040 5340 11040 {}
C {lab_pin.sym} 5340 11040 0 0 {name=l35336 lab=BL27}
N 5360 11000 5340 11000 {}
C {lab_pin.sym} 5340 11000 0 0 {name=l35337 lab=BLB27}
N 5360 10960 5340 10960 {}
C {lab_pin.sym} 5340 10960 0 0 {name=l35338 lab=WL55}
N 5440 11040 5460 11040 {}
C {lab_pin.sym} 5460 11040 0 0 {name=l35339 lab=VDD}
N 5440 10960 5460 10960 {}
C {lab_pin.sym} 5460 10960 0 0 {name=l35340 lab=VSS}
C {bitcell_6t.sym} 5600 11000 0 0 {name=Xr55c28}
N 5560 11040 5540 11040 {}
C {lab_pin.sym} 5540 11040 0 0 {name=l35341 lab=BL28}
N 5560 11000 5540 11000 {}
C {lab_pin.sym} 5540 11000 0 0 {name=l35342 lab=BLB28}
N 5560 10960 5540 10960 {}
C {lab_pin.sym} 5540 10960 0 0 {name=l35343 lab=WL55}
N 5640 11040 5660 11040 {}
C {lab_pin.sym} 5660 11040 0 0 {name=l35344 lab=VDD}
N 5640 10960 5660 10960 {}
C {lab_pin.sym} 5660 10960 0 0 {name=l35345 lab=VSS}
C {bitcell_6t.sym} 5800 11000 0 0 {name=Xr55c29}
N 5760 11040 5740 11040 {}
C {lab_pin.sym} 5740 11040 0 0 {name=l35346 lab=BL29}
N 5760 11000 5740 11000 {}
C {lab_pin.sym} 5740 11000 0 0 {name=l35347 lab=BLB29}
N 5760 10960 5740 10960 {}
C {lab_pin.sym} 5740 10960 0 0 {name=l35348 lab=WL55}
N 5840 11040 5860 11040 {}
C {lab_pin.sym} 5860 11040 0 0 {name=l35349 lab=VDD}
N 5840 10960 5860 10960 {}
C {lab_pin.sym} 5860 10960 0 0 {name=l35350 lab=VSS}
C {bitcell_6t.sym} 6000 11000 0 0 {name=Xr55c30}
N 5960 11040 5940 11040 {}
C {lab_pin.sym} 5940 11040 0 0 {name=l35351 lab=BL30}
N 5960 11000 5940 11000 {}
C {lab_pin.sym} 5940 11000 0 0 {name=l35352 lab=BLB30}
N 5960 10960 5940 10960 {}
C {lab_pin.sym} 5940 10960 0 0 {name=l35353 lab=WL55}
N 6040 11040 6060 11040 {}
C {lab_pin.sym} 6060 11040 0 0 {name=l35354 lab=VDD}
N 6040 10960 6060 10960 {}
C {lab_pin.sym} 6060 10960 0 0 {name=l35355 lab=VSS}
C {bitcell_6t.sym} 6200 11000 0 0 {name=Xr55c31}
N 6160 11040 6140 11040 {}
C {lab_pin.sym} 6140 11040 0 0 {name=l35356 lab=BL31}
N 6160 11000 6140 11000 {}
C {lab_pin.sym} 6140 11000 0 0 {name=l35357 lab=BLB31}
N 6160 10960 6140 10960 {}
C {lab_pin.sym} 6140 10960 0 0 {name=l35358 lab=WL55}
N 6240 11040 6260 11040 {}
C {lab_pin.sym} 6260 11040 0 0 {name=l35359 lab=VDD}
N 6240 10960 6260 10960 {}
C {lab_pin.sym} 6260 10960 0 0 {name=l35360 lab=VSS}
C {bitcell_6t.sym} 6400 11000 0 0 {name=Xr55c32}
N 6360 11040 6340 11040 {}
C {lab_pin.sym} 6340 11040 0 0 {name=l35361 lab=BL32}
N 6360 11000 6340 11000 {}
C {lab_pin.sym} 6340 11000 0 0 {name=l35362 lab=BLB32}
N 6360 10960 6340 10960 {}
C {lab_pin.sym} 6340 10960 0 0 {name=l35363 lab=WL55}
N 6440 11040 6460 11040 {}
C {lab_pin.sym} 6460 11040 0 0 {name=l35364 lab=VDD}
N 6440 10960 6460 10960 {}
C {lab_pin.sym} 6460 10960 0 0 {name=l35365 lab=VSS}
C {bitcell_6t.sym} 6600 11000 0 0 {name=Xr55c33}
N 6560 11040 6540 11040 {}
C {lab_pin.sym} 6540 11040 0 0 {name=l35366 lab=BL33}
N 6560 11000 6540 11000 {}
C {lab_pin.sym} 6540 11000 0 0 {name=l35367 lab=BLB33}
N 6560 10960 6540 10960 {}
C {lab_pin.sym} 6540 10960 0 0 {name=l35368 lab=WL55}
N 6640 11040 6660 11040 {}
C {lab_pin.sym} 6660 11040 0 0 {name=l35369 lab=VDD}
N 6640 10960 6660 10960 {}
C {lab_pin.sym} 6660 10960 0 0 {name=l35370 lab=VSS}
C {bitcell_6t.sym} 6800 11000 0 0 {name=Xr55c34}
N 6760 11040 6740 11040 {}
C {lab_pin.sym} 6740 11040 0 0 {name=l35371 lab=BL34}
N 6760 11000 6740 11000 {}
C {lab_pin.sym} 6740 11000 0 0 {name=l35372 lab=BLB34}
N 6760 10960 6740 10960 {}
C {lab_pin.sym} 6740 10960 0 0 {name=l35373 lab=WL55}
N 6840 11040 6860 11040 {}
C {lab_pin.sym} 6860 11040 0 0 {name=l35374 lab=VDD}
N 6840 10960 6860 10960 {}
C {lab_pin.sym} 6860 10960 0 0 {name=l35375 lab=VSS}
C {bitcell_6t.sym} 7000 11000 0 0 {name=Xr55c35}
N 6960 11040 6940 11040 {}
C {lab_pin.sym} 6940 11040 0 0 {name=l35376 lab=BL35}
N 6960 11000 6940 11000 {}
C {lab_pin.sym} 6940 11000 0 0 {name=l35377 lab=BLB35}
N 6960 10960 6940 10960 {}
C {lab_pin.sym} 6940 10960 0 0 {name=l35378 lab=WL55}
N 7040 11040 7060 11040 {}
C {lab_pin.sym} 7060 11040 0 0 {name=l35379 lab=VDD}
N 7040 10960 7060 10960 {}
C {lab_pin.sym} 7060 10960 0 0 {name=l35380 lab=VSS}
C {bitcell_6t.sym} 7200 11000 0 0 {name=Xr55c36}
N 7160 11040 7140 11040 {}
C {lab_pin.sym} 7140 11040 0 0 {name=l35381 lab=BL36}
N 7160 11000 7140 11000 {}
C {lab_pin.sym} 7140 11000 0 0 {name=l35382 lab=BLB36}
N 7160 10960 7140 10960 {}
C {lab_pin.sym} 7140 10960 0 0 {name=l35383 lab=WL55}
N 7240 11040 7260 11040 {}
C {lab_pin.sym} 7260 11040 0 0 {name=l35384 lab=VDD}
N 7240 10960 7260 10960 {}
C {lab_pin.sym} 7260 10960 0 0 {name=l35385 lab=VSS}
C {bitcell_6t.sym} 7400 11000 0 0 {name=Xr55c37}
N 7360 11040 7340 11040 {}
C {lab_pin.sym} 7340 11040 0 0 {name=l35386 lab=BL37}
N 7360 11000 7340 11000 {}
C {lab_pin.sym} 7340 11000 0 0 {name=l35387 lab=BLB37}
N 7360 10960 7340 10960 {}
C {lab_pin.sym} 7340 10960 0 0 {name=l35388 lab=WL55}
N 7440 11040 7460 11040 {}
C {lab_pin.sym} 7460 11040 0 0 {name=l35389 lab=VDD}
N 7440 10960 7460 10960 {}
C {lab_pin.sym} 7460 10960 0 0 {name=l35390 lab=VSS}
C {bitcell_6t.sym} 7600 11000 0 0 {name=Xr55c38}
N 7560 11040 7540 11040 {}
C {lab_pin.sym} 7540 11040 0 0 {name=l35391 lab=BL38}
N 7560 11000 7540 11000 {}
C {lab_pin.sym} 7540 11000 0 0 {name=l35392 lab=BLB38}
N 7560 10960 7540 10960 {}
C {lab_pin.sym} 7540 10960 0 0 {name=l35393 lab=WL55}
N 7640 11040 7660 11040 {}
C {lab_pin.sym} 7660 11040 0 0 {name=l35394 lab=VDD}
N 7640 10960 7660 10960 {}
C {lab_pin.sym} 7660 10960 0 0 {name=l35395 lab=VSS}
C {bitcell_6t.sym} 7800 11000 0 0 {name=Xr55c39}
N 7760 11040 7740 11040 {}
C {lab_pin.sym} 7740 11040 0 0 {name=l35396 lab=BL39}
N 7760 11000 7740 11000 {}
C {lab_pin.sym} 7740 11000 0 0 {name=l35397 lab=BLB39}
N 7760 10960 7740 10960 {}
C {lab_pin.sym} 7740 10960 0 0 {name=l35398 lab=WL55}
N 7840 11040 7860 11040 {}
C {lab_pin.sym} 7860 11040 0 0 {name=l35399 lab=VDD}
N 7840 10960 7860 10960 {}
C {lab_pin.sym} 7860 10960 0 0 {name=l35400 lab=VSS}
C {bitcell_6t.sym} 8000 11000 0 0 {name=Xr55c40}
N 7960 11040 7940 11040 {}
C {lab_pin.sym} 7940 11040 0 0 {name=l35401 lab=BL40}
N 7960 11000 7940 11000 {}
C {lab_pin.sym} 7940 11000 0 0 {name=l35402 lab=BLB40}
N 7960 10960 7940 10960 {}
C {lab_pin.sym} 7940 10960 0 0 {name=l35403 lab=WL55}
N 8040 11040 8060 11040 {}
C {lab_pin.sym} 8060 11040 0 0 {name=l35404 lab=VDD}
N 8040 10960 8060 10960 {}
C {lab_pin.sym} 8060 10960 0 0 {name=l35405 lab=VSS}
C {bitcell_6t.sym} 8200 11000 0 0 {name=Xr55c41}
N 8160 11040 8140 11040 {}
C {lab_pin.sym} 8140 11040 0 0 {name=l35406 lab=BL41}
N 8160 11000 8140 11000 {}
C {lab_pin.sym} 8140 11000 0 0 {name=l35407 lab=BLB41}
N 8160 10960 8140 10960 {}
C {lab_pin.sym} 8140 10960 0 0 {name=l35408 lab=WL55}
N 8240 11040 8260 11040 {}
C {lab_pin.sym} 8260 11040 0 0 {name=l35409 lab=VDD}
N 8240 10960 8260 10960 {}
C {lab_pin.sym} 8260 10960 0 0 {name=l35410 lab=VSS}
C {bitcell_6t.sym} 8400 11000 0 0 {name=Xr55c42}
N 8360 11040 8340 11040 {}
C {lab_pin.sym} 8340 11040 0 0 {name=l35411 lab=BL42}
N 8360 11000 8340 11000 {}
C {lab_pin.sym} 8340 11000 0 0 {name=l35412 lab=BLB42}
N 8360 10960 8340 10960 {}
C {lab_pin.sym} 8340 10960 0 0 {name=l35413 lab=WL55}
N 8440 11040 8460 11040 {}
C {lab_pin.sym} 8460 11040 0 0 {name=l35414 lab=VDD}
N 8440 10960 8460 10960 {}
C {lab_pin.sym} 8460 10960 0 0 {name=l35415 lab=VSS}
C {bitcell_6t.sym} 8600 11000 0 0 {name=Xr55c43}
N 8560 11040 8540 11040 {}
C {lab_pin.sym} 8540 11040 0 0 {name=l35416 lab=BL43}
N 8560 11000 8540 11000 {}
C {lab_pin.sym} 8540 11000 0 0 {name=l35417 lab=BLB43}
N 8560 10960 8540 10960 {}
C {lab_pin.sym} 8540 10960 0 0 {name=l35418 lab=WL55}
N 8640 11040 8660 11040 {}
C {lab_pin.sym} 8660 11040 0 0 {name=l35419 lab=VDD}
N 8640 10960 8660 10960 {}
C {lab_pin.sym} 8660 10960 0 0 {name=l35420 lab=VSS}
C {bitcell_6t.sym} 8800 11000 0 0 {name=Xr55c44}
N 8760 11040 8740 11040 {}
C {lab_pin.sym} 8740 11040 0 0 {name=l35421 lab=BL44}
N 8760 11000 8740 11000 {}
C {lab_pin.sym} 8740 11000 0 0 {name=l35422 lab=BLB44}
N 8760 10960 8740 10960 {}
C {lab_pin.sym} 8740 10960 0 0 {name=l35423 lab=WL55}
N 8840 11040 8860 11040 {}
C {lab_pin.sym} 8860 11040 0 0 {name=l35424 lab=VDD}
N 8840 10960 8860 10960 {}
C {lab_pin.sym} 8860 10960 0 0 {name=l35425 lab=VSS}
C {bitcell_6t.sym} 9000 11000 0 0 {name=Xr55c45}
N 8960 11040 8940 11040 {}
C {lab_pin.sym} 8940 11040 0 0 {name=l35426 lab=BL45}
N 8960 11000 8940 11000 {}
C {lab_pin.sym} 8940 11000 0 0 {name=l35427 lab=BLB45}
N 8960 10960 8940 10960 {}
C {lab_pin.sym} 8940 10960 0 0 {name=l35428 lab=WL55}
N 9040 11040 9060 11040 {}
C {lab_pin.sym} 9060 11040 0 0 {name=l35429 lab=VDD}
N 9040 10960 9060 10960 {}
C {lab_pin.sym} 9060 10960 0 0 {name=l35430 lab=VSS}
C {bitcell_6t.sym} 9200 11000 0 0 {name=Xr55c46}
N 9160 11040 9140 11040 {}
C {lab_pin.sym} 9140 11040 0 0 {name=l35431 lab=BL46}
N 9160 11000 9140 11000 {}
C {lab_pin.sym} 9140 11000 0 0 {name=l35432 lab=BLB46}
N 9160 10960 9140 10960 {}
C {lab_pin.sym} 9140 10960 0 0 {name=l35433 lab=WL55}
N 9240 11040 9260 11040 {}
C {lab_pin.sym} 9260 11040 0 0 {name=l35434 lab=VDD}
N 9240 10960 9260 10960 {}
C {lab_pin.sym} 9260 10960 0 0 {name=l35435 lab=VSS}
C {bitcell_6t.sym} 9400 11000 0 0 {name=Xr55c47}
N 9360 11040 9340 11040 {}
C {lab_pin.sym} 9340 11040 0 0 {name=l35436 lab=BL47}
N 9360 11000 9340 11000 {}
C {lab_pin.sym} 9340 11000 0 0 {name=l35437 lab=BLB47}
N 9360 10960 9340 10960 {}
C {lab_pin.sym} 9340 10960 0 0 {name=l35438 lab=WL55}
N 9440 11040 9460 11040 {}
C {lab_pin.sym} 9460 11040 0 0 {name=l35439 lab=VDD}
N 9440 10960 9460 10960 {}
C {lab_pin.sym} 9460 10960 0 0 {name=l35440 lab=VSS}
C {bitcell_6t.sym} 9600 11000 0 0 {name=Xr55c48}
N 9560 11040 9540 11040 {}
C {lab_pin.sym} 9540 11040 0 0 {name=l35441 lab=BL48}
N 9560 11000 9540 11000 {}
C {lab_pin.sym} 9540 11000 0 0 {name=l35442 lab=BLB48}
N 9560 10960 9540 10960 {}
C {lab_pin.sym} 9540 10960 0 0 {name=l35443 lab=WL55}
N 9640 11040 9660 11040 {}
C {lab_pin.sym} 9660 11040 0 0 {name=l35444 lab=VDD}
N 9640 10960 9660 10960 {}
C {lab_pin.sym} 9660 10960 0 0 {name=l35445 lab=VSS}
C {bitcell_6t.sym} 9800 11000 0 0 {name=Xr55c49}
N 9760 11040 9740 11040 {}
C {lab_pin.sym} 9740 11040 0 0 {name=l35446 lab=BL49}
N 9760 11000 9740 11000 {}
C {lab_pin.sym} 9740 11000 0 0 {name=l35447 lab=BLB49}
N 9760 10960 9740 10960 {}
C {lab_pin.sym} 9740 10960 0 0 {name=l35448 lab=WL55}
N 9840 11040 9860 11040 {}
C {lab_pin.sym} 9860 11040 0 0 {name=l35449 lab=VDD}
N 9840 10960 9860 10960 {}
C {lab_pin.sym} 9860 10960 0 0 {name=l35450 lab=VSS}
C {bitcell_6t.sym} 10000 11000 0 0 {name=Xr55c50}
N 9960 11040 9940 11040 {}
C {lab_pin.sym} 9940 11040 0 0 {name=l35451 lab=BL50}
N 9960 11000 9940 11000 {}
C {lab_pin.sym} 9940 11000 0 0 {name=l35452 lab=BLB50}
N 9960 10960 9940 10960 {}
C {lab_pin.sym} 9940 10960 0 0 {name=l35453 lab=WL55}
N 10040 11040 10060 11040 {}
C {lab_pin.sym} 10060 11040 0 0 {name=l35454 lab=VDD}
N 10040 10960 10060 10960 {}
C {lab_pin.sym} 10060 10960 0 0 {name=l35455 lab=VSS}
C {bitcell_6t.sym} 10200 11000 0 0 {name=Xr55c51}
N 10160 11040 10140 11040 {}
C {lab_pin.sym} 10140 11040 0 0 {name=l35456 lab=BL51}
N 10160 11000 10140 11000 {}
C {lab_pin.sym} 10140 11000 0 0 {name=l35457 lab=BLB51}
N 10160 10960 10140 10960 {}
C {lab_pin.sym} 10140 10960 0 0 {name=l35458 lab=WL55}
N 10240 11040 10260 11040 {}
C {lab_pin.sym} 10260 11040 0 0 {name=l35459 lab=VDD}
N 10240 10960 10260 10960 {}
C {lab_pin.sym} 10260 10960 0 0 {name=l35460 lab=VSS}
C {bitcell_6t.sym} 10400 11000 0 0 {name=Xr55c52}
N 10360 11040 10340 11040 {}
C {lab_pin.sym} 10340 11040 0 0 {name=l35461 lab=BL52}
N 10360 11000 10340 11000 {}
C {lab_pin.sym} 10340 11000 0 0 {name=l35462 lab=BLB52}
N 10360 10960 10340 10960 {}
C {lab_pin.sym} 10340 10960 0 0 {name=l35463 lab=WL55}
N 10440 11040 10460 11040 {}
C {lab_pin.sym} 10460 11040 0 0 {name=l35464 lab=VDD}
N 10440 10960 10460 10960 {}
C {lab_pin.sym} 10460 10960 0 0 {name=l35465 lab=VSS}
C {bitcell_6t.sym} 10600 11000 0 0 {name=Xr55c53}
N 10560 11040 10540 11040 {}
C {lab_pin.sym} 10540 11040 0 0 {name=l35466 lab=BL53}
N 10560 11000 10540 11000 {}
C {lab_pin.sym} 10540 11000 0 0 {name=l35467 lab=BLB53}
N 10560 10960 10540 10960 {}
C {lab_pin.sym} 10540 10960 0 0 {name=l35468 lab=WL55}
N 10640 11040 10660 11040 {}
C {lab_pin.sym} 10660 11040 0 0 {name=l35469 lab=VDD}
N 10640 10960 10660 10960 {}
C {lab_pin.sym} 10660 10960 0 0 {name=l35470 lab=VSS}
C {bitcell_6t.sym} 10800 11000 0 0 {name=Xr55c54}
N 10760 11040 10740 11040 {}
C {lab_pin.sym} 10740 11040 0 0 {name=l35471 lab=BL54}
N 10760 11000 10740 11000 {}
C {lab_pin.sym} 10740 11000 0 0 {name=l35472 lab=BLB54}
N 10760 10960 10740 10960 {}
C {lab_pin.sym} 10740 10960 0 0 {name=l35473 lab=WL55}
N 10840 11040 10860 11040 {}
C {lab_pin.sym} 10860 11040 0 0 {name=l35474 lab=VDD}
N 10840 10960 10860 10960 {}
C {lab_pin.sym} 10860 10960 0 0 {name=l35475 lab=VSS}
C {bitcell_6t.sym} 11000 11000 0 0 {name=Xr55c55}
N 10960 11040 10940 11040 {}
C {lab_pin.sym} 10940 11040 0 0 {name=l35476 lab=BL55}
N 10960 11000 10940 11000 {}
C {lab_pin.sym} 10940 11000 0 0 {name=l35477 lab=BLB55}
N 10960 10960 10940 10960 {}
C {lab_pin.sym} 10940 10960 0 0 {name=l35478 lab=WL55}
N 11040 11040 11060 11040 {}
C {lab_pin.sym} 11060 11040 0 0 {name=l35479 lab=VDD}
N 11040 10960 11060 10960 {}
C {lab_pin.sym} 11060 10960 0 0 {name=l35480 lab=VSS}
C {bitcell_6t.sym} 11200 11000 0 0 {name=Xr55c56}
N 11160 11040 11140 11040 {}
C {lab_pin.sym} 11140 11040 0 0 {name=l35481 lab=BL56}
N 11160 11000 11140 11000 {}
C {lab_pin.sym} 11140 11000 0 0 {name=l35482 lab=BLB56}
N 11160 10960 11140 10960 {}
C {lab_pin.sym} 11140 10960 0 0 {name=l35483 lab=WL55}
N 11240 11040 11260 11040 {}
C {lab_pin.sym} 11260 11040 0 0 {name=l35484 lab=VDD}
N 11240 10960 11260 10960 {}
C {lab_pin.sym} 11260 10960 0 0 {name=l35485 lab=VSS}
C {bitcell_6t.sym} 11400 11000 0 0 {name=Xr55c57}
N 11360 11040 11340 11040 {}
C {lab_pin.sym} 11340 11040 0 0 {name=l35486 lab=BL57}
N 11360 11000 11340 11000 {}
C {lab_pin.sym} 11340 11000 0 0 {name=l35487 lab=BLB57}
N 11360 10960 11340 10960 {}
C {lab_pin.sym} 11340 10960 0 0 {name=l35488 lab=WL55}
N 11440 11040 11460 11040 {}
C {lab_pin.sym} 11460 11040 0 0 {name=l35489 lab=VDD}
N 11440 10960 11460 10960 {}
C {lab_pin.sym} 11460 10960 0 0 {name=l35490 lab=VSS}
C {bitcell_6t.sym} 11600 11000 0 0 {name=Xr55c58}
N 11560 11040 11540 11040 {}
C {lab_pin.sym} 11540 11040 0 0 {name=l35491 lab=BL58}
N 11560 11000 11540 11000 {}
C {lab_pin.sym} 11540 11000 0 0 {name=l35492 lab=BLB58}
N 11560 10960 11540 10960 {}
C {lab_pin.sym} 11540 10960 0 0 {name=l35493 lab=WL55}
N 11640 11040 11660 11040 {}
C {lab_pin.sym} 11660 11040 0 0 {name=l35494 lab=VDD}
N 11640 10960 11660 10960 {}
C {lab_pin.sym} 11660 10960 0 0 {name=l35495 lab=VSS}
C {bitcell_6t.sym} 11800 11000 0 0 {name=Xr55c59}
N 11760 11040 11740 11040 {}
C {lab_pin.sym} 11740 11040 0 0 {name=l35496 lab=BL59}
N 11760 11000 11740 11000 {}
C {lab_pin.sym} 11740 11000 0 0 {name=l35497 lab=BLB59}
N 11760 10960 11740 10960 {}
C {lab_pin.sym} 11740 10960 0 0 {name=l35498 lab=WL55}
N 11840 11040 11860 11040 {}
C {lab_pin.sym} 11860 11040 0 0 {name=l35499 lab=VDD}
N 11840 10960 11860 10960 {}
C {lab_pin.sym} 11860 10960 0 0 {name=l35500 lab=VSS}
C {bitcell_6t.sym} 12000 11000 0 0 {name=Xr55c60}
N 11960 11040 11940 11040 {}
C {lab_pin.sym} 11940 11040 0 0 {name=l35501 lab=BL60}
N 11960 11000 11940 11000 {}
C {lab_pin.sym} 11940 11000 0 0 {name=l35502 lab=BLB60}
N 11960 10960 11940 10960 {}
C {lab_pin.sym} 11940 10960 0 0 {name=l35503 lab=WL55}
N 12040 11040 12060 11040 {}
C {lab_pin.sym} 12060 11040 0 0 {name=l35504 lab=VDD}
N 12040 10960 12060 10960 {}
C {lab_pin.sym} 12060 10960 0 0 {name=l35505 lab=VSS}
C {bitcell_6t.sym} 12200 11000 0 0 {name=Xr55c61}
N 12160 11040 12140 11040 {}
C {lab_pin.sym} 12140 11040 0 0 {name=l35506 lab=BL61}
N 12160 11000 12140 11000 {}
C {lab_pin.sym} 12140 11000 0 0 {name=l35507 lab=BLB61}
N 12160 10960 12140 10960 {}
C {lab_pin.sym} 12140 10960 0 0 {name=l35508 lab=WL55}
N 12240 11040 12260 11040 {}
C {lab_pin.sym} 12260 11040 0 0 {name=l35509 lab=VDD}
N 12240 10960 12260 10960 {}
C {lab_pin.sym} 12260 10960 0 0 {name=l35510 lab=VSS}
C {bitcell_6t.sym} 12400 11000 0 0 {name=Xr55c62}
N 12360 11040 12340 11040 {}
C {lab_pin.sym} 12340 11040 0 0 {name=l35511 lab=BL62}
N 12360 11000 12340 11000 {}
C {lab_pin.sym} 12340 11000 0 0 {name=l35512 lab=BLB62}
N 12360 10960 12340 10960 {}
C {lab_pin.sym} 12340 10960 0 0 {name=l35513 lab=WL55}
N 12440 11040 12460 11040 {}
C {lab_pin.sym} 12460 11040 0 0 {name=l35514 lab=VDD}
N 12440 10960 12460 10960 {}
C {lab_pin.sym} 12460 10960 0 0 {name=l35515 lab=VSS}
C {bitcell_6t.sym} 12600 11000 0 0 {name=Xr55c63}
N 12560 11040 12540 11040 {}
C {lab_pin.sym} 12540 11040 0 0 {name=l35516 lab=BL63}
N 12560 11000 12540 11000 {}
C {lab_pin.sym} 12540 11000 0 0 {name=l35517 lab=BLB63}
N 12560 10960 12540 10960 {}
C {lab_pin.sym} 12540 10960 0 0 {name=l35518 lab=WL55}
N 12640 11040 12660 11040 {}
C {lab_pin.sym} 12660 11040 0 0 {name=l35519 lab=VDD}
N 12640 10960 12660 10960 {}
C {lab_pin.sym} 12660 10960 0 0 {name=l35520 lab=VSS}
C {bitcell_6t.sym} 12800 11000 0 0 {name=Xr55c64}
N 12760 11040 12740 11040 {}
C {lab_pin.sym} 12740 11040 0 0 {name=l35521 lab=BL64}
N 12760 11000 12740 11000 {}
C {lab_pin.sym} 12740 11000 0 0 {name=l35522 lab=BLB64}
N 12760 10960 12740 10960 {}
C {lab_pin.sym} 12740 10960 0 0 {name=l35523 lab=WL55}
N 12840 11040 12860 11040 {}
C {lab_pin.sym} 12860 11040 0 0 {name=l35524 lab=VDD}
N 12840 10960 12860 10960 {}
C {lab_pin.sym} 12860 10960 0 0 {name=l35525 lab=VSS}
C {bitcell_6t.sym} 13000 11000 0 0 {name=Xr55c65}
N 12960 11040 12940 11040 {}
C {lab_pin.sym} 12940 11040 0 0 {name=l35526 lab=BL65}
N 12960 11000 12940 11000 {}
C {lab_pin.sym} 12940 11000 0 0 {name=l35527 lab=BLB65}
N 12960 10960 12940 10960 {}
C {lab_pin.sym} 12940 10960 0 0 {name=l35528 lab=WL55}
N 13040 11040 13060 11040 {}
C {lab_pin.sym} 13060 11040 0 0 {name=l35529 lab=VDD}
N 13040 10960 13060 10960 {}
C {lab_pin.sym} 13060 10960 0 0 {name=l35530 lab=VSS}
C {bitcell_6t.sym} 13200 11000 0 0 {name=Xr55c66}
N 13160 11040 13140 11040 {}
C {lab_pin.sym} 13140 11040 0 0 {name=l35531 lab=BL66}
N 13160 11000 13140 11000 {}
C {lab_pin.sym} 13140 11000 0 0 {name=l35532 lab=BLB66}
N 13160 10960 13140 10960 {}
C {lab_pin.sym} 13140 10960 0 0 {name=l35533 lab=WL55}
N 13240 11040 13260 11040 {}
C {lab_pin.sym} 13260 11040 0 0 {name=l35534 lab=VDD}
N 13240 10960 13260 10960 {}
C {lab_pin.sym} 13260 10960 0 0 {name=l35535 lab=VSS}
C {bitcell_6t.sym} 13400 11000 0 0 {name=Xr55c67}
N 13360 11040 13340 11040 {}
C {lab_pin.sym} 13340 11040 0 0 {name=l35536 lab=BL67}
N 13360 11000 13340 11000 {}
C {lab_pin.sym} 13340 11000 0 0 {name=l35537 lab=BLB67}
N 13360 10960 13340 10960 {}
C {lab_pin.sym} 13340 10960 0 0 {name=l35538 lab=WL55}
N 13440 11040 13460 11040 {}
C {lab_pin.sym} 13460 11040 0 0 {name=l35539 lab=VDD}
N 13440 10960 13460 10960 {}
C {lab_pin.sym} 13460 10960 0 0 {name=l35540 lab=VSS}
C {bitcell_6t.sym} 13600 11000 0 0 {name=Xr55c68}
N 13560 11040 13540 11040 {}
C {lab_pin.sym} 13540 11040 0 0 {name=l35541 lab=BL68}
N 13560 11000 13540 11000 {}
C {lab_pin.sym} 13540 11000 0 0 {name=l35542 lab=BLB68}
N 13560 10960 13540 10960 {}
C {lab_pin.sym} 13540 10960 0 0 {name=l35543 lab=WL55}
N 13640 11040 13660 11040 {}
C {lab_pin.sym} 13660 11040 0 0 {name=l35544 lab=VDD}
N 13640 10960 13660 10960 {}
C {lab_pin.sym} 13660 10960 0 0 {name=l35545 lab=VSS}
C {bitcell_6t.sym} 13800 11000 0 0 {name=Xr55c69}
N 13760 11040 13740 11040 {}
C {lab_pin.sym} 13740 11040 0 0 {name=l35546 lab=BL69}
N 13760 11000 13740 11000 {}
C {lab_pin.sym} 13740 11000 0 0 {name=l35547 lab=BLB69}
N 13760 10960 13740 10960 {}
C {lab_pin.sym} 13740 10960 0 0 {name=l35548 lab=WL55}
N 13840 11040 13860 11040 {}
C {lab_pin.sym} 13860 11040 0 0 {name=l35549 lab=VDD}
N 13840 10960 13860 10960 {}
C {lab_pin.sym} 13860 10960 0 0 {name=l35550 lab=VSS}
C {bitcell_6t.sym} 14000 11000 0 0 {name=Xr55c70}
N 13960 11040 13940 11040 {}
C {lab_pin.sym} 13940 11040 0 0 {name=l35551 lab=BL70}
N 13960 11000 13940 11000 {}
C {lab_pin.sym} 13940 11000 0 0 {name=l35552 lab=BLB70}
N 13960 10960 13940 10960 {}
C {lab_pin.sym} 13940 10960 0 0 {name=l35553 lab=WL55}
N 14040 11040 14060 11040 {}
C {lab_pin.sym} 14060 11040 0 0 {name=l35554 lab=VDD}
N 14040 10960 14060 10960 {}
C {lab_pin.sym} 14060 10960 0 0 {name=l35555 lab=VSS}
C {bitcell_6t.sym} 14200 11000 0 0 {name=Xr55c71}
N 14160 11040 14140 11040 {}
C {lab_pin.sym} 14140 11040 0 0 {name=l35556 lab=BL71}
N 14160 11000 14140 11000 {}
C {lab_pin.sym} 14140 11000 0 0 {name=l35557 lab=BLB71}
N 14160 10960 14140 10960 {}
C {lab_pin.sym} 14140 10960 0 0 {name=l35558 lab=WL55}
N 14240 11040 14260 11040 {}
C {lab_pin.sym} 14260 11040 0 0 {name=l35559 lab=VDD}
N 14240 10960 14260 10960 {}
C {lab_pin.sym} 14260 10960 0 0 {name=l35560 lab=VSS}
C {bitcell_6t.sym} 14400 11000 0 0 {name=Xr55c72}
N 14360 11040 14340 11040 {}
C {lab_pin.sym} 14340 11040 0 0 {name=l35561 lab=BL72}
N 14360 11000 14340 11000 {}
C {lab_pin.sym} 14340 11000 0 0 {name=l35562 lab=BLB72}
N 14360 10960 14340 10960 {}
C {lab_pin.sym} 14340 10960 0 0 {name=l35563 lab=WL55}
N 14440 11040 14460 11040 {}
C {lab_pin.sym} 14460 11040 0 0 {name=l35564 lab=VDD}
N 14440 10960 14460 10960 {}
C {lab_pin.sym} 14460 10960 0 0 {name=l35565 lab=VSS}
C {bitcell_6t.sym} 14600 11000 0 0 {name=Xr55c73}
N 14560 11040 14540 11040 {}
C {lab_pin.sym} 14540 11040 0 0 {name=l35566 lab=BL73}
N 14560 11000 14540 11000 {}
C {lab_pin.sym} 14540 11000 0 0 {name=l35567 lab=BLB73}
N 14560 10960 14540 10960 {}
C {lab_pin.sym} 14540 10960 0 0 {name=l35568 lab=WL55}
N 14640 11040 14660 11040 {}
C {lab_pin.sym} 14660 11040 0 0 {name=l35569 lab=VDD}
N 14640 10960 14660 10960 {}
C {lab_pin.sym} 14660 10960 0 0 {name=l35570 lab=VSS}
C {bitcell_6t.sym} 14800 11000 0 0 {name=Xr55c74}
N 14760 11040 14740 11040 {}
C {lab_pin.sym} 14740 11040 0 0 {name=l35571 lab=BL74}
N 14760 11000 14740 11000 {}
C {lab_pin.sym} 14740 11000 0 0 {name=l35572 lab=BLB74}
N 14760 10960 14740 10960 {}
C {lab_pin.sym} 14740 10960 0 0 {name=l35573 lab=WL55}
N 14840 11040 14860 11040 {}
C {lab_pin.sym} 14860 11040 0 0 {name=l35574 lab=VDD}
N 14840 10960 14860 10960 {}
C {lab_pin.sym} 14860 10960 0 0 {name=l35575 lab=VSS}
C {bitcell_6t.sym} 15000 11000 0 0 {name=Xr55c75}
N 14960 11040 14940 11040 {}
C {lab_pin.sym} 14940 11040 0 0 {name=l35576 lab=BL75}
N 14960 11000 14940 11000 {}
C {lab_pin.sym} 14940 11000 0 0 {name=l35577 lab=BLB75}
N 14960 10960 14940 10960 {}
C {lab_pin.sym} 14940 10960 0 0 {name=l35578 lab=WL55}
N 15040 11040 15060 11040 {}
C {lab_pin.sym} 15060 11040 0 0 {name=l35579 lab=VDD}
N 15040 10960 15060 10960 {}
C {lab_pin.sym} 15060 10960 0 0 {name=l35580 lab=VSS}
C {bitcell_6t.sym} 15200 11000 0 0 {name=Xr55c76}
N 15160 11040 15140 11040 {}
C {lab_pin.sym} 15140 11040 0 0 {name=l35581 lab=BL76}
N 15160 11000 15140 11000 {}
C {lab_pin.sym} 15140 11000 0 0 {name=l35582 lab=BLB76}
N 15160 10960 15140 10960 {}
C {lab_pin.sym} 15140 10960 0 0 {name=l35583 lab=WL55}
N 15240 11040 15260 11040 {}
C {lab_pin.sym} 15260 11040 0 0 {name=l35584 lab=VDD}
N 15240 10960 15260 10960 {}
C {lab_pin.sym} 15260 10960 0 0 {name=l35585 lab=VSS}
C {bitcell_6t.sym} 15400 11000 0 0 {name=Xr55c77}
N 15360 11040 15340 11040 {}
C {lab_pin.sym} 15340 11040 0 0 {name=l35586 lab=BL77}
N 15360 11000 15340 11000 {}
C {lab_pin.sym} 15340 11000 0 0 {name=l35587 lab=BLB77}
N 15360 10960 15340 10960 {}
C {lab_pin.sym} 15340 10960 0 0 {name=l35588 lab=WL55}
N 15440 11040 15460 11040 {}
C {lab_pin.sym} 15460 11040 0 0 {name=l35589 lab=VDD}
N 15440 10960 15460 10960 {}
C {lab_pin.sym} 15460 10960 0 0 {name=l35590 lab=VSS}
C {bitcell_6t.sym} 15600 11000 0 0 {name=Xr55c78}
N 15560 11040 15540 11040 {}
C {lab_pin.sym} 15540 11040 0 0 {name=l35591 lab=BL78}
N 15560 11000 15540 11000 {}
C {lab_pin.sym} 15540 11000 0 0 {name=l35592 lab=BLB78}
N 15560 10960 15540 10960 {}
C {lab_pin.sym} 15540 10960 0 0 {name=l35593 lab=WL55}
N 15640 11040 15660 11040 {}
C {lab_pin.sym} 15660 11040 0 0 {name=l35594 lab=VDD}
N 15640 10960 15660 10960 {}
C {lab_pin.sym} 15660 10960 0 0 {name=l35595 lab=VSS}
C {bitcell_6t.sym} 15800 11000 0 0 {name=Xr55c79}
N 15760 11040 15740 11040 {}
C {lab_pin.sym} 15740 11040 0 0 {name=l35596 lab=BL79}
N 15760 11000 15740 11000 {}
C {lab_pin.sym} 15740 11000 0 0 {name=l35597 lab=BLB79}
N 15760 10960 15740 10960 {}
C {lab_pin.sym} 15740 10960 0 0 {name=l35598 lab=WL55}
N 15840 11040 15860 11040 {}
C {lab_pin.sym} 15860 11040 0 0 {name=l35599 lab=VDD}
N 15840 10960 15860 10960 {}
C {lab_pin.sym} 15860 10960 0 0 {name=l35600 lab=VSS}
C {bitcell_6t.sym} 16000 11000 0 0 {name=Xr55c80}
N 15960 11040 15940 11040 {}
C {lab_pin.sym} 15940 11040 0 0 {name=l35601 lab=BL80}
N 15960 11000 15940 11000 {}
C {lab_pin.sym} 15940 11000 0 0 {name=l35602 lab=BLB80}
N 15960 10960 15940 10960 {}
C {lab_pin.sym} 15940 10960 0 0 {name=l35603 lab=WL55}
N 16040 11040 16060 11040 {}
C {lab_pin.sym} 16060 11040 0 0 {name=l35604 lab=VDD}
N 16040 10960 16060 10960 {}
C {lab_pin.sym} 16060 10960 0 0 {name=l35605 lab=VSS}
C {bitcell_6t.sym} 16200 11000 0 0 {name=Xr55c81}
N 16160 11040 16140 11040 {}
C {lab_pin.sym} 16140 11040 0 0 {name=l35606 lab=BL81}
N 16160 11000 16140 11000 {}
C {lab_pin.sym} 16140 11000 0 0 {name=l35607 lab=BLB81}
N 16160 10960 16140 10960 {}
C {lab_pin.sym} 16140 10960 0 0 {name=l35608 lab=WL55}
N 16240 11040 16260 11040 {}
C {lab_pin.sym} 16260 11040 0 0 {name=l35609 lab=VDD}
N 16240 10960 16260 10960 {}
C {lab_pin.sym} 16260 10960 0 0 {name=l35610 lab=VSS}
C {bitcell_6t.sym} 16400 11000 0 0 {name=Xr55c82}
N 16360 11040 16340 11040 {}
C {lab_pin.sym} 16340 11040 0 0 {name=l35611 lab=BL82}
N 16360 11000 16340 11000 {}
C {lab_pin.sym} 16340 11000 0 0 {name=l35612 lab=BLB82}
N 16360 10960 16340 10960 {}
C {lab_pin.sym} 16340 10960 0 0 {name=l35613 lab=WL55}
N 16440 11040 16460 11040 {}
C {lab_pin.sym} 16460 11040 0 0 {name=l35614 lab=VDD}
N 16440 10960 16460 10960 {}
C {lab_pin.sym} 16460 10960 0 0 {name=l35615 lab=VSS}
C {bitcell_6t.sym} 16600 11000 0 0 {name=Xr55c83}
N 16560 11040 16540 11040 {}
C {lab_pin.sym} 16540 11040 0 0 {name=l35616 lab=BL83}
N 16560 11000 16540 11000 {}
C {lab_pin.sym} 16540 11000 0 0 {name=l35617 lab=BLB83}
N 16560 10960 16540 10960 {}
C {lab_pin.sym} 16540 10960 0 0 {name=l35618 lab=WL55}
N 16640 11040 16660 11040 {}
C {lab_pin.sym} 16660 11040 0 0 {name=l35619 lab=VDD}
N 16640 10960 16660 10960 {}
C {lab_pin.sym} 16660 10960 0 0 {name=l35620 lab=VSS}
C {bitcell_6t.sym} 16800 11000 0 0 {name=Xr55c84}
N 16760 11040 16740 11040 {}
C {lab_pin.sym} 16740 11040 0 0 {name=l35621 lab=BL84}
N 16760 11000 16740 11000 {}
C {lab_pin.sym} 16740 11000 0 0 {name=l35622 lab=BLB84}
N 16760 10960 16740 10960 {}
C {lab_pin.sym} 16740 10960 0 0 {name=l35623 lab=WL55}
N 16840 11040 16860 11040 {}
C {lab_pin.sym} 16860 11040 0 0 {name=l35624 lab=VDD}
N 16840 10960 16860 10960 {}
C {lab_pin.sym} 16860 10960 0 0 {name=l35625 lab=VSS}
C {bitcell_6t.sym} 17000 11000 0 0 {name=Xr55c85}
N 16960 11040 16940 11040 {}
C {lab_pin.sym} 16940 11040 0 0 {name=l35626 lab=BL85}
N 16960 11000 16940 11000 {}
C {lab_pin.sym} 16940 11000 0 0 {name=l35627 lab=BLB85}
N 16960 10960 16940 10960 {}
C {lab_pin.sym} 16940 10960 0 0 {name=l35628 lab=WL55}
N 17040 11040 17060 11040 {}
C {lab_pin.sym} 17060 11040 0 0 {name=l35629 lab=VDD}
N 17040 10960 17060 10960 {}
C {lab_pin.sym} 17060 10960 0 0 {name=l35630 lab=VSS}
C {bitcell_6t.sym} 17200 11000 0 0 {name=Xr55c86}
N 17160 11040 17140 11040 {}
C {lab_pin.sym} 17140 11040 0 0 {name=l35631 lab=BL86}
N 17160 11000 17140 11000 {}
C {lab_pin.sym} 17140 11000 0 0 {name=l35632 lab=BLB86}
N 17160 10960 17140 10960 {}
C {lab_pin.sym} 17140 10960 0 0 {name=l35633 lab=WL55}
N 17240 11040 17260 11040 {}
C {lab_pin.sym} 17260 11040 0 0 {name=l35634 lab=VDD}
N 17240 10960 17260 10960 {}
C {lab_pin.sym} 17260 10960 0 0 {name=l35635 lab=VSS}
C {bitcell_6t.sym} 17400 11000 0 0 {name=Xr55c87}
N 17360 11040 17340 11040 {}
C {lab_pin.sym} 17340 11040 0 0 {name=l35636 lab=BL87}
N 17360 11000 17340 11000 {}
C {lab_pin.sym} 17340 11000 0 0 {name=l35637 lab=BLB87}
N 17360 10960 17340 10960 {}
C {lab_pin.sym} 17340 10960 0 0 {name=l35638 lab=WL55}
N 17440 11040 17460 11040 {}
C {lab_pin.sym} 17460 11040 0 0 {name=l35639 lab=VDD}
N 17440 10960 17460 10960 {}
C {lab_pin.sym} 17460 10960 0 0 {name=l35640 lab=VSS}
C {bitcell_6t.sym} 17600 11000 0 0 {name=Xr55c88}
N 17560 11040 17540 11040 {}
C {lab_pin.sym} 17540 11040 0 0 {name=l35641 lab=BL88}
N 17560 11000 17540 11000 {}
C {lab_pin.sym} 17540 11000 0 0 {name=l35642 lab=BLB88}
N 17560 10960 17540 10960 {}
C {lab_pin.sym} 17540 10960 0 0 {name=l35643 lab=WL55}
N 17640 11040 17660 11040 {}
C {lab_pin.sym} 17660 11040 0 0 {name=l35644 lab=VDD}
N 17640 10960 17660 10960 {}
C {lab_pin.sym} 17660 10960 0 0 {name=l35645 lab=VSS}
C {bitcell_6t.sym} 17800 11000 0 0 {name=Xr55c89}
N 17760 11040 17740 11040 {}
C {lab_pin.sym} 17740 11040 0 0 {name=l35646 lab=BL89}
N 17760 11000 17740 11000 {}
C {lab_pin.sym} 17740 11000 0 0 {name=l35647 lab=BLB89}
N 17760 10960 17740 10960 {}
C {lab_pin.sym} 17740 10960 0 0 {name=l35648 lab=WL55}
N 17840 11040 17860 11040 {}
C {lab_pin.sym} 17860 11040 0 0 {name=l35649 lab=VDD}
N 17840 10960 17860 10960 {}
C {lab_pin.sym} 17860 10960 0 0 {name=l35650 lab=VSS}
C {bitcell_6t.sym} 18000 11000 0 0 {name=Xr55c90}
N 17960 11040 17940 11040 {}
C {lab_pin.sym} 17940 11040 0 0 {name=l35651 lab=BL90}
N 17960 11000 17940 11000 {}
C {lab_pin.sym} 17940 11000 0 0 {name=l35652 lab=BLB90}
N 17960 10960 17940 10960 {}
C {lab_pin.sym} 17940 10960 0 0 {name=l35653 lab=WL55}
N 18040 11040 18060 11040 {}
C {lab_pin.sym} 18060 11040 0 0 {name=l35654 lab=VDD}
N 18040 10960 18060 10960 {}
C {lab_pin.sym} 18060 10960 0 0 {name=l35655 lab=VSS}
C {bitcell_6t.sym} 18200 11000 0 0 {name=Xr55c91}
N 18160 11040 18140 11040 {}
C {lab_pin.sym} 18140 11040 0 0 {name=l35656 lab=BL91}
N 18160 11000 18140 11000 {}
C {lab_pin.sym} 18140 11000 0 0 {name=l35657 lab=BLB91}
N 18160 10960 18140 10960 {}
C {lab_pin.sym} 18140 10960 0 0 {name=l35658 lab=WL55}
N 18240 11040 18260 11040 {}
C {lab_pin.sym} 18260 11040 0 0 {name=l35659 lab=VDD}
N 18240 10960 18260 10960 {}
C {lab_pin.sym} 18260 10960 0 0 {name=l35660 lab=VSS}
C {bitcell_6t.sym} 18400 11000 0 0 {name=Xr55c92}
N 18360 11040 18340 11040 {}
C {lab_pin.sym} 18340 11040 0 0 {name=l35661 lab=BL92}
N 18360 11000 18340 11000 {}
C {lab_pin.sym} 18340 11000 0 0 {name=l35662 lab=BLB92}
N 18360 10960 18340 10960 {}
C {lab_pin.sym} 18340 10960 0 0 {name=l35663 lab=WL55}
N 18440 11040 18460 11040 {}
C {lab_pin.sym} 18460 11040 0 0 {name=l35664 lab=VDD}
N 18440 10960 18460 10960 {}
C {lab_pin.sym} 18460 10960 0 0 {name=l35665 lab=VSS}
C {bitcell_6t.sym} 18600 11000 0 0 {name=Xr55c93}
N 18560 11040 18540 11040 {}
C {lab_pin.sym} 18540 11040 0 0 {name=l35666 lab=BL93}
N 18560 11000 18540 11000 {}
C {lab_pin.sym} 18540 11000 0 0 {name=l35667 lab=BLB93}
N 18560 10960 18540 10960 {}
C {lab_pin.sym} 18540 10960 0 0 {name=l35668 lab=WL55}
N 18640 11040 18660 11040 {}
C {lab_pin.sym} 18660 11040 0 0 {name=l35669 lab=VDD}
N 18640 10960 18660 10960 {}
C {lab_pin.sym} 18660 10960 0 0 {name=l35670 lab=VSS}
C {bitcell_6t.sym} 18800 11000 0 0 {name=Xr55c94}
N 18760 11040 18740 11040 {}
C {lab_pin.sym} 18740 11040 0 0 {name=l35671 lab=BL94}
N 18760 11000 18740 11000 {}
C {lab_pin.sym} 18740 11000 0 0 {name=l35672 lab=BLB94}
N 18760 10960 18740 10960 {}
C {lab_pin.sym} 18740 10960 0 0 {name=l35673 lab=WL55}
N 18840 11040 18860 11040 {}
C {lab_pin.sym} 18860 11040 0 0 {name=l35674 lab=VDD}
N 18840 10960 18860 10960 {}
C {lab_pin.sym} 18860 10960 0 0 {name=l35675 lab=VSS}
C {bitcell_6t.sym} 19000 11000 0 0 {name=Xr55c95}
N 18960 11040 18940 11040 {}
C {lab_pin.sym} 18940 11040 0 0 {name=l35676 lab=BL95}
N 18960 11000 18940 11000 {}
C {lab_pin.sym} 18940 11000 0 0 {name=l35677 lab=BLB95}
N 18960 10960 18940 10960 {}
C {lab_pin.sym} 18940 10960 0 0 {name=l35678 lab=WL55}
N 19040 11040 19060 11040 {}
C {lab_pin.sym} 19060 11040 0 0 {name=l35679 lab=VDD}
N 19040 10960 19060 10960 {}
C {lab_pin.sym} 19060 10960 0 0 {name=l35680 lab=VSS}
C {bitcell_6t.sym} 19200 11000 0 0 {name=Xr55c96}
N 19160 11040 19140 11040 {}
C {lab_pin.sym} 19140 11040 0 0 {name=l35681 lab=BL96}
N 19160 11000 19140 11000 {}
C {lab_pin.sym} 19140 11000 0 0 {name=l35682 lab=BLB96}
N 19160 10960 19140 10960 {}
C {lab_pin.sym} 19140 10960 0 0 {name=l35683 lab=WL55}
N 19240 11040 19260 11040 {}
C {lab_pin.sym} 19260 11040 0 0 {name=l35684 lab=VDD}
N 19240 10960 19260 10960 {}
C {lab_pin.sym} 19260 10960 0 0 {name=l35685 lab=VSS}
C {bitcell_6t.sym} 19400 11000 0 0 {name=Xr55c97}
N 19360 11040 19340 11040 {}
C {lab_pin.sym} 19340 11040 0 0 {name=l35686 lab=BL97}
N 19360 11000 19340 11000 {}
C {lab_pin.sym} 19340 11000 0 0 {name=l35687 lab=BLB97}
N 19360 10960 19340 10960 {}
C {lab_pin.sym} 19340 10960 0 0 {name=l35688 lab=WL55}
N 19440 11040 19460 11040 {}
C {lab_pin.sym} 19460 11040 0 0 {name=l35689 lab=VDD}
N 19440 10960 19460 10960 {}
C {lab_pin.sym} 19460 10960 0 0 {name=l35690 lab=VSS}
C {bitcell_6t.sym} 19600 11000 0 0 {name=Xr55c98}
N 19560 11040 19540 11040 {}
C {lab_pin.sym} 19540 11040 0 0 {name=l35691 lab=BL98}
N 19560 11000 19540 11000 {}
C {lab_pin.sym} 19540 11000 0 0 {name=l35692 lab=BLB98}
N 19560 10960 19540 10960 {}
C {lab_pin.sym} 19540 10960 0 0 {name=l35693 lab=WL55}
N 19640 11040 19660 11040 {}
C {lab_pin.sym} 19660 11040 0 0 {name=l35694 lab=VDD}
N 19640 10960 19660 10960 {}
C {lab_pin.sym} 19660 10960 0 0 {name=l35695 lab=VSS}
C {bitcell_6t.sym} 19800 11000 0 0 {name=Xr55c99}
N 19760 11040 19740 11040 {}
C {lab_pin.sym} 19740 11040 0 0 {name=l35696 lab=BL99}
N 19760 11000 19740 11000 {}
C {lab_pin.sym} 19740 11000 0 0 {name=l35697 lab=BLB99}
N 19760 10960 19740 10960 {}
C {lab_pin.sym} 19740 10960 0 0 {name=l35698 lab=WL55}
N 19840 11040 19860 11040 {}
C {lab_pin.sym} 19860 11040 0 0 {name=l35699 lab=VDD}
N 19840 10960 19860 10960 {}
C {lab_pin.sym} 19860 10960 0 0 {name=l35700 lab=VSS}
C {bitcell_6t.sym} 20000 11000 0 0 {name=Xr55c100}
N 19960 11040 19940 11040 {}
C {lab_pin.sym} 19940 11040 0 0 {name=l35701 lab=BL100}
N 19960 11000 19940 11000 {}
C {lab_pin.sym} 19940 11000 0 0 {name=l35702 lab=BLB100}
N 19960 10960 19940 10960 {}
C {lab_pin.sym} 19940 10960 0 0 {name=l35703 lab=WL55}
N 20040 11040 20060 11040 {}
C {lab_pin.sym} 20060 11040 0 0 {name=l35704 lab=VDD}
N 20040 10960 20060 10960 {}
C {lab_pin.sym} 20060 10960 0 0 {name=l35705 lab=VSS}
C {bitcell_6t.sym} 20200 11000 0 0 {name=Xr55c101}
N 20160 11040 20140 11040 {}
C {lab_pin.sym} 20140 11040 0 0 {name=l35706 lab=BL101}
N 20160 11000 20140 11000 {}
C {lab_pin.sym} 20140 11000 0 0 {name=l35707 lab=BLB101}
N 20160 10960 20140 10960 {}
C {lab_pin.sym} 20140 10960 0 0 {name=l35708 lab=WL55}
N 20240 11040 20260 11040 {}
C {lab_pin.sym} 20260 11040 0 0 {name=l35709 lab=VDD}
N 20240 10960 20260 10960 {}
C {lab_pin.sym} 20260 10960 0 0 {name=l35710 lab=VSS}
C {bitcell_6t.sym} 20400 11000 0 0 {name=Xr55c102}
N 20360 11040 20340 11040 {}
C {lab_pin.sym} 20340 11040 0 0 {name=l35711 lab=BL102}
N 20360 11000 20340 11000 {}
C {lab_pin.sym} 20340 11000 0 0 {name=l35712 lab=BLB102}
N 20360 10960 20340 10960 {}
C {lab_pin.sym} 20340 10960 0 0 {name=l35713 lab=WL55}
N 20440 11040 20460 11040 {}
C {lab_pin.sym} 20460 11040 0 0 {name=l35714 lab=VDD}
N 20440 10960 20460 10960 {}
C {lab_pin.sym} 20460 10960 0 0 {name=l35715 lab=VSS}
C {bitcell_6t.sym} 20600 11000 0 0 {name=Xr55c103}
N 20560 11040 20540 11040 {}
C {lab_pin.sym} 20540 11040 0 0 {name=l35716 lab=BL103}
N 20560 11000 20540 11000 {}
C {lab_pin.sym} 20540 11000 0 0 {name=l35717 lab=BLB103}
N 20560 10960 20540 10960 {}
C {lab_pin.sym} 20540 10960 0 0 {name=l35718 lab=WL55}
N 20640 11040 20660 11040 {}
C {lab_pin.sym} 20660 11040 0 0 {name=l35719 lab=VDD}
N 20640 10960 20660 10960 {}
C {lab_pin.sym} 20660 10960 0 0 {name=l35720 lab=VSS}
C {bitcell_6t.sym} 20800 11000 0 0 {name=Xr55c104}
N 20760 11040 20740 11040 {}
C {lab_pin.sym} 20740 11040 0 0 {name=l35721 lab=BL104}
N 20760 11000 20740 11000 {}
C {lab_pin.sym} 20740 11000 0 0 {name=l35722 lab=BLB104}
N 20760 10960 20740 10960 {}
C {lab_pin.sym} 20740 10960 0 0 {name=l35723 lab=WL55}
N 20840 11040 20860 11040 {}
C {lab_pin.sym} 20860 11040 0 0 {name=l35724 lab=VDD}
N 20840 10960 20860 10960 {}
C {lab_pin.sym} 20860 10960 0 0 {name=l35725 lab=VSS}
C {bitcell_6t.sym} 21000 11000 0 0 {name=Xr55c105}
N 20960 11040 20940 11040 {}
C {lab_pin.sym} 20940 11040 0 0 {name=l35726 lab=BL105}
N 20960 11000 20940 11000 {}
C {lab_pin.sym} 20940 11000 0 0 {name=l35727 lab=BLB105}
N 20960 10960 20940 10960 {}
C {lab_pin.sym} 20940 10960 0 0 {name=l35728 lab=WL55}
N 21040 11040 21060 11040 {}
C {lab_pin.sym} 21060 11040 0 0 {name=l35729 lab=VDD}
N 21040 10960 21060 10960 {}
C {lab_pin.sym} 21060 10960 0 0 {name=l35730 lab=VSS}
C {bitcell_6t.sym} 21200 11000 0 0 {name=Xr55c106}
N 21160 11040 21140 11040 {}
C {lab_pin.sym} 21140 11040 0 0 {name=l35731 lab=BL106}
N 21160 11000 21140 11000 {}
C {lab_pin.sym} 21140 11000 0 0 {name=l35732 lab=BLB106}
N 21160 10960 21140 10960 {}
C {lab_pin.sym} 21140 10960 0 0 {name=l35733 lab=WL55}
N 21240 11040 21260 11040 {}
C {lab_pin.sym} 21260 11040 0 0 {name=l35734 lab=VDD}
N 21240 10960 21260 10960 {}
C {lab_pin.sym} 21260 10960 0 0 {name=l35735 lab=VSS}
C {bitcell_6t.sym} 21400 11000 0 0 {name=Xr55c107}
N 21360 11040 21340 11040 {}
C {lab_pin.sym} 21340 11040 0 0 {name=l35736 lab=BL107}
N 21360 11000 21340 11000 {}
C {lab_pin.sym} 21340 11000 0 0 {name=l35737 lab=BLB107}
N 21360 10960 21340 10960 {}
C {lab_pin.sym} 21340 10960 0 0 {name=l35738 lab=WL55}
N 21440 11040 21460 11040 {}
C {lab_pin.sym} 21460 11040 0 0 {name=l35739 lab=VDD}
N 21440 10960 21460 10960 {}
C {lab_pin.sym} 21460 10960 0 0 {name=l35740 lab=VSS}
C {bitcell_6t.sym} 21600 11000 0 0 {name=Xr55c108}
N 21560 11040 21540 11040 {}
C {lab_pin.sym} 21540 11040 0 0 {name=l35741 lab=BL108}
N 21560 11000 21540 11000 {}
C {lab_pin.sym} 21540 11000 0 0 {name=l35742 lab=BLB108}
N 21560 10960 21540 10960 {}
C {lab_pin.sym} 21540 10960 0 0 {name=l35743 lab=WL55}
N 21640 11040 21660 11040 {}
C {lab_pin.sym} 21660 11040 0 0 {name=l35744 lab=VDD}
N 21640 10960 21660 10960 {}
C {lab_pin.sym} 21660 10960 0 0 {name=l35745 lab=VSS}
C {bitcell_6t.sym} 21800 11000 0 0 {name=Xr55c109}
N 21760 11040 21740 11040 {}
C {lab_pin.sym} 21740 11040 0 0 {name=l35746 lab=BL109}
N 21760 11000 21740 11000 {}
C {lab_pin.sym} 21740 11000 0 0 {name=l35747 lab=BLB109}
N 21760 10960 21740 10960 {}
C {lab_pin.sym} 21740 10960 0 0 {name=l35748 lab=WL55}
N 21840 11040 21860 11040 {}
C {lab_pin.sym} 21860 11040 0 0 {name=l35749 lab=VDD}
N 21840 10960 21860 10960 {}
C {lab_pin.sym} 21860 10960 0 0 {name=l35750 lab=VSS}
C {bitcell_6t.sym} 22000 11000 0 0 {name=Xr55c110}
N 21960 11040 21940 11040 {}
C {lab_pin.sym} 21940 11040 0 0 {name=l35751 lab=BL110}
N 21960 11000 21940 11000 {}
C {lab_pin.sym} 21940 11000 0 0 {name=l35752 lab=BLB110}
N 21960 10960 21940 10960 {}
C {lab_pin.sym} 21940 10960 0 0 {name=l35753 lab=WL55}
N 22040 11040 22060 11040 {}
C {lab_pin.sym} 22060 11040 0 0 {name=l35754 lab=VDD}
N 22040 10960 22060 10960 {}
C {lab_pin.sym} 22060 10960 0 0 {name=l35755 lab=VSS}
C {bitcell_6t.sym} 22200 11000 0 0 {name=Xr55c111}
N 22160 11040 22140 11040 {}
C {lab_pin.sym} 22140 11040 0 0 {name=l35756 lab=BL111}
N 22160 11000 22140 11000 {}
C {lab_pin.sym} 22140 11000 0 0 {name=l35757 lab=BLB111}
N 22160 10960 22140 10960 {}
C {lab_pin.sym} 22140 10960 0 0 {name=l35758 lab=WL55}
N 22240 11040 22260 11040 {}
C {lab_pin.sym} 22260 11040 0 0 {name=l35759 lab=VDD}
N 22240 10960 22260 10960 {}
C {lab_pin.sym} 22260 10960 0 0 {name=l35760 lab=VSS}
C {bitcell_6t.sym} 22400 11000 0 0 {name=Xr55c112}
N 22360 11040 22340 11040 {}
C {lab_pin.sym} 22340 11040 0 0 {name=l35761 lab=BL112}
N 22360 11000 22340 11000 {}
C {lab_pin.sym} 22340 11000 0 0 {name=l35762 lab=BLB112}
N 22360 10960 22340 10960 {}
C {lab_pin.sym} 22340 10960 0 0 {name=l35763 lab=WL55}
N 22440 11040 22460 11040 {}
C {lab_pin.sym} 22460 11040 0 0 {name=l35764 lab=VDD}
N 22440 10960 22460 10960 {}
C {lab_pin.sym} 22460 10960 0 0 {name=l35765 lab=VSS}
C {bitcell_6t.sym} 22600 11000 0 0 {name=Xr55c113}
N 22560 11040 22540 11040 {}
C {lab_pin.sym} 22540 11040 0 0 {name=l35766 lab=BL113}
N 22560 11000 22540 11000 {}
C {lab_pin.sym} 22540 11000 0 0 {name=l35767 lab=BLB113}
N 22560 10960 22540 10960 {}
C {lab_pin.sym} 22540 10960 0 0 {name=l35768 lab=WL55}
N 22640 11040 22660 11040 {}
C {lab_pin.sym} 22660 11040 0 0 {name=l35769 lab=VDD}
N 22640 10960 22660 10960 {}
C {lab_pin.sym} 22660 10960 0 0 {name=l35770 lab=VSS}
C {bitcell_6t.sym} 22800 11000 0 0 {name=Xr55c114}
N 22760 11040 22740 11040 {}
C {lab_pin.sym} 22740 11040 0 0 {name=l35771 lab=BL114}
N 22760 11000 22740 11000 {}
C {lab_pin.sym} 22740 11000 0 0 {name=l35772 lab=BLB114}
N 22760 10960 22740 10960 {}
C {lab_pin.sym} 22740 10960 0 0 {name=l35773 lab=WL55}
N 22840 11040 22860 11040 {}
C {lab_pin.sym} 22860 11040 0 0 {name=l35774 lab=VDD}
N 22840 10960 22860 10960 {}
C {lab_pin.sym} 22860 10960 0 0 {name=l35775 lab=VSS}
C {bitcell_6t.sym} 23000 11000 0 0 {name=Xr55c115}
N 22960 11040 22940 11040 {}
C {lab_pin.sym} 22940 11040 0 0 {name=l35776 lab=BL115}
N 22960 11000 22940 11000 {}
C {lab_pin.sym} 22940 11000 0 0 {name=l35777 lab=BLB115}
N 22960 10960 22940 10960 {}
C {lab_pin.sym} 22940 10960 0 0 {name=l35778 lab=WL55}
N 23040 11040 23060 11040 {}
C {lab_pin.sym} 23060 11040 0 0 {name=l35779 lab=VDD}
N 23040 10960 23060 10960 {}
C {lab_pin.sym} 23060 10960 0 0 {name=l35780 lab=VSS}
C {bitcell_6t.sym} 23200 11000 0 0 {name=Xr55c116}
N 23160 11040 23140 11040 {}
C {lab_pin.sym} 23140 11040 0 0 {name=l35781 lab=BL116}
N 23160 11000 23140 11000 {}
C {lab_pin.sym} 23140 11000 0 0 {name=l35782 lab=BLB116}
N 23160 10960 23140 10960 {}
C {lab_pin.sym} 23140 10960 0 0 {name=l35783 lab=WL55}
N 23240 11040 23260 11040 {}
C {lab_pin.sym} 23260 11040 0 0 {name=l35784 lab=VDD}
N 23240 10960 23260 10960 {}
C {lab_pin.sym} 23260 10960 0 0 {name=l35785 lab=VSS}
C {bitcell_6t.sym} 23400 11000 0 0 {name=Xr55c117}
N 23360 11040 23340 11040 {}
C {lab_pin.sym} 23340 11040 0 0 {name=l35786 lab=BL117}
N 23360 11000 23340 11000 {}
C {lab_pin.sym} 23340 11000 0 0 {name=l35787 lab=BLB117}
N 23360 10960 23340 10960 {}
C {lab_pin.sym} 23340 10960 0 0 {name=l35788 lab=WL55}
N 23440 11040 23460 11040 {}
C {lab_pin.sym} 23460 11040 0 0 {name=l35789 lab=VDD}
N 23440 10960 23460 10960 {}
C {lab_pin.sym} 23460 10960 0 0 {name=l35790 lab=VSS}
C {bitcell_6t.sym} 23600 11000 0 0 {name=Xr55c118}
N 23560 11040 23540 11040 {}
C {lab_pin.sym} 23540 11040 0 0 {name=l35791 lab=BL118}
N 23560 11000 23540 11000 {}
C {lab_pin.sym} 23540 11000 0 0 {name=l35792 lab=BLB118}
N 23560 10960 23540 10960 {}
C {lab_pin.sym} 23540 10960 0 0 {name=l35793 lab=WL55}
N 23640 11040 23660 11040 {}
C {lab_pin.sym} 23660 11040 0 0 {name=l35794 lab=VDD}
N 23640 10960 23660 10960 {}
C {lab_pin.sym} 23660 10960 0 0 {name=l35795 lab=VSS}
C {bitcell_6t.sym} 23800 11000 0 0 {name=Xr55c119}
N 23760 11040 23740 11040 {}
C {lab_pin.sym} 23740 11040 0 0 {name=l35796 lab=BL119}
N 23760 11000 23740 11000 {}
C {lab_pin.sym} 23740 11000 0 0 {name=l35797 lab=BLB119}
N 23760 10960 23740 10960 {}
C {lab_pin.sym} 23740 10960 0 0 {name=l35798 lab=WL55}
N 23840 11040 23860 11040 {}
C {lab_pin.sym} 23860 11040 0 0 {name=l35799 lab=VDD}
N 23840 10960 23860 10960 {}
C {lab_pin.sym} 23860 10960 0 0 {name=l35800 lab=VSS}
C {bitcell_6t.sym} 24000 11000 0 0 {name=Xr55c120}
N 23960 11040 23940 11040 {}
C {lab_pin.sym} 23940 11040 0 0 {name=l35801 lab=BL120}
N 23960 11000 23940 11000 {}
C {lab_pin.sym} 23940 11000 0 0 {name=l35802 lab=BLB120}
N 23960 10960 23940 10960 {}
C {lab_pin.sym} 23940 10960 0 0 {name=l35803 lab=WL55}
N 24040 11040 24060 11040 {}
C {lab_pin.sym} 24060 11040 0 0 {name=l35804 lab=VDD}
N 24040 10960 24060 10960 {}
C {lab_pin.sym} 24060 10960 0 0 {name=l35805 lab=VSS}
C {bitcell_6t.sym} 24200 11000 0 0 {name=Xr55c121}
N 24160 11040 24140 11040 {}
C {lab_pin.sym} 24140 11040 0 0 {name=l35806 lab=BL121}
N 24160 11000 24140 11000 {}
C {lab_pin.sym} 24140 11000 0 0 {name=l35807 lab=BLB121}
N 24160 10960 24140 10960 {}
C {lab_pin.sym} 24140 10960 0 0 {name=l35808 lab=WL55}
N 24240 11040 24260 11040 {}
C {lab_pin.sym} 24260 11040 0 0 {name=l35809 lab=VDD}
N 24240 10960 24260 10960 {}
C {lab_pin.sym} 24260 10960 0 0 {name=l35810 lab=VSS}
C {bitcell_6t.sym} 24400 11000 0 0 {name=Xr55c122}
N 24360 11040 24340 11040 {}
C {lab_pin.sym} 24340 11040 0 0 {name=l35811 lab=BL122}
N 24360 11000 24340 11000 {}
C {lab_pin.sym} 24340 11000 0 0 {name=l35812 lab=BLB122}
N 24360 10960 24340 10960 {}
C {lab_pin.sym} 24340 10960 0 0 {name=l35813 lab=WL55}
N 24440 11040 24460 11040 {}
C {lab_pin.sym} 24460 11040 0 0 {name=l35814 lab=VDD}
N 24440 10960 24460 10960 {}
C {lab_pin.sym} 24460 10960 0 0 {name=l35815 lab=VSS}
C {bitcell_6t.sym} 24600 11000 0 0 {name=Xr55c123}
N 24560 11040 24540 11040 {}
C {lab_pin.sym} 24540 11040 0 0 {name=l35816 lab=BL123}
N 24560 11000 24540 11000 {}
C {lab_pin.sym} 24540 11000 0 0 {name=l35817 lab=BLB123}
N 24560 10960 24540 10960 {}
C {lab_pin.sym} 24540 10960 0 0 {name=l35818 lab=WL55}
N 24640 11040 24660 11040 {}
C {lab_pin.sym} 24660 11040 0 0 {name=l35819 lab=VDD}
N 24640 10960 24660 10960 {}
C {lab_pin.sym} 24660 10960 0 0 {name=l35820 lab=VSS}
C {bitcell_6t.sym} 24800 11000 0 0 {name=Xr55c124}
N 24760 11040 24740 11040 {}
C {lab_pin.sym} 24740 11040 0 0 {name=l35821 lab=BL124}
N 24760 11000 24740 11000 {}
C {lab_pin.sym} 24740 11000 0 0 {name=l35822 lab=BLB124}
N 24760 10960 24740 10960 {}
C {lab_pin.sym} 24740 10960 0 0 {name=l35823 lab=WL55}
N 24840 11040 24860 11040 {}
C {lab_pin.sym} 24860 11040 0 0 {name=l35824 lab=VDD}
N 24840 10960 24860 10960 {}
C {lab_pin.sym} 24860 10960 0 0 {name=l35825 lab=VSS}
C {bitcell_6t.sym} 25000 11000 0 0 {name=Xr55c125}
N 24960 11040 24940 11040 {}
C {lab_pin.sym} 24940 11040 0 0 {name=l35826 lab=BL125}
N 24960 11000 24940 11000 {}
C {lab_pin.sym} 24940 11000 0 0 {name=l35827 lab=BLB125}
N 24960 10960 24940 10960 {}
C {lab_pin.sym} 24940 10960 0 0 {name=l35828 lab=WL55}
N 25040 11040 25060 11040 {}
C {lab_pin.sym} 25060 11040 0 0 {name=l35829 lab=VDD}
N 25040 10960 25060 10960 {}
C {lab_pin.sym} 25060 10960 0 0 {name=l35830 lab=VSS}
C {bitcell_6t.sym} 25200 11000 0 0 {name=Xr55c126}
N 25160 11040 25140 11040 {}
C {lab_pin.sym} 25140 11040 0 0 {name=l35831 lab=BL126}
N 25160 11000 25140 11000 {}
C {lab_pin.sym} 25140 11000 0 0 {name=l35832 lab=BLB126}
N 25160 10960 25140 10960 {}
C {lab_pin.sym} 25140 10960 0 0 {name=l35833 lab=WL55}
N 25240 11040 25260 11040 {}
C {lab_pin.sym} 25260 11040 0 0 {name=l35834 lab=VDD}
N 25240 10960 25260 10960 {}
C {lab_pin.sym} 25260 10960 0 0 {name=l35835 lab=VSS}
C {bitcell_6t.sym} 25400 11000 0 0 {name=Xr55c127}
N 25360 11040 25340 11040 {}
C {lab_pin.sym} 25340 11040 0 0 {name=l35836 lab=BL127}
N 25360 11000 25340 11000 {}
C {lab_pin.sym} 25340 11000 0 0 {name=l35837 lab=BLB127}
N 25360 10960 25340 10960 {}
C {lab_pin.sym} 25340 10960 0 0 {name=l35838 lab=WL55}
N 25440 11040 25460 11040 {}
C {lab_pin.sym} 25460 11040 0 0 {name=l35839 lab=VDD}
N 25440 10960 25460 10960 {}
C {lab_pin.sym} 25460 10960 0 0 {name=l35840 lab=VSS}
C {bitcell_6t.sym} 0 11200 0 0 {name=Xr56c0}
N -40 11240 -60 11240 {}
C {lab_pin.sym} -60 11240 0 0 {name=l35841 lab=BL0}
N -40 11200 -60 11200 {}
C {lab_pin.sym} -60 11200 0 0 {name=l35842 lab=BLB0}
N -40 11160 -60 11160 {}
C {lab_pin.sym} -60 11160 0 0 {name=l35843 lab=WL56}
N 40 11240 60 11240 {}
C {lab_pin.sym} 60 11240 0 0 {name=l35844 lab=VDD}
N 40 11160 60 11160 {}
C {lab_pin.sym} 60 11160 0 0 {name=l35845 lab=VSS}
C {bitcell_6t.sym} 200 11200 0 0 {name=Xr56c1}
N 160 11240 140 11240 {}
C {lab_pin.sym} 140 11240 0 0 {name=l35846 lab=BL1}
N 160 11200 140 11200 {}
C {lab_pin.sym} 140 11200 0 0 {name=l35847 lab=BLB1}
N 160 11160 140 11160 {}
C {lab_pin.sym} 140 11160 0 0 {name=l35848 lab=WL56}
N 240 11240 260 11240 {}
C {lab_pin.sym} 260 11240 0 0 {name=l35849 lab=VDD}
N 240 11160 260 11160 {}
C {lab_pin.sym} 260 11160 0 0 {name=l35850 lab=VSS}
C {bitcell_6t.sym} 400 11200 0 0 {name=Xr56c2}
N 360 11240 340 11240 {}
C {lab_pin.sym} 340 11240 0 0 {name=l35851 lab=BL2}
N 360 11200 340 11200 {}
C {lab_pin.sym} 340 11200 0 0 {name=l35852 lab=BLB2}
N 360 11160 340 11160 {}
C {lab_pin.sym} 340 11160 0 0 {name=l35853 lab=WL56}
N 440 11240 460 11240 {}
C {lab_pin.sym} 460 11240 0 0 {name=l35854 lab=VDD}
N 440 11160 460 11160 {}
C {lab_pin.sym} 460 11160 0 0 {name=l35855 lab=VSS}
C {bitcell_6t.sym} 600 11200 0 0 {name=Xr56c3}
N 560 11240 540 11240 {}
C {lab_pin.sym} 540 11240 0 0 {name=l35856 lab=BL3}
N 560 11200 540 11200 {}
C {lab_pin.sym} 540 11200 0 0 {name=l35857 lab=BLB3}
N 560 11160 540 11160 {}
C {lab_pin.sym} 540 11160 0 0 {name=l35858 lab=WL56}
N 640 11240 660 11240 {}
C {lab_pin.sym} 660 11240 0 0 {name=l35859 lab=VDD}
N 640 11160 660 11160 {}
C {lab_pin.sym} 660 11160 0 0 {name=l35860 lab=VSS}
C {bitcell_6t.sym} 800 11200 0 0 {name=Xr56c4}
N 760 11240 740 11240 {}
C {lab_pin.sym} 740 11240 0 0 {name=l35861 lab=BL4}
N 760 11200 740 11200 {}
C {lab_pin.sym} 740 11200 0 0 {name=l35862 lab=BLB4}
N 760 11160 740 11160 {}
C {lab_pin.sym} 740 11160 0 0 {name=l35863 lab=WL56}
N 840 11240 860 11240 {}
C {lab_pin.sym} 860 11240 0 0 {name=l35864 lab=VDD}
N 840 11160 860 11160 {}
C {lab_pin.sym} 860 11160 0 0 {name=l35865 lab=VSS}
C {bitcell_6t.sym} 1000 11200 0 0 {name=Xr56c5}
N 960 11240 940 11240 {}
C {lab_pin.sym} 940 11240 0 0 {name=l35866 lab=BL5}
N 960 11200 940 11200 {}
C {lab_pin.sym} 940 11200 0 0 {name=l35867 lab=BLB5}
N 960 11160 940 11160 {}
C {lab_pin.sym} 940 11160 0 0 {name=l35868 lab=WL56}
N 1040 11240 1060 11240 {}
C {lab_pin.sym} 1060 11240 0 0 {name=l35869 lab=VDD}
N 1040 11160 1060 11160 {}
C {lab_pin.sym} 1060 11160 0 0 {name=l35870 lab=VSS}
C {bitcell_6t.sym} 1200 11200 0 0 {name=Xr56c6}
N 1160 11240 1140 11240 {}
C {lab_pin.sym} 1140 11240 0 0 {name=l35871 lab=BL6}
N 1160 11200 1140 11200 {}
C {lab_pin.sym} 1140 11200 0 0 {name=l35872 lab=BLB6}
N 1160 11160 1140 11160 {}
C {lab_pin.sym} 1140 11160 0 0 {name=l35873 lab=WL56}
N 1240 11240 1260 11240 {}
C {lab_pin.sym} 1260 11240 0 0 {name=l35874 lab=VDD}
N 1240 11160 1260 11160 {}
C {lab_pin.sym} 1260 11160 0 0 {name=l35875 lab=VSS}
C {bitcell_6t.sym} 1400 11200 0 0 {name=Xr56c7}
N 1360 11240 1340 11240 {}
C {lab_pin.sym} 1340 11240 0 0 {name=l35876 lab=BL7}
N 1360 11200 1340 11200 {}
C {lab_pin.sym} 1340 11200 0 0 {name=l35877 lab=BLB7}
N 1360 11160 1340 11160 {}
C {lab_pin.sym} 1340 11160 0 0 {name=l35878 lab=WL56}
N 1440 11240 1460 11240 {}
C {lab_pin.sym} 1460 11240 0 0 {name=l35879 lab=VDD}
N 1440 11160 1460 11160 {}
C {lab_pin.sym} 1460 11160 0 0 {name=l35880 lab=VSS}
C {bitcell_6t.sym} 1600 11200 0 0 {name=Xr56c8}
N 1560 11240 1540 11240 {}
C {lab_pin.sym} 1540 11240 0 0 {name=l35881 lab=BL8}
N 1560 11200 1540 11200 {}
C {lab_pin.sym} 1540 11200 0 0 {name=l35882 lab=BLB8}
N 1560 11160 1540 11160 {}
C {lab_pin.sym} 1540 11160 0 0 {name=l35883 lab=WL56}
N 1640 11240 1660 11240 {}
C {lab_pin.sym} 1660 11240 0 0 {name=l35884 lab=VDD}
N 1640 11160 1660 11160 {}
C {lab_pin.sym} 1660 11160 0 0 {name=l35885 lab=VSS}
C {bitcell_6t.sym} 1800 11200 0 0 {name=Xr56c9}
N 1760 11240 1740 11240 {}
C {lab_pin.sym} 1740 11240 0 0 {name=l35886 lab=BL9}
N 1760 11200 1740 11200 {}
C {lab_pin.sym} 1740 11200 0 0 {name=l35887 lab=BLB9}
N 1760 11160 1740 11160 {}
C {lab_pin.sym} 1740 11160 0 0 {name=l35888 lab=WL56}
N 1840 11240 1860 11240 {}
C {lab_pin.sym} 1860 11240 0 0 {name=l35889 lab=VDD}
N 1840 11160 1860 11160 {}
C {lab_pin.sym} 1860 11160 0 0 {name=l35890 lab=VSS}
C {bitcell_6t.sym} 2000 11200 0 0 {name=Xr56c10}
N 1960 11240 1940 11240 {}
C {lab_pin.sym} 1940 11240 0 0 {name=l35891 lab=BL10}
N 1960 11200 1940 11200 {}
C {lab_pin.sym} 1940 11200 0 0 {name=l35892 lab=BLB10}
N 1960 11160 1940 11160 {}
C {lab_pin.sym} 1940 11160 0 0 {name=l35893 lab=WL56}
N 2040 11240 2060 11240 {}
C {lab_pin.sym} 2060 11240 0 0 {name=l35894 lab=VDD}
N 2040 11160 2060 11160 {}
C {lab_pin.sym} 2060 11160 0 0 {name=l35895 lab=VSS}
C {bitcell_6t.sym} 2200 11200 0 0 {name=Xr56c11}
N 2160 11240 2140 11240 {}
C {lab_pin.sym} 2140 11240 0 0 {name=l35896 lab=BL11}
N 2160 11200 2140 11200 {}
C {lab_pin.sym} 2140 11200 0 0 {name=l35897 lab=BLB11}
N 2160 11160 2140 11160 {}
C {lab_pin.sym} 2140 11160 0 0 {name=l35898 lab=WL56}
N 2240 11240 2260 11240 {}
C {lab_pin.sym} 2260 11240 0 0 {name=l35899 lab=VDD}
N 2240 11160 2260 11160 {}
C {lab_pin.sym} 2260 11160 0 0 {name=l35900 lab=VSS}
C {bitcell_6t.sym} 2400 11200 0 0 {name=Xr56c12}
N 2360 11240 2340 11240 {}
C {lab_pin.sym} 2340 11240 0 0 {name=l35901 lab=BL12}
N 2360 11200 2340 11200 {}
C {lab_pin.sym} 2340 11200 0 0 {name=l35902 lab=BLB12}
N 2360 11160 2340 11160 {}
C {lab_pin.sym} 2340 11160 0 0 {name=l35903 lab=WL56}
N 2440 11240 2460 11240 {}
C {lab_pin.sym} 2460 11240 0 0 {name=l35904 lab=VDD}
N 2440 11160 2460 11160 {}
C {lab_pin.sym} 2460 11160 0 0 {name=l35905 lab=VSS}
C {bitcell_6t.sym} 2600 11200 0 0 {name=Xr56c13}
N 2560 11240 2540 11240 {}
C {lab_pin.sym} 2540 11240 0 0 {name=l35906 lab=BL13}
N 2560 11200 2540 11200 {}
C {lab_pin.sym} 2540 11200 0 0 {name=l35907 lab=BLB13}
N 2560 11160 2540 11160 {}
C {lab_pin.sym} 2540 11160 0 0 {name=l35908 lab=WL56}
N 2640 11240 2660 11240 {}
C {lab_pin.sym} 2660 11240 0 0 {name=l35909 lab=VDD}
N 2640 11160 2660 11160 {}
C {lab_pin.sym} 2660 11160 0 0 {name=l35910 lab=VSS}
C {bitcell_6t.sym} 2800 11200 0 0 {name=Xr56c14}
N 2760 11240 2740 11240 {}
C {lab_pin.sym} 2740 11240 0 0 {name=l35911 lab=BL14}
N 2760 11200 2740 11200 {}
C {lab_pin.sym} 2740 11200 0 0 {name=l35912 lab=BLB14}
N 2760 11160 2740 11160 {}
C {lab_pin.sym} 2740 11160 0 0 {name=l35913 lab=WL56}
N 2840 11240 2860 11240 {}
C {lab_pin.sym} 2860 11240 0 0 {name=l35914 lab=VDD}
N 2840 11160 2860 11160 {}
C {lab_pin.sym} 2860 11160 0 0 {name=l35915 lab=VSS}
C {bitcell_6t.sym} 3000 11200 0 0 {name=Xr56c15}
N 2960 11240 2940 11240 {}
C {lab_pin.sym} 2940 11240 0 0 {name=l35916 lab=BL15}
N 2960 11200 2940 11200 {}
C {lab_pin.sym} 2940 11200 0 0 {name=l35917 lab=BLB15}
N 2960 11160 2940 11160 {}
C {lab_pin.sym} 2940 11160 0 0 {name=l35918 lab=WL56}
N 3040 11240 3060 11240 {}
C {lab_pin.sym} 3060 11240 0 0 {name=l35919 lab=VDD}
N 3040 11160 3060 11160 {}
C {lab_pin.sym} 3060 11160 0 0 {name=l35920 lab=VSS}
C {bitcell_6t.sym} 3200 11200 0 0 {name=Xr56c16}
N 3160 11240 3140 11240 {}
C {lab_pin.sym} 3140 11240 0 0 {name=l35921 lab=BL16}
N 3160 11200 3140 11200 {}
C {lab_pin.sym} 3140 11200 0 0 {name=l35922 lab=BLB16}
N 3160 11160 3140 11160 {}
C {lab_pin.sym} 3140 11160 0 0 {name=l35923 lab=WL56}
N 3240 11240 3260 11240 {}
C {lab_pin.sym} 3260 11240 0 0 {name=l35924 lab=VDD}
N 3240 11160 3260 11160 {}
C {lab_pin.sym} 3260 11160 0 0 {name=l35925 lab=VSS}
C {bitcell_6t.sym} 3400 11200 0 0 {name=Xr56c17}
N 3360 11240 3340 11240 {}
C {lab_pin.sym} 3340 11240 0 0 {name=l35926 lab=BL17}
N 3360 11200 3340 11200 {}
C {lab_pin.sym} 3340 11200 0 0 {name=l35927 lab=BLB17}
N 3360 11160 3340 11160 {}
C {lab_pin.sym} 3340 11160 0 0 {name=l35928 lab=WL56}
N 3440 11240 3460 11240 {}
C {lab_pin.sym} 3460 11240 0 0 {name=l35929 lab=VDD}
N 3440 11160 3460 11160 {}
C {lab_pin.sym} 3460 11160 0 0 {name=l35930 lab=VSS}
C {bitcell_6t.sym} 3600 11200 0 0 {name=Xr56c18}
N 3560 11240 3540 11240 {}
C {lab_pin.sym} 3540 11240 0 0 {name=l35931 lab=BL18}
N 3560 11200 3540 11200 {}
C {lab_pin.sym} 3540 11200 0 0 {name=l35932 lab=BLB18}
N 3560 11160 3540 11160 {}
C {lab_pin.sym} 3540 11160 0 0 {name=l35933 lab=WL56}
N 3640 11240 3660 11240 {}
C {lab_pin.sym} 3660 11240 0 0 {name=l35934 lab=VDD}
N 3640 11160 3660 11160 {}
C {lab_pin.sym} 3660 11160 0 0 {name=l35935 lab=VSS}
C {bitcell_6t.sym} 3800 11200 0 0 {name=Xr56c19}
N 3760 11240 3740 11240 {}
C {lab_pin.sym} 3740 11240 0 0 {name=l35936 lab=BL19}
N 3760 11200 3740 11200 {}
C {lab_pin.sym} 3740 11200 0 0 {name=l35937 lab=BLB19}
N 3760 11160 3740 11160 {}
C {lab_pin.sym} 3740 11160 0 0 {name=l35938 lab=WL56}
N 3840 11240 3860 11240 {}
C {lab_pin.sym} 3860 11240 0 0 {name=l35939 lab=VDD}
N 3840 11160 3860 11160 {}
C {lab_pin.sym} 3860 11160 0 0 {name=l35940 lab=VSS}
C {bitcell_6t.sym} 4000 11200 0 0 {name=Xr56c20}
N 3960 11240 3940 11240 {}
C {lab_pin.sym} 3940 11240 0 0 {name=l35941 lab=BL20}
N 3960 11200 3940 11200 {}
C {lab_pin.sym} 3940 11200 0 0 {name=l35942 lab=BLB20}
N 3960 11160 3940 11160 {}
C {lab_pin.sym} 3940 11160 0 0 {name=l35943 lab=WL56}
N 4040 11240 4060 11240 {}
C {lab_pin.sym} 4060 11240 0 0 {name=l35944 lab=VDD}
N 4040 11160 4060 11160 {}
C {lab_pin.sym} 4060 11160 0 0 {name=l35945 lab=VSS}
C {bitcell_6t.sym} 4200 11200 0 0 {name=Xr56c21}
N 4160 11240 4140 11240 {}
C {lab_pin.sym} 4140 11240 0 0 {name=l35946 lab=BL21}
N 4160 11200 4140 11200 {}
C {lab_pin.sym} 4140 11200 0 0 {name=l35947 lab=BLB21}
N 4160 11160 4140 11160 {}
C {lab_pin.sym} 4140 11160 0 0 {name=l35948 lab=WL56}
N 4240 11240 4260 11240 {}
C {lab_pin.sym} 4260 11240 0 0 {name=l35949 lab=VDD}
N 4240 11160 4260 11160 {}
C {lab_pin.sym} 4260 11160 0 0 {name=l35950 lab=VSS}
C {bitcell_6t.sym} 4400 11200 0 0 {name=Xr56c22}
N 4360 11240 4340 11240 {}
C {lab_pin.sym} 4340 11240 0 0 {name=l35951 lab=BL22}
N 4360 11200 4340 11200 {}
C {lab_pin.sym} 4340 11200 0 0 {name=l35952 lab=BLB22}
N 4360 11160 4340 11160 {}
C {lab_pin.sym} 4340 11160 0 0 {name=l35953 lab=WL56}
N 4440 11240 4460 11240 {}
C {lab_pin.sym} 4460 11240 0 0 {name=l35954 lab=VDD}
N 4440 11160 4460 11160 {}
C {lab_pin.sym} 4460 11160 0 0 {name=l35955 lab=VSS}
C {bitcell_6t.sym} 4600 11200 0 0 {name=Xr56c23}
N 4560 11240 4540 11240 {}
C {lab_pin.sym} 4540 11240 0 0 {name=l35956 lab=BL23}
N 4560 11200 4540 11200 {}
C {lab_pin.sym} 4540 11200 0 0 {name=l35957 lab=BLB23}
N 4560 11160 4540 11160 {}
C {lab_pin.sym} 4540 11160 0 0 {name=l35958 lab=WL56}
N 4640 11240 4660 11240 {}
C {lab_pin.sym} 4660 11240 0 0 {name=l35959 lab=VDD}
N 4640 11160 4660 11160 {}
C {lab_pin.sym} 4660 11160 0 0 {name=l35960 lab=VSS}
C {bitcell_6t.sym} 4800 11200 0 0 {name=Xr56c24}
N 4760 11240 4740 11240 {}
C {lab_pin.sym} 4740 11240 0 0 {name=l35961 lab=BL24}
N 4760 11200 4740 11200 {}
C {lab_pin.sym} 4740 11200 0 0 {name=l35962 lab=BLB24}
N 4760 11160 4740 11160 {}
C {lab_pin.sym} 4740 11160 0 0 {name=l35963 lab=WL56}
N 4840 11240 4860 11240 {}
C {lab_pin.sym} 4860 11240 0 0 {name=l35964 lab=VDD}
N 4840 11160 4860 11160 {}
C {lab_pin.sym} 4860 11160 0 0 {name=l35965 lab=VSS}
C {bitcell_6t.sym} 5000 11200 0 0 {name=Xr56c25}
N 4960 11240 4940 11240 {}
C {lab_pin.sym} 4940 11240 0 0 {name=l35966 lab=BL25}
N 4960 11200 4940 11200 {}
C {lab_pin.sym} 4940 11200 0 0 {name=l35967 lab=BLB25}
N 4960 11160 4940 11160 {}
C {lab_pin.sym} 4940 11160 0 0 {name=l35968 lab=WL56}
N 5040 11240 5060 11240 {}
C {lab_pin.sym} 5060 11240 0 0 {name=l35969 lab=VDD}
N 5040 11160 5060 11160 {}
C {lab_pin.sym} 5060 11160 0 0 {name=l35970 lab=VSS}
C {bitcell_6t.sym} 5200 11200 0 0 {name=Xr56c26}
N 5160 11240 5140 11240 {}
C {lab_pin.sym} 5140 11240 0 0 {name=l35971 lab=BL26}
N 5160 11200 5140 11200 {}
C {lab_pin.sym} 5140 11200 0 0 {name=l35972 lab=BLB26}
N 5160 11160 5140 11160 {}
C {lab_pin.sym} 5140 11160 0 0 {name=l35973 lab=WL56}
N 5240 11240 5260 11240 {}
C {lab_pin.sym} 5260 11240 0 0 {name=l35974 lab=VDD}
N 5240 11160 5260 11160 {}
C {lab_pin.sym} 5260 11160 0 0 {name=l35975 lab=VSS}
C {bitcell_6t.sym} 5400 11200 0 0 {name=Xr56c27}
N 5360 11240 5340 11240 {}
C {lab_pin.sym} 5340 11240 0 0 {name=l35976 lab=BL27}
N 5360 11200 5340 11200 {}
C {lab_pin.sym} 5340 11200 0 0 {name=l35977 lab=BLB27}
N 5360 11160 5340 11160 {}
C {lab_pin.sym} 5340 11160 0 0 {name=l35978 lab=WL56}
N 5440 11240 5460 11240 {}
C {lab_pin.sym} 5460 11240 0 0 {name=l35979 lab=VDD}
N 5440 11160 5460 11160 {}
C {lab_pin.sym} 5460 11160 0 0 {name=l35980 lab=VSS}
C {bitcell_6t.sym} 5600 11200 0 0 {name=Xr56c28}
N 5560 11240 5540 11240 {}
C {lab_pin.sym} 5540 11240 0 0 {name=l35981 lab=BL28}
N 5560 11200 5540 11200 {}
C {lab_pin.sym} 5540 11200 0 0 {name=l35982 lab=BLB28}
N 5560 11160 5540 11160 {}
C {lab_pin.sym} 5540 11160 0 0 {name=l35983 lab=WL56}
N 5640 11240 5660 11240 {}
C {lab_pin.sym} 5660 11240 0 0 {name=l35984 lab=VDD}
N 5640 11160 5660 11160 {}
C {lab_pin.sym} 5660 11160 0 0 {name=l35985 lab=VSS}
C {bitcell_6t.sym} 5800 11200 0 0 {name=Xr56c29}
N 5760 11240 5740 11240 {}
C {lab_pin.sym} 5740 11240 0 0 {name=l35986 lab=BL29}
N 5760 11200 5740 11200 {}
C {lab_pin.sym} 5740 11200 0 0 {name=l35987 lab=BLB29}
N 5760 11160 5740 11160 {}
C {lab_pin.sym} 5740 11160 0 0 {name=l35988 lab=WL56}
N 5840 11240 5860 11240 {}
C {lab_pin.sym} 5860 11240 0 0 {name=l35989 lab=VDD}
N 5840 11160 5860 11160 {}
C {lab_pin.sym} 5860 11160 0 0 {name=l35990 lab=VSS}
C {bitcell_6t.sym} 6000 11200 0 0 {name=Xr56c30}
N 5960 11240 5940 11240 {}
C {lab_pin.sym} 5940 11240 0 0 {name=l35991 lab=BL30}
N 5960 11200 5940 11200 {}
C {lab_pin.sym} 5940 11200 0 0 {name=l35992 lab=BLB30}
N 5960 11160 5940 11160 {}
C {lab_pin.sym} 5940 11160 0 0 {name=l35993 lab=WL56}
N 6040 11240 6060 11240 {}
C {lab_pin.sym} 6060 11240 0 0 {name=l35994 lab=VDD}
