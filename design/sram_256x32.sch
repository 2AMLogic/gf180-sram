v {xschem version=3.4.7 file_version=1.2
* sram_256x32 -- MACHINE-GENERATED by design/generate_periphery.py;
* do not hand-edit, re-run the generator (see design/README.md).
* Macro top level -- the LVS reference for the macro. Ports are exactly
* the #198 pins (A[7:0], CEN, GWEN, CLK, D[31:0], WEN[31:0], Q[31:0])
* plus VDD/VSS; WL*/BL*/BLB* and every control net are internal.
}
G {}
K {}
V {}
S {}
E {}
C {sram_ctrl.sym} 0 640 0 0 {name=Xctrl}
N -40 420 -60 420 {}
C {lab_pin.sym} -60 420 0 0 {name=l1 lab=A[0]}
N -40 440 -60 440 {}
C {lab_pin.sym} -60 440 0 0 {name=l2 lab=A[1]}
N -40 460 -60 460 {}
C {lab_pin.sym} -60 460 0 0 {name=l3 lab=A[2]}
N -40 480 -60 480 {}
C {lab_pin.sym} -60 480 0 0 {name=l4 lab=A[3]}
N -40 500 -60 500 {}
C {lab_pin.sym} -60 500 0 0 {name=l5 lab=A[4]}
N -40 520 -60 520 {}
C {lab_pin.sym} -60 520 0 0 {name=l6 lab=A[5]}
N -40 540 -60 540 {}
C {lab_pin.sym} -60 540 0 0 {name=l7 lab=A[6]}
N -40 560 -60 560 {}
C {lab_pin.sym} -60 560 0 0 {name=l8 lab=A[7]}
N -40 580 -60 580 {}
C {lab_pin.sym} -60 580 0 0 {name=l9 lab=CEN}
N -40 600 -60 600 {}
C {lab_pin.sym} -60 600 0 0 {name=l10 lab=GWEN}
N -40 620 -60 620 {}
C {lab_pin.sym} -60 620 0 0 {name=l11 lab=CLK}
N 40 420 60 420 {}
C {lab_pin.sym} 60 420 0 0 {name=l12 lab=aq0}
N 40 440 60 440 {}
C {lab_pin.sym} 60 440 0 0 {name=l13 lab=aq1}
N 40 460 60 460 {}
C {lab_pin.sym} 60 460 0 0 {name=l14 lab=aq2}
N 40 480 60 480 {}
C {lab_pin.sym} 60 480 0 0 {name=l15 lab=aq3}
N 40 500 60 500 {}
C {lab_pin.sym} 60 500 0 0 {name=l16 lab=aq4}
N 40 520 60 520 {}
C {lab_pin.sym} 60 520 0 0 {name=l17 lab=aq5}
N 40 540 60 540 {}
C {lab_pin.sym} 60 540 0 0 {name=l18 lab=aq6}
N 40 560 60 560 {}
C {lab_pin.sym} 60 560 0 0 {name=l19 lab=aq7}
N 40 580 60 580 {}
C {lab_pin.sym} 60 580 0 0 {name=l20 lab=aqb0}
N 40 600 60 600 {}
C {lab_pin.sym} 60 600 0 0 {name=l21 lab=aqb1}
N 40 620 60 620 {}
C {lab_pin.sym} 60 620 0 0 {name=l22 lab=aqb2}
N 40 640 60 640 {}
C {lab_pin.sym} 60 640 0 0 {name=l23 lab=aqb3}
N 40 660 60 660 {}
C {lab_pin.sym} 60 660 0 0 {name=l24 lab=aqb4}
N 40 680 60 680 {}
C {lab_pin.sym} 60 680 0 0 {name=l25 lab=aqb5}
N 40 700 60 700 {}
C {lab_pin.sym} 60 700 0 0 {name=l26 lab=aqb6}
N 40 720 60 720 {}
C {lab_pin.sym} 60 720 0 0 {name=l27 lab=aqb7}
N 40 740 60 740 {}
C {lab_pin.sym} 60 740 0 0 {name=l28 lab=clk_buf}
N 40 760 60 760 {}
C {lab_pin.sym} 60 760 0 0 {name=l29 lab=wl_en}
N 40 780 60 780 {}
C {lab_pin.sym} 60 780 0 0 {name=l30 lab=wl_en_n}
N 40 800 60 800 {}
C {lab_pin.sym} 60 800 0 0 {name=l31 lab=s_en}
N 40 820 60 820 {}
C {lab_pin.sym} 60 820 0 0 {name=l32 lab=q_clk}
N 40 840 60 840 {}
C {lab_pin.sym} 60 840 0 0 {name=l33 lab=wpn}
N 0 380 0 360 {}
C {lab_pin.sym} 0 360 0 0 {name=l34 lab=VDD}
N 0 900 0 920 {}
C {lab_pin.sym} 0 920 0 0 {name=l35 lab=VSS}
C {row_path.sym} 0 1740 0 0 {name=Xrow}
N -40 1100 -60 1100 {}
C {lab_pin.sym} -60 1100 0 0 {name=l36 lab=aq2}
N -40 1120 -60 1120 {}
C {lab_pin.sym} -60 1120 0 0 {name=l37 lab=aq3}
N -40 1140 -60 1140 {}
C {lab_pin.sym} -60 1140 0 0 {name=l38 lab=aq4}
N -40 1160 -60 1160 {}
C {lab_pin.sym} -60 1160 0 0 {name=l39 lab=aq5}
N -40 1180 -60 1180 {}
C {lab_pin.sym} -60 1180 0 0 {name=l40 lab=aq6}
N -40 1200 -60 1200 {}
C {lab_pin.sym} -60 1200 0 0 {name=l41 lab=aq7}
N -40 1220 -60 1220 {}
C {lab_pin.sym} -60 1220 0 0 {name=l42 lab=aqb2}
N -40 1240 -60 1240 {}
C {lab_pin.sym} -60 1240 0 0 {name=l43 lab=aqb3}
N -40 1260 -60 1260 {}
C {lab_pin.sym} -60 1260 0 0 {name=l44 lab=aqb4}
N -40 1280 -60 1280 {}
C {lab_pin.sym} -60 1280 0 0 {name=l45 lab=aqb5}
N -40 1300 -60 1300 {}
C {lab_pin.sym} -60 1300 0 0 {name=l46 lab=aqb6}
N -40 1320 -60 1320 {}
C {lab_pin.sym} -60 1320 0 0 {name=l47 lab=aqb7}
N -40 1340 -60 1340 {}
C {lab_pin.sym} -60 1340 0 0 {name=l48 lab=wl_en}
N 40 1100 60 1100 {}
C {lab_pin.sym} 60 1100 0 0 {name=l49 lab=WL0}
N 40 1120 60 1120 {}
C {lab_pin.sym} 60 1120 0 0 {name=l50 lab=WL1}
N 40 1140 60 1140 {}
C {lab_pin.sym} 60 1140 0 0 {name=l51 lab=WL2}
N 40 1160 60 1160 {}
C {lab_pin.sym} 60 1160 0 0 {name=l52 lab=WL3}
N 40 1180 60 1180 {}
C {lab_pin.sym} 60 1180 0 0 {name=l53 lab=WL4}
N 40 1200 60 1200 {}
C {lab_pin.sym} 60 1200 0 0 {name=l54 lab=WL5}
N 40 1220 60 1220 {}
C {lab_pin.sym} 60 1220 0 0 {name=l55 lab=WL6}
N 40 1240 60 1240 {}
C {lab_pin.sym} 60 1240 0 0 {name=l56 lab=WL7}
N 40 1260 60 1260 {}
C {lab_pin.sym} 60 1260 0 0 {name=l57 lab=WL8}
N 40 1280 60 1280 {}
C {lab_pin.sym} 60 1280 0 0 {name=l58 lab=WL9}
N 40 1300 60 1300 {}
C {lab_pin.sym} 60 1300 0 0 {name=l59 lab=WL10}
N 40 1320 60 1320 {}
C {lab_pin.sym} 60 1320 0 0 {name=l60 lab=WL11}
N 40 1340 60 1340 {}
C {lab_pin.sym} 60 1340 0 0 {name=l61 lab=WL12}
N 40 1360 60 1360 {}
C {lab_pin.sym} 60 1360 0 0 {name=l62 lab=WL13}
N 40 1380 60 1380 {}
C {lab_pin.sym} 60 1380 0 0 {name=l63 lab=WL14}
N 40 1400 60 1400 {}
C {lab_pin.sym} 60 1400 0 0 {name=l64 lab=WL15}
N 40 1420 60 1420 {}
C {lab_pin.sym} 60 1420 0 0 {name=l65 lab=WL16}
N 40 1440 60 1440 {}
C {lab_pin.sym} 60 1440 0 0 {name=l66 lab=WL17}
N 40 1460 60 1460 {}
C {lab_pin.sym} 60 1460 0 0 {name=l67 lab=WL18}
N 40 1480 60 1480 {}
C {lab_pin.sym} 60 1480 0 0 {name=l68 lab=WL19}
N 40 1500 60 1500 {}
C {lab_pin.sym} 60 1500 0 0 {name=l69 lab=WL20}
N 40 1520 60 1520 {}
C {lab_pin.sym} 60 1520 0 0 {name=l70 lab=WL21}
N 40 1540 60 1540 {}
C {lab_pin.sym} 60 1540 0 0 {name=l71 lab=WL22}
N 40 1560 60 1560 {}
C {lab_pin.sym} 60 1560 0 0 {name=l72 lab=WL23}
N 40 1580 60 1580 {}
C {lab_pin.sym} 60 1580 0 0 {name=l73 lab=WL24}
N 40 1600 60 1600 {}
C {lab_pin.sym} 60 1600 0 0 {name=l74 lab=WL25}
N 40 1620 60 1620 {}
C {lab_pin.sym} 60 1620 0 0 {name=l75 lab=WL26}
N 40 1640 60 1640 {}
C {lab_pin.sym} 60 1640 0 0 {name=l76 lab=WL27}
N 40 1660 60 1660 {}
C {lab_pin.sym} 60 1660 0 0 {name=l77 lab=WL28}
N 40 1680 60 1680 {}
C {lab_pin.sym} 60 1680 0 0 {name=l78 lab=WL29}
N 40 1700 60 1700 {}
C {lab_pin.sym} 60 1700 0 0 {name=l79 lab=WL30}
N 40 1720 60 1720 {}
C {lab_pin.sym} 60 1720 0 0 {name=l80 lab=WL31}
N 40 1740 60 1740 {}
C {lab_pin.sym} 60 1740 0 0 {name=l81 lab=WL32}
N 40 1760 60 1760 {}
C {lab_pin.sym} 60 1760 0 0 {name=l82 lab=WL33}
N 40 1780 60 1780 {}
C {lab_pin.sym} 60 1780 0 0 {name=l83 lab=WL34}
N 40 1800 60 1800 {}
C {lab_pin.sym} 60 1800 0 0 {name=l84 lab=WL35}
N 40 1820 60 1820 {}
C {lab_pin.sym} 60 1820 0 0 {name=l85 lab=WL36}
N 40 1840 60 1840 {}
C {lab_pin.sym} 60 1840 0 0 {name=l86 lab=WL37}
N 40 1860 60 1860 {}
C {lab_pin.sym} 60 1860 0 0 {name=l87 lab=WL38}
N 40 1880 60 1880 {}
C {lab_pin.sym} 60 1880 0 0 {name=l88 lab=WL39}
N 40 1900 60 1900 {}
C {lab_pin.sym} 60 1900 0 0 {name=l89 lab=WL40}
N 40 1920 60 1920 {}
C {lab_pin.sym} 60 1920 0 0 {name=l90 lab=WL41}
N 40 1940 60 1940 {}
C {lab_pin.sym} 60 1940 0 0 {name=l91 lab=WL42}
N 40 1960 60 1960 {}
C {lab_pin.sym} 60 1960 0 0 {name=l92 lab=WL43}
N 40 1980 60 1980 {}
C {lab_pin.sym} 60 1980 0 0 {name=l93 lab=WL44}
N 40 2000 60 2000 {}
C {lab_pin.sym} 60 2000 0 0 {name=l94 lab=WL45}
N 40 2020 60 2020 {}
C {lab_pin.sym} 60 2020 0 0 {name=l95 lab=WL46}
N 40 2040 60 2040 {}
C {lab_pin.sym} 60 2040 0 0 {name=l96 lab=WL47}
N 40 2060 60 2060 {}
C {lab_pin.sym} 60 2060 0 0 {name=l97 lab=WL48}
N 40 2080 60 2080 {}
C {lab_pin.sym} 60 2080 0 0 {name=l98 lab=WL49}
N 40 2100 60 2100 {}
C {lab_pin.sym} 60 2100 0 0 {name=l99 lab=WL50}
N 40 2120 60 2120 {}
C {lab_pin.sym} 60 2120 0 0 {name=l100 lab=WL51}
N 40 2140 60 2140 {}
C {lab_pin.sym} 60 2140 0 0 {name=l101 lab=WL52}
N 40 2160 60 2160 {}
C {lab_pin.sym} 60 2160 0 0 {name=l102 lab=WL53}
N 40 2180 60 2180 {}
C {lab_pin.sym} 60 2180 0 0 {name=l103 lab=WL54}
N 40 2200 60 2200 {}
C {lab_pin.sym} 60 2200 0 0 {name=l104 lab=WL55}
N 40 2220 60 2220 {}
C {lab_pin.sym} 60 2220 0 0 {name=l105 lab=WL56}
N 40 2240 60 2240 {}
C {lab_pin.sym} 60 2240 0 0 {name=l106 lab=WL57}
N 40 2260 60 2260 {}
C {lab_pin.sym} 60 2260 0 0 {name=l107 lab=WL58}
N 40 2280 60 2280 {}
C {lab_pin.sym} 60 2280 0 0 {name=l108 lab=WL59}
N 40 2300 60 2300 {}
C {lab_pin.sym} 60 2300 0 0 {name=l109 lab=WL60}
N 40 2320 60 2320 {}
C {lab_pin.sym} 60 2320 0 0 {name=l110 lab=WL61}
N 40 2340 60 2340 {}
C {lab_pin.sym} 60 2340 0 0 {name=l111 lab=WL62}
N 40 2360 60 2360 {}
C {lab_pin.sym} 60 2360 0 0 {name=l112 lab=WL63}
N 0 1060 0 1040 {}
C {lab_pin.sym} 0 1040 0 0 {name=l113 lab=VDD}
N 0 2420 0 2440 {}
C {lab_pin.sym} 0 2440 0 0 {name=l114 lab=VSS}
C {col_decode.sym} 0 2700 0 0 {name=Xcol}
N -40 2620 -60 2620 {}
C {lab_pin.sym} -60 2620 0 0 {name=l115 lab=aq0}
N -40 2640 -60 2640 {}
C {lab_pin.sym} -60 2640 0 0 {name=l116 lab=aqb0}
N -40 2660 -60 2660 {}
C {lab_pin.sym} -60 2660 0 0 {name=l117 lab=aq1}
N -40 2680 -60 2680 {}
C {lab_pin.sym} -60 2680 0 0 {name=l118 lab=aqb1}
N -40 2700 -60 2700 {}
C {lab_pin.sym} -60 2700 0 0 {name=l119 lab=wl_en}
N 40 2620 60 2620 {}
C {lab_pin.sym} 60 2620 0 0 {name=l120 lab=csel0}
N 40 2640 60 2640 {}
C {lab_pin.sym} 60 2640 0 0 {name=l121 lab=csel1}
N 40 2660 60 2660 {}
C {lab_pin.sym} 60 2660 0 0 {name=l122 lab=csel2}
N 40 2680 60 2680 {}
C {lab_pin.sym} 60 2680 0 0 {name=l123 lab=csel3}
N 40 2700 60 2700 {}
C {lab_pin.sym} 60 2700 0 0 {name=l124 lab=cseln0}
N 40 2720 60 2720 {}
C {lab_pin.sym} 60 2720 0 0 {name=l125 lab=cseln1}
N 40 2740 60 2740 {}
C {lab_pin.sym} 60 2740 0 0 {name=l126 lab=cseln2}
N 40 2760 60 2760 {}
C {lab_pin.sym} 60 2760 0 0 {name=l127 lab=cseln3}
N 0 2580 0 2560 {}
C {lab_pin.sym} 0 2560 0 0 {name=l128 lab=VDD}
N 0 2820 0 2840 {}
C {lab_pin.sym} 0 2840 0 0 {name=l129 lab=VSS}
C {sram_64x128_array.sym} 0 5580 0 0 {name=Xarray}
N -40 3020 -60 3020 {}
C {lab_pin.sym} -60 3020 0 0 {name=l130 lab=WL0}
N -40 3040 -60 3040 {}
C {lab_pin.sym} -60 3040 0 0 {name=l131 lab=WL1}
N -40 3060 -60 3060 {}
C {lab_pin.sym} -60 3060 0 0 {name=l132 lab=WL2}
N -40 3080 -60 3080 {}
C {lab_pin.sym} -60 3080 0 0 {name=l133 lab=WL3}
N -40 3100 -60 3100 {}
C {lab_pin.sym} -60 3100 0 0 {name=l134 lab=WL4}
N -40 3120 -60 3120 {}
C {lab_pin.sym} -60 3120 0 0 {name=l135 lab=WL5}
N -40 3140 -60 3140 {}
C {lab_pin.sym} -60 3140 0 0 {name=l136 lab=WL6}
N -40 3160 -60 3160 {}
C {lab_pin.sym} -60 3160 0 0 {name=l137 lab=WL7}
N -40 3180 -60 3180 {}
C {lab_pin.sym} -60 3180 0 0 {name=l138 lab=WL8}
N -40 3200 -60 3200 {}
C {lab_pin.sym} -60 3200 0 0 {name=l139 lab=WL9}
N -40 3220 -60 3220 {}
C {lab_pin.sym} -60 3220 0 0 {name=l140 lab=WL10}
N -40 3240 -60 3240 {}
C {lab_pin.sym} -60 3240 0 0 {name=l141 lab=WL11}
N -40 3260 -60 3260 {}
C {lab_pin.sym} -60 3260 0 0 {name=l142 lab=WL12}
N -40 3280 -60 3280 {}
C {lab_pin.sym} -60 3280 0 0 {name=l143 lab=WL13}
N -40 3300 -60 3300 {}
C {lab_pin.sym} -60 3300 0 0 {name=l144 lab=WL14}
N -40 3320 -60 3320 {}
C {lab_pin.sym} -60 3320 0 0 {name=l145 lab=WL15}
N -40 3340 -60 3340 {}
C {lab_pin.sym} -60 3340 0 0 {name=l146 lab=WL16}
N -40 3360 -60 3360 {}
C {lab_pin.sym} -60 3360 0 0 {name=l147 lab=WL17}
N -40 3380 -60 3380 {}
C {lab_pin.sym} -60 3380 0 0 {name=l148 lab=WL18}
N -40 3400 -60 3400 {}
C {lab_pin.sym} -60 3400 0 0 {name=l149 lab=WL19}
N -40 3420 -60 3420 {}
C {lab_pin.sym} -60 3420 0 0 {name=l150 lab=WL20}
N -40 3440 -60 3440 {}
C {lab_pin.sym} -60 3440 0 0 {name=l151 lab=WL21}
N -40 3460 -60 3460 {}
C {lab_pin.sym} -60 3460 0 0 {name=l152 lab=WL22}
N -40 3480 -60 3480 {}
C {lab_pin.sym} -60 3480 0 0 {name=l153 lab=WL23}
N -40 3500 -60 3500 {}
C {lab_pin.sym} -60 3500 0 0 {name=l154 lab=WL24}
N -40 3520 -60 3520 {}
C {lab_pin.sym} -60 3520 0 0 {name=l155 lab=WL25}
N -40 3540 -60 3540 {}
C {lab_pin.sym} -60 3540 0 0 {name=l156 lab=WL26}
N -40 3560 -60 3560 {}
C {lab_pin.sym} -60 3560 0 0 {name=l157 lab=WL27}
N -40 3580 -60 3580 {}
C {lab_pin.sym} -60 3580 0 0 {name=l158 lab=WL28}
N -40 3600 -60 3600 {}
C {lab_pin.sym} -60 3600 0 0 {name=l159 lab=WL29}
N -40 3620 -60 3620 {}
C {lab_pin.sym} -60 3620 0 0 {name=l160 lab=WL30}
N -40 3640 -60 3640 {}
C {lab_pin.sym} -60 3640 0 0 {name=l161 lab=WL31}
N -40 3660 -60 3660 {}
C {lab_pin.sym} -60 3660 0 0 {name=l162 lab=WL32}
N -40 3680 -60 3680 {}
C {lab_pin.sym} -60 3680 0 0 {name=l163 lab=WL33}
N -40 3700 -60 3700 {}
C {lab_pin.sym} -60 3700 0 0 {name=l164 lab=WL34}
N -40 3720 -60 3720 {}
C {lab_pin.sym} -60 3720 0 0 {name=l165 lab=WL35}
N -40 3740 -60 3740 {}
C {lab_pin.sym} -60 3740 0 0 {name=l166 lab=WL36}
N -40 3760 -60 3760 {}
C {lab_pin.sym} -60 3760 0 0 {name=l167 lab=WL37}
N -40 3780 -60 3780 {}
C {lab_pin.sym} -60 3780 0 0 {name=l168 lab=WL38}
N -40 3800 -60 3800 {}
C {lab_pin.sym} -60 3800 0 0 {name=l169 lab=WL39}
N -40 3820 -60 3820 {}
C {lab_pin.sym} -60 3820 0 0 {name=l170 lab=WL40}
N -40 3840 -60 3840 {}
C {lab_pin.sym} -60 3840 0 0 {name=l171 lab=WL41}
N -40 3860 -60 3860 {}
C {lab_pin.sym} -60 3860 0 0 {name=l172 lab=WL42}
N -40 3880 -60 3880 {}
C {lab_pin.sym} -60 3880 0 0 {name=l173 lab=WL43}
N -40 3900 -60 3900 {}
C {lab_pin.sym} -60 3900 0 0 {name=l174 lab=WL44}
N -40 3920 -60 3920 {}
C {lab_pin.sym} -60 3920 0 0 {name=l175 lab=WL45}
N -40 3940 -60 3940 {}
C {lab_pin.sym} -60 3940 0 0 {name=l176 lab=WL46}
N -40 3960 -60 3960 {}
C {lab_pin.sym} -60 3960 0 0 {name=l177 lab=WL47}
N -40 3980 -60 3980 {}
C {lab_pin.sym} -60 3980 0 0 {name=l178 lab=WL48}
N -40 4000 -60 4000 {}
C {lab_pin.sym} -60 4000 0 0 {name=l179 lab=WL49}
N -40 4020 -60 4020 {}
C {lab_pin.sym} -60 4020 0 0 {name=l180 lab=WL50}
N -40 4040 -60 4040 {}
C {lab_pin.sym} -60 4040 0 0 {name=l181 lab=WL51}
N -40 4060 -60 4060 {}
C {lab_pin.sym} -60 4060 0 0 {name=l182 lab=WL52}
N -40 4080 -60 4080 {}
C {lab_pin.sym} -60 4080 0 0 {name=l183 lab=WL53}
N -40 4100 -60 4100 {}
C {lab_pin.sym} -60 4100 0 0 {name=l184 lab=WL54}
N -40 4120 -60 4120 {}
C {lab_pin.sym} -60 4120 0 0 {name=l185 lab=WL55}
N -40 4140 -60 4140 {}
C {lab_pin.sym} -60 4140 0 0 {name=l186 lab=WL56}
N -40 4160 -60 4160 {}
C {lab_pin.sym} -60 4160 0 0 {name=l187 lab=WL57}
N -40 4180 -60 4180 {}
C {lab_pin.sym} -60 4180 0 0 {name=l188 lab=WL58}
N -40 4200 -60 4200 {}
C {lab_pin.sym} -60 4200 0 0 {name=l189 lab=WL59}
N -40 4220 -60 4220 {}
C {lab_pin.sym} -60 4220 0 0 {name=l190 lab=WL60}
N -40 4240 -60 4240 {}
C {lab_pin.sym} -60 4240 0 0 {name=l191 lab=WL61}
N -40 4260 -60 4260 {}
C {lab_pin.sym} -60 4260 0 0 {name=l192 lab=WL62}
N -40 4280 -60 4280 {}
C {lab_pin.sym} -60 4280 0 0 {name=l193 lab=WL63}
N 40 3020 60 3020 {}
C {lab_pin.sym} 60 3020 0 0 {name=l194 lab=BL0}
N 40 3040 60 3040 {}
C {lab_pin.sym} 60 3040 0 0 {name=l195 lab=BLB0}
N 40 3060 60 3060 {}
C {lab_pin.sym} 60 3060 0 0 {name=l196 lab=BL1}
N 40 3080 60 3080 {}
C {lab_pin.sym} 60 3080 0 0 {name=l197 lab=BLB1}
N 40 3100 60 3100 {}
C {lab_pin.sym} 60 3100 0 0 {name=l198 lab=BL2}
N 40 3120 60 3120 {}
C {lab_pin.sym} 60 3120 0 0 {name=l199 lab=BLB2}
N 40 3140 60 3140 {}
C {lab_pin.sym} 60 3140 0 0 {name=l200 lab=BL3}
N 40 3160 60 3160 {}
C {lab_pin.sym} 60 3160 0 0 {name=l201 lab=BLB3}
N 40 3180 60 3180 {}
C {lab_pin.sym} 60 3180 0 0 {name=l202 lab=BL4}
N 40 3200 60 3200 {}
C {lab_pin.sym} 60 3200 0 0 {name=l203 lab=BLB4}
N 40 3220 60 3220 {}
C {lab_pin.sym} 60 3220 0 0 {name=l204 lab=BL5}
N 40 3240 60 3240 {}
C {lab_pin.sym} 60 3240 0 0 {name=l205 lab=BLB5}
N 40 3260 60 3260 {}
C {lab_pin.sym} 60 3260 0 0 {name=l206 lab=BL6}
N 40 3280 60 3280 {}
C {lab_pin.sym} 60 3280 0 0 {name=l207 lab=BLB6}
N 40 3300 60 3300 {}
C {lab_pin.sym} 60 3300 0 0 {name=l208 lab=BL7}
N 40 3320 60 3320 {}
C {lab_pin.sym} 60 3320 0 0 {name=l209 lab=BLB7}
N 40 3340 60 3340 {}
C {lab_pin.sym} 60 3340 0 0 {name=l210 lab=BL8}
N 40 3360 60 3360 {}
C {lab_pin.sym} 60 3360 0 0 {name=l211 lab=BLB8}
N 40 3380 60 3380 {}
C {lab_pin.sym} 60 3380 0 0 {name=l212 lab=BL9}
N 40 3400 60 3400 {}
C {lab_pin.sym} 60 3400 0 0 {name=l213 lab=BLB9}
N 40 3420 60 3420 {}
C {lab_pin.sym} 60 3420 0 0 {name=l214 lab=BL10}
N 40 3440 60 3440 {}
C {lab_pin.sym} 60 3440 0 0 {name=l215 lab=BLB10}
N 40 3460 60 3460 {}
C {lab_pin.sym} 60 3460 0 0 {name=l216 lab=BL11}
N 40 3480 60 3480 {}
C {lab_pin.sym} 60 3480 0 0 {name=l217 lab=BLB11}
N 40 3500 60 3500 {}
C {lab_pin.sym} 60 3500 0 0 {name=l218 lab=BL12}
N 40 3520 60 3520 {}
C {lab_pin.sym} 60 3520 0 0 {name=l219 lab=BLB12}
N 40 3540 60 3540 {}
C {lab_pin.sym} 60 3540 0 0 {name=l220 lab=BL13}
N 40 3560 60 3560 {}
C {lab_pin.sym} 60 3560 0 0 {name=l221 lab=BLB13}
N 40 3580 60 3580 {}
C {lab_pin.sym} 60 3580 0 0 {name=l222 lab=BL14}
N 40 3600 60 3600 {}
C {lab_pin.sym} 60 3600 0 0 {name=l223 lab=BLB14}
N 40 3620 60 3620 {}
C {lab_pin.sym} 60 3620 0 0 {name=l224 lab=BL15}
N 40 3640 60 3640 {}
C {lab_pin.sym} 60 3640 0 0 {name=l225 lab=BLB15}
N 40 3660 60 3660 {}
C {lab_pin.sym} 60 3660 0 0 {name=l226 lab=BL16}
N 40 3680 60 3680 {}
C {lab_pin.sym} 60 3680 0 0 {name=l227 lab=BLB16}
N 40 3700 60 3700 {}
C {lab_pin.sym} 60 3700 0 0 {name=l228 lab=BL17}
N 40 3720 60 3720 {}
C {lab_pin.sym} 60 3720 0 0 {name=l229 lab=BLB17}
N 40 3740 60 3740 {}
C {lab_pin.sym} 60 3740 0 0 {name=l230 lab=BL18}
N 40 3760 60 3760 {}
C {lab_pin.sym} 60 3760 0 0 {name=l231 lab=BLB18}
N 40 3780 60 3780 {}
C {lab_pin.sym} 60 3780 0 0 {name=l232 lab=BL19}
N 40 3800 60 3800 {}
C {lab_pin.sym} 60 3800 0 0 {name=l233 lab=BLB19}
N 40 3820 60 3820 {}
C {lab_pin.sym} 60 3820 0 0 {name=l234 lab=BL20}
N 40 3840 60 3840 {}
C {lab_pin.sym} 60 3840 0 0 {name=l235 lab=BLB20}
N 40 3860 60 3860 {}
C {lab_pin.sym} 60 3860 0 0 {name=l236 lab=BL21}
N 40 3880 60 3880 {}
C {lab_pin.sym} 60 3880 0 0 {name=l237 lab=BLB21}
N 40 3900 60 3900 {}
C {lab_pin.sym} 60 3900 0 0 {name=l238 lab=BL22}
N 40 3920 60 3920 {}
C {lab_pin.sym} 60 3920 0 0 {name=l239 lab=BLB22}
N 40 3940 60 3940 {}
C {lab_pin.sym} 60 3940 0 0 {name=l240 lab=BL23}
N 40 3960 60 3960 {}
C {lab_pin.sym} 60 3960 0 0 {name=l241 lab=BLB23}
N 40 3980 60 3980 {}
C {lab_pin.sym} 60 3980 0 0 {name=l242 lab=BL24}
N 40 4000 60 4000 {}
C {lab_pin.sym} 60 4000 0 0 {name=l243 lab=BLB24}
N 40 4020 60 4020 {}
C {lab_pin.sym} 60 4020 0 0 {name=l244 lab=BL25}
N 40 4040 60 4040 {}
C {lab_pin.sym} 60 4040 0 0 {name=l245 lab=BLB25}
N 40 4060 60 4060 {}
C {lab_pin.sym} 60 4060 0 0 {name=l246 lab=BL26}
N 40 4080 60 4080 {}
C {lab_pin.sym} 60 4080 0 0 {name=l247 lab=BLB26}
N 40 4100 60 4100 {}
C {lab_pin.sym} 60 4100 0 0 {name=l248 lab=BL27}
N 40 4120 60 4120 {}
C {lab_pin.sym} 60 4120 0 0 {name=l249 lab=BLB27}
N 40 4140 60 4140 {}
C {lab_pin.sym} 60 4140 0 0 {name=l250 lab=BL28}
N 40 4160 60 4160 {}
C {lab_pin.sym} 60 4160 0 0 {name=l251 lab=BLB28}
N 40 4180 60 4180 {}
C {lab_pin.sym} 60 4180 0 0 {name=l252 lab=BL29}
N 40 4200 60 4200 {}
C {lab_pin.sym} 60 4200 0 0 {name=l253 lab=BLB29}
N 40 4220 60 4220 {}
C {lab_pin.sym} 60 4220 0 0 {name=l254 lab=BL30}
N 40 4240 60 4240 {}
C {lab_pin.sym} 60 4240 0 0 {name=l255 lab=BLB30}
N 40 4260 60 4260 {}
C {lab_pin.sym} 60 4260 0 0 {name=l256 lab=BL31}
N 40 4280 60 4280 {}
C {lab_pin.sym} 60 4280 0 0 {name=l257 lab=BLB31}
N 40 4300 60 4300 {}
C {lab_pin.sym} 60 4300 0 0 {name=l258 lab=BL32}
N 40 4320 60 4320 {}
C {lab_pin.sym} 60 4320 0 0 {name=l259 lab=BLB32}
N 40 4340 60 4340 {}
C {lab_pin.sym} 60 4340 0 0 {name=l260 lab=BL33}
N 40 4360 60 4360 {}
C {lab_pin.sym} 60 4360 0 0 {name=l261 lab=BLB33}
N 40 4380 60 4380 {}
C {lab_pin.sym} 60 4380 0 0 {name=l262 lab=BL34}
N 40 4400 60 4400 {}
C {lab_pin.sym} 60 4400 0 0 {name=l263 lab=BLB34}
N 40 4420 60 4420 {}
C {lab_pin.sym} 60 4420 0 0 {name=l264 lab=BL35}
N 40 4440 60 4440 {}
C {lab_pin.sym} 60 4440 0 0 {name=l265 lab=BLB35}
N 40 4460 60 4460 {}
C {lab_pin.sym} 60 4460 0 0 {name=l266 lab=BL36}
N 40 4480 60 4480 {}
C {lab_pin.sym} 60 4480 0 0 {name=l267 lab=BLB36}
N 40 4500 60 4500 {}
C {lab_pin.sym} 60 4500 0 0 {name=l268 lab=BL37}
N 40 4520 60 4520 {}
C {lab_pin.sym} 60 4520 0 0 {name=l269 lab=BLB37}
N 40 4540 60 4540 {}
C {lab_pin.sym} 60 4540 0 0 {name=l270 lab=BL38}
N 40 4560 60 4560 {}
C {lab_pin.sym} 60 4560 0 0 {name=l271 lab=BLB38}
N 40 4580 60 4580 {}
C {lab_pin.sym} 60 4580 0 0 {name=l272 lab=BL39}
N 40 4600 60 4600 {}
C {lab_pin.sym} 60 4600 0 0 {name=l273 lab=BLB39}
N 40 4620 60 4620 {}
C {lab_pin.sym} 60 4620 0 0 {name=l274 lab=BL40}
N 40 4640 60 4640 {}
C {lab_pin.sym} 60 4640 0 0 {name=l275 lab=BLB40}
N 40 4660 60 4660 {}
C {lab_pin.sym} 60 4660 0 0 {name=l276 lab=BL41}
N 40 4680 60 4680 {}
C {lab_pin.sym} 60 4680 0 0 {name=l277 lab=BLB41}
N 40 4700 60 4700 {}
C {lab_pin.sym} 60 4700 0 0 {name=l278 lab=BL42}
N 40 4720 60 4720 {}
C {lab_pin.sym} 60 4720 0 0 {name=l279 lab=BLB42}
N 40 4740 60 4740 {}
C {lab_pin.sym} 60 4740 0 0 {name=l280 lab=BL43}
N 40 4760 60 4760 {}
C {lab_pin.sym} 60 4760 0 0 {name=l281 lab=BLB43}
N 40 4780 60 4780 {}
C {lab_pin.sym} 60 4780 0 0 {name=l282 lab=BL44}
N 40 4800 60 4800 {}
C {lab_pin.sym} 60 4800 0 0 {name=l283 lab=BLB44}
N 40 4820 60 4820 {}
C {lab_pin.sym} 60 4820 0 0 {name=l284 lab=BL45}
N 40 4840 60 4840 {}
C {lab_pin.sym} 60 4840 0 0 {name=l285 lab=BLB45}
N 40 4860 60 4860 {}
C {lab_pin.sym} 60 4860 0 0 {name=l286 lab=BL46}
N 40 4880 60 4880 {}
C {lab_pin.sym} 60 4880 0 0 {name=l287 lab=BLB46}
N 40 4900 60 4900 {}
C {lab_pin.sym} 60 4900 0 0 {name=l288 lab=BL47}
N 40 4920 60 4920 {}
C {lab_pin.sym} 60 4920 0 0 {name=l289 lab=BLB47}
N 40 4940 60 4940 {}
C {lab_pin.sym} 60 4940 0 0 {name=l290 lab=BL48}
N 40 4960 60 4960 {}
C {lab_pin.sym} 60 4960 0 0 {name=l291 lab=BLB48}
N 40 4980 60 4980 {}
C {lab_pin.sym} 60 4980 0 0 {name=l292 lab=BL49}
N 40 5000 60 5000 {}
C {lab_pin.sym} 60 5000 0 0 {name=l293 lab=BLB49}
N 40 5020 60 5020 {}
C {lab_pin.sym} 60 5020 0 0 {name=l294 lab=BL50}
N 40 5040 60 5040 {}
C {lab_pin.sym} 60 5040 0 0 {name=l295 lab=BLB50}
N 40 5060 60 5060 {}
C {lab_pin.sym} 60 5060 0 0 {name=l296 lab=BL51}
N 40 5080 60 5080 {}
C {lab_pin.sym} 60 5080 0 0 {name=l297 lab=BLB51}
N 40 5100 60 5100 {}
C {lab_pin.sym} 60 5100 0 0 {name=l298 lab=BL52}
N 40 5120 60 5120 {}
C {lab_pin.sym} 60 5120 0 0 {name=l299 lab=BLB52}
N 40 5140 60 5140 {}
C {lab_pin.sym} 60 5140 0 0 {name=l300 lab=BL53}
N 40 5160 60 5160 {}
C {lab_pin.sym} 60 5160 0 0 {name=l301 lab=BLB53}
N 40 5180 60 5180 {}
C {lab_pin.sym} 60 5180 0 0 {name=l302 lab=BL54}
N 40 5200 60 5200 {}
C {lab_pin.sym} 60 5200 0 0 {name=l303 lab=BLB54}
N 40 5220 60 5220 {}
C {lab_pin.sym} 60 5220 0 0 {name=l304 lab=BL55}
N 40 5240 60 5240 {}
C {lab_pin.sym} 60 5240 0 0 {name=l305 lab=BLB55}
N 40 5260 60 5260 {}
C {lab_pin.sym} 60 5260 0 0 {name=l306 lab=BL56}
N 40 5280 60 5280 {}
C {lab_pin.sym} 60 5280 0 0 {name=l307 lab=BLB56}
N 40 5300 60 5300 {}
C {lab_pin.sym} 60 5300 0 0 {name=l308 lab=BL57}
N 40 5320 60 5320 {}
C {lab_pin.sym} 60 5320 0 0 {name=l309 lab=BLB57}
N 40 5340 60 5340 {}
C {lab_pin.sym} 60 5340 0 0 {name=l310 lab=BL58}
N 40 5360 60 5360 {}
C {lab_pin.sym} 60 5360 0 0 {name=l311 lab=BLB58}
N 40 5380 60 5380 {}
C {lab_pin.sym} 60 5380 0 0 {name=l312 lab=BL59}
N 40 5400 60 5400 {}
C {lab_pin.sym} 60 5400 0 0 {name=l313 lab=BLB59}
N 40 5420 60 5420 {}
C {lab_pin.sym} 60 5420 0 0 {name=l314 lab=BL60}
N 40 5440 60 5440 {}
C {lab_pin.sym} 60 5440 0 0 {name=l315 lab=BLB60}
N 40 5460 60 5460 {}
C {lab_pin.sym} 60 5460 0 0 {name=l316 lab=BL61}
N 40 5480 60 5480 {}
C {lab_pin.sym} 60 5480 0 0 {name=l317 lab=BLB61}
N 40 5500 60 5500 {}
C {lab_pin.sym} 60 5500 0 0 {name=l318 lab=BL62}
N 40 5520 60 5520 {}
C {lab_pin.sym} 60 5520 0 0 {name=l319 lab=BLB62}
N 40 5540 60 5540 {}
C {lab_pin.sym} 60 5540 0 0 {name=l320 lab=BL63}
N 40 5560 60 5560 {}
C {lab_pin.sym} 60 5560 0 0 {name=l321 lab=BLB63}
N 40 5580 60 5580 {}
C {lab_pin.sym} 60 5580 0 0 {name=l322 lab=BL64}
N 40 5600 60 5600 {}
C {lab_pin.sym} 60 5600 0 0 {name=l323 lab=BLB64}
N 40 5620 60 5620 {}
C {lab_pin.sym} 60 5620 0 0 {name=l324 lab=BL65}
N 40 5640 60 5640 {}
C {lab_pin.sym} 60 5640 0 0 {name=l325 lab=BLB65}
N 40 5660 60 5660 {}
C {lab_pin.sym} 60 5660 0 0 {name=l326 lab=BL66}
N 40 5680 60 5680 {}
C {lab_pin.sym} 60 5680 0 0 {name=l327 lab=BLB66}
N 40 5700 60 5700 {}
C {lab_pin.sym} 60 5700 0 0 {name=l328 lab=BL67}
N 40 5720 60 5720 {}
C {lab_pin.sym} 60 5720 0 0 {name=l329 lab=BLB67}
N 40 5740 60 5740 {}
C {lab_pin.sym} 60 5740 0 0 {name=l330 lab=BL68}
N 40 5760 60 5760 {}
C {lab_pin.sym} 60 5760 0 0 {name=l331 lab=BLB68}
N 40 5780 60 5780 {}
C {lab_pin.sym} 60 5780 0 0 {name=l332 lab=BL69}
N 40 5800 60 5800 {}
C {lab_pin.sym} 60 5800 0 0 {name=l333 lab=BLB69}
N 40 5820 60 5820 {}
C {lab_pin.sym} 60 5820 0 0 {name=l334 lab=BL70}
N 40 5840 60 5840 {}
C {lab_pin.sym} 60 5840 0 0 {name=l335 lab=BLB70}
N 40 5860 60 5860 {}
C {lab_pin.sym} 60 5860 0 0 {name=l336 lab=BL71}
N 40 5880 60 5880 {}
C {lab_pin.sym} 60 5880 0 0 {name=l337 lab=BLB71}
N 40 5900 60 5900 {}
C {lab_pin.sym} 60 5900 0 0 {name=l338 lab=BL72}
N 40 5920 60 5920 {}
C {lab_pin.sym} 60 5920 0 0 {name=l339 lab=BLB72}
N 40 5940 60 5940 {}
C {lab_pin.sym} 60 5940 0 0 {name=l340 lab=BL73}
N 40 5960 60 5960 {}
C {lab_pin.sym} 60 5960 0 0 {name=l341 lab=BLB73}
N 40 5980 60 5980 {}
C {lab_pin.sym} 60 5980 0 0 {name=l342 lab=BL74}
N 40 6000 60 6000 {}
C {lab_pin.sym} 60 6000 0 0 {name=l343 lab=BLB74}
N 40 6020 60 6020 {}
C {lab_pin.sym} 60 6020 0 0 {name=l344 lab=BL75}
N 40 6040 60 6040 {}
C {lab_pin.sym} 60 6040 0 0 {name=l345 lab=BLB75}
N 40 6060 60 6060 {}
C {lab_pin.sym} 60 6060 0 0 {name=l346 lab=BL76}
N 40 6080 60 6080 {}
C {lab_pin.sym} 60 6080 0 0 {name=l347 lab=BLB76}
N 40 6100 60 6100 {}
C {lab_pin.sym} 60 6100 0 0 {name=l348 lab=BL77}
N 40 6120 60 6120 {}
C {lab_pin.sym} 60 6120 0 0 {name=l349 lab=BLB77}
N 40 6140 60 6140 {}
C {lab_pin.sym} 60 6140 0 0 {name=l350 lab=BL78}
N 40 6160 60 6160 {}
C {lab_pin.sym} 60 6160 0 0 {name=l351 lab=BLB78}
N 40 6180 60 6180 {}
C {lab_pin.sym} 60 6180 0 0 {name=l352 lab=BL79}
N 40 6200 60 6200 {}
C {lab_pin.sym} 60 6200 0 0 {name=l353 lab=BLB79}
N 40 6220 60 6220 {}
C {lab_pin.sym} 60 6220 0 0 {name=l354 lab=BL80}
N 40 6240 60 6240 {}
C {lab_pin.sym} 60 6240 0 0 {name=l355 lab=BLB80}
N 40 6260 60 6260 {}
C {lab_pin.sym} 60 6260 0 0 {name=l356 lab=BL81}
N 40 6280 60 6280 {}
C {lab_pin.sym} 60 6280 0 0 {name=l357 lab=BLB81}
N 40 6300 60 6300 {}
C {lab_pin.sym} 60 6300 0 0 {name=l358 lab=BL82}
N 40 6320 60 6320 {}
C {lab_pin.sym} 60 6320 0 0 {name=l359 lab=BLB82}
N 40 6340 60 6340 {}
C {lab_pin.sym} 60 6340 0 0 {name=l360 lab=BL83}
N 40 6360 60 6360 {}
C {lab_pin.sym} 60 6360 0 0 {name=l361 lab=BLB83}
N 40 6380 60 6380 {}
C {lab_pin.sym} 60 6380 0 0 {name=l362 lab=BL84}
N 40 6400 60 6400 {}
C {lab_pin.sym} 60 6400 0 0 {name=l363 lab=BLB84}
N 40 6420 60 6420 {}
C {lab_pin.sym} 60 6420 0 0 {name=l364 lab=BL85}
N 40 6440 60 6440 {}
C {lab_pin.sym} 60 6440 0 0 {name=l365 lab=BLB85}
N 40 6460 60 6460 {}
C {lab_pin.sym} 60 6460 0 0 {name=l366 lab=BL86}
N 40 6480 60 6480 {}
C {lab_pin.sym} 60 6480 0 0 {name=l367 lab=BLB86}
N 40 6500 60 6500 {}
C {lab_pin.sym} 60 6500 0 0 {name=l368 lab=BL87}
N 40 6520 60 6520 {}
C {lab_pin.sym} 60 6520 0 0 {name=l369 lab=BLB87}
N 40 6540 60 6540 {}
C {lab_pin.sym} 60 6540 0 0 {name=l370 lab=BL88}
N 40 6560 60 6560 {}
C {lab_pin.sym} 60 6560 0 0 {name=l371 lab=BLB88}
N 40 6580 60 6580 {}
C {lab_pin.sym} 60 6580 0 0 {name=l372 lab=BL89}
N 40 6600 60 6600 {}
C {lab_pin.sym} 60 6600 0 0 {name=l373 lab=BLB89}
N 40 6620 60 6620 {}
C {lab_pin.sym} 60 6620 0 0 {name=l374 lab=BL90}
N 40 6640 60 6640 {}
C {lab_pin.sym} 60 6640 0 0 {name=l375 lab=BLB90}
N 40 6660 60 6660 {}
C {lab_pin.sym} 60 6660 0 0 {name=l376 lab=BL91}
N 40 6680 60 6680 {}
C {lab_pin.sym} 60 6680 0 0 {name=l377 lab=BLB91}
N 40 6700 60 6700 {}
C {lab_pin.sym} 60 6700 0 0 {name=l378 lab=BL92}
N 40 6720 60 6720 {}
C {lab_pin.sym} 60 6720 0 0 {name=l379 lab=BLB92}
N 40 6740 60 6740 {}
C {lab_pin.sym} 60 6740 0 0 {name=l380 lab=BL93}
N 40 6760 60 6760 {}
C {lab_pin.sym} 60 6760 0 0 {name=l381 lab=BLB93}
N 40 6780 60 6780 {}
C {lab_pin.sym} 60 6780 0 0 {name=l382 lab=BL94}
N 40 6800 60 6800 {}
C {lab_pin.sym} 60 6800 0 0 {name=l383 lab=BLB94}
N 40 6820 60 6820 {}
C {lab_pin.sym} 60 6820 0 0 {name=l384 lab=BL95}
N 40 6840 60 6840 {}
C {lab_pin.sym} 60 6840 0 0 {name=l385 lab=BLB95}
N 40 6860 60 6860 {}
C {lab_pin.sym} 60 6860 0 0 {name=l386 lab=BL96}
N 40 6880 60 6880 {}
C {lab_pin.sym} 60 6880 0 0 {name=l387 lab=BLB96}
N 40 6900 60 6900 {}
C {lab_pin.sym} 60 6900 0 0 {name=l388 lab=BL97}
N 40 6920 60 6920 {}
C {lab_pin.sym} 60 6920 0 0 {name=l389 lab=BLB97}
N 40 6940 60 6940 {}
C {lab_pin.sym} 60 6940 0 0 {name=l390 lab=BL98}
N 40 6960 60 6960 {}
C {lab_pin.sym} 60 6960 0 0 {name=l391 lab=BLB98}
N 40 6980 60 6980 {}
C {lab_pin.sym} 60 6980 0 0 {name=l392 lab=BL99}
N 40 7000 60 7000 {}
C {lab_pin.sym} 60 7000 0 0 {name=l393 lab=BLB99}
N 40 7020 60 7020 {}
C {lab_pin.sym} 60 7020 0 0 {name=l394 lab=BL100}
N 40 7040 60 7040 {}
C {lab_pin.sym} 60 7040 0 0 {name=l395 lab=BLB100}
N 40 7060 60 7060 {}
C {lab_pin.sym} 60 7060 0 0 {name=l396 lab=BL101}
N 40 7080 60 7080 {}
C {lab_pin.sym} 60 7080 0 0 {name=l397 lab=BLB101}
N 40 7100 60 7100 {}
C {lab_pin.sym} 60 7100 0 0 {name=l398 lab=BL102}
N 40 7120 60 7120 {}
C {lab_pin.sym} 60 7120 0 0 {name=l399 lab=BLB102}
N 40 7140 60 7140 {}
C {lab_pin.sym} 60 7140 0 0 {name=l400 lab=BL103}
N 40 7160 60 7160 {}
C {lab_pin.sym} 60 7160 0 0 {name=l401 lab=BLB103}
N 40 7180 60 7180 {}
C {lab_pin.sym} 60 7180 0 0 {name=l402 lab=BL104}
N 40 7200 60 7200 {}
C {lab_pin.sym} 60 7200 0 0 {name=l403 lab=BLB104}
N 40 7220 60 7220 {}
C {lab_pin.sym} 60 7220 0 0 {name=l404 lab=BL105}
N 40 7240 60 7240 {}
C {lab_pin.sym} 60 7240 0 0 {name=l405 lab=BLB105}
N 40 7260 60 7260 {}
C {lab_pin.sym} 60 7260 0 0 {name=l406 lab=BL106}
N 40 7280 60 7280 {}
C {lab_pin.sym} 60 7280 0 0 {name=l407 lab=BLB106}
N 40 7300 60 7300 {}
C {lab_pin.sym} 60 7300 0 0 {name=l408 lab=BL107}
N 40 7320 60 7320 {}
C {lab_pin.sym} 60 7320 0 0 {name=l409 lab=BLB107}
N 40 7340 60 7340 {}
C {lab_pin.sym} 60 7340 0 0 {name=l410 lab=BL108}
N 40 7360 60 7360 {}
C {lab_pin.sym} 60 7360 0 0 {name=l411 lab=BLB108}
N 40 7380 60 7380 {}
C {lab_pin.sym} 60 7380 0 0 {name=l412 lab=BL109}
N 40 7400 60 7400 {}
C {lab_pin.sym} 60 7400 0 0 {name=l413 lab=BLB109}
N 40 7420 60 7420 {}
C {lab_pin.sym} 60 7420 0 0 {name=l414 lab=BL110}
N 40 7440 60 7440 {}
C {lab_pin.sym} 60 7440 0 0 {name=l415 lab=BLB110}
N 40 7460 60 7460 {}
C {lab_pin.sym} 60 7460 0 0 {name=l416 lab=BL111}
N 40 7480 60 7480 {}
C {lab_pin.sym} 60 7480 0 0 {name=l417 lab=BLB111}
N 40 7500 60 7500 {}
C {lab_pin.sym} 60 7500 0 0 {name=l418 lab=BL112}
N 40 7520 60 7520 {}
C {lab_pin.sym} 60 7520 0 0 {name=l419 lab=BLB112}
N 40 7540 60 7540 {}
C {lab_pin.sym} 60 7540 0 0 {name=l420 lab=BL113}
N 40 7560 60 7560 {}
C {lab_pin.sym} 60 7560 0 0 {name=l421 lab=BLB113}
N 40 7580 60 7580 {}
C {lab_pin.sym} 60 7580 0 0 {name=l422 lab=BL114}
N 40 7600 60 7600 {}
C {lab_pin.sym} 60 7600 0 0 {name=l423 lab=BLB114}
N 40 7620 60 7620 {}
C {lab_pin.sym} 60 7620 0 0 {name=l424 lab=BL115}
N 40 7640 60 7640 {}
C {lab_pin.sym} 60 7640 0 0 {name=l425 lab=BLB115}
N 40 7660 60 7660 {}
C {lab_pin.sym} 60 7660 0 0 {name=l426 lab=BL116}
N 40 7680 60 7680 {}
C {lab_pin.sym} 60 7680 0 0 {name=l427 lab=BLB116}
N 40 7700 60 7700 {}
C {lab_pin.sym} 60 7700 0 0 {name=l428 lab=BL117}
N 40 7720 60 7720 {}
C {lab_pin.sym} 60 7720 0 0 {name=l429 lab=BLB117}
N 40 7740 60 7740 {}
C {lab_pin.sym} 60 7740 0 0 {name=l430 lab=BL118}
N 40 7760 60 7760 {}
C {lab_pin.sym} 60 7760 0 0 {name=l431 lab=BLB118}
N 40 7780 60 7780 {}
C {lab_pin.sym} 60 7780 0 0 {name=l432 lab=BL119}
N 40 7800 60 7800 {}
C {lab_pin.sym} 60 7800 0 0 {name=l433 lab=BLB119}
N 40 7820 60 7820 {}
C {lab_pin.sym} 60 7820 0 0 {name=l434 lab=BL120}
N 40 7840 60 7840 {}
C {lab_pin.sym} 60 7840 0 0 {name=l435 lab=BLB120}
N 40 7860 60 7860 {}
C {lab_pin.sym} 60 7860 0 0 {name=l436 lab=BL121}
N 40 7880 60 7880 {}
C {lab_pin.sym} 60 7880 0 0 {name=l437 lab=BLB121}
N 40 7900 60 7900 {}
C {lab_pin.sym} 60 7900 0 0 {name=l438 lab=BL122}
N 40 7920 60 7920 {}
C {lab_pin.sym} 60 7920 0 0 {name=l439 lab=BLB122}
N 40 7940 60 7940 {}
C {lab_pin.sym} 60 7940 0 0 {name=l440 lab=BL123}
N 40 7960 60 7960 {}
C {lab_pin.sym} 60 7960 0 0 {name=l441 lab=BLB123}
N 40 7980 60 7980 {}
C {lab_pin.sym} 60 7980 0 0 {name=l442 lab=BL124}
N 40 8000 60 8000 {}
C {lab_pin.sym} 60 8000 0 0 {name=l443 lab=BLB124}
N 40 8020 60 8020 {}
C {lab_pin.sym} 60 8020 0 0 {name=l444 lab=BL125}
N 40 8040 60 8040 {}
C {lab_pin.sym} 60 8040 0 0 {name=l445 lab=BLB125}
N 40 8060 60 8060 {}
C {lab_pin.sym} 60 8060 0 0 {name=l446 lab=BL126}
N 40 8080 60 8080 {}
C {lab_pin.sym} 60 8080 0 0 {name=l447 lab=BLB126}
N 40 8100 60 8100 {}
C {lab_pin.sym} 60 8100 0 0 {name=l448 lab=BL127}
N 40 8120 60 8120 {}
C {lab_pin.sym} 60 8120 0 0 {name=l449 lab=BLB127}
N 0 2980 0 2960 {}
C {lab_pin.sym} 0 2960 0 0 {name=l450 lab=VDD}
N 0 8180 0 8200 {}
C {lab_pin.sym} 0 8200 0 0 {name=l451 lab=VSS}
C {precharge_slice.sym} 0 8460 0 0 {name=Xpc0}
N -40 8380 -60 8380 {}
C {lab_pin.sym} -60 8380 0 0 {name=l452 lab=csel0}
N -40 8400 -60 8400 {}
C {lab_pin.sym} -60 8400 0 0 {name=l453 lab=csel1}
N -40 8420 -60 8420 {}
C {lab_pin.sym} -60 8420 0 0 {name=l454 lab=csel2}
N -40 8440 -60 8440 {}
C {lab_pin.sym} -60 8440 0 0 {name=l455 lab=csel3}
N 40 8380 60 8380 {}
C {lab_pin.sym} 60 8380 0 0 {name=l456 lab=BL0}
N 40 8400 60 8400 {}
C {lab_pin.sym} 60 8400 0 0 {name=l457 lab=BL1}
N 40 8420 60 8420 {}
C {lab_pin.sym} 60 8420 0 0 {name=l458 lab=BL2}
N 40 8440 60 8440 {}
C {lab_pin.sym} 60 8440 0 0 {name=l459 lab=BL3}
N 40 8460 60 8460 {}
C {lab_pin.sym} 60 8460 0 0 {name=l460 lab=BLB0}
N 40 8480 60 8480 {}
C {lab_pin.sym} 60 8480 0 0 {name=l461 lab=BLB1}
N 40 8500 60 8500 {}
C {lab_pin.sym} 60 8500 0 0 {name=l462 lab=BLB2}
N 40 8520 60 8520 {}
C {lab_pin.sym} 60 8520 0 0 {name=l463 lab=BLB3}
N 0 8340 0 8320 {}
C {lab_pin.sym} 0 8320 0 0 {name=l464 lab=VDD}
N 0 8580 0 8600 {}
C {lab_pin.sym} 0 8600 0 0 {name=l465 lab=VSS}
C {io_slice.sym} 0 8930 0 0 {name=Xio0}
N -40 8780 -60 8780 {}
C {lab_pin.sym} -60 8780 0 0 {name=l466 lab=csel0}
N -40 8800 -60 8800 {}
C {lab_pin.sym} -60 8800 0 0 {name=l467 lab=csel1}
N -40 8820 -60 8820 {}
C {lab_pin.sym} -60 8820 0 0 {name=l468 lab=csel2}
N -40 8840 -60 8840 {}
C {lab_pin.sym} -60 8840 0 0 {name=l469 lab=csel3}
N -40 8860 -60 8860 {}
C {lab_pin.sym} -60 8860 0 0 {name=l470 lab=cseln0}
N -40 8880 -60 8880 {}
C {lab_pin.sym} -60 8880 0 0 {name=l471 lab=cseln1}
N -40 8900 -60 8900 {}
C {lab_pin.sym} -60 8900 0 0 {name=l472 lab=cseln2}
N -40 8920 -60 8920 {}
C {lab_pin.sym} -60 8920 0 0 {name=l473 lab=cseln3}
N -40 8940 -60 8940 {}
C {lab_pin.sym} -60 8940 0 0 {name=l474 lab=D[0]}
N -40 8960 -60 8960 {}
C {lab_pin.sym} -60 8960 0 0 {name=l475 lab=WEN[0]}
N -40 8980 -60 8980 {}
C {lab_pin.sym} -60 8980 0 0 {name=l476 lab=clk_buf}
N -40 9000 -60 9000 {}
C {lab_pin.sym} -60 9000 0 0 {name=l477 lab=q_clk}
N -40 9020 -60 9020 {}
C {lab_pin.sym} -60 9020 0 0 {name=l478 lab=s_en}
N -40 9040 -60 9040 {}
C {lab_pin.sym} -60 9040 0 0 {name=l479 lab=wl_en_n}
N -40 9060 -60 9060 {}
C {lab_pin.sym} -60 9060 0 0 {name=l480 lab=wpn}
N 40 8780 60 8780 {}
C {lab_pin.sym} 60 8780 0 0 {name=l481 lab=Q[0]}
N 40 8800 60 8800 {}
C {lab_pin.sym} 60 8800 0 0 {name=l482 lab=BL0}
N 40 8820 60 8820 {}
C {lab_pin.sym} 60 8820 0 0 {name=l483 lab=BL1}
N 40 8840 60 8840 {}
C {lab_pin.sym} 60 8840 0 0 {name=l484 lab=BL2}
N 40 8860 60 8860 {}
C {lab_pin.sym} 60 8860 0 0 {name=l485 lab=BL3}
N 40 8880 60 8880 {}
C {lab_pin.sym} 60 8880 0 0 {name=l486 lab=BLB0}
N 40 8900 60 8900 {}
C {lab_pin.sym} 60 8900 0 0 {name=l487 lab=BLB1}
N 40 8920 60 8920 {}
C {lab_pin.sym} 60 8920 0 0 {name=l488 lab=BLB2}
N 40 8940 60 8940 {}
C {lab_pin.sym} 60 8940 0 0 {name=l489 lab=BLB3}
N 0 8740 0 8720 {}
C {lab_pin.sym} 0 8720 0 0 {name=l490 lab=VDD}
N 0 9120 0 9140 {}
C {lab_pin.sym} 0 9140 0 0 {name=l491 lab=VSS}
C {precharge_slice.sym} 0 9400 0 0 {name=Xpc1}
N -40 9320 -60 9320 {}
C {lab_pin.sym} -60 9320 0 0 {name=l492 lab=csel0}
N -40 9340 -60 9340 {}
C {lab_pin.sym} -60 9340 0 0 {name=l493 lab=csel1}
N -40 9360 -60 9360 {}
C {lab_pin.sym} -60 9360 0 0 {name=l494 lab=csel2}
N -40 9380 -60 9380 {}
C {lab_pin.sym} -60 9380 0 0 {name=l495 lab=csel3}
N 40 9320 60 9320 {}
C {lab_pin.sym} 60 9320 0 0 {name=l496 lab=BL4}
N 40 9340 60 9340 {}
C {lab_pin.sym} 60 9340 0 0 {name=l497 lab=BL5}
N 40 9360 60 9360 {}
C {lab_pin.sym} 60 9360 0 0 {name=l498 lab=BL6}
N 40 9380 60 9380 {}
C {lab_pin.sym} 60 9380 0 0 {name=l499 lab=BL7}
N 40 9400 60 9400 {}
C {lab_pin.sym} 60 9400 0 0 {name=l500 lab=BLB4}
N 40 9420 60 9420 {}
C {lab_pin.sym} 60 9420 0 0 {name=l501 lab=BLB5}
N 40 9440 60 9440 {}
C {lab_pin.sym} 60 9440 0 0 {name=l502 lab=BLB6}
N 40 9460 60 9460 {}
C {lab_pin.sym} 60 9460 0 0 {name=l503 lab=BLB7}
N 0 9280 0 9260 {}
C {lab_pin.sym} 0 9260 0 0 {name=l504 lab=VDD}
N 0 9520 0 9540 {}
C {lab_pin.sym} 0 9540 0 0 {name=l505 lab=VSS}
C {io_slice.sym} 0 9870 0 0 {name=Xio1}
N -40 9720 -60 9720 {}
C {lab_pin.sym} -60 9720 0 0 {name=l506 lab=csel0}
N -40 9740 -60 9740 {}
C {lab_pin.sym} -60 9740 0 0 {name=l507 lab=csel1}
N -40 9760 -60 9760 {}
C {lab_pin.sym} -60 9760 0 0 {name=l508 lab=csel2}
N -40 9780 -60 9780 {}
C {lab_pin.sym} -60 9780 0 0 {name=l509 lab=csel3}
N -40 9800 -60 9800 {}
C {lab_pin.sym} -60 9800 0 0 {name=l510 lab=cseln0}
N -40 9820 -60 9820 {}
C {lab_pin.sym} -60 9820 0 0 {name=l511 lab=cseln1}
N -40 9840 -60 9840 {}
C {lab_pin.sym} -60 9840 0 0 {name=l512 lab=cseln2}
N -40 9860 -60 9860 {}
C {lab_pin.sym} -60 9860 0 0 {name=l513 lab=cseln3}
N -40 9880 -60 9880 {}
C {lab_pin.sym} -60 9880 0 0 {name=l514 lab=D[1]}
N -40 9900 -60 9900 {}
C {lab_pin.sym} -60 9900 0 0 {name=l515 lab=WEN[1]}
N -40 9920 -60 9920 {}
C {lab_pin.sym} -60 9920 0 0 {name=l516 lab=clk_buf}
N -40 9940 -60 9940 {}
C {lab_pin.sym} -60 9940 0 0 {name=l517 lab=q_clk}
N -40 9960 -60 9960 {}
C {lab_pin.sym} -60 9960 0 0 {name=l518 lab=s_en}
N -40 9980 -60 9980 {}
C {lab_pin.sym} -60 9980 0 0 {name=l519 lab=wl_en_n}
N -40 10000 -60 10000 {}
C {lab_pin.sym} -60 10000 0 0 {name=l520 lab=wpn}
N 40 9720 60 9720 {}
C {lab_pin.sym} 60 9720 0 0 {name=l521 lab=Q[1]}
N 40 9740 60 9740 {}
C {lab_pin.sym} 60 9740 0 0 {name=l522 lab=BL4}
N 40 9760 60 9760 {}
C {lab_pin.sym} 60 9760 0 0 {name=l523 lab=BL5}
N 40 9780 60 9780 {}
C {lab_pin.sym} 60 9780 0 0 {name=l524 lab=BL6}
N 40 9800 60 9800 {}
C {lab_pin.sym} 60 9800 0 0 {name=l525 lab=BL7}
N 40 9820 60 9820 {}
C {lab_pin.sym} 60 9820 0 0 {name=l526 lab=BLB4}
N 40 9840 60 9840 {}
C {lab_pin.sym} 60 9840 0 0 {name=l527 lab=BLB5}
N 40 9860 60 9860 {}
C {lab_pin.sym} 60 9860 0 0 {name=l528 lab=BLB6}
N 40 9880 60 9880 {}
C {lab_pin.sym} 60 9880 0 0 {name=l529 lab=BLB7}
N 0 9680 0 9660 {}
C {lab_pin.sym} 0 9660 0 0 {name=l530 lab=VDD}
N 0 10060 0 10080 {}
C {lab_pin.sym} 0 10080 0 0 {name=l531 lab=VSS}
C {precharge_slice.sym} 0 10340 0 0 {name=Xpc2}
N -40 10260 -60 10260 {}
C {lab_pin.sym} -60 10260 0 0 {name=l532 lab=csel0}
N -40 10280 -60 10280 {}
C {lab_pin.sym} -60 10280 0 0 {name=l533 lab=csel1}
N -40 10300 -60 10300 {}
C {lab_pin.sym} -60 10300 0 0 {name=l534 lab=csel2}
N -40 10320 -60 10320 {}
C {lab_pin.sym} -60 10320 0 0 {name=l535 lab=csel3}
N 40 10260 60 10260 {}
C {lab_pin.sym} 60 10260 0 0 {name=l536 lab=BL8}
N 40 10280 60 10280 {}
C {lab_pin.sym} 60 10280 0 0 {name=l537 lab=BL9}
N 40 10300 60 10300 {}
C {lab_pin.sym} 60 10300 0 0 {name=l538 lab=BL10}
N 40 10320 60 10320 {}
C {lab_pin.sym} 60 10320 0 0 {name=l539 lab=BL11}
N 40 10340 60 10340 {}
C {lab_pin.sym} 60 10340 0 0 {name=l540 lab=BLB8}
N 40 10360 60 10360 {}
C {lab_pin.sym} 60 10360 0 0 {name=l541 lab=BLB9}
N 40 10380 60 10380 {}
C {lab_pin.sym} 60 10380 0 0 {name=l542 lab=BLB10}
N 40 10400 60 10400 {}
C {lab_pin.sym} 60 10400 0 0 {name=l543 lab=BLB11}
N 0 10220 0 10200 {}
C {lab_pin.sym} 0 10200 0 0 {name=l544 lab=VDD}
N 0 10460 0 10480 {}
C {lab_pin.sym} 0 10480 0 0 {name=l545 lab=VSS}
C {io_slice.sym} 0 10810 0 0 {name=Xio2}
N -40 10660 -60 10660 {}
C {lab_pin.sym} -60 10660 0 0 {name=l546 lab=csel0}
N -40 10680 -60 10680 {}
C {lab_pin.sym} -60 10680 0 0 {name=l547 lab=csel1}
N -40 10700 -60 10700 {}
C {lab_pin.sym} -60 10700 0 0 {name=l548 lab=csel2}
N -40 10720 -60 10720 {}
C {lab_pin.sym} -60 10720 0 0 {name=l549 lab=csel3}
N -40 10740 -60 10740 {}
C {lab_pin.sym} -60 10740 0 0 {name=l550 lab=cseln0}
N -40 10760 -60 10760 {}
C {lab_pin.sym} -60 10760 0 0 {name=l551 lab=cseln1}
N -40 10780 -60 10780 {}
C {lab_pin.sym} -60 10780 0 0 {name=l552 lab=cseln2}
N -40 10800 -60 10800 {}
C {lab_pin.sym} -60 10800 0 0 {name=l553 lab=cseln3}
N -40 10820 -60 10820 {}
C {lab_pin.sym} -60 10820 0 0 {name=l554 lab=D[2]}
N -40 10840 -60 10840 {}
C {lab_pin.sym} -60 10840 0 0 {name=l555 lab=WEN[2]}
N -40 10860 -60 10860 {}
C {lab_pin.sym} -60 10860 0 0 {name=l556 lab=clk_buf}
N -40 10880 -60 10880 {}
C {lab_pin.sym} -60 10880 0 0 {name=l557 lab=q_clk}
N -40 10900 -60 10900 {}
C {lab_pin.sym} -60 10900 0 0 {name=l558 lab=s_en}
N -40 10920 -60 10920 {}
C {lab_pin.sym} -60 10920 0 0 {name=l559 lab=wl_en_n}
N -40 10940 -60 10940 {}
C {lab_pin.sym} -60 10940 0 0 {name=l560 lab=wpn}
N 40 10660 60 10660 {}
C {lab_pin.sym} 60 10660 0 0 {name=l561 lab=Q[2]}
N 40 10680 60 10680 {}
C {lab_pin.sym} 60 10680 0 0 {name=l562 lab=BL8}
N 40 10700 60 10700 {}
C {lab_pin.sym} 60 10700 0 0 {name=l563 lab=BL9}
N 40 10720 60 10720 {}
C {lab_pin.sym} 60 10720 0 0 {name=l564 lab=BL10}
N 40 10740 60 10740 {}
C {lab_pin.sym} 60 10740 0 0 {name=l565 lab=BL11}
N 40 10760 60 10760 {}
C {lab_pin.sym} 60 10760 0 0 {name=l566 lab=BLB8}
N 40 10780 60 10780 {}
C {lab_pin.sym} 60 10780 0 0 {name=l567 lab=BLB9}
N 40 10800 60 10800 {}
C {lab_pin.sym} 60 10800 0 0 {name=l568 lab=BLB10}
N 40 10820 60 10820 {}
C {lab_pin.sym} 60 10820 0 0 {name=l569 lab=BLB11}
N 0 10620 0 10600 {}
C {lab_pin.sym} 0 10600 0 0 {name=l570 lab=VDD}
N 0 11000 0 11020 {}
C {lab_pin.sym} 0 11020 0 0 {name=l571 lab=VSS}
C {precharge_slice.sym} 0 11280 0 0 {name=Xpc3}
N -40 11200 -60 11200 {}
C {lab_pin.sym} -60 11200 0 0 {name=l572 lab=csel0}
N -40 11220 -60 11220 {}
C {lab_pin.sym} -60 11220 0 0 {name=l573 lab=csel1}
N -40 11240 -60 11240 {}
C {lab_pin.sym} -60 11240 0 0 {name=l574 lab=csel2}
N -40 11260 -60 11260 {}
C {lab_pin.sym} -60 11260 0 0 {name=l575 lab=csel3}
N 40 11200 60 11200 {}
C {lab_pin.sym} 60 11200 0 0 {name=l576 lab=BL12}
N 40 11220 60 11220 {}
C {lab_pin.sym} 60 11220 0 0 {name=l577 lab=BL13}
N 40 11240 60 11240 {}
C {lab_pin.sym} 60 11240 0 0 {name=l578 lab=BL14}
N 40 11260 60 11260 {}
C {lab_pin.sym} 60 11260 0 0 {name=l579 lab=BL15}
N 40 11280 60 11280 {}
C {lab_pin.sym} 60 11280 0 0 {name=l580 lab=BLB12}
N 40 11300 60 11300 {}
C {lab_pin.sym} 60 11300 0 0 {name=l581 lab=BLB13}
N 40 11320 60 11320 {}
C {lab_pin.sym} 60 11320 0 0 {name=l582 lab=BLB14}
N 40 11340 60 11340 {}
C {lab_pin.sym} 60 11340 0 0 {name=l583 lab=BLB15}
N 0 11160 0 11140 {}
C {lab_pin.sym} 0 11140 0 0 {name=l584 lab=VDD}
N 0 11400 0 11420 {}
C {lab_pin.sym} 0 11420 0 0 {name=l585 lab=VSS}
C {io_slice.sym} 0 11750 0 0 {name=Xio3}
N -40 11600 -60 11600 {}
C {lab_pin.sym} -60 11600 0 0 {name=l586 lab=csel0}
N -40 11620 -60 11620 {}
C {lab_pin.sym} -60 11620 0 0 {name=l587 lab=csel1}
N -40 11640 -60 11640 {}
C {lab_pin.sym} -60 11640 0 0 {name=l588 lab=csel2}
N -40 11660 -60 11660 {}
C {lab_pin.sym} -60 11660 0 0 {name=l589 lab=csel3}
N -40 11680 -60 11680 {}
C {lab_pin.sym} -60 11680 0 0 {name=l590 lab=cseln0}
N -40 11700 -60 11700 {}
C {lab_pin.sym} -60 11700 0 0 {name=l591 lab=cseln1}
N -40 11720 -60 11720 {}
C {lab_pin.sym} -60 11720 0 0 {name=l592 lab=cseln2}
N -40 11740 -60 11740 {}
C {lab_pin.sym} -60 11740 0 0 {name=l593 lab=cseln3}
N -40 11760 -60 11760 {}
C {lab_pin.sym} -60 11760 0 0 {name=l594 lab=D[3]}
N -40 11780 -60 11780 {}
C {lab_pin.sym} -60 11780 0 0 {name=l595 lab=WEN[3]}
N -40 11800 -60 11800 {}
C {lab_pin.sym} -60 11800 0 0 {name=l596 lab=clk_buf}
N -40 11820 -60 11820 {}
C {lab_pin.sym} -60 11820 0 0 {name=l597 lab=q_clk}
N -40 11840 -60 11840 {}
C {lab_pin.sym} -60 11840 0 0 {name=l598 lab=s_en}
N -40 11860 -60 11860 {}
C {lab_pin.sym} -60 11860 0 0 {name=l599 lab=wl_en_n}
N -40 11880 -60 11880 {}
C {lab_pin.sym} -60 11880 0 0 {name=l600 lab=wpn}
N 40 11600 60 11600 {}
C {lab_pin.sym} 60 11600 0 0 {name=l601 lab=Q[3]}
N 40 11620 60 11620 {}
C {lab_pin.sym} 60 11620 0 0 {name=l602 lab=BL12}
N 40 11640 60 11640 {}
C {lab_pin.sym} 60 11640 0 0 {name=l603 lab=BL13}
N 40 11660 60 11660 {}
C {lab_pin.sym} 60 11660 0 0 {name=l604 lab=BL14}
N 40 11680 60 11680 {}
C {lab_pin.sym} 60 11680 0 0 {name=l605 lab=BL15}
N 40 11700 60 11700 {}
C {lab_pin.sym} 60 11700 0 0 {name=l606 lab=BLB12}
N 40 11720 60 11720 {}
C {lab_pin.sym} 60 11720 0 0 {name=l607 lab=BLB13}
N 40 11740 60 11740 {}
C {lab_pin.sym} 60 11740 0 0 {name=l608 lab=BLB14}
N 40 11760 60 11760 {}
C {lab_pin.sym} 60 11760 0 0 {name=l609 lab=BLB15}
N 0 11560 0 11540 {}
C {lab_pin.sym} 0 11540 0 0 {name=l610 lab=VDD}
N 0 11940 0 11960 {}
C {lab_pin.sym} 0 11960 0 0 {name=l611 lab=VSS}
C {precharge_slice.sym} 0 12220 0 0 {name=Xpc4}
N -40 12140 -60 12140 {}
C {lab_pin.sym} -60 12140 0 0 {name=l612 lab=csel0}
N -40 12160 -60 12160 {}
C {lab_pin.sym} -60 12160 0 0 {name=l613 lab=csel1}
N -40 12180 -60 12180 {}
C {lab_pin.sym} -60 12180 0 0 {name=l614 lab=csel2}
N -40 12200 -60 12200 {}
C {lab_pin.sym} -60 12200 0 0 {name=l615 lab=csel3}
N 40 12140 60 12140 {}
C {lab_pin.sym} 60 12140 0 0 {name=l616 lab=BL16}
N 40 12160 60 12160 {}
C {lab_pin.sym} 60 12160 0 0 {name=l617 lab=BL17}
N 40 12180 60 12180 {}
C {lab_pin.sym} 60 12180 0 0 {name=l618 lab=BL18}
N 40 12200 60 12200 {}
C {lab_pin.sym} 60 12200 0 0 {name=l619 lab=BL19}
N 40 12220 60 12220 {}
C {lab_pin.sym} 60 12220 0 0 {name=l620 lab=BLB16}
N 40 12240 60 12240 {}
C {lab_pin.sym} 60 12240 0 0 {name=l621 lab=BLB17}
N 40 12260 60 12260 {}
C {lab_pin.sym} 60 12260 0 0 {name=l622 lab=BLB18}
N 40 12280 60 12280 {}
C {lab_pin.sym} 60 12280 0 0 {name=l623 lab=BLB19}
N 0 12100 0 12080 {}
C {lab_pin.sym} 0 12080 0 0 {name=l624 lab=VDD}
N 0 12340 0 12360 {}
C {lab_pin.sym} 0 12360 0 0 {name=l625 lab=VSS}
C {io_slice.sym} 0 12690 0 0 {name=Xio4}
N -40 12540 -60 12540 {}
C {lab_pin.sym} -60 12540 0 0 {name=l626 lab=csel0}
N -40 12560 -60 12560 {}
C {lab_pin.sym} -60 12560 0 0 {name=l627 lab=csel1}
N -40 12580 -60 12580 {}
C {lab_pin.sym} -60 12580 0 0 {name=l628 lab=csel2}
N -40 12600 -60 12600 {}
C {lab_pin.sym} -60 12600 0 0 {name=l629 lab=csel3}
N -40 12620 -60 12620 {}
C {lab_pin.sym} -60 12620 0 0 {name=l630 lab=cseln0}
N -40 12640 -60 12640 {}
C {lab_pin.sym} -60 12640 0 0 {name=l631 lab=cseln1}
N -40 12660 -60 12660 {}
C {lab_pin.sym} -60 12660 0 0 {name=l632 lab=cseln2}
N -40 12680 -60 12680 {}
C {lab_pin.sym} -60 12680 0 0 {name=l633 lab=cseln3}
N -40 12700 -60 12700 {}
C {lab_pin.sym} -60 12700 0 0 {name=l634 lab=D[4]}
N -40 12720 -60 12720 {}
C {lab_pin.sym} -60 12720 0 0 {name=l635 lab=WEN[4]}
N -40 12740 -60 12740 {}
C {lab_pin.sym} -60 12740 0 0 {name=l636 lab=clk_buf}
N -40 12760 -60 12760 {}
C {lab_pin.sym} -60 12760 0 0 {name=l637 lab=q_clk}
N -40 12780 -60 12780 {}
C {lab_pin.sym} -60 12780 0 0 {name=l638 lab=s_en}
N -40 12800 -60 12800 {}
C {lab_pin.sym} -60 12800 0 0 {name=l639 lab=wl_en_n}
N -40 12820 -60 12820 {}
C {lab_pin.sym} -60 12820 0 0 {name=l640 lab=wpn}
N 40 12540 60 12540 {}
C {lab_pin.sym} 60 12540 0 0 {name=l641 lab=Q[4]}
N 40 12560 60 12560 {}
C {lab_pin.sym} 60 12560 0 0 {name=l642 lab=BL16}
N 40 12580 60 12580 {}
C {lab_pin.sym} 60 12580 0 0 {name=l643 lab=BL17}
N 40 12600 60 12600 {}
C {lab_pin.sym} 60 12600 0 0 {name=l644 lab=BL18}
N 40 12620 60 12620 {}
C {lab_pin.sym} 60 12620 0 0 {name=l645 lab=BL19}
N 40 12640 60 12640 {}
C {lab_pin.sym} 60 12640 0 0 {name=l646 lab=BLB16}
N 40 12660 60 12660 {}
C {lab_pin.sym} 60 12660 0 0 {name=l647 lab=BLB17}
N 40 12680 60 12680 {}
C {lab_pin.sym} 60 12680 0 0 {name=l648 lab=BLB18}
N 40 12700 60 12700 {}
C {lab_pin.sym} 60 12700 0 0 {name=l649 lab=BLB19}
N 0 12500 0 12480 {}
C {lab_pin.sym} 0 12480 0 0 {name=l650 lab=VDD}
N 0 12880 0 12900 {}
C {lab_pin.sym} 0 12900 0 0 {name=l651 lab=VSS}
C {precharge_slice.sym} 0 13160 0 0 {name=Xpc5}
N -40 13080 -60 13080 {}
C {lab_pin.sym} -60 13080 0 0 {name=l652 lab=csel0}
N -40 13100 -60 13100 {}
C {lab_pin.sym} -60 13100 0 0 {name=l653 lab=csel1}
N -40 13120 -60 13120 {}
C {lab_pin.sym} -60 13120 0 0 {name=l654 lab=csel2}
N -40 13140 -60 13140 {}
C {lab_pin.sym} -60 13140 0 0 {name=l655 lab=csel3}
N 40 13080 60 13080 {}
C {lab_pin.sym} 60 13080 0 0 {name=l656 lab=BL20}
N 40 13100 60 13100 {}
C {lab_pin.sym} 60 13100 0 0 {name=l657 lab=BL21}
N 40 13120 60 13120 {}
C {lab_pin.sym} 60 13120 0 0 {name=l658 lab=BL22}
N 40 13140 60 13140 {}
C {lab_pin.sym} 60 13140 0 0 {name=l659 lab=BL23}
N 40 13160 60 13160 {}
C {lab_pin.sym} 60 13160 0 0 {name=l660 lab=BLB20}
N 40 13180 60 13180 {}
C {lab_pin.sym} 60 13180 0 0 {name=l661 lab=BLB21}
N 40 13200 60 13200 {}
C {lab_pin.sym} 60 13200 0 0 {name=l662 lab=BLB22}
N 40 13220 60 13220 {}
C {lab_pin.sym} 60 13220 0 0 {name=l663 lab=BLB23}
N 0 13040 0 13020 {}
C {lab_pin.sym} 0 13020 0 0 {name=l664 lab=VDD}
N 0 13280 0 13300 {}
C {lab_pin.sym} 0 13300 0 0 {name=l665 lab=VSS}
C {io_slice.sym} 0 13630 0 0 {name=Xio5}
N -40 13480 -60 13480 {}
C {lab_pin.sym} -60 13480 0 0 {name=l666 lab=csel0}
N -40 13500 -60 13500 {}
C {lab_pin.sym} -60 13500 0 0 {name=l667 lab=csel1}
N -40 13520 -60 13520 {}
C {lab_pin.sym} -60 13520 0 0 {name=l668 lab=csel2}
N -40 13540 -60 13540 {}
C {lab_pin.sym} -60 13540 0 0 {name=l669 lab=csel3}
N -40 13560 -60 13560 {}
C {lab_pin.sym} -60 13560 0 0 {name=l670 lab=cseln0}
N -40 13580 -60 13580 {}
C {lab_pin.sym} -60 13580 0 0 {name=l671 lab=cseln1}
N -40 13600 -60 13600 {}
C {lab_pin.sym} -60 13600 0 0 {name=l672 lab=cseln2}
N -40 13620 -60 13620 {}
C {lab_pin.sym} -60 13620 0 0 {name=l673 lab=cseln3}
N -40 13640 -60 13640 {}
C {lab_pin.sym} -60 13640 0 0 {name=l674 lab=D[5]}
N -40 13660 -60 13660 {}
C {lab_pin.sym} -60 13660 0 0 {name=l675 lab=WEN[5]}
N -40 13680 -60 13680 {}
C {lab_pin.sym} -60 13680 0 0 {name=l676 lab=clk_buf}
N -40 13700 -60 13700 {}
C {lab_pin.sym} -60 13700 0 0 {name=l677 lab=q_clk}
N -40 13720 -60 13720 {}
C {lab_pin.sym} -60 13720 0 0 {name=l678 lab=s_en}
N -40 13740 -60 13740 {}
C {lab_pin.sym} -60 13740 0 0 {name=l679 lab=wl_en_n}
N -40 13760 -60 13760 {}
C {lab_pin.sym} -60 13760 0 0 {name=l680 lab=wpn}
N 40 13480 60 13480 {}
C {lab_pin.sym} 60 13480 0 0 {name=l681 lab=Q[5]}
N 40 13500 60 13500 {}
C {lab_pin.sym} 60 13500 0 0 {name=l682 lab=BL20}
N 40 13520 60 13520 {}
C {lab_pin.sym} 60 13520 0 0 {name=l683 lab=BL21}
N 40 13540 60 13540 {}
C {lab_pin.sym} 60 13540 0 0 {name=l684 lab=BL22}
N 40 13560 60 13560 {}
C {lab_pin.sym} 60 13560 0 0 {name=l685 lab=BL23}
N 40 13580 60 13580 {}
C {lab_pin.sym} 60 13580 0 0 {name=l686 lab=BLB20}
N 40 13600 60 13600 {}
C {lab_pin.sym} 60 13600 0 0 {name=l687 lab=BLB21}
N 40 13620 60 13620 {}
C {lab_pin.sym} 60 13620 0 0 {name=l688 lab=BLB22}
N 40 13640 60 13640 {}
C {lab_pin.sym} 60 13640 0 0 {name=l689 lab=BLB23}
N 0 13440 0 13420 {}
C {lab_pin.sym} 0 13420 0 0 {name=l690 lab=VDD}
N 0 13820 0 13840 {}
C {lab_pin.sym} 0 13840 0 0 {name=l691 lab=VSS}
C {precharge_slice.sym} 0 14100 0 0 {name=Xpc6}
N -40 14020 -60 14020 {}
C {lab_pin.sym} -60 14020 0 0 {name=l692 lab=csel0}
N -40 14040 -60 14040 {}
C {lab_pin.sym} -60 14040 0 0 {name=l693 lab=csel1}
N -40 14060 -60 14060 {}
C {lab_pin.sym} -60 14060 0 0 {name=l694 lab=csel2}
N -40 14080 -60 14080 {}
C {lab_pin.sym} -60 14080 0 0 {name=l695 lab=csel3}
N 40 14020 60 14020 {}
C {lab_pin.sym} 60 14020 0 0 {name=l696 lab=BL24}
N 40 14040 60 14040 {}
C {lab_pin.sym} 60 14040 0 0 {name=l697 lab=BL25}
N 40 14060 60 14060 {}
C {lab_pin.sym} 60 14060 0 0 {name=l698 lab=BL26}
N 40 14080 60 14080 {}
C {lab_pin.sym} 60 14080 0 0 {name=l699 lab=BL27}
N 40 14100 60 14100 {}
C {lab_pin.sym} 60 14100 0 0 {name=l700 lab=BLB24}
N 40 14120 60 14120 {}
C {lab_pin.sym} 60 14120 0 0 {name=l701 lab=BLB25}
N 40 14140 60 14140 {}
C {lab_pin.sym} 60 14140 0 0 {name=l702 lab=BLB26}
N 40 14160 60 14160 {}
C {lab_pin.sym} 60 14160 0 0 {name=l703 lab=BLB27}
N 0 13980 0 13960 {}
C {lab_pin.sym} 0 13960 0 0 {name=l704 lab=VDD}
N 0 14220 0 14240 {}
C {lab_pin.sym} 0 14240 0 0 {name=l705 lab=VSS}
C {io_slice.sym} 0 14570 0 0 {name=Xio6}
N -40 14420 -60 14420 {}
C {lab_pin.sym} -60 14420 0 0 {name=l706 lab=csel0}
N -40 14440 -60 14440 {}
C {lab_pin.sym} -60 14440 0 0 {name=l707 lab=csel1}
N -40 14460 -60 14460 {}
C {lab_pin.sym} -60 14460 0 0 {name=l708 lab=csel2}
N -40 14480 -60 14480 {}
C {lab_pin.sym} -60 14480 0 0 {name=l709 lab=csel3}
N -40 14500 -60 14500 {}
C {lab_pin.sym} -60 14500 0 0 {name=l710 lab=cseln0}
N -40 14520 -60 14520 {}
C {lab_pin.sym} -60 14520 0 0 {name=l711 lab=cseln1}
N -40 14540 -60 14540 {}
C {lab_pin.sym} -60 14540 0 0 {name=l712 lab=cseln2}
N -40 14560 -60 14560 {}
C {lab_pin.sym} -60 14560 0 0 {name=l713 lab=cseln3}
N -40 14580 -60 14580 {}
C {lab_pin.sym} -60 14580 0 0 {name=l714 lab=D[6]}
N -40 14600 -60 14600 {}
C {lab_pin.sym} -60 14600 0 0 {name=l715 lab=WEN[6]}
N -40 14620 -60 14620 {}
C {lab_pin.sym} -60 14620 0 0 {name=l716 lab=clk_buf}
N -40 14640 -60 14640 {}
C {lab_pin.sym} -60 14640 0 0 {name=l717 lab=q_clk}
N -40 14660 -60 14660 {}
C {lab_pin.sym} -60 14660 0 0 {name=l718 lab=s_en}
N -40 14680 -60 14680 {}
C {lab_pin.sym} -60 14680 0 0 {name=l719 lab=wl_en_n}
N -40 14700 -60 14700 {}
C {lab_pin.sym} -60 14700 0 0 {name=l720 lab=wpn}
N 40 14420 60 14420 {}
C {lab_pin.sym} 60 14420 0 0 {name=l721 lab=Q[6]}
N 40 14440 60 14440 {}
C {lab_pin.sym} 60 14440 0 0 {name=l722 lab=BL24}
N 40 14460 60 14460 {}
C {lab_pin.sym} 60 14460 0 0 {name=l723 lab=BL25}
N 40 14480 60 14480 {}
C {lab_pin.sym} 60 14480 0 0 {name=l724 lab=BL26}
N 40 14500 60 14500 {}
C {lab_pin.sym} 60 14500 0 0 {name=l725 lab=BL27}
N 40 14520 60 14520 {}
C {lab_pin.sym} 60 14520 0 0 {name=l726 lab=BLB24}
N 40 14540 60 14540 {}
C {lab_pin.sym} 60 14540 0 0 {name=l727 lab=BLB25}
N 40 14560 60 14560 {}
C {lab_pin.sym} 60 14560 0 0 {name=l728 lab=BLB26}
N 40 14580 60 14580 {}
C {lab_pin.sym} 60 14580 0 0 {name=l729 lab=BLB27}
N 0 14380 0 14360 {}
C {lab_pin.sym} 0 14360 0 0 {name=l730 lab=VDD}
N 0 14760 0 14780 {}
C {lab_pin.sym} 0 14780 0 0 {name=l731 lab=VSS}
C {precharge_slice.sym} 0 15040 0 0 {name=Xpc7}
N -40 14960 -60 14960 {}
C {lab_pin.sym} -60 14960 0 0 {name=l732 lab=csel0}
N -40 14980 -60 14980 {}
C {lab_pin.sym} -60 14980 0 0 {name=l733 lab=csel1}
N -40 15000 -60 15000 {}
C {lab_pin.sym} -60 15000 0 0 {name=l734 lab=csel2}
N -40 15020 -60 15020 {}
C {lab_pin.sym} -60 15020 0 0 {name=l735 lab=csel3}
N 40 14960 60 14960 {}
C {lab_pin.sym} 60 14960 0 0 {name=l736 lab=BL28}
N 40 14980 60 14980 {}
C {lab_pin.sym} 60 14980 0 0 {name=l737 lab=BL29}
N 40 15000 60 15000 {}
C {lab_pin.sym} 60 15000 0 0 {name=l738 lab=BL30}
N 40 15020 60 15020 {}
C {lab_pin.sym} 60 15020 0 0 {name=l739 lab=BL31}
N 40 15040 60 15040 {}
C {lab_pin.sym} 60 15040 0 0 {name=l740 lab=BLB28}
N 40 15060 60 15060 {}
C {lab_pin.sym} 60 15060 0 0 {name=l741 lab=BLB29}
N 40 15080 60 15080 {}
C {lab_pin.sym} 60 15080 0 0 {name=l742 lab=BLB30}
N 40 15100 60 15100 {}
C {lab_pin.sym} 60 15100 0 0 {name=l743 lab=BLB31}
N 0 14920 0 14900 {}
C {lab_pin.sym} 0 14900 0 0 {name=l744 lab=VDD}
N 0 15160 0 15180 {}
C {lab_pin.sym} 0 15180 0 0 {name=l745 lab=VSS}
C {io_slice.sym} 0 15510 0 0 {name=Xio7}
N -40 15360 -60 15360 {}
C {lab_pin.sym} -60 15360 0 0 {name=l746 lab=csel0}
N -40 15380 -60 15380 {}
C {lab_pin.sym} -60 15380 0 0 {name=l747 lab=csel1}
N -40 15400 -60 15400 {}
C {lab_pin.sym} -60 15400 0 0 {name=l748 lab=csel2}
N -40 15420 -60 15420 {}
C {lab_pin.sym} -60 15420 0 0 {name=l749 lab=csel3}
N -40 15440 -60 15440 {}
C {lab_pin.sym} -60 15440 0 0 {name=l750 lab=cseln0}
N -40 15460 -60 15460 {}
C {lab_pin.sym} -60 15460 0 0 {name=l751 lab=cseln1}
N -40 15480 -60 15480 {}
C {lab_pin.sym} -60 15480 0 0 {name=l752 lab=cseln2}
N -40 15500 -60 15500 {}
C {lab_pin.sym} -60 15500 0 0 {name=l753 lab=cseln3}
N -40 15520 -60 15520 {}
C {lab_pin.sym} -60 15520 0 0 {name=l754 lab=D[7]}
N -40 15540 -60 15540 {}
C {lab_pin.sym} -60 15540 0 0 {name=l755 lab=WEN[7]}
N -40 15560 -60 15560 {}
C {lab_pin.sym} -60 15560 0 0 {name=l756 lab=clk_buf}
N -40 15580 -60 15580 {}
C {lab_pin.sym} -60 15580 0 0 {name=l757 lab=q_clk}
N -40 15600 -60 15600 {}
C {lab_pin.sym} -60 15600 0 0 {name=l758 lab=s_en}
N -40 15620 -60 15620 {}
C {lab_pin.sym} -60 15620 0 0 {name=l759 lab=wl_en_n}
N -40 15640 -60 15640 {}
C {lab_pin.sym} -60 15640 0 0 {name=l760 lab=wpn}
N 40 15360 60 15360 {}
C {lab_pin.sym} 60 15360 0 0 {name=l761 lab=Q[7]}
N 40 15380 60 15380 {}
C {lab_pin.sym} 60 15380 0 0 {name=l762 lab=BL28}
N 40 15400 60 15400 {}
C {lab_pin.sym} 60 15400 0 0 {name=l763 lab=BL29}
N 40 15420 60 15420 {}
C {lab_pin.sym} 60 15420 0 0 {name=l764 lab=BL30}
N 40 15440 60 15440 {}
C {lab_pin.sym} 60 15440 0 0 {name=l765 lab=BL31}
N 40 15460 60 15460 {}
C {lab_pin.sym} 60 15460 0 0 {name=l766 lab=BLB28}
N 40 15480 60 15480 {}
C {lab_pin.sym} 60 15480 0 0 {name=l767 lab=BLB29}
N 40 15500 60 15500 {}
C {lab_pin.sym} 60 15500 0 0 {name=l768 lab=BLB30}
N 40 15520 60 15520 {}
C {lab_pin.sym} 60 15520 0 0 {name=l769 lab=BLB31}
N 0 15320 0 15300 {}
C {lab_pin.sym} 0 15300 0 0 {name=l770 lab=VDD}
N 0 15700 0 15720 {}
C {lab_pin.sym} 0 15720 0 0 {name=l771 lab=VSS}
C {precharge_slice.sym} 0 15980 0 0 {name=Xpc8}
N -40 15900 -60 15900 {}
C {lab_pin.sym} -60 15900 0 0 {name=l772 lab=csel0}
N -40 15920 -60 15920 {}
C {lab_pin.sym} -60 15920 0 0 {name=l773 lab=csel1}
N -40 15940 -60 15940 {}
C {lab_pin.sym} -60 15940 0 0 {name=l774 lab=csel2}
N -40 15960 -60 15960 {}
C {lab_pin.sym} -60 15960 0 0 {name=l775 lab=csel3}
N 40 15900 60 15900 {}
C {lab_pin.sym} 60 15900 0 0 {name=l776 lab=BL32}
N 40 15920 60 15920 {}
C {lab_pin.sym} 60 15920 0 0 {name=l777 lab=BL33}
N 40 15940 60 15940 {}
C {lab_pin.sym} 60 15940 0 0 {name=l778 lab=BL34}
N 40 15960 60 15960 {}
C {lab_pin.sym} 60 15960 0 0 {name=l779 lab=BL35}
N 40 15980 60 15980 {}
C {lab_pin.sym} 60 15980 0 0 {name=l780 lab=BLB32}
N 40 16000 60 16000 {}
C {lab_pin.sym} 60 16000 0 0 {name=l781 lab=BLB33}
N 40 16020 60 16020 {}
C {lab_pin.sym} 60 16020 0 0 {name=l782 lab=BLB34}
N 40 16040 60 16040 {}
C {lab_pin.sym} 60 16040 0 0 {name=l783 lab=BLB35}
N 0 15860 0 15840 {}
C {lab_pin.sym} 0 15840 0 0 {name=l784 lab=VDD}
N 0 16100 0 16120 {}
C {lab_pin.sym} 0 16120 0 0 {name=l785 lab=VSS}
C {io_slice.sym} 0 16450 0 0 {name=Xio8}
N -40 16300 -60 16300 {}
C {lab_pin.sym} -60 16300 0 0 {name=l786 lab=csel0}
N -40 16320 -60 16320 {}
C {lab_pin.sym} -60 16320 0 0 {name=l787 lab=csel1}
N -40 16340 -60 16340 {}
C {lab_pin.sym} -60 16340 0 0 {name=l788 lab=csel2}
N -40 16360 -60 16360 {}
C {lab_pin.sym} -60 16360 0 0 {name=l789 lab=csel3}
N -40 16380 -60 16380 {}
C {lab_pin.sym} -60 16380 0 0 {name=l790 lab=cseln0}
N -40 16400 -60 16400 {}
C {lab_pin.sym} -60 16400 0 0 {name=l791 lab=cseln1}
N -40 16420 -60 16420 {}
C {lab_pin.sym} -60 16420 0 0 {name=l792 lab=cseln2}
N -40 16440 -60 16440 {}
C {lab_pin.sym} -60 16440 0 0 {name=l793 lab=cseln3}
N -40 16460 -60 16460 {}
C {lab_pin.sym} -60 16460 0 0 {name=l794 lab=D[8]}
N -40 16480 -60 16480 {}
C {lab_pin.sym} -60 16480 0 0 {name=l795 lab=WEN[8]}
N -40 16500 -60 16500 {}
C {lab_pin.sym} -60 16500 0 0 {name=l796 lab=clk_buf}
N -40 16520 -60 16520 {}
C {lab_pin.sym} -60 16520 0 0 {name=l797 lab=q_clk}
N -40 16540 -60 16540 {}
C {lab_pin.sym} -60 16540 0 0 {name=l798 lab=s_en}
N -40 16560 -60 16560 {}
C {lab_pin.sym} -60 16560 0 0 {name=l799 lab=wl_en_n}
N -40 16580 -60 16580 {}
C {lab_pin.sym} -60 16580 0 0 {name=l800 lab=wpn}
N 40 16300 60 16300 {}
C {lab_pin.sym} 60 16300 0 0 {name=l801 lab=Q[8]}
N 40 16320 60 16320 {}
C {lab_pin.sym} 60 16320 0 0 {name=l802 lab=BL32}
N 40 16340 60 16340 {}
C {lab_pin.sym} 60 16340 0 0 {name=l803 lab=BL33}
N 40 16360 60 16360 {}
C {lab_pin.sym} 60 16360 0 0 {name=l804 lab=BL34}
N 40 16380 60 16380 {}
C {lab_pin.sym} 60 16380 0 0 {name=l805 lab=BL35}
N 40 16400 60 16400 {}
C {lab_pin.sym} 60 16400 0 0 {name=l806 lab=BLB32}
N 40 16420 60 16420 {}
C {lab_pin.sym} 60 16420 0 0 {name=l807 lab=BLB33}
N 40 16440 60 16440 {}
C {lab_pin.sym} 60 16440 0 0 {name=l808 lab=BLB34}
N 40 16460 60 16460 {}
C {lab_pin.sym} 60 16460 0 0 {name=l809 lab=BLB35}
N 0 16260 0 16240 {}
C {lab_pin.sym} 0 16240 0 0 {name=l810 lab=VDD}
N 0 16640 0 16660 {}
C {lab_pin.sym} 0 16660 0 0 {name=l811 lab=VSS}
C {precharge_slice.sym} 0 16920 0 0 {name=Xpc9}
N -40 16840 -60 16840 {}
C {lab_pin.sym} -60 16840 0 0 {name=l812 lab=csel0}
N -40 16860 -60 16860 {}
C {lab_pin.sym} -60 16860 0 0 {name=l813 lab=csel1}
N -40 16880 -60 16880 {}
C {lab_pin.sym} -60 16880 0 0 {name=l814 lab=csel2}
N -40 16900 -60 16900 {}
C {lab_pin.sym} -60 16900 0 0 {name=l815 lab=csel3}
N 40 16840 60 16840 {}
C {lab_pin.sym} 60 16840 0 0 {name=l816 lab=BL36}
N 40 16860 60 16860 {}
C {lab_pin.sym} 60 16860 0 0 {name=l817 lab=BL37}
N 40 16880 60 16880 {}
C {lab_pin.sym} 60 16880 0 0 {name=l818 lab=BL38}
N 40 16900 60 16900 {}
C {lab_pin.sym} 60 16900 0 0 {name=l819 lab=BL39}
N 40 16920 60 16920 {}
C {lab_pin.sym} 60 16920 0 0 {name=l820 lab=BLB36}
N 40 16940 60 16940 {}
C {lab_pin.sym} 60 16940 0 0 {name=l821 lab=BLB37}
N 40 16960 60 16960 {}
C {lab_pin.sym} 60 16960 0 0 {name=l822 lab=BLB38}
N 40 16980 60 16980 {}
C {lab_pin.sym} 60 16980 0 0 {name=l823 lab=BLB39}
N 0 16800 0 16780 {}
C {lab_pin.sym} 0 16780 0 0 {name=l824 lab=VDD}
N 0 17040 0 17060 {}
C {lab_pin.sym} 0 17060 0 0 {name=l825 lab=VSS}
C {io_slice.sym} 0 17390 0 0 {name=Xio9}
N -40 17240 -60 17240 {}
C {lab_pin.sym} -60 17240 0 0 {name=l826 lab=csel0}
N -40 17260 -60 17260 {}
C {lab_pin.sym} -60 17260 0 0 {name=l827 lab=csel1}
N -40 17280 -60 17280 {}
C {lab_pin.sym} -60 17280 0 0 {name=l828 lab=csel2}
N -40 17300 -60 17300 {}
C {lab_pin.sym} -60 17300 0 0 {name=l829 lab=csel3}
N -40 17320 -60 17320 {}
C {lab_pin.sym} -60 17320 0 0 {name=l830 lab=cseln0}
N -40 17340 -60 17340 {}
C {lab_pin.sym} -60 17340 0 0 {name=l831 lab=cseln1}
N -40 17360 -60 17360 {}
C {lab_pin.sym} -60 17360 0 0 {name=l832 lab=cseln2}
N -40 17380 -60 17380 {}
C {lab_pin.sym} -60 17380 0 0 {name=l833 lab=cseln3}
N -40 17400 -60 17400 {}
C {lab_pin.sym} -60 17400 0 0 {name=l834 lab=D[9]}
N -40 17420 -60 17420 {}
C {lab_pin.sym} -60 17420 0 0 {name=l835 lab=WEN[9]}
N -40 17440 -60 17440 {}
C {lab_pin.sym} -60 17440 0 0 {name=l836 lab=clk_buf}
N -40 17460 -60 17460 {}
C {lab_pin.sym} -60 17460 0 0 {name=l837 lab=q_clk}
N -40 17480 -60 17480 {}
C {lab_pin.sym} -60 17480 0 0 {name=l838 lab=s_en}
N -40 17500 -60 17500 {}
C {lab_pin.sym} -60 17500 0 0 {name=l839 lab=wl_en_n}
N -40 17520 -60 17520 {}
C {lab_pin.sym} -60 17520 0 0 {name=l840 lab=wpn}
N 40 17240 60 17240 {}
C {lab_pin.sym} 60 17240 0 0 {name=l841 lab=Q[9]}
N 40 17260 60 17260 {}
C {lab_pin.sym} 60 17260 0 0 {name=l842 lab=BL36}
N 40 17280 60 17280 {}
C {lab_pin.sym} 60 17280 0 0 {name=l843 lab=BL37}
N 40 17300 60 17300 {}
C {lab_pin.sym} 60 17300 0 0 {name=l844 lab=BL38}
N 40 17320 60 17320 {}
C {lab_pin.sym} 60 17320 0 0 {name=l845 lab=BL39}
N 40 17340 60 17340 {}
C {lab_pin.sym} 60 17340 0 0 {name=l846 lab=BLB36}
N 40 17360 60 17360 {}
C {lab_pin.sym} 60 17360 0 0 {name=l847 lab=BLB37}
N 40 17380 60 17380 {}
C {lab_pin.sym} 60 17380 0 0 {name=l848 lab=BLB38}
N 40 17400 60 17400 {}
C {lab_pin.sym} 60 17400 0 0 {name=l849 lab=BLB39}
N 0 17200 0 17180 {}
C {lab_pin.sym} 0 17180 0 0 {name=l850 lab=VDD}
N 0 17580 0 17600 {}
C {lab_pin.sym} 0 17600 0 0 {name=l851 lab=VSS}
C {precharge_slice.sym} 0 17860 0 0 {name=Xpc10}
N -40 17780 -60 17780 {}
C {lab_pin.sym} -60 17780 0 0 {name=l852 lab=csel0}
N -40 17800 -60 17800 {}
C {lab_pin.sym} -60 17800 0 0 {name=l853 lab=csel1}
N -40 17820 -60 17820 {}
C {lab_pin.sym} -60 17820 0 0 {name=l854 lab=csel2}
N -40 17840 -60 17840 {}
C {lab_pin.sym} -60 17840 0 0 {name=l855 lab=csel3}
N 40 17780 60 17780 {}
C {lab_pin.sym} 60 17780 0 0 {name=l856 lab=BL40}
N 40 17800 60 17800 {}
C {lab_pin.sym} 60 17800 0 0 {name=l857 lab=BL41}
N 40 17820 60 17820 {}
C {lab_pin.sym} 60 17820 0 0 {name=l858 lab=BL42}
N 40 17840 60 17840 {}
C {lab_pin.sym} 60 17840 0 0 {name=l859 lab=BL43}
N 40 17860 60 17860 {}
C {lab_pin.sym} 60 17860 0 0 {name=l860 lab=BLB40}
N 40 17880 60 17880 {}
C {lab_pin.sym} 60 17880 0 0 {name=l861 lab=BLB41}
N 40 17900 60 17900 {}
C {lab_pin.sym} 60 17900 0 0 {name=l862 lab=BLB42}
N 40 17920 60 17920 {}
C {lab_pin.sym} 60 17920 0 0 {name=l863 lab=BLB43}
N 0 17740 0 17720 {}
C {lab_pin.sym} 0 17720 0 0 {name=l864 lab=VDD}
N 0 17980 0 18000 {}
C {lab_pin.sym} 0 18000 0 0 {name=l865 lab=VSS}
C {io_slice.sym} 0 18330 0 0 {name=Xio10}
N -40 18180 -60 18180 {}
C {lab_pin.sym} -60 18180 0 0 {name=l866 lab=csel0}
N -40 18200 -60 18200 {}
C {lab_pin.sym} -60 18200 0 0 {name=l867 lab=csel1}
N -40 18220 -60 18220 {}
C {lab_pin.sym} -60 18220 0 0 {name=l868 lab=csel2}
N -40 18240 -60 18240 {}
C {lab_pin.sym} -60 18240 0 0 {name=l869 lab=csel3}
N -40 18260 -60 18260 {}
C {lab_pin.sym} -60 18260 0 0 {name=l870 lab=cseln0}
N -40 18280 -60 18280 {}
C {lab_pin.sym} -60 18280 0 0 {name=l871 lab=cseln1}
N -40 18300 -60 18300 {}
C {lab_pin.sym} -60 18300 0 0 {name=l872 lab=cseln2}
N -40 18320 -60 18320 {}
C {lab_pin.sym} -60 18320 0 0 {name=l873 lab=cseln3}
N -40 18340 -60 18340 {}
C {lab_pin.sym} -60 18340 0 0 {name=l874 lab=D[10]}
N -40 18360 -60 18360 {}
C {lab_pin.sym} -60 18360 0 0 {name=l875 lab=WEN[10]}
N -40 18380 -60 18380 {}
C {lab_pin.sym} -60 18380 0 0 {name=l876 lab=clk_buf}
N -40 18400 -60 18400 {}
C {lab_pin.sym} -60 18400 0 0 {name=l877 lab=q_clk}
N -40 18420 -60 18420 {}
C {lab_pin.sym} -60 18420 0 0 {name=l878 lab=s_en}
N -40 18440 -60 18440 {}
C {lab_pin.sym} -60 18440 0 0 {name=l879 lab=wl_en_n}
N -40 18460 -60 18460 {}
C {lab_pin.sym} -60 18460 0 0 {name=l880 lab=wpn}
N 40 18180 60 18180 {}
C {lab_pin.sym} 60 18180 0 0 {name=l881 lab=Q[10]}
N 40 18200 60 18200 {}
C {lab_pin.sym} 60 18200 0 0 {name=l882 lab=BL40}
N 40 18220 60 18220 {}
C {lab_pin.sym} 60 18220 0 0 {name=l883 lab=BL41}
N 40 18240 60 18240 {}
C {lab_pin.sym} 60 18240 0 0 {name=l884 lab=BL42}
N 40 18260 60 18260 {}
C {lab_pin.sym} 60 18260 0 0 {name=l885 lab=BL43}
N 40 18280 60 18280 {}
C {lab_pin.sym} 60 18280 0 0 {name=l886 lab=BLB40}
N 40 18300 60 18300 {}
C {lab_pin.sym} 60 18300 0 0 {name=l887 lab=BLB41}
N 40 18320 60 18320 {}
C {lab_pin.sym} 60 18320 0 0 {name=l888 lab=BLB42}
N 40 18340 60 18340 {}
C {lab_pin.sym} 60 18340 0 0 {name=l889 lab=BLB43}
N 0 18140 0 18120 {}
C {lab_pin.sym} 0 18120 0 0 {name=l890 lab=VDD}
N 0 18520 0 18540 {}
C {lab_pin.sym} 0 18540 0 0 {name=l891 lab=VSS}
C {precharge_slice.sym} 0 18800 0 0 {name=Xpc11}
N -40 18720 -60 18720 {}
C {lab_pin.sym} -60 18720 0 0 {name=l892 lab=csel0}
N -40 18740 -60 18740 {}
C {lab_pin.sym} -60 18740 0 0 {name=l893 lab=csel1}
N -40 18760 -60 18760 {}
C {lab_pin.sym} -60 18760 0 0 {name=l894 lab=csel2}
N -40 18780 -60 18780 {}
C {lab_pin.sym} -60 18780 0 0 {name=l895 lab=csel3}
N 40 18720 60 18720 {}
C {lab_pin.sym} 60 18720 0 0 {name=l896 lab=BL44}
N 40 18740 60 18740 {}
C {lab_pin.sym} 60 18740 0 0 {name=l897 lab=BL45}
N 40 18760 60 18760 {}
C {lab_pin.sym} 60 18760 0 0 {name=l898 lab=BL46}
N 40 18780 60 18780 {}
C {lab_pin.sym} 60 18780 0 0 {name=l899 lab=BL47}
N 40 18800 60 18800 {}
C {lab_pin.sym} 60 18800 0 0 {name=l900 lab=BLB44}
N 40 18820 60 18820 {}
C {lab_pin.sym} 60 18820 0 0 {name=l901 lab=BLB45}
N 40 18840 60 18840 {}
C {lab_pin.sym} 60 18840 0 0 {name=l902 lab=BLB46}
N 40 18860 60 18860 {}
C {lab_pin.sym} 60 18860 0 0 {name=l903 lab=BLB47}
N 0 18680 0 18660 {}
C {lab_pin.sym} 0 18660 0 0 {name=l904 lab=VDD}
N 0 18920 0 18940 {}
C {lab_pin.sym} 0 18940 0 0 {name=l905 lab=VSS}
C {io_slice.sym} 0 19270 0 0 {name=Xio11}
N -40 19120 -60 19120 {}
C {lab_pin.sym} -60 19120 0 0 {name=l906 lab=csel0}
N -40 19140 -60 19140 {}
C {lab_pin.sym} -60 19140 0 0 {name=l907 lab=csel1}
N -40 19160 -60 19160 {}
C {lab_pin.sym} -60 19160 0 0 {name=l908 lab=csel2}
N -40 19180 -60 19180 {}
C {lab_pin.sym} -60 19180 0 0 {name=l909 lab=csel3}
N -40 19200 -60 19200 {}
C {lab_pin.sym} -60 19200 0 0 {name=l910 lab=cseln0}
N -40 19220 -60 19220 {}
C {lab_pin.sym} -60 19220 0 0 {name=l911 lab=cseln1}
N -40 19240 -60 19240 {}
C {lab_pin.sym} -60 19240 0 0 {name=l912 lab=cseln2}
N -40 19260 -60 19260 {}
C {lab_pin.sym} -60 19260 0 0 {name=l913 lab=cseln3}
N -40 19280 -60 19280 {}
C {lab_pin.sym} -60 19280 0 0 {name=l914 lab=D[11]}
N -40 19300 -60 19300 {}
C {lab_pin.sym} -60 19300 0 0 {name=l915 lab=WEN[11]}
N -40 19320 -60 19320 {}
C {lab_pin.sym} -60 19320 0 0 {name=l916 lab=clk_buf}
N -40 19340 -60 19340 {}
C {lab_pin.sym} -60 19340 0 0 {name=l917 lab=q_clk}
N -40 19360 -60 19360 {}
C {lab_pin.sym} -60 19360 0 0 {name=l918 lab=s_en}
N -40 19380 -60 19380 {}
C {lab_pin.sym} -60 19380 0 0 {name=l919 lab=wl_en_n}
N -40 19400 -60 19400 {}
C {lab_pin.sym} -60 19400 0 0 {name=l920 lab=wpn}
N 40 19120 60 19120 {}
C {lab_pin.sym} 60 19120 0 0 {name=l921 lab=Q[11]}
N 40 19140 60 19140 {}
C {lab_pin.sym} 60 19140 0 0 {name=l922 lab=BL44}
N 40 19160 60 19160 {}
C {lab_pin.sym} 60 19160 0 0 {name=l923 lab=BL45}
N 40 19180 60 19180 {}
C {lab_pin.sym} 60 19180 0 0 {name=l924 lab=BL46}
N 40 19200 60 19200 {}
C {lab_pin.sym} 60 19200 0 0 {name=l925 lab=BL47}
N 40 19220 60 19220 {}
C {lab_pin.sym} 60 19220 0 0 {name=l926 lab=BLB44}
N 40 19240 60 19240 {}
C {lab_pin.sym} 60 19240 0 0 {name=l927 lab=BLB45}
N 40 19260 60 19260 {}
C {lab_pin.sym} 60 19260 0 0 {name=l928 lab=BLB46}
N 40 19280 60 19280 {}
C {lab_pin.sym} 60 19280 0 0 {name=l929 lab=BLB47}
N 0 19080 0 19060 {}
C {lab_pin.sym} 0 19060 0 0 {name=l930 lab=VDD}
N 0 19460 0 19480 {}
C {lab_pin.sym} 0 19480 0 0 {name=l931 lab=VSS}
C {precharge_slice.sym} 0 19740 0 0 {name=Xpc12}
N -40 19660 -60 19660 {}
C {lab_pin.sym} -60 19660 0 0 {name=l932 lab=csel0}
N -40 19680 -60 19680 {}
C {lab_pin.sym} -60 19680 0 0 {name=l933 lab=csel1}
N -40 19700 -60 19700 {}
C {lab_pin.sym} -60 19700 0 0 {name=l934 lab=csel2}
N -40 19720 -60 19720 {}
C {lab_pin.sym} -60 19720 0 0 {name=l935 lab=csel3}
N 40 19660 60 19660 {}
C {lab_pin.sym} 60 19660 0 0 {name=l936 lab=BL48}
N 40 19680 60 19680 {}
C {lab_pin.sym} 60 19680 0 0 {name=l937 lab=BL49}
N 40 19700 60 19700 {}
C {lab_pin.sym} 60 19700 0 0 {name=l938 lab=BL50}
N 40 19720 60 19720 {}
C {lab_pin.sym} 60 19720 0 0 {name=l939 lab=BL51}
N 40 19740 60 19740 {}
C {lab_pin.sym} 60 19740 0 0 {name=l940 lab=BLB48}
N 40 19760 60 19760 {}
C {lab_pin.sym} 60 19760 0 0 {name=l941 lab=BLB49}
N 40 19780 60 19780 {}
C {lab_pin.sym} 60 19780 0 0 {name=l942 lab=BLB50}
N 40 19800 60 19800 {}
C {lab_pin.sym} 60 19800 0 0 {name=l943 lab=BLB51}
N 0 19620 0 19600 {}
C {lab_pin.sym} 0 19600 0 0 {name=l944 lab=VDD}
N 0 19860 0 19880 {}
C {lab_pin.sym} 0 19880 0 0 {name=l945 lab=VSS}
C {io_slice.sym} 0 20210 0 0 {name=Xio12}
N -40 20060 -60 20060 {}
C {lab_pin.sym} -60 20060 0 0 {name=l946 lab=csel0}
N -40 20080 -60 20080 {}
C {lab_pin.sym} -60 20080 0 0 {name=l947 lab=csel1}
N -40 20100 -60 20100 {}
C {lab_pin.sym} -60 20100 0 0 {name=l948 lab=csel2}
N -40 20120 -60 20120 {}
C {lab_pin.sym} -60 20120 0 0 {name=l949 lab=csel3}
N -40 20140 -60 20140 {}
C {lab_pin.sym} -60 20140 0 0 {name=l950 lab=cseln0}
N -40 20160 -60 20160 {}
C {lab_pin.sym} -60 20160 0 0 {name=l951 lab=cseln1}
N -40 20180 -60 20180 {}
C {lab_pin.sym} -60 20180 0 0 {name=l952 lab=cseln2}
N -40 20200 -60 20200 {}
C {lab_pin.sym} -60 20200 0 0 {name=l953 lab=cseln3}
N -40 20220 -60 20220 {}
C {lab_pin.sym} -60 20220 0 0 {name=l954 lab=D[12]}
N -40 20240 -60 20240 {}
C {lab_pin.sym} -60 20240 0 0 {name=l955 lab=WEN[12]}
N -40 20260 -60 20260 {}
C {lab_pin.sym} -60 20260 0 0 {name=l956 lab=clk_buf}
N -40 20280 -60 20280 {}
C {lab_pin.sym} -60 20280 0 0 {name=l957 lab=q_clk}
N -40 20300 -60 20300 {}
C {lab_pin.sym} -60 20300 0 0 {name=l958 lab=s_en}
N -40 20320 -60 20320 {}
C {lab_pin.sym} -60 20320 0 0 {name=l959 lab=wl_en_n}
N -40 20340 -60 20340 {}
C {lab_pin.sym} -60 20340 0 0 {name=l960 lab=wpn}
N 40 20060 60 20060 {}
C {lab_pin.sym} 60 20060 0 0 {name=l961 lab=Q[12]}
N 40 20080 60 20080 {}
C {lab_pin.sym} 60 20080 0 0 {name=l962 lab=BL48}
N 40 20100 60 20100 {}
C {lab_pin.sym} 60 20100 0 0 {name=l963 lab=BL49}
N 40 20120 60 20120 {}
C {lab_pin.sym} 60 20120 0 0 {name=l964 lab=BL50}
N 40 20140 60 20140 {}
C {lab_pin.sym} 60 20140 0 0 {name=l965 lab=BL51}
N 40 20160 60 20160 {}
C {lab_pin.sym} 60 20160 0 0 {name=l966 lab=BLB48}
N 40 20180 60 20180 {}
C {lab_pin.sym} 60 20180 0 0 {name=l967 lab=BLB49}
N 40 20200 60 20200 {}
C {lab_pin.sym} 60 20200 0 0 {name=l968 lab=BLB50}
N 40 20220 60 20220 {}
C {lab_pin.sym} 60 20220 0 0 {name=l969 lab=BLB51}
N 0 20020 0 20000 {}
C {lab_pin.sym} 0 20000 0 0 {name=l970 lab=VDD}
N 0 20400 0 20420 {}
C {lab_pin.sym} 0 20420 0 0 {name=l971 lab=VSS}
C {precharge_slice.sym} 0 20680 0 0 {name=Xpc13}
N -40 20600 -60 20600 {}
C {lab_pin.sym} -60 20600 0 0 {name=l972 lab=csel0}
N -40 20620 -60 20620 {}
C {lab_pin.sym} -60 20620 0 0 {name=l973 lab=csel1}
N -40 20640 -60 20640 {}
C {lab_pin.sym} -60 20640 0 0 {name=l974 lab=csel2}
N -40 20660 -60 20660 {}
C {lab_pin.sym} -60 20660 0 0 {name=l975 lab=csel3}
N 40 20600 60 20600 {}
C {lab_pin.sym} 60 20600 0 0 {name=l976 lab=BL52}
N 40 20620 60 20620 {}
C {lab_pin.sym} 60 20620 0 0 {name=l977 lab=BL53}
N 40 20640 60 20640 {}
C {lab_pin.sym} 60 20640 0 0 {name=l978 lab=BL54}
N 40 20660 60 20660 {}
C {lab_pin.sym} 60 20660 0 0 {name=l979 lab=BL55}
N 40 20680 60 20680 {}
C {lab_pin.sym} 60 20680 0 0 {name=l980 lab=BLB52}
N 40 20700 60 20700 {}
C {lab_pin.sym} 60 20700 0 0 {name=l981 lab=BLB53}
N 40 20720 60 20720 {}
C {lab_pin.sym} 60 20720 0 0 {name=l982 lab=BLB54}
N 40 20740 60 20740 {}
C {lab_pin.sym} 60 20740 0 0 {name=l983 lab=BLB55}
N 0 20560 0 20540 {}
C {lab_pin.sym} 0 20540 0 0 {name=l984 lab=VDD}
N 0 20800 0 20820 {}
C {lab_pin.sym} 0 20820 0 0 {name=l985 lab=VSS}
C {io_slice.sym} 0 21150 0 0 {name=Xio13}
N -40 21000 -60 21000 {}
C {lab_pin.sym} -60 21000 0 0 {name=l986 lab=csel0}
N -40 21020 -60 21020 {}
C {lab_pin.sym} -60 21020 0 0 {name=l987 lab=csel1}
N -40 21040 -60 21040 {}
C {lab_pin.sym} -60 21040 0 0 {name=l988 lab=csel2}
N -40 21060 -60 21060 {}
C {lab_pin.sym} -60 21060 0 0 {name=l989 lab=csel3}
N -40 21080 -60 21080 {}
C {lab_pin.sym} -60 21080 0 0 {name=l990 lab=cseln0}
N -40 21100 -60 21100 {}
C {lab_pin.sym} -60 21100 0 0 {name=l991 lab=cseln1}
N -40 21120 -60 21120 {}
C {lab_pin.sym} -60 21120 0 0 {name=l992 lab=cseln2}
N -40 21140 -60 21140 {}
C {lab_pin.sym} -60 21140 0 0 {name=l993 lab=cseln3}
N -40 21160 -60 21160 {}
C {lab_pin.sym} -60 21160 0 0 {name=l994 lab=D[13]}
N -40 21180 -60 21180 {}
C {lab_pin.sym} -60 21180 0 0 {name=l995 lab=WEN[13]}
N -40 21200 -60 21200 {}
C {lab_pin.sym} -60 21200 0 0 {name=l996 lab=clk_buf}
N -40 21220 -60 21220 {}
C {lab_pin.sym} -60 21220 0 0 {name=l997 lab=q_clk}
N -40 21240 -60 21240 {}
C {lab_pin.sym} -60 21240 0 0 {name=l998 lab=s_en}
N -40 21260 -60 21260 {}
C {lab_pin.sym} -60 21260 0 0 {name=l999 lab=wl_en_n}
N -40 21280 -60 21280 {}
C {lab_pin.sym} -60 21280 0 0 {name=l1000 lab=wpn}
N 40 21000 60 21000 {}
C {lab_pin.sym} 60 21000 0 0 {name=l1001 lab=Q[13]}
N 40 21020 60 21020 {}
C {lab_pin.sym} 60 21020 0 0 {name=l1002 lab=BL52}
N 40 21040 60 21040 {}
C {lab_pin.sym} 60 21040 0 0 {name=l1003 lab=BL53}
N 40 21060 60 21060 {}
C {lab_pin.sym} 60 21060 0 0 {name=l1004 lab=BL54}
N 40 21080 60 21080 {}
C {lab_pin.sym} 60 21080 0 0 {name=l1005 lab=BL55}
N 40 21100 60 21100 {}
C {lab_pin.sym} 60 21100 0 0 {name=l1006 lab=BLB52}
N 40 21120 60 21120 {}
C {lab_pin.sym} 60 21120 0 0 {name=l1007 lab=BLB53}
N 40 21140 60 21140 {}
C {lab_pin.sym} 60 21140 0 0 {name=l1008 lab=BLB54}
N 40 21160 60 21160 {}
C {lab_pin.sym} 60 21160 0 0 {name=l1009 lab=BLB55}
N 0 20960 0 20940 {}
C {lab_pin.sym} 0 20940 0 0 {name=l1010 lab=VDD}
N 0 21340 0 21360 {}
C {lab_pin.sym} 0 21360 0 0 {name=l1011 lab=VSS}
C {precharge_slice.sym} 0 21620 0 0 {name=Xpc14}
N -40 21540 -60 21540 {}
C {lab_pin.sym} -60 21540 0 0 {name=l1012 lab=csel0}
N -40 21560 -60 21560 {}
C {lab_pin.sym} -60 21560 0 0 {name=l1013 lab=csel1}
N -40 21580 -60 21580 {}
C {lab_pin.sym} -60 21580 0 0 {name=l1014 lab=csel2}
N -40 21600 -60 21600 {}
C {lab_pin.sym} -60 21600 0 0 {name=l1015 lab=csel3}
N 40 21540 60 21540 {}
C {lab_pin.sym} 60 21540 0 0 {name=l1016 lab=BL56}
N 40 21560 60 21560 {}
C {lab_pin.sym} 60 21560 0 0 {name=l1017 lab=BL57}
N 40 21580 60 21580 {}
C {lab_pin.sym} 60 21580 0 0 {name=l1018 lab=BL58}
N 40 21600 60 21600 {}
C {lab_pin.sym} 60 21600 0 0 {name=l1019 lab=BL59}
N 40 21620 60 21620 {}
C {lab_pin.sym} 60 21620 0 0 {name=l1020 lab=BLB56}
N 40 21640 60 21640 {}
C {lab_pin.sym} 60 21640 0 0 {name=l1021 lab=BLB57}
N 40 21660 60 21660 {}
C {lab_pin.sym} 60 21660 0 0 {name=l1022 lab=BLB58}
N 40 21680 60 21680 {}
C {lab_pin.sym} 60 21680 0 0 {name=l1023 lab=BLB59}
N 0 21500 0 21480 {}
C {lab_pin.sym} 0 21480 0 0 {name=l1024 lab=VDD}
N 0 21740 0 21760 {}
C {lab_pin.sym} 0 21760 0 0 {name=l1025 lab=VSS}
C {io_slice.sym} 0 22090 0 0 {name=Xio14}
N -40 21940 -60 21940 {}
C {lab_pin.sym} -60 21940 0 0 {name=l1026 lab=csel0}
N -40 21960 -60 21960 {}
C {lab_pin.sym} -60 21960 0 0 {name=l1027 lab=csel1}
N -40 21980 -60 21980 {}
C {lab_pin.sym} -60 21980 0 0 {name=l1028 lab=csel2}
N -40 22000 -60 22000 {}
C {lab_pin.sym} -60 22000 0 0 {name=l1029 lab=csel3}
N -40 22020 -60 22020 {}
C {lab_pin.sym} -60 22020 0 0 {name=l1030 lab=cseln0}
N -40 22040 -60 22040 {}
C {lab_pin.sym} -60 22040 0 0 {name=l1031 lab=cseln1}
N -40 22060 -60 22060 {}
C {lab_pin.sym} -60 22060 0 0 {name=l1032 lab=cseln2}
N -40 22080 -60 22080 {}
C {lab_pin.sym} -60 22080 0 0 {name=l1033 lab=cseln3}
N -40 22100 -60 22100 {}
C {lab_pin.sym} -60 22100 0 0 {name=l1034 lab=D[14]}
N -40 22120 -60 22120 {}
C {lab_pin.sym} -60 22120 0 0 {name=l1035 lab=WEN[14]}
N -40 22140 -60 22140 {}
C {lab_pin.sym} -60 22140 0 0 {name=l1036 lab=clk_buf}
N -40 22160 -60 22160 {}
C {lab_pin.sym} -60 22160 0 0 {name=l1037 lab=q_clk}
N -40 22180 -60 22180 {}
C {lab_pin.sym} -60 22180 0 0 {name=l1038 lab=s_en}
N -40 22200 -60 22200 {}
C {lab_pin.sym} -60 22200 0 0 {name=l1039 lab=wl_en_n}
N -40 22220 -60 22220 {}
C {lab_pin.sym} -60 22220 0 0 {name=l1040 lab=wpn}
N 40 21940 60 21940 {}
C {lab_pin.sym} 60 21940 0 0 {name=l1041 lab=Q[14]}
N 40 21960 60 21960 {}
C {lab_pin.sym} 60 21960 0 0 {name=l1042 lab=BL56}
N 40 21980 60 21980 {}
C {lab_pin.sym} 60 21980 0 0 {name=l1043 lab=BL57}
N 40 22000 60 22000 {}
C {lab_pin.sym} 60 22000 0 0 {name=l1044 lab=BL58}
N 40 22020 60 22020 {}
C {lab_pin.sym} 60 22020 0 0 {name=l1045 lab=BL59}
N 40 22040 60 22040 {}
C {lab_pin.sym} 60 22040 0 0 {name=l1046 lab=BLB56}
N 40 22060 60 22060 {}
C {lab_pin.sym} 60 22060 0 0 {name=l1047 lab=BLB57}
N 40 22080 60 22080 {}
C {lab_pin.sym} 60 22080 0 0 {name=l1048 lab=BLB58}
N 40 22100 60 22100 {}
C {lab_pin.sym} 60 22100 0 0 {name=l1049 lab=BLB59}
N 0 21900 0 21880 {}
C {lab_pin.sym} 0 21880 0 0 {name=l1050 lab=VDD}
N 0 22280 0 22300 {}
C {lab_pin.sym} 0 22300 0 0 {name=l1051 lab=VSS}
C {precharge_slice.sym} 0 22560 0 0 {name=Xpc15}
N -40 22480 -60 22480 {}
C {lab_pin.sym} -60 22480 0 0 {name=l1052 lab=csel0}
N -40 22500 -60 22500 {}
C {lab_pin.sym} -60 22500 0 0 {name=l1053 lab=csel1}
N -40 22520 -60 22520 {}
C {lab_pin.sym} -60 22520 0 0 {name=l1054 lab=csel2}
N -40 22540 -60 22540 {}
C {lab_pin.sym} -60 22540 0 0 {name=l1055 lab=csel3}
N 40 22480 60 22480 {}
C {lab_pin.sym} 60 22480 0 0 {name=l1056 lab=BL60}
N 40 22500 60 22500 {}
C {lab_pin.sym} 60 22500 0 0 {name=l1057 lab=BL61}
N 40 22520 60 22520 {}
C {lab_pin.sym} 60 22520 0 0 {name=l1058 lab=BL62}
N 40 22540 60 22540 {}
C {lab_pin.sym} 60 22540 0 0 {name=l1059 lab=BL63}
N 40 22560 60 22560 {}
C {lab_pin.sym} 60 22560 0 0 {name=l1060 lab=BLB60}
N 40 22580 60 22580 {}
C {lab_pin.sym} 60 22580 0 0 {name=l1061 lab=BLB61}
N 40 22600 60 22600 {}
C {lab_pin.sym} 60 22600 0 0 {name=l1062 lab=BLB62}
N 40 22620 60 22620 {}
C {lab_pin.sym} 60 22620 0 0 {name=l1063 lab=BLB63}
N 0 22440 0 22420 {}
C {lab_pin.sym} 0 22420 0 0 {name=l1064 lab=VDD}
N 0 22680 0 22700 {}
C {lab_pin.sym} 0 22700 0 0 {name=l1065 lab=VSS}
C {io_slice.sym} 0 23030 0 0 {name=Xio15}
N -40 22880 -60 22880 {}
C {lab_pin.sym} -60 22880 0 0 {name=l1066 lab=csel0}
N -40 22900 -60 22900 {}
C {lab_pin.sym} -60 22900 0 0 {name=l1067 lab=csel1}
N -40 22920 -60 22920 {}
C {lab_pin.sym} -60 22920 0 0 {name=l1068 lab=csel2}
N -40 22940 -60 22940 {}
C {lab_pin.sym} -60 22940 0 0 {name=l1069 lab=csel3}
N -40 22960 -60 22960 {}
C {lab_pin.sym} -60 22960 0 0 {name=l1070 lab=cseln0}
N -40 22980 -60 22980 {}
C {lab_pin.sym} -60 22980 0 0 {name=l1071 lab=cseln1}
N -40 23000 -60 23000 {}
C {lab_pin.sym} -60 23000 0 0 {name=l1072 lab=cseln2}
N -40 23020 -60 23020 {}
C {lab_pin.sym} -60 23020 0 0 {name=l1073 lab=cseln3}
N -40 23040 -60 23040 {}
C {lab_pin.sym} -60 23040 0 0 {name=l1074 lab=D[15]}
N -40 23060 -60 23060 {}
C {lab_pin.sym} -60 23060 0 0 {name=l1075 lab=WEN[15]}
N -40 23080 -60 23080 {}
C {lab_pin.sym} -60 23080 0 0 {name=l1076 lab=clk_buf}
N -40 23100 -60 23100 {}
C {lab_pin.sym} -60 23100 0 0 {name=l1077 lab=q_clk}
N -40 23120 -60 23120 {}
C {lab_pin.sym} -60 23120 0 0 {name=l1078 lab=s_en}
N -40 23140 -60 23140 {}
C {lab_pin.sym} -60 23140 0 0 {name=l1079 lab=wl_en_n}
N -40 23160 -60 23160 {}
C {lab_pin.sym} -60 23160 0 0 {name=l1080 lab=wpn}
N 40 22880 60 22880 {}
C {lab_pin.sym} 60 22880 0 0 {name=l1081 lab=Q[15]}
N 40 22900 60 22900 {}
C {lab_pin.sym} 60 22900 0 0 {name=l1082 lab=BL60}
N 40 22920 60 22920 {}
C {lab_pin.sym} 60 22920 0 0 {name=l1083 lab=BL61}
N 40 22940 60 22940 {}
C {lab_pin.sym} 60 22940 0 0 {name=l1084 lab=BL62}
N 40 22960 60 22960 {}
C {lab_pin.sym} 60 22960 0 0 {name=l1085 lab=BL63}
N 40 22980 60 22980 {}
C {lab_pin.sym} 60 22980 0 0 {name=l1086 lab=BLB60}
N 40 23000 60 23000 {}
C {lab_pin.sym} 60 23000 0 0 {name=l1087 lab=BLB61}
N 40 23020 60 23020 {}
C {lab_pin.sym} 60 23020 0 0 {name=l1088 lab=BLB62}
N 40 23040 60 23040 {}
C {lab_pin.sym} 60 23040 0 0 {name=l1089 lab=BLB63}
N 0 22840 0 22820 {}
C {lab_pin.sym} 0 22820 0 0 {name=l1090 lab=VDD}
N 0 23220 0 23240 {}
C {lab_pin.sym} 0 23240 0 0 {name=l1091 lab=VSS}
C {precharge_slice.sym} 0 23500 0 0 {name=Xpc16}
N -40 23420 -60 23420 {}
C {lab_pin.sym} -60 23420 0 0 {name=l1092 lab=csel0}
N -40 23440 -60 23440 {}
C {lab_pin.sym} -60 23440 0 0 {name=l1093 lab=csel1}
N -40 23460 -60 23460 {}
C {lab_pin.sym} -60 23460 0 0 {name=l1094 lab=csel2}
N -40 23480 -60 23480 {}
C {lab_pin.sym} -60 23480 0 0 {name=l1095 lab=csel3}
N 40 23420 60 23420 {}
C {lab_pin.sym} 60 23420 0 0 {name=l1096 lab=BL64}
N 40 23440 60 23440 {}
C {lab_pin.sym} 60 23440 0 0 {name=l1097 lab=BL65}
N 40 23460 60 23460 {}
C {lab_pin.sym} 60 23460 0 0 {name=l1098 lab=BL66}
N 40 23480 60 23480 {}
C {lab_pin.sym} 60 23480 0 0 {name=l1099 lab=BL67}
N 40 23500 60 23500 {}
C {lab_pin.sym} 60 23500 0 0 {name=l1100 lab=BLB64}
N 40 23520 60 23520 {}
C {lab_pin.sym} 60 23520 0 0 {name=l1101 lab=BLB65}
N 40 23540 60 23540 {}
C {lab_pin.sym} 60 23540 0 0 {name=l1102 lab=BLB66}
N 40 23560 60 23560 {}
C {lab_pin.sym} 60 23560 0 0 {name=l1103 lab=BLB67}
N 0 23380 0 23360 {}
C {lab_pin.sym} 0 23360 0 0 {name=l1104 lab=VDD}
N 0 23620 0 23640 {}
C {lab_pin.sym} 0 23640 0 0 {name=l1105 lab=VSS}
C {io_slice.sym} 0 23970 0 0 {name=Xio16}
N -40 23820 -60 23820 {}
C {lab_pin.sym} -60 23820 0 0 {name=l1106 lab=csel0}
N -40 23840 -60 23840 {}
C {lab_pin.sym} -60 23840 0 0 {name=l1107 lab=csel1}
N -40 23860 -60 23860 {}
C {lab_pin.sym} -60 23860 0 0 {name=l1108 lab=csel2}
N -40 23880 -60 23880 {}
C {lab_pin.sym} -60 23880 0 0 {name=l1109 lab=csel3}
N -40 23900 -60 23900 {}
C {lab_pin.sym} -60 23900 0 0 {name=l1110 lab=cseln0}
N -40 23920 -60 23920 {}
C {lab_pin.sym} -60 23920 0 0 {name=l1111 lab=cseln1}
N -40 23940 -60 23940 {}
C {lab_pin.sym} -60 23940 0 0 {name=l1112 lab=cseln2}
N -40 23960 -60 23960 {}
C {lab_pin.sym} -60 23960 0 0 {name=l1113 lab=cseln3}
N -40 23980 -60 23980 {}
C {lab_pin.sym} -60 23980 0 0 {name=l1114 lab=D[16]}
N -40 24000 -60 24000 {}
C {lab_pin.sym} -60 24000 0 0 {name=l1115 lab=WEN[16]}
N -40 24020 -60 24020 {}
C {lab_pin.sym} -60 24020 0 0 {name=l1116 lab=clk_buf}
N -40 24040 -60 24040 {}
C {lab_pin.sym} -60 24040 0 0 {name=l1117 lab=q_clk}
N -40 24060 -60 24060 {}
C {lab_pin.sym} -60 24060 0 0 {name=l1118 lab=s_en}
N -40 24080 -60 24080 {}
C {lab_pin.sym} -60 24080 0 0 {name=l1119 lab=wl_en_n}
N -40 24100 -60 24100 {}
C {lab_pin.sym} -60 24100 0 0 {name=l1120 lab=wpn}
N 40 23820 60 23820 {}
C {lab_pin.sym} 60 23820 0 0 {name=l1121 lab=Q[16]}
N 40 23840 60 23840 {}
C {lab_pin.sym} 60 23840 0 0 {name=l1122 lab=BL64}
N 40 23860 60 23860 {}
C {lab_pin.sym} 60 23860 0 0 {name=l1123 lab=BL65}
N 40 23880 60 23880 {}
C {lab_pin.sym} 60 23880 0 0 {name=l1124 lab=BL66}
N 40 23900 60 23900 {}
C {lab_pin.sym} 60 23900 0 0 {name=l1125 lab=BL67}
N 40 23920 60 23920 {}
C {lab_pin.sym} 60 23920 0 0 {name=l1126 lab=BLB64}
N 40 23940 60 23940 {}
C {lab_pin.sym} 60 23940 0 0 {name=l1127 lab=BLB65}
N 40 23960 60 23960 {}
C {lab_pin.sym} 60 23960 0 0 {name=l1128 lab=BLB66}
N 40 23980 60 23980 {}
C {lab_pin.sym} 60 23980 0 0 {name=l1129 lab=BLB67}
N 0 23780 0 23760 {}
C {lab_pin.sym} 0 23760 0 0 {name=l1130 lab=VDD}
N 0 24160 0 24180 {}
C {lab_pin.sym} 0 24180 0 0 {name=l1131 lab=VSS}
C {precharge_slice.sym} 0 24440 0 0 {name=Xpc17}
N -40 24360 -60 24360 {}
C {lab_pin.sym} -60 24360 0 0 {name=l1132 lab=csel0}
N -40 24380 -60 24380 {}
C {lab_pin.sym} -60 24380 0 0 {name=l1133 lab=csel1}
N -40 24400 -60 24400 {}
C {lab_pin.sym} -60 24400 0 0 {name=l1134 lab=csel2}
N -40 24420 -60 24420 {}
C {lab_pin.sym} -60 24420 0 0 {name=l1135 lab=csel3}
N 40 24360 60 24360 {}
C {lab_pin.sym} 60 24360 0 0 {name=l1136 lab=BL68}
N 40 24380 60 24380 {}
C {lab_pin.sym} 60 24380 0 0 {name=l1137 lab=BL69}
N 40 24400 60 24400 {}
C {lab_pin.sym} 60 24400 0 0 {name=l1138 lab=BL70}
N 40 24420 60 24420 {}
C {lab_pin.sym} 60 24420 0 0 {name=l1139 lab=BL71}
N 40 24440 60 24440 {}
C {lab_pin.sym} 60 24440 0 0 {name=l1140 lab=BLB68}
N 40 24460 60 24460 {}
C {lab_pin.sym} 60 24460 0 0 {name=l1141 lab=BLB69}
N 40 24480 60 24480 {}
C {lab_pin.sym} 60 24480 0 0 {name=l1142 lab=BLB70}
N 40 24500 60 24500 {}
C {lab_pin.sym} 60 24500 0 0 {name=l1143 lab=BLB71}
N 0 24320 0 24300 {}
C {lab_pin.sym} 0 24300 0 0 {name=l1144 lab=VDD}
N 0 24560 0 24580 {}
C {lab_pin.sym} 0 24580 0 0 {name=l1145 lab=VSS}
C {io_slice.sym} 0 24910 0 0 {name=Xio17}
N -40 24760 -60 24760 {}
C {lab_pin.sym} -60 24760 0 0 {name=l1146 lab=csel0}
N -40 24780 -60 24780 {}
C {lab_pin.sym} -60 24780 0 0 {name=l1147 lab=csel1}
N -40 24800 -60 24800 {}
C {lab_pin.sym} -60 24800 0 0 {name=l1148 lab=csel2}
N -40 24820 -60 24820 {}
C {lab_pin.sym} -60 24820 0 0 {name=l1149 lab=csel3}
N -40 24840 -60 24840 {}
C {lab_pin.sym} -60 24840 0 0 {name=l1150 lab=cseln0}
N -40 24860 -60 24860 {}
C {lab_pin.sym} -60 24860 0 0 {name=l1151 lab=cseln1}
N -40 24880 -60 24880 {}
C {lab_pin.sym} -60 24880 0 0 {name=l1152 lab=cseln2}
N -40 24900 -60 24900 {}
C {lab_pin.sym} -60 24900 0 0 {name=l1153 lab=cseln3}
N -40 24920 -60 24920 {}
C {lab_pin.sym} -60 24920 0 0 {name=l1154 lab=D[17]}
N -40 24940 -60 24940 {}
C {lab_pin.sym} -60 24940 0 0 {name=l1155 lab=WEN[17]}
N -40 24960 -60 24960 {}
C {lab_pin.sym} -60 24960 0 0 {name=l1156 lab=clk_buf}
N -40 24980 -60 24980 {}
C {lab_pin.sym} -60 24980 0 0 {name=l1157 lab=q_clk}
N -40 25000 -60 25000 {}
C {lab_pin.sym} -60 25000 0 0 {name=l1158 lab=s_en}
N -40 25020 -60 25020 {}
C {lab_pin.sym} -60 25020 0 0 {name=l1159 lab=wl_en_n}
N -40 25040 -60 25040 {}
C {lab_pin.sym} -60 25040 0 0 {name=l1160 lab=wpn}
N 40 24760 60 24760 {}
C {lab_pin.sym} 60 24760 0 0 {name=l1161 lab=Q[17]}
N 40 24780 60 24780 {}
C {lab_pin.sym} 60 24780 0 0 {name=l1162 lab=BL68}
N 40 24800 60 24800 {}
C {lab_pin.sym} 60 24800 0 0 {name=l1163 lab=BL69}
N 40 24820 60 24820 {}
C {lab_pin.sym} 60 24820 0 0 {name=l1164 lab=BL70}
N 40 24840 60 24840 {}
C {lab_pin.sym} 60 24840 0 0 {name=l1165 lab=BL71}
N 40 24860 60 24860 {}
C {lab_pin.sym} 60 24860 0 0 {name=l1166 lab=BLB68}
N 40 24880 60 24880 {}
C {lab_pin.sym} 60 24880 0 0 {name=l1167 lab=BLB69}
N 40 24900 60 24900 {}
C {lab_pin.sym} 60 24900 0 0 {name=l1168 lab=BLB70}
N 40 24920 60 24920 {}
C {lab_pin.sym} 60 24920 0 0 {name=l1169 lab=BLB71}
N 0 24720 0 24700 {}
C {lab_pin.sym} 0 24700 0 0 {name=l1170 lab=VDD}
N 0 25100 0 25120 {}
C {lab_pin.sym} 0 25120 0 0 {name=l1171 lab=VSS}
C {precharge_slice.sym} 0 25380 0 0 {name=Xpc18}
N -40 25300 -60 25300 {}
C {lab_pin.sym} -60 25300 0 0 {name=l1172 lab=csel0}
N -40 25320 -60 25320 {}
C {lab_pin.sym} -60 25320 0 0 {name=l1173 lab=csel1}
N -40 25340 -60 25340 {}
C {lab_pin.sym} -60 25340 0 0 {name=l1174 lab=csel2}
N -40 25360 -60 25360 {}
C {lab_pin.sym} -60 25360 0 0 {name=l1175 lab=csel3}
N 40 25300 60 25300 {}
C {lab_pin.sym} 60 25300 0 0 {name=l1176 lab=BL72}
N 40 25320 60 25320 {}
C {lab_pin.sym} 60 25320 0 0 {name=l1177 lab=BL73}
N 40 25340 60 25340 {}
C {lab_pin.sym} 60 25340 0 0 {name=l1178 lab=BL74}
N 40 25360 60 25360 {}
C {lab_pin.sym} 60 25360 0 0 {name=l1179 lab=BL75}
N 40 25380 60 25380 {}
C {lab_pin.sym} 60 25380 0 0 {name=l1180 lab=BLB72}
N 40 25400 60 25400 {}
C {lab_pin.sym} 60 25400 0 0 {name=l1181 lab=BLB73}
N 40 25420 60 25420 {}
C {lab_pin.sym} 60 25420 0 0 {name=l1182 lab=BLB74}
N 40 25440 60 25440 {}
C {lab_pin.sym} 60 25440 0 0 {name=l1183 lab=BLB75}
N 0 25260 0 25240 {}
C {lab_pin.sym} 0 25240 0 0 {name=l1184 lab=VDD}
N 0 25500 0 25520 {}
C {lab_pin.sym} 0 25520 0 0 {name=l1185 lab=VSS}
C {io_slice.sym} 0 25850 0 0 {name=Xio18}
N -40 25700 -60 25700 {}
C {lab_pin.sym} -60 25700 0 0 {name=l1186 lab=csel0}
N -40 25720 -60 25720 {}
C {lab_pin.sym} -60 25720 0 0 {name=l1187 lab=csel1}
N -40 25740 -60 25740 {}
C {lab_pin.sym} -60 25740 0 0 {name=l1188 lab=csel2}
N -40 25760 -60 25760 {}
C {lab_pin.sym} -60 25760 0 0 {name=l1189 lab=csel3}
N -40 25780 -60 25780 {}
C {lab_pin.sym} -60 25780 0 0 {name=l1190 lab=cseln0}
N -40 25800 -60 25800 {}
C {lab_pin.sym} -60 25800 0 0 {name=l1191 lab=cseln1}
N -40 25820 -60 25820 {}
C {lab_pin.sym} -60 25820 0 0 {name=l1192 lab=cseln2}
N -40 25840 -60 25840 {}
C {lab_pin.sym} -60 25840 0 0 {name=l1193 lab=cseln3}
N -40 25860 -60 25860 {}
C {lab_pin.sym} -60 25860 0 0 {name=l1194 lab=D[18]}
N -40 25880 -60 25880 {}
C {lab_pin.sym} -60 25880 0 0 {name=l1195 lab=WEN[18]}
N -40 25900 -60 25900 {}
C {lab_pin.sym} -60 25900 0 0 {name=l1196 lab=clk_buf}
N -40 25920 -60 25920 {}
C {lab_pin.sym} -60 25920 0 0 {name=l1197 lab=q_clk}
N -40 25940 -60 25940 {}
C {lab_pin.sym} -60 25940 0 0 {name=l1198 lab=s_en}
N -40 25960 -60 25960 {}
C {lab_pin.sym} -60 25960 0 0 {name=l1199 lab=wl_en_n}
N -40 25980 -60 25980 {}
C {lab_pin.sym} -60 25980 0 0 {name=l1200 lab=wpn}
N 40 25700 60 25700 {}
C {lab_pin.sym} 60 25700 0 0 {name=l1201 lab=Q[18]}
N 40 25720 60 25720 {}
C {lab_pin.sym} 60 25720 0 0 {name=l1202 lab=BL72}
N 40 25740 60 25740 {}
C {lab_pin.sym} 60 25740 0 0 {name=l1203 lab=BL73}
N 40 25760 60 25760 {}
C {lab_pin.sym} 60 25760 0 0 {name=l1204 lab=BL74}
N 40 25780 60 25780 {}
C {lab_pin.sym} 60 25780 0 0 {name=l1205 lab=BL75}
N 40 25800 60 25800 {}
C {lab_pin.sym} 60 25800 0 0 {name=l1206 lab=BLB72}
N 40 25820 60 25820 {}
C {lab_pin.sym} 60 25820 0 0 {name=l1207 lab=BLB73}
N 40 25840 60 25840 {}
C {lab_pin.sym} 60 25840 0 0 {name=l1208 lab=BLB74}
N 40 25860 60 25860 {}
C {lab_pin.sym} 60 25860 0 0 {name=l1209 lab=BLB75}
N 0 25660 0 25640 {}
C {lab_pin.sym} 0 25640 0 0 {name=l1210 lab=VDD}
N 0 26040 0 26060 {}
C {lab_pin.sym} 0 26060 0 0 {name=l1211 lab=VSS}
C {precharge_slice.sym} 0 26320 0 0 {name=Xpc19}
N -40 26240 -60 26240 {}
C {lab_pin.sym} -60 26240 0 0 {name=l1212 lab=csel0}
N -40 26260 -60 26260 {}
C {lab_pin.sym} -60 26260 0 0 {name=l1213 lab=csel1}
N -40 26280 -60 26280 {}
C {lab_pin.sym} -60 26280 0 0 {name=l1214 lab=csel2}
N -40 26300 -60 26300 {}
C {lab_pin.sym} -60 26300 0 0 {name=l1215 lab=csel3}
N 40 26240 60 26240 {}
C {lab_pin.sym} 60 26240 0 0 {name=l1216 lab=BL76}
N 40 26260 60 26260 {}
C {lab_pin.sym} 60 26260 0 0 {name=l1217 lab=BL77}
N 40 26280 60 26280 {}
C {lab_pin.sym} 60 26280 0 0 {name=l1218 lab=BL78}
N 40 26300 60 26300 {}
C {lab_pin.sym} 60 26300 0 0 {name=l1219 lab=BL79}
N 40 26320 60 26320 {}
C {lab_pin.sym} 60 26320 0 0 {name=l1220 lab=BLB76}
N 40 26340 60 26340 {}
C {lab_pin.sym} 60 26340 0 0 {name=l1221 lab=BLB77}
N 40 26360 60 26360 {}
C {lab_pin.sym} 60 26360 0 0 {name=l1222 lab=BLB78}
N 40 26380 60 26380 {}
C {lab_pin.sym} 60 26380 0 0 {name=l1223 lab=BLB79}
N 0 26200 0 26180 {}
C {lab_pin.sym} 0 26180 0 0 {name=l1224 lab=VDD}
N 0 26440 0 26460 {}
C {lab_pin.sym} 0 26460 0 0 {name=l1225 lab=VSS}
C {io_slice.sym} 0 26790 0 0 {name=Xio19}
N -40 26640 -60 26640 {}
C {lab_pin.sym} -60 26640 0 0 {name=l1226 lab=csel0}
N -40 26660 -60 26660 {}
C {lab_pin.sym} -60 26660 0 0 {name=l1227 lab=csel1}
N -40 26680 -60 26680 {}
C {lab_pin.sym} -60 26680 0 0 {name=l1228 lab=csel2}
N -40 26700 -60 26700 {}
C {lab_pin.sym} -60 26700 0 0 {name=l1229 lab=csel3}
N -40 26720 -60 26720 {}
C {lab_pin.sym} -60 26720 0 0 {name=l1230 lab=cseln0}
N -40 26740 -60 26740 {}
C {lab_pin.sym} -60 26740 0 0 {name=l1231 lab=cseln1}
N -40 26760 -60 26760 {}
C {lab_pin.sym} -60 26760 0 0 {name=l1232 lab=cseln2}
N -40 26780 -60 26780 {}
C {lab_pin.sym} -60 26780 0 0 {name=l1233 lab=cseln3}
N -40 26800 -60 26800 {}
C {lab_pin.sym} -60 26800 0 0 {name=l1234 lab=D[19]}
N -40 26820 -60 26820 {}
C {lab_pin.sym} -60 26820 0 0 {name=l1235 lab=WEN[19]}
N -40 26840 -60 26840 {}
C {lab_pin.sym} -60 26840 0 0 {name=l1236 lab=clk_buf}
N -40 26860 -60 26860 {}
C {lab_pin.sym} -60 26860 0 0 {name=l1237 lab=q_clk}
N -40 26880 -60 26880 {}
C {lab_pin.sym} -60 26880 0 0 {name=l1238 lab=s_en}
N -40 26900 -60 26900 {}
C {lab_pin.sym} -60 26900 0 0 {name=l1239 lab=wl_en_n}
N -40 26920 -60 26920 {}
C {lab_pin.sym} -60 26920 0 0 {name=l1240 lab=wpn}
N 40 26640 60 26640 {}
C {lab_pin.sym} 60 26640 0 0 {name=l1241 lab=Q[19]}
N 40 26660 60 26660 {}
C {lab_pin.sym} 60 26660 0 0 {name=l1242 lab=BL76}
N 40 26680 60 26680 {}
C {lab_pin.sym} 60 26680 0 0 {name=l1243 lab=BL77}
N 40 26700 60 26700 {}
C {lab_pin.sym} 60 26700 0 0 {name=l1244 lab=BL78}
N 40 26720 60 26720 {}
C {lab_pin.sym} 60 26720 0 0 {name=l1245 lab=BL79}
N 40 26740 60 26740 {}
C {lab_pin.sym} 60 26740 0 0 {name=l1246 lab=BLB76}
N 40 26760 60 26760 {}
C {lab_pin.sym} 60 26760 0 0 {name=l1247 lab=BLB77}
N 40 26780 60 26780 {}
C {lab_pin.sym} 60 26780 0 0 {name=l1248 lab=BLB78}
N 40 26800 60 26800 {}
C {lab_pin.sym} 60 26800 0 0 {name=l1249 lab=BLB79}
N 0 26600 0 26580 {}
C {lab_pin.sym} 0 26580 0 0 {name=l1250 lab=VDD}
N 0 26980 0 27000 {}
C {lab_pin.sym} 0 27000 0 0 {name=l1251 lab=VSS}
C {precharge_slice.sym} 0 27260 0 0 {name=Xpc20}
N -40 27180 -60 27180 {}
C {lab_pin.sym} -60 27180 0 0 {name=l1252 lab=csel0}
N -40 27200 -60 27200 {}
C {lab_pin.sym} -60 27200 0 0 {name=l1253 lab=csel1}
N -40 27220 -60 27220 {}
C {lab_pin.sym} -60 27220 0 0 {name=l1254 lab=csel2}
N -40 27240 -60 27240 {}
C {lab_pin.sym} -60 27240 0 0 {name=l1255 lab=csel3}
N 40 27180 60 27180 {}
C {lab_pin.sym} 60 27180 0 0 {name=l1256 lab=BL80}
N 40 27200 60 27200 {}
C {lab_pin.sym} 60 27200 0 0 {name=l1257 lab=BL81}
N 40 27220 60 27220 {}
C {lab_pin.sym} 60 27220 0 0 {name=l1258 lab=BL82}
N 40 27240 60 27240 {}
C {lab_pin.sym} 60 27240 0 0 {name=l1259 lab=BL83}
N 40 27260 60 27260 {}
C {lab_pin.sym} 60 27260 0 0 {name=l1260 lab=BLB80}
N 40 27280 60 27280 {}
C {lab_pin.sym} 60 27280 0 0 {name=l1261 lab=BLB81}
N 40 27300 60 27300 {}
C {lab_pin.sym} 60 27300 0 0 {name=l1262 lab=BLB82}
N 40 27320 60 27320 {}
C {lab_pin.sym} 60 27320 0 0 {name=l1263 lab=BLB83}
N 0 27140 0 27120 {}
C {lab_pin.sym} 0 27120 0 0 {name=l1264 lab=VDD}
N 0 27380 0 27400 {}
C {lab_pin.sym} 0 27400 0 0 {name=l1265 lab=VSS}
C {io_slice.sym} 0 27730 0 0 {name=Xio20}
N -40 27580 -60 27580 {}
C {lab_pin.sym} -60 27580 0 0 {name=l1266 lab=csel0}
N -40 27600 -60 27600 {}
C {lab_pin.sym} -60 27600 0 0 {name=l1267 lab=csel1}
N -40 27620 -60 27620 {}
C {lab_pin.sym} -60 27620 0 0 {name=l1268 lab=csel2}
N -40 27640 -60 27640 {}
C {lab_pin.sym} -60 27640 0 0 {name=l1269 lab=csel3}
N -40 27660 -60 27660 {}
C {lab_pin.sym} -60 27660 0 0 {name=l1270 lab=cseln0}
N -40 27680 -60 27680 {}
C {lab_pin.sym} -60 27680 0 0 {name=l1271 lab=cseln1}
N -40 27700 -60 27700 {}
C {lab_pin.sym} -60 27700 0 0 {name=l1272 lab=cseln2}
N -40 27720 -60 27720 {}
C {lab_pin.sym} -60 27720 0 0 {name=l1273 lab=cseln3}
N -40 27740 -60 27740 {}
C {lab_pin.sym} -60 27740 0 0 {name=l1274 lab=D[20]}
N -40 27760 -60 27760 {}
C {lab_pin.sym} -60 27760 0 0 {name=l1275 lab=WEN[20]}
N -40 27780 -60 27780 {}
C {lab_pin.sym} -60 27780 0 0 {name=l1276 lab=clk_buf}
N -40 27800 -60 27800 {}
C {lab_pin.sym} -60 27800 0 0 {name=l1277 lab=q_clk}
N -40 27820 -60 27820 {}
C {lab_pin.sym} -60 27820 0 0 {name=l1278 lab=s_en}
N -40 27840 -60 27840 {}
C {lab_pin.sym} -60 27840 0 0 {name=l1279 lab=wl_en_n}
N -40 27860 -60 27860 {}
C {lab_pin.sym} -60 27860 0 0 {name=l1280 lab=wpn}
N 40 27580 60 27580 {}
C {lab_pin.sym} 60 27580 0 0 {name=l1281 lab=Q[20]}
N 40 27600 60 27600 {}
C {lab_pin.sym} 60 27600 0 0 {name=l1282 lab=BL80}
N 40 27620 60 27620 {}
C {lab_pin.sym} 60 27620 0 0 {name=l1283 lab=BL81}
N 40 27640 60 27640 {}
C {lab_pin.sym} 60 27640 0 0 {name=l1284 lab=BL82}
N 40 27660 60 27660 {}
C {lab_pin.sym} 60 27660 0 0 {name=l1285 lab=BL83}
N 40 27680 60 27680 {}
C {lab_pin.sym} 60 27680 0 0 {name=l1286 lab=BLB80}
N 40 27700 60 27700 {}
C {lab_pin.sym} 60 27700 0 0 {name=l1287 lab=BLB81}
N 40 27720 60 27720 {}
C {lab_pin.sym} 60 27720 0 0 {name=l1288 lab=BLB82}
N 40 27740 60 27740 {}
C {lab_pin.sym} 60 27740 0 0 {name=l1289 lab=BLB83}
N 0 27540 0 27520 {}
C {lab_pin.sym} 0 27520 0 0 {name=l1290 lab=VDD}
N 0 27920 0 27940 {}
C {lab_pin.sym} 0 27940 0 0 {name=l1291 lab=VSS}
C {precharge_slice.sym} 0 28200 0 0 {name=Xpc21}
N -40 28120 -60 28120 {}
C {lab_pin.sym} -60 28120 0 0 {name=l1292 lab=csel0}
N -40 28140 -60 28140 {}
C {lab_pin.sym} -60 28140 0 0 {name=l1293 lab=csel1}
N -40 28160 -60 28160 {}
C {lab_pin.sym} -60 28160 0 0 {name=l1294 lab=csel2}
N -40 28180 -60 28180 {}
C {lab_pin.sym} -60 28180 0 0 {name=l1295 lab=csel3}
N 40 28120 60 28120 {}
C {lab_pin.sym} 60 28120 0 0 {name=l1296 lab=BL84}
N 40 28140 60 28140 {}
C {lab_pin.sym} 60 28140 0 0 {name=l1297 lab=BL85}
N 40 28160 60 28160 {}
C {lab_pin.sym} 60 28160 0 0 {name=l1298 lab=BL86}
N 40 28180 60 28180 {}
C {lab_pin.sym} 60 28180 0 0 {name=l1299 lab=BL87}
N 40 28200 60 28200 {}
C {lab_pin.sym} 60 28200 0 0 {name=l1300 lab=BLB84}
N 40 28220 60 28220 {}
C {lab_pin.sym} 60 28220 0 0 {name=l1301 lab=BLB85}
N 40 28240 60 28240 {}
C {lab_pin.sym} 60 28240 0 0 {name=l1302 lab=BLB86}
N 40 28260 60 28260 {}
C {lab_pin.sym} 60 28260 0 0 {name=l1303 lab=BLB87}
N 0 28080 0 28060 {}
C {lab_pin.sym} 0 28060 0 0 {name=l1304 lab=VDD}
N 0 28320 0 28340 {}
C {lab_pin.sym} 0 28340 0 0 {name=l1305 lab=VSS}
C {io_slice.sym} 0 28670 0 0 {name=Xio21}
N -40 28520 -60 28520 {}
C {lab_pin.sym} -60 28520 0 0 {name=l1306 lab=csel0}
N -40 28540 -60 28540 {}
C {lab_pin.sym} -60 28540 0 0 {name=l1307 lab=csel1}
N -40 28560 -60 28560 {}
C {lab_pin.sym} -60 28560 0 0 {name=l1308 lab=csel2}
N -40 28580 -60 28580 {}
C {lab_pin.sym} -60 28580 0 0 {name=l1309 lab=csel3}
N -40 28600 -60 28600 {}
C {lab_pin.sym} -60 28600 0 0 {name=l1310 lab=cseln0}
N -40 28620 -60 28620 {}
C {lab_pin.sym} -60 28620 0 0 {name=l1311 lab=cseln1}
N -40 28640 -60 28640 {}
C {lab_pin.sym} -60 28640 0 0 {name=l1312 lab=cseln2}
N -40 28660 -60 28660 {}
C {lab_pin.sym} -60 28660 0 0 {name=l1313 lab=cseln3}
N -40 28680 -60 28680 {}
C {lab_pin.sym} -60 28680 0 0 {name=l1314 lab=D[21]}
N -40 28700 -60 28700 {}
C {lab_pin.sym} -60 28700 0 0 {name=l1315 lab=WEN[21]}
N -40 28720 -60 28720 {}
C {lab_pin.sym} -60 28720 0 0 {name=l1316 lab=clk_buf}
N -40 28740 -60 28740 {}
C {lab_pin.sym} -60 28740 0 0 {name=l1317 lab=q_clk}
N -40 28760 -60 28760 {}
C {lab_pin.sym} -60 28760 0 0 {name=l1318 lab=s_en}
N -40 28780 -60 28780 {}
C {lab_pin.sym} -60 28780 0 0 {name=l1319 lab=wl_en_n}
N -40 28800 -60 28800 {}
C {lab_pin.sym} -60 28800 0 0 {name=l1320 lab=wpn}
N 40 28520 60 28520 {}
C {lab_pin.sym} 60 28520 0 0 {name=l1321 lab=Q[21]}
N 40 28540 60 28540 {}
C {lab_pin.sym} 60 28540 0 0 {name=l1322 lab=BL84}
N 40 28560 60 28560 {}
C {lab_pin.sym} 60 28560 0 0 {name=l1323 lab=BL85}
N 40 28580 60 28580 {}
C {lab_pin.sym} 60 28580 0 0 {name=l1324 lab=BL86}
N 40 28600 60 28600 {}
C {lab_pin.sym} 60 28600 0 0 {name=l1325 lab=BL87}
N 40 28620 60 28620 {}
C {lab_pin.sym} 60 28620 0 0 {name=l1326 lab=BLB84}
N 40 28640 60 28640 {}
C {lab_pin.sym} 60 28640 0 0 {name=l1327 lab=BLB85}
N 40 28660 60 28660 {}
C {lab_pin.sym} 60 28660 0 0 {name=l1328 lab=BLB86}
N 40 28680 60 28680 {}
C {lab_pin.sym} 60 28680 0 0 {name=l1329 lab=BLB87}
N 0 28480 0 28460 {}
C {lab_pin.sym} 0 28460 0 0 {name=l1330 lab=VDD}
N 0 28860 0 28880 {}
C {lab_pin.sym} 0 28880 0 0 {name=l1331 lab=VSS}
C {precharge_slice.sym} 0 29140 0 0 {name=Xpc22}
N -40 29060 -60 29060 {}
C {lab_pin.sym} -60 29060 0 0 {name=l1332 lab=csel0}
N -40 29080 -60 29080 {}
C {lab_pin.sym} -60 29080 0 0 {name=l1333 lab=csel1}
N -40 29100 -60 29100 {}
C {lab_pin.sym} -60 29100 0 0 {name=l1334 lab=csel2}
N -40 29120 -60 29120 {}
C {lab_pin.sym} -60 29120 0 0 {name=l1335 lab=csel3}
N 40 29060 60 29060 {}
C {lab_pin.sym} 60 29060 0 0 {name=l1336 lab=BL88}
N 40 29080 60 29080 {}
C {lab_pin.sym} 60 29080 0 0 {name=l1337 lab=BL89}
N 40 29100 60 29100 {}
C {lab_pin.sym} 60 29100 0 0 {name=l1338 lab=BL90}
N 40 29120 60 29120 {}
C {lab_pin.sym} 60 29120 0 0 {name=l1339 lab=BL91}
N 40 29140 60 29140 {}
C {lab_pin.sym} 60 29140 0 0 {name=l1340 lab=BLB88}
N 40 29160 60 29160 {}
C {lab_pin.sym} 60 29160 0 0 {name=l1341 lab=BLB89}
N 40 29180 60 29180 {}
C {lab_pin.sym} 60 29180 0 0 {name=l1342 lab=BLB90}
N 40 29200 60 29200 {}
C {lab_pin.sym} 60 29200 0 0 {name=l1343 lab=BLB91}
N 0 29020 0 29000 {}
C {lab_pin.sym} 0 29000 0 0 {name=l1344 lab=VDD}
N 0 29260 0 29280 {}
C {lab_pin.sym} 0 29280 0 0 {name=l1345 lab=VSS}
C {io_slice.sym} 0 29610 0 0 {name=Xio22}
N -40 29460 -60 29460 {}
C {lab_pin.sym} -60 29460 0 0 {name=l1346 lab=csel0}
N -40 29480 -60 29480 {}
C {lab_pin.sym} -60 29480 0 0 {name=l1347 lab=csel1}
N -40 29500 -60 29500 {}
C {lab_pin.sym} -60 29500 0 0 {name=l1348 lab=csel2}
N -40 29520 -60 29520 {}
C {lab_pin.sym} -60 29520 0 0 {name=l1349 lab=csel3}
N -40 29540 -60 29540 {}
C {lab_pin.sym} -60 29540 0 0 {name=l1350 lab=cseln0}
N -40 29560 -60 29560 {}
C {lab_pin.sym} -60 29560 0 0 {name=l1351 lab=cseln1}
N -40 29580 -60 29580 {}
C {lab_pin.sym} -60 29580 0 0 {name=l1352 lab=cseln2}
N -40 29600 -60 29600 {}
C {lab_pin.sym} -60 29600 0 0 {name=l1353 lab=cseln3}
N -40 29620 -60 29620 {}
C {lab_pin.sym} -60 29620 0 0 {name=l1354 lab=D[22]}
N -40 29640 -60 29640 {}
C {lab_pin.sym} -60 29640 0 0 {name=l1355 lab=WEN[22]}
N -40 29660 -60 29660 {}
C {lab_pin.sym} -60 29660 0 0 {name=l1356 lab=clk_buf}
N -40 29680 -60 29680 {}
C {lab_pin.sym} -60 29680 0 0 {name=l1357 lab=q_clk}
N -40 29700 -60 29700 {}
C {lab_pin.sym} -60 29700 0 0 {name=l1358 lab=s_en}
N -40 29720 -60 29720 {}
C {lab_pin.sym} -60 29720 0 0 {name=l1359 lab=wl_en_n}
N -40 29740 -60 29740 {}
C {lab_pin.sym} -60 29740 0 0 {name=l1360 lab=wpn}
N 40 29460 60 29460 {}
C {lab_pin.sym} 60 29460 0 0 {name=l1361 lab=Q[22]}
N 40 29480 60 29480 {}
C {lab_pin.sym} 60 29480 0 0 {name=l1362 lab=BL88}
N 40 29500 60 29500 {}
C {lab_pin.sym} 60 29500 0 0 {name=l1363 lab=BL89}
N 40 29520 60 29520 {}
C {lab_pin.sym} 60 29520 0 0 {name=l1364 lab=BL90}
N 40 29540 60 29540 {}
C {lab_pin.sym} 60 29540 0 0 {name=l1365 lab=BL91}
N 40 29560 60 29560 {}
C {lab_pin.sym} 60 29560 0 0 {name=l1366 lab=BLB88}
N 40 29580 60 29580 {}
C {lab_pin.sym} 60 29580 0 0 {name=l1367 lab=BLB89}
N 40 29600 60 29600 {}
C {lab_pin.sym} 60 29600 0 0 {name=l1368 lab=BLB90}
N 40 29620 60 29620 {}
C {lab_pin.sym} 60 29620 0 0 {name=l1369 lab=BLB91}
N 0 29420 0 29400 {}
C {lab_pin.sym} 0 29400 0 0 {name=l1370 lab=VDD}
N 0 29800 0 29820 {}
C {lab_pin.sym} 0 29820 0 0 {name=l1371 lab=VSS}
C {precharge_slice.sym} 0 30080 0 0 {name=Xpc23}
N -40 30000 -60 30000 {}
C {lab_pin.sym} -60 30000 0 0 {name=l1372 lab=csel0}
N -40 30020 -60 30020 {}
C {lab_pin.sym} -60 30020 0 0 {name=l1373 lab=csel1}
N -40 30040 -60 30040 {}
C {lab_pin.sym} -60 30040 0 0 {name=l1374 lab=csel2}
N -40 30060 -60 30060 {}
C {lab_pin.sym} -60 30060 0 0 {name=l1375 lab=csel3}
N 40 30000 60 30000 {}
C {lab_pin.sym} 60 30000 0 0 {name=l1376 lab=BL92}
N 40 30020 60 30020 {}
C {lab_pin.sym} 60 30020 0 0 {name=l1377 lab=BL93}
N 40 30040 60 30040 {}
C {lab_pin.sym} 60 30040 0 0 {name=l1378 lab=BL94}
N 40 30060 60 30060 {}
C {lab_pin.sym} 60 30060 0 0 {name=l1379 lab=BL95}
N 40 30080 60 30080 {}
C {lab_pin.sym} 60 30080 0 0 {name=l1380 lab=BLB92}
N 40 30100 60 30100 {}
C {lab_pin.sym} 60 30100 0 0 {name=l1381 lab=BLB93}
N 40 30120 60 30120 {}
C {lab_pin.sym} 60 30120 0 0 {name=l1382 lab=BLB94}
N 40 30140 60 30140 {}
C {lab_pin.sym} 60 30140 0 0 {name=l1383 lab=BLB95}
N 0 29960 0 29940 {}
C {lab_pin.sym} 0 29940 0 0 {name=l1384 lab=VDD}
N 0 30200 0 30220 {}
C {lab_pin.sym} 0 30220 0 0 {name=l1385 lab=VSS}
C {io_slice.sym} 0 30550 0 0 {name=Xio23}
N -40 30400 -60 30400 {}
C {lab_pin.sym} -60 30400 0 0 {name=l1386 lab=csel0}
N -40 30420 -60 30420 {}
C {lab_pin.sym} -60 30420 0 0 {name=l1387 lab=csel1}
N -40 30440 -60 30440 {}
C {lab_pin.sym} -60 30440 0 0 {name=l1388 lab=csel2}
N -40 30460 -60 30460 {}
C {lab_pin.sym} -60 30460 0 0 {name=l1389 lab=csel3}
N -40 30480 -60 30480 {}
C {lab_pin.sym} -60 30480 0 0 {name=l1390 lab=cseln0}
N -40 30500 -60 30500 {}
C {lab_pin.sym} -60 30500 0 0 {name=l1391 lab=cseln1}
N -40 30520 -60 30520 {}
C {lab_pin.sym} -60 30520 0 0 {name=l1392 lab=cseln2}
N -40 30540 -60 30540 {}
C {lab_pin.sym} -60 30540 0 0 {name=l1393 lab=cseln3}
N -40 30560 -60 30560 {}
C {lab_pin.sym} -60 30560 0 0 {name=l1394 lab=D[23]}
N -40 30580 -60 30580 {}
C {lab_pin.sym} -60 30580 0 0 {name=l1395 lab=WEN[23]}
N -40 30600 -60 30600 {}
C {lab_pin.sym} -60 30600 0 0 {name=l1396 lab=clk_buf}
N -40 30620 -60 30620 {}
C {lab_pin.sym} -60 30620 0 0 {name=l1397 lab=q_clk}
N -40 30640 -60 30640 {}
C {lab_pin.sym} -60 30640 0 0 {name=l1398 lab=s_en}
N -40 30660 -60 30660 {}
C {lab_pin.sym} -60 30660 0 0 {name=l1399 lab=wl_en_n}
N -40 30680 -60 30680 {}
C {lab_pin.sym} -60 30680 0 0 {name=l1400 lab=wpn}
N 40 30400 60 30400 {}
C {lab_pin.sym} 60 30400 0 0 {name=l1401 lab=Q[23]}
N 40 30420 60 30420 {}
C {lab_pin.sym} 60 30420 0 0 {name=l1402 lab=BL92}
N 40 30440 60 30440 {}
C {lab_pin.sym} 60 30440 0 0 {name=l1403 lab=BL93}
N 40 30460 60 30460 {}
C {lab_pin.sym} 60 30460 0 0 {name=l1404 lab=BL94}
N 40 30480 60 30480 {}
C {lab_pin.sym} 60 30480 0 0 {name=l1405 lab=BL95}
N 40 30500 60 30500 {}
C {lab_pin.sym} 60 30500 0 0 {name=l1406 lab=BLB92}
N 40 30520 60 30520 {}
C {lab_pin.sym} 60 30520 0 0 {name=l1407 lab=BLB93}
N 40 30540 60 30540 {}
C {lab_pin.sym} 60 30540 0 0 {name=l1408 lab=BLB94}
N 40 30560 60 30560 {}
C {lab_pin.sym} 60 30560 0 0 {name=l1409 lab=BLB95}
N 0 30360 0 30340 {}
C {lab_pin.sym} 0 30340 0 0 {name=l1410 lab=VDD}
N 0 30740 0 30760 {}
C {lab_pin.sym} 0 30760 0 0 {name=l1411 lab=VSS}
C {precharge_slice.sym} 0 31020 0 0 {name=Xpc24}
N -40 30940 -60 30940 {}
C {lab_pin.sym} -60 30940 0 0 {name=l1412 lab=csel0}
N -40 30960 -60 30960 {}
C {lab_pin.sym} -60 30960 0 0 {name=l1413 lab=csel1}
N -40 30980 -60 30980 {}
C {lab_pin.sym} -60 30980 0 0 {name=l1414 lab=csel2}
N -40 31000 -60 31000 {}
C {lab_pin.sym} -60 31000 0 0 {name=l1415 lab=csel3}
N 40 30940 60 30940 {}
C {lab_pin.sym} 60 30940 0 0 {name=l1416 lab=BL96}
N 40 30960 60 30960 {}
C {lab_pin.sym} 60 30960 0 0 {name=l1417 lab=BL97}
N 40 30980 60 30980 {}
C {lab_pin.sym} 60 30980 0 0 {name=l1418 lab=BL98}
N 40 31000 60 31000 {}
C {lab_pin.sym} 60 31000 0 0 {name=l1419 lab=BL99}
N 40 31020 60 31020 {}
C {lab_pin.sym} 60 31020 0 0 {name=l1420 lab=BLB96}
N 40 31040 60 31040 {}
C {lab_pin.sym} 60 31040 0 0 {name=l1421 lab=BLB97}
N 40 31060 60 31060 {}
C {lab_pin.sym} 60 31060 0 0 {name=l1422 lab=BLB98}
N 40 31080 60 31080 {}
C {lab_pin.sym} 60 31080 0 0 {name=l1423 lab=BLB99}
N 0 30900 0 30880 {}
C {lab_pin.sym} 0 30880 0 0 {name=l1424 lab=VDD}
N 0 31140 0 31160 {}
C {lab_pin.sym} 0 31160 0 0 {name=l1425 lab=VSS}
C {io_slice.sym} 0 31490 0 0 {name=Xio24}
N -40 31340 -60 31340 {}
C {lab_pin.sym} -60 31340 0 0 {name=l1426 lab=csel0}
N -40 31360 -60 31360 {}
C {lab_pin.sym} -60 31360 0 0 {name=l1427 lab=csel1}
N -40 31380 -60 31380 {}
C {lab_pin.sym} -60 31380 0 0 {name=l1428 lab=csel2}
N -40 31400 -60 31400 {}
C {lab_pin.sym} -60 31400 0 0 {name=l1429 lab=csel3}
N -40 31420 -60 31420 {}
C {lab_pin.sym} -60 31420 0 0 {name=l1430 lab=cseln0}
N -40 31440 -60 31440 {}
C {lab_pin.sym} -60 31440 0 0 {name=l1431 lab=cseln1}
N -40 31460 -60 31460 {}
C {lab_pin.sym} -60 31460 0 0 {name=l1432 lab=cseln2}
N -40 31480 -60 31480 {}
C {lab_pin.sym} -60 31480 0 0 {name=l1433 lab=cseln3}
N -40 31500 -60 31500 {}
C {lab_pin.sym} -60 31500 0 0 {name=l1434 lab=D[24]}
N -40 31520 -60 31520 {}
C {lab_pin.sym} -60 31520 0 0 {name=l1435 lab=WEN[24]}
N -40 31540 -60 31540 {}
C {lab_pin.sym} -60 31540 0 0 {name=l1436 lab=clk_buf}
N -40 31560 -60 31560 {}
C {lab_pin.sym} -60 31560 0 0 {name=l1437 lab=q_clk}
N -40 31580 -60 31580 {}
C {lab_pin.sym} -60 31580 0 0 {name=l1438 lab=s_en}
N -40 31600 -60 31600 {}
C {lab_pin.sym} -60 31600 0 0 {name=l1439 lab=wl_en_n}
N -40 31620 -60 31620 {}
C {lab_pin.sym} -60 31620 0 0 {name=l1440 lab=wpn}
N 40 31340 60 31340 {}
C {lab_pin.sym} 60 31340 0 0 {name=l1441 lab=Q[24]}
N 40 31360 60 31360 {}
C {lab_pin.sym} 60 31360 0 0 {name=l1442 lab=BL96}
N 40 31380 60 31380 {}
C {lab_pin.sym} 60 31380 0 0 {name=l1443 lab=BL97}
N 40 31400 60 31400 {}
C {lab_pin.sym} 60 31400 0 0 {name=l1444 lab=BL98}
N 40 31420 60 31420 {}
C {lab_pin.sym} 60 31420 0 0 {name=l1445 lab=BL99}
N 40 31440 60 31440 {}
C {lab_pin.sym} 60 31440 0 0 {name=l1446 lab=BLB96}
N 40 31460 60 31460 {}
C {lab_pin.sym} 60 31460 0 0 {name=l1447 lab=BLB97}
N 40 31480 60 31480 {}
C {lab_pin.sym} 60 31480 0 0 {name=l1448 lab=BLB98}
N 40 31500 60 31500 {}
C {lab_pin.sym} 60 31500 0 0 {name=l1449 lab=BLB99}
N 0 31300 0 31280 {}
C {lab_pin.sym} 0 31280 0 0 {name=l1450 lab=VDD}
N 0 31680 0 31700 {}
C {lab_pin.sym} 0 31700 0 0 {name=l1451 lab=VSS}
C {precharge_slice.sym} 0 31960 0 0 {name=Xpc25}
N -40 31880 -60 31880 {}
C {lab_pin.sym} -60 31880 0 0 {name=l1452 lab=csel0}
N -40 31900 -60 31900 {}
C {lab_pin.sym} -60 31900 0 0 {name=l1453 lab=csel1}
N -40 31920 -60 31920 {}
C {lab_pin.sym} -60 31920 0 0 {name=l1454 lab=csel2}
N -40 31940 -60 31940 {}
C {lab_pin.sym} -60 31940 0 0 {name=l1455 lab=csel3}
N 40 31880 60 31880 {}
C {lab_pin.sym} 60 31880 0 0 {name=l1456 lab=BL100}
N 40 31900 60 31900 {}
C {lab_pin.sym} 60 31900 0 0 {name=l1457 lab=BL101}
N 40 31920 60 31920 {}
C {lab_pin.sym} 60 31920 0 0 {name=l1458 lab=BL102}
N 40 31940 60 31940 {}
C {lab_pin.sym} 60 31940 0 0 {name=l1459 lab=BL103}
N 40 31960 60 31960 {}
C {lab_pin.sym} 60 31960 0 0 {name=l1460 lab=BLB100}
N 40 31980 60 31980 {}
C {lab_pin.sym} 60 31980 0 0 {name=l1461 lab=BLB101}
N 40 32000 60 32000 {}
C {lab_pin.sym} 60 32000 0 0 {name=l1462 lab=BLB102}
N 40 32020 60 32020 {}
C {lab_pin.sym} 60 32020 0 0 {name=l1463 lab=BLB103}
N 0 31840 0 31820 {}
C {lab_pin.sym} 0 31820 0 0 {name=l1464 lab=VDD}
N 0 32080 0 32100 {}
C {lab_pin.sym} 0 32100 0 0 {name=l1465 lab=VSS}
C {io_slice.sym} 0 32430 0 0 {name=Xio25}
N -40 32280 -60 32280 {}
C {lab_pin.sym} -60 32280 0 0 {name=l1466 lab=csel0}
N -40 32300 -60 32300 {}
C {lab_pin.sym} -60 32300 0 0 {name=l1467 lab=csel1}
N -40 32320 -60 32320 {}
C {lab_pin.sym} -60 32320 0 0 {name=l1468 lab=csel2}
N -40 32340 -60 32340 {}
C {lab_pin.sym} -60 32340 0 0 {name=l1469 lab=csel3}
N -40 32360 -60 32360 {}
C {lab_pin.sym} -60 32360 0 0 {name=l1470 lab=cseln0}
N -40 32380 -60 32380 {}
C {lab_pin.sym} -60 32380 0 0 {name=l1471 lab=cseln1}
N -40 32400 -60 32400 {}
C {lab_pin.sym} -60 32400 0 0 {name=l1472 lab=cseln2}
N -40 32420 -60 32420 {}
C {lab_pin.sym} -60 32420 0 0 {name=l1473 lab=cseln3}
N -40 32440 -60 32440 {}
C {lab_pin.sym} -60 32440 0 0 {name=l1474 lab=D[25]}
N -40 32460 -60 32460 {}
C {lab_pin.sym} -60 32460 0 0 {name=l1475 lab=WEN[25]}
N -40 32480 -60 32480 {}
C {lab_pin.sym} -60 32480 0 0 {name=l1476 lab=clk_buf}
N -40 32500 -60 32500 {}
C {lab_pin.sym} -60 32500 0 0 {name=l1477 lab=q_clk}
N -40 32520 -60 32520 {}
C {lab_pin.sym} -60 32520 0 0 {name=l1478 lab=s_en}
N -40 32540 -60 32540 {}
C {lab_pin.sym} -60 32540 0 0 {name=l1479 lab=wl_en_n}
N -40 32560 -60 32560 {}
C {lab_pin.sym} -60 32560 0 0 {name=l1480 lab=wpn}
N 40 32280 60 32280 {}
C {lab_pin.sym} 60 32280 0 0 {name=l1481 lab=Q[25]}
N 40 32300 60 32300 {}
C {lab_pin.sym} 60 32300 0 0 {name=l1482 lab=BL100}
N 40 32320 60 32320 {}
C {lab_pin.sym} 60 32320 0 0 {name=l1483 lab=BL101}
N 40 32340 60 32340 {}
C {lab_pin.sym} 60 32340 0 0 {name=l1484 lab=BL102}
N 40 32360 60 32360 {}
C {lab_pin.sym} 60 32360 0 0 {name=l1485 lab=BL103}
N 40 32380 60 32380 {}
C {lab_pin.sym} 60 32380 0 0 {name=l1486 lab=BLB100}
N 40 32400 60 32400 {}
C {lab_pin.sym} 60 32400 0 0 {name=l1487 lab=BLB101}
N 40 32420 60 32420 {}
C {lab_pin.sym} 60 32420 0 0 {name=l1488 lab=BLB102}
N 40 32440 60 32440 {}
C {lab_pin.sym} 60 32440 0 0 {name=l1489 lab=BLB103}
N 0 32240 0 32220 {}
C {lab_pin.sym} 0 32220 0 0 {name=l1490 lab=VDD}
N 0 32620 0 32640 {}
C {lab_pin.sym} 0 32640 0 0 {name=l1491 lab=VSS}
C {precharge_slice.sym} 0 32900 0 0 {name=Xpc26}
N -40 32820 -60 32820 {}
C {lab_pin.sym} -60 32820 0 0 {name=l1492 lab=csel0}
N -40 32840 -60 32840 {}
C {lab_pin.sym} -60 32840 0 0 {name=l1493 lab=csel1}
N -40 32860 -60 32860 {}
C {lab_pin.sym} -60 32860 0 0 {name=l1494 lab=csel2}
N -40 32880 -60 32880 {}
C {lab_pin.sym} -60 32880 0 0 {name=l1495 lab=csel3}
N 40 32820 60 32820 {}
C {lab_pin.sym} 60 32820 0 0 {name=l1496 lab=BL104}
N 40 32840 60 32840 {}
C {lab_pin.sym} 60 32840 0 0 {name=l1497 lab=BL105}
N 40 32860 60 32860 {}
C {lab_pin.sym} 60 32860 0 0 {name=l1498 lab=BL106}
N 40 32880 60 32880 {}
C {lab_pin.sym} 60 32880 0 0 {name=l1499 lab=BL107}
N 40 32900 60 32900 {}
C {lab_pin.sym} 60 32900 0 0 {name=l1500 lab=BLB104}
N 40 32920 60 32920 {}
C {lab_pin.sym} 60 32920 0 0 {name=l1501 lab=BLB105}
N 40 32940 60 32940 {}
C {lab_pin.sym} 60 32940 0 0 {name=l1502 lab=BLB106}
N 40 32960 60 32960 {}
C {lab_pin.sym} 60 32960 0 0 {name=l1503 lab=BLB107}
N 0 32780 0 32760 {}
C {lab_pin.sym} 0 32760 0 0 {name=l1504 lab=VDD}
N 0 33020 0 33040 {}
C {lab_pin.sym} 0 33040 0 0 {name=l1505 lab=VSS}
C {io_slice.sym} 0 33370 0 0 {name=Xio26}
N -40 33220 -60 33220 {}
C {lab_pin.sym} -60 33220 0 0 {name=l1506 lab=csel0}
N -40 33240 -60 33240 {}
C {lab_pin.sym} -60 33240 0 0 {name=l1507 lab=csel1}
N -40 33260 -60 33260 {}
C {lab_pin.sym} -60 33260 0 0 {name=l1508 lab=csel2}
N -40 33280 -60 33280 {}
C {lab_pin.sym} -60 33280 0 0 {name=l1509 lab=csel3}
N -40 33300 -60 33300 {}
C {lab_pin.sym} -60 33300 0 0 {name=l1510 lab=cseln0}
N -40 33320 -60 33320 {}
C {lab_pin.sym} -60 33320 0 0 {name=l1511 lab=cseln1}
N -40 33340 -60 33340 {}
C {lab_pin.sym} -60 33340 0 0 {name=l1512 lab=cseln2}
N -40 33360 -60 33360 {}
C {lab_pin.sym} -60 33360 0 0 {name=l1513 lab=cseln3}
N -40 33380 -60 33380 {}
C {lab_pin.sym} -60 33380 0 0 {name=l1514 lab=D[26]}
N -40 33400 -60 33400 {}
C {lab_pin.sym} -60 33400 0 0 {name=l1515 lab=WEN[26]}
N -40 33420 -60 33420 {}
C {lab_pin.sym} -60 33420 0 0 {name=l1516 lab=clk_buf}
N -40 33440 -60 33440 {}
C {lab_pin.sym} -60 33440 0 0 {name=l1517 lab=q_clk}
N -40 33460 -60 33460 {}
C {lab_pin.sym} -60 33460 0 0 {name=l1518 lab=s_en}
N -40 33480 -60 33480 {}
C {lab_pin.sym} -60 33480 0 0 {name=l1519 lab=wl_en_n}
N -40 33500 -60 33500 {}
C {lab_pin.sym} -60 33500 0 0 {name=l1520 lab=wpn}
N 40 33220 60 33220 {}
C {lab_pin.sym} 60 33220 0 0 {name=l1521 lab=Q[26]}
N 40 33240 60 33240 {}
C {lab_pin.sym} 60 33240 0 0 {name=l1522 lab=BL104}
N 40 33260 60 33260 {}
C {lab_pin.sym} 60 33260 0 0 {name=l1523 lab=BL105}
N 40 33280 60 33280 {}
C {lab_pin.sym} 60 33280 0 0 {name=l1524 lab=BL106}
N 40 33300 60 33300 {}
C {lab_pin.sym} 60 33300 0 0 {name=l1525 lab=BL107}
N 40 33320 60 33320 {}
C {lab_pin.sym} 60 33320 0 0 {name=l1526 lab=BLB104}
N 40 33340 60 33340 {}
C {lab_pin.sym} 60 33340 0 0 {name=l1527 lab=BLB105}
N 40 33360 60 33360 {}
C {lab_pin.sym} 60 33360 0 0 {name=l1528 lab=BLB106}
N 40 33380 60 33380 {}
C {lab_pin.sym} 60 33380 0 0 {name=l1529 lab=BLB107}
N 0 33180 0 33160 {}
C {lab_pin.sym} 0 33160 0 0 {name=l1530 lab=VDD}
N 0 33560 0 33580 {}
C {lab_pin.sym} 0 33580 0 0 {name=l1531 lab=VSS}
C {precharge_slice.sym} 0 33840 0 0 {name=Xpc27}
N -40 33760 -60 33760 {}
C {lab_pin.sym} -60 33760 0 0 {name=l1532 lab=csel0}
N -40 33780 -60 33780 {}
C {lab_pin.sym} -60 33780 0 0 {name=l1533 lab=csel1}
N -40 33800 -60 33800 {}
C {lab_pin.sym} -60 33800 0 0 {name=l1534 lab=csel2}
N -40 33820 -60 33820 {}
C {lab_pin.sym} -60 33820 0 0 {name=l1535 lab=csel3}
N 40 33760 60 33760 {}
C {lab_pin.sym} 60 33760 0 0 {name=l1536 lab=BL108}
N 40 33780 60 33780 {}
C {lab_pin.sym} 60 33780 0 0 {name=l1537 lab=BL109}
N 40 33800 60 33800 {}
C {lab_pin.sym} 60 33800 0 0 {name=l1538 lab=BL110}
N 40 33820 60 33820 {}
C {lab_pin.sym} 60 33820 0 0 {name=l1539 lab=BL111}
N 40 33840 60 33840 {}
C {lab_pin.sym} 60 33840 0 0 {name=l1540 lab=BLB108}
N 40 33860 60 33860 {}
C {lab_pin.sym} 60 33860 0 0 {name=l1541 lab=BLB109}
N 40 33880 60 33880 {}
C {lab_pin.sym} 60 33880 0 0 {name=l1542 lab=BLB110}
N 40 33900 60 33900 {}
C {lab_pin.sym} 60 33900 0 0 {name=l1543 lab=BLB111}
N 0 33720 0 33700 {}
C {lab_pin.sym} 0 33700 0 0 {name=l1544 lab=VDD}
N 0 33960 0 33980 {}
C {lab_pin.sym} 0 33980 0 0 {name=l1545 lab=VSS}
C {io_slice.sym} 0 34310 0 0 {name=Xio27}
N -40 34160 -60 34160 {}
C {lab_pin.sym} -60 34160 0 0 {name=l1546 lab=csel0}
N -40 34180 -60 34180 {}
C {lab_pin.sym} -60 34180 0 0 {name=l1547 lab=csel1}
N -40 34200 -60 34200 {}
C {lab_pin.sym} -60 34200 0 0 {name=l1548 lab=csel2}
N -40 34220 -60 34220 {}
C {lab_pin.sym} -60 34220 0 0 {name=l1549 lab=csel3}
N -40 34240 -60 34240 {}
C {lab_pin.sym} -60 34240 0 0 {name=l1550 lab=cseln0}
N -40 34260 -60 34260 {}
C {lab_pin.sym} -60 34260 0 0 {name=l1551 lab=cseln1}
N -40 34280 -60 34280 {}
C {lab_pin.sym} -60 34280 0 0 {name=l1552 lab=cseln2}
N -40 34300 -60 34300 {}
C {lab_pin.sym} -60 34300 0 0 {name=l1553 lab=cseln3}
N -40 34320 -60 34320 {}
C {lab_pin.sym} -60 34320 0 0 {name=l1554 lab=D[27]}
N -40 34340 -60 34340 {}
C {lab_pin.sym} -60 34340 0 0 {name=l1555 lab=WEN[27]}
N -40 34360 -60 34360 {}
C {lab_pin.sym} -60 34360 0 0 {name=l1556 lab=clk_buf}
N -40 34380 -60 34380 {}
C {lab_pin.sym} -60 34380 0 0 {name=l1557 lab=q_clk}
N -40 34400 -60 34400 {}
C {lab_pin.sym} -60 34400 0 0 {name=l1558 lab=s_en}
N -40 34420 -60 34420 {}
C {lab_pin.sym} -60 34420 0 0 {name=l1559 lab=wl_en_n}
N -40 34440 -60 34440 {}
C {lab_pin.sym} -60 34440 0 0 {name=l1560 lab=wpn}
N 40 34160 60 34160 {}
C {lab_pin.sym} 60 34160 0 0 {name=l1561 lab=Q[27]}
N 40 34180 60 34180 {}
C {lab_pin.sym} 60 34180 0 0 {name=l1562 lab=BL108}
N 40 34200 60 34200 {}
C {lab_pin.sym} 60 34200 0 0 {name=l1563 lab=BL109}
N 40 34220 60 34220 {}
C {lab_pin.sym} 60 34220 0 0 {name=l1564 lab=BL110}
N 40 34240 60 34240 {}
C {lab_pin.sym} 60 34240 0 0 {name=l1565 lab=BL111}
N 40 34260 60 34260 {}
C {lab_pin.sym} 60 34260 0 0 {name=l1566 lab=BLB108}
N 40 34280 60 34280 {}
C {lab_pin.sym} 60 34280 0 0 {name=l1567 lab=BLB109}
N 40 34300 60 34300 {}
C {lab_pin.sym} 60 34300 0 0 {name=l1568 lab=BLB110}
N 40 34320 60 34320 {}
C {lab_pin.sym} 60 34320 0 0 {name=l1569 lab=BLB111}
N 0 34120 0 34100 {}
C {lab_pin.sym} 0 34100 0 0 {name=l1570 lab=VDD}
N 0 34500 0 34520 {}
C {lab_pin.sym} 0 34520 0 0 {name=l1571 lab=VSS}
C {precharge_slice.sym} 0 34780 0 0 {name=Xpc28}
N -40 34700 -60 34700 {}
C {lab_pin.sym} -60 34700 0 0 {name=l1572 lab=csel0}
N -40 34720 -60 34720 {}
C {lab_pin.sym} -60 34720 0 0 {name=l1573 lab=csel1}
N -40 34740 -60 34740 {}
C {lab_pin.sym} -60 34740 0 0 {name=l1574 lab=csel2}
N -40 34760 -60 34760 {}
C {lab_pin.sym} -60 34760 0 0 {name=l1575 lab=csel3}
N 40 34700 60 34700 {}
C {lab_pin.sym} 60 34700 0 0 {name=l1576 lab=BL112}
N 40 34720 60 34720 {}
C {lab_pin.sym} 60 34720 0 0 {name=l1577 lab=BL113}
N 40 34740 60 34740 {}
C {lab_pin.sym} 60 34740 0 0 {name=l1578 lab=BL114}
N 40 34760 60 34760 {}
C {lab_pin.sym} 60 34760 0 0 {name=l1579 lab=BL115}
N 40 34780 60 34780 {}
C {lab_pin.sym} 60 34780 0 0 {name=l1580 lab=BLB112}
N 40 34800 60 34800 {}
C {lab_pin.sym} 60 34800 0 0 {name=l1581 lab=BLB113}
N 40 34820 60 34820 {}
C {lab_pin.sym} 60 34820 0 0 {name=l1582 lab=BLB114}
N 40 34840 60 34840 {}
C {lab_pin.sym} 60 34840 0 0 {name=l1583 lab=BLB115}
N 0 34660 0 34640 {}
C {lab_pin.sym} 0 34640 0 0 {name=l1584 lab=VDD}
N 0 34900 0 34920 {}
C {lab_pin.sym} 0 34920 0 0 {name=l1585 lab=VSS}
C {io_slice.sym} 0 35250 0 0 {name=Xio28}
N -40 35100 -60 35100 {}
C {lab_pin.sym} -60 35100 0 0 {name=l1586 lab=csel0}
N -40 35120 -60 35120 {}
C {lab_pin.sym} -60 35120 0 0 {name=l1587 lab=csel1}
N -40 35140 -60 35140 {}
C {lab_pin.sym} -60 35140 0 0 {name=l1588 lab=csel2}
N -40 35160 -60 35160 {}
C {lab_pin.sym} -60 35160 0 0 {name=l1589 lab=csel3}
N -40 35180 -60 35180 {}
C {lab_pin.sym} -60 35180 0 0 {name=l1590 lab=cseln0}
N -40 35200 -60 35200 {}
C {lab_pin.sym} -60 35200 0 0 {name=l1591 lab=cseln1}
N -40 35220 -60 35220 {}
C {lab_pin.sym} -60 35220 0 0 {name=l1592 lab=cseln2}
N -40 35240 -60 35240 {}
C {lab_pin.sym} -60 35240 0 0 {name=l1593 lab=cseln3}
N -40 35260 -60 35260 {}
C {lab_pin.sym} -60 35260 0 0 {name=l1594 lab=D[28]}
N -40 35280 -60 35280 {}
C {lab_pin.sym} -60 35280 0 0 {name=l1595 lab=WEN[28]}
N -40 35300 -60 35300 {}
C {lab_pin.sym} -60 35300 0 0 {name=l1596 lab=clk_buf}
N -40 35320 -60 35320 {}
C {lab_pin.sym} -60 35320 0 0 {name=l1597 lab=q_clk}
N -40 35340 -60 35340 {}
C {lab_pin.sym} -60 35340 0 0 {name=l1598 lab=s_en}
N -40 35360 -60 35360 {}
C {lab_pin.sym} -60 35360 0 0 {name=l1599 lab=wl_en_n}
N -40 35380 -60 35380 {}
C {lab_pin.sym} -60 35380 0 0 {name=l1600 lab=wpn}
N 40 35100 60 35100 {}
C {lab_pin.sym} 60 35100 0 0 {name=l1601 lab=Q[28]}
N 40 35120 60 35120 {}
C {lab_pin.sym} 60 35120 0 0 {name=l1602 lab=BL112}
N 40 35140 60 35140 {}
C {lab_pin.sym} 60 35140 0 0 {name=l1603 lab=BL113}
N 40 35160 60 35160 {}
C {lab_pin.sym} 60 35160 0 0 {name=l1604 lab=BL114}
N 40 35180 60 35180 {}
C {lab_pin.sym} 60 35180 0 0 {name=l1605 lab=BL115}
N 40 35200 60 35200 {}
C {lab_pin.sym} 60 35200 0 0 {name=l1606 lab=BLB112}
N 40 35220 60 35220 {}
C {lab_pin.sym} 60 35220 0 0 {name=l1607 lab=BLB113}
N 40 35240 60 35240 {}
C {lab_pin.sym} 60 35240 0 0 {name=l1608 lab=BLB114}
N 40 35260 60 35260 {}
C {lab_pin.sym} 60 35260 0 0 {name=l1609 lab=BLB115}
N 0 35060 0 35040 {}
C {lab_pin.sym} 0 35040 0 0 {name=l1610 lab=VDD}
N 0 35440 0 35460 {}
C {lab_pin.sym} 0 35460 0 0 {name=l1611 lab=VSS}
C {precharge_slice.sym} 0 35720 0 0 {name=Xpc29}
N -40 35640 -60 35640 {}
C {lab_pin.sym} -60 35640 0 0 {name=l1612 lab=csel0}
N -40 35660 -60 35660 {}
C {lab_pin.sym} -60 35660 0 0 {name=l1613 lab=csel1}
N -40 35680 -60 35680 {}
C {lab_pin.sym} -60 35680 0 0 {name=l1614 lab=csel2}
N -40 35700 -60 35700 {}
C {lab_pin.sym} -60 35700 0 0 {name=l1615 lab=csel3}
N 40 35640 60 35640 {}
C {lab_pin.sym} 60 35640 0 0 {name=l1616 lab=BL116}
N 40 35660 60 35660 {}
C {lab_pin.sym} 60 35660 0 0 {name=l1617 lab=BL117}
N 40 35680 60 35680 {}
C {lab_pin.sym} 60 35680 0 0 {name=l1618 lab=BL118}
N 40 35700 60 35700 {}
C {lab_pin.sym} 60 35700 0 0 {name=l1619 lab=BL119}
N 40 35720 60 35720 {}
C {lab_pin.sym} 60 35720 0 0 {name=l1620 lab=BLB116}
N 40 35740 60 35740 {}
C {lab_pin.sym} 60 35740 0 0 {name=l1621 lab=BLB117}
N 40 35760 60 35760 {}
C {lab_pin.sym} 60 35760 0 0 {name=l1622 lab=BLB118}
N 40 35780 60 35780 {}
C {lab_pin.sym} 60 35780 0 0 {name=l1623 lab=BLB119}
N 0 35600 0 35580 {}
C {lab_pin.sym} 0 35580 0 0 {name=l1624 lab=VDD}
N 0 35840 0 35860 {}
C {lab_pin.sym} 0 35860 0 0 {name=l1625 lab=VSS}
C {io_slice.sym} 0 36190 0 0 {name=Xio29}
N -40 36040 -60 36040 {}
C {lab_pin.sym} -60 36040 0 0 {name=l1626 lab=csel0}
N -40 36060 -60 36060 {}
C {lab_pin.sym} -60 36060 0 0 {name=l1627 lab=csel1}
N -40 36080 -60 36080 {}
C {lab_pin.sym} -60 36080 0 0 {name=l1628 lab=csel2}
N -40 36100 -60 36100 {}
C {lab_pin.sym} -60 36100 0 0 {name=l1629 lab=csel3}
N -40 36120 -60 36120 {}
C {lab_pin.sym} -60 36120 0 0 {name=l1630 lab=cseln0}
N -40 36140 -60 36140 {}
C {lab_pin.sym} -60 36140 0 0 {name=l1631 lab=cseln1}
N -40 36160 -60 36160 {}
C {lab_pin.sym} -60 36160 0 0 {name=l1632 lab=cseln2}
N -40 36180 -60 36180 {}
C {lab_pin.sym} -60 36180 0 0 {name=l1633 lab=cseln3}
N -40 36200 -60 36200 {}
C {lab_pin.sym} -60 36200 0 0 {name=l1634 lab=D[29]}
N -40 36220 -60 36220 {}
C {lab_pin.sym} -60 36220 0 0 {name=l1635 lab=WEN[29]}
N -40 36240 -60 36240 {}
C {lab_pin.sym} -60 36240 0 0 {name=l1636 lab=clk_buf}
N -40 36260 -60 36260 {}
C {lab_pin.sym} -60 36260 0 0 {name=l1637 lab=q_clk}
N -40 36280 -60 36280 {}
C {lab_pin.sym} -60 36280 0 0 {name=l1638 lab=s_en}
N -40 36300 -60 36300 {}
C {lab_pin.sym} -60 36300 0 0 {name=l1639 lab=wl_en_n}
N -40 36320 -60 36320 {}
C {lab_pin.sym} -60 36320 0 0 {name=l1640 lab=wpn}
N 40 36040 60 36040 {}
C {lab_pin.sym} 60 36040 0 0 {name=l1641 lab=Q[29]}
N 40 36060 60 36060 {}
C {lab_pin.sym} 60 36060 0 0 {name=l1642 lab=BL116}
N 40 36080 60 36080 {}
C {lab_pin.sym} 60 36080 0 0 {name=l1643 lab=BL117}
N 40 36100 60 36100 {}
C {lab_pin.sym} 60 36100 0 0 {name=l1644 lab=BL118}
N 40 36120 60 36120 {}
C {lab_pin.sym} 60 36120 0 0 {name=l1645 lab=BL119}
N 40 36140 60 36140 {}
C {lab_pin.sym} 60 36140 0 0 {name=l1646 lab=BLB116}
N 40 36160 60 36160 {}
C {lab_pin.sym} 60 36160 0 0 {name=l1647 lab=BLB117}
N 40 36180 60 36180 {}
C {lab_pin.sym} 60 36180 0 0 {name=l1648 lab=BLB118}
N 40 36200 60 36200 {}
C {lab_pin.sym} 60 36200 0 0 {name=l1649 lab=BLB119}
N 0 36000 0 35980 {}
C {lab_pin.sym} 0 35980 0 0 {name=l1650 lab=VDD}
N 0 36380 0 36400 {}
C {lab_pin.sym} 0 36400 0 0 {name=l1651 lab=VSS}
C {precharge_slice.sym} 0 36660 0 0 {name=Xpc30}
N -40 36580 -60 36580 {}
C {lab_pin.sym} -60 36580 0 0 {name=l1652 lab=csel0}
N -40 36600 -60 36600 {}
C {lab_pin.sym} -60 36600 0 0 {name=l1653 lab=csel1}
N -40 36620 -60 36620 {}
C {lab_pin.sym} -60 36620 0 0 {name=l1654 lab=csel2}
N -40 36640 -60 36640 {}
C {lab_pin.sym} -60 36640 0 0 {name=l1655 lab=csel3}
N 40 36580 60 36580 {}
C {lab_pin.sym} 60 36580 0 0 {name=l1656 lab=BL120}
N 40 36600 60 36600 {}
C {lab_pin.sym} 60 36600 0 0 {name=l1657 lab=BL121}
N 40 36620 60 36620 {}
C {lab_pin.sym} 60 36620 0 0 {name=l1658 lab=BL122}
N 40 36640 60 36640 {}
C {lab_pin.sym} 60 36640 0 0 {name=l1659 lab=BL123}
N 40 36660 60 36660 {}
C {lab_pin.sym} 60 36660 0 0 {name=l1660 lab=BLB120}
N 40 36680 60 36680 {}
C {lab_pin.sym} 60 36680 0 0 {name=l1661 lab=BLB121}
N 40 36700 60 36700 {}
C {lab_pin.sym} 60 36700 0 0 {name=l1662 lab=BLB122}
N 40 36720 60 36720 {}
C {lab_pin.sym} 60 36720 0 0 {name=l1663 lab=BLB123}
N 0 36540 0 36520 {}
C {lab_pin.sym} 0 36520 0 0 {name=l1664 lab=VDD}
N 0 36780 0 36800 {}
C {lab_pin.sym} 0 36800 0 0 {name=l1665 lab=VSS}
C {io_slice.sym} 0 37130 0 0 {name=Xio30}
N -40 36980 -60 36980 {}
C {lab_pin.sym} -60 36980 0 0 {name=l1666 lab=csel0}
N -40 37000 -60 37000 {}
C {lab_pin.sym} -60 37000 0 0 {name=l1667 lab=csel1}
N -40 37020 -60 37020 {}
C {lab_pin.sym} -60 37020 0 0 {name=l1668 lab=csel2}
N -40 37040 -60 37040 {}
C {lab_pin.sym} -60 37040 0 0 {name=l1669 lab=csel3}
N -40 37060 -60 37060 {}
C {lab_pin.sym} -60 37060 0 0 {name=l1670 lab=cseln0}
N -40 37080 -60 37080 {}
C {lab_pin.sym} -60 37080 0 0 {name=l1671 lab=cseln1}
N -40 37100 -60 37100 {}
C {lab_pin.sym} -60 37100 0 0 {name=l1672 lab=cseln2}
N -40 37120 -60 37120 {}
C {lab_pin.sym} -60 37120 0 0 {name=l1673 lab=cseln3}
N -40 37140 -60 37140 {}
C {lab_pin.sym} -60 37140 0 0 {name=l1674 lab=D[30]}
N -40 37160 -60 37160 {}
C {lab_pin.sym} -60 37160 0 0 {name=l1675 lab=WEN[30]}
N -40 37180 -60 37180 {}
C {lab_pin.sym} -60 37180 0 0 {name=l1676 lab=clk_buf}
N -40 37200 -60 37200 {}
C {lab_pin.sym} -60 37200 0 0 {name=l1677 lab=q_clk}
N -40 37220 -60 37220 {}
C {lab_pin.sym} -60 37220 0 0 {name=l1678 lab=s_en}
N -40 37240 -60 37240 {}
C {lab_pin.sym} -60 37240 0 0 {name=l1679 lab=wl_en_n}
N -40 37260 -60 37260 {}
C {lab_pin.sym} -60 37260 0 0 {name=l1680 lab=wpn}
N 40 36980 60 36980 {}
C {lab_pin.sym} 60 36980 0 0 {name=l1681 lab=Q[30]}
N 40 37000 60 37000 {}
C {lab_pin.sym} 60 37000 0 0 {name=l1682 lab=BL120}
N 40 37020 60 37020 {}
C {lab_pin.sym} 60 37020 0 0 {name=l1683 lab=BL121}
N 40 37040 60 37040 {}
C {lab_pin.sym} 60 37040 0 0 {name=l1684 lab=BL122}
N 40 37060 60 37060 {}
C {lab_pin.sym} 60 37060 0 0 {name=l1685 lab=BL123}
N 40 37080 60 37080 {}
C {lab_pin.sym} 60 37080 0 0 {name=l1686 lab=BLB120}
N 40 37100 60 37100 {}
C {lab_pin.sym} 60 37100 0 0 {name=l1687 lab=BLB121}
N 40 37120 60 37120 {}
C {lab_pin.sym} 60 37120 0 0 {name=l1688 lab=BLB122}
N 40 37140 60 37140 {}
C {lab_pin.sym} 60 37140 0 0 {name=l1689 lab=BLB123}
N 0 36940 0 36920 {}
C {lab_pin.sym} 0 36920 0 0 {name=l1690 lab=VDD}
N 0 37320 0 37340 {}
C {lab_pin.sym} 0 37340 0 0 {name=l1691 lab=VSS}
C {precharge_slice.sym} 0 37600 0 0 {name=Xpc31}
N -40 37520 -60 37520 {}
C {lab_pin.sym} -60 37520 0 0 {name=l1692 lab=csel0}
N -40 37540 -60 37540 {}
C {lab_pin.sym} -60 37540 0 0 {name=l1693 lab=csel1}
N -40 37560 -60 37560 {}
C {lab_pin.sym} -60 37560 0 0 {name=l1694 lab=csel2}
N -40 37580 -60 37580 {}
C {lab_pin.sym} -60 37580 0 0 {name=l1695 lab=csel3}
N 40 37520 60 37520 {}
C {lab_pin.sym} 60 37520 0 0 {name=l1696 lab=BL124}
N 40 37540 60 37540 {}
C {lab_pin.sym} 60 37540 0 0 {name=l1697 lab=BL125}
N 40 37560 60 37560 {}
C {lab_pin.sym} 60 37560 0 0 {name=l1698 lab=BL126}
N 40 37580 60 37580 {}
C {lab_pin.sym} 60 37580 0 0 {name=l1699 lab=BL127}
N 40 37600 60 37600 {}
C {lab_pin.sym} 60 37600 0 0 {name=l1700 lab=BLB124}
N 40 37620 60 37620 {}
C {lab_pin.sym} 60 37620 0 0 {name=l1701 lab=BLB125}
N 40 37640 60 37640 {}
C {lab_pin.sym} 60 37640 0 0 {name=l1702 lab=BLB126}
N 40 37660 60 37660 {}
C {lab_pin.sym} 60 37660 0 0 {name=l1703 lab=BLB127}
N 0 37480 0 37460 {}
C {lab_pin.sym} 0 37460 0 0 {name=l1704 lab=VDD}
N 0 37720 0 37740 {}
C {lab_pin.sym} 0 37740 0 0 {name=l1705 lab=VSS}
C {io_slice.sym} 0 38070 0 0 {name=Xio31}
N -40 37920 -60 37920 {}
C {lab_pin.sym} -60 37920 0 0 {name=l1706 lab=csel0}
N -40 37940 -60 37940 {}
C {lab_pin.sym} -60 37940 0 0 {name=l1707 lab=csel1}
N -40 37960 -60 37960 {}
C {lab_pin.sym} -60 37960 0 0 {name=l1708 lab=csel2}
N -40 37980 -60 37980 {}
C {lab_pin.sym} -60 37980 0 0 {name=l1709 lab=csel3}
N -40 38000 -60 38000 {}
C {lab_pin.sym} -60 38000 0 0 {name=l1710 lab=cseln0}
N -40 38020 -60 38020 {}
C {lab_pin.sym} -60 38020 0 0 {name=l1711 lab=cseln1}
N -40 38040 -60 38040 {}
C {lab_pin.sym} -60 38040 0 0 {name=l1712 lab=cseln2}
N -40 38060 -60 38060 {}
C {lab_pin.sym} -60 38060 0 0 {name=l1713 lab=cseln3}
N -40 38080 -60 38080 {}
C {lab_pin.sym} -60 38080 0 0 {name=l1714 lab=D[31]}
N -40 38100 -60 38100 {}
C {lab_pin.sym} -60 38100 0 0 {name=l1715 lab=WEN[31]}
N -40 38120 -60 38120 {}
C {lab_pin.sym} -60 38120 0 0 {name=l1716 lab=clk_buf}
N -40 38140 -60 38140 {}
C {lab_pin.sym} -60 38140 0 0 {name=l1717 lab=q_clk}
N -40 38160 -60 38160 {}
C {lab_pin.sym} -60 38160 0 0 {name=l1718 lab=s_en}
N -40 38180 -60 38180 {}
C {lab_pin.sym} -60 38180 0 0 {name=l1719 lab=wl_en_n}
N -40 38200 -60 38200 {}
C {lab_pin.sym} -60 38200 0 0 {name=l1720 lab=wpn}
N 40 37920 60 37920 {}
C {lab_pin.sym} 60 37920 0 0 {name=l1721 lab=Q[31]}
N 40 37940 60 37940 {}
C {lab_pin.sym} 60 37940 0 0 {name=l1722 lab=BL124}
N 40 37960 60 37960 {}
C {lab_pin.sym} 60 37960 0 0 {name=l1723 lab=BL125}
N 40 37980 60 37980 {}
C {lab_pin.sym} 60 37980 0 0 {name=l1724 lab=BL126}
N 40 38000 60 38000 {}
C {lab_pin.sym} 60 38000 0 0 {name=l1725 lab=BL127}
N 40 38020 60 38020 {}
C {lab_pin.sym} 60 38020 0 0 {name=l1726 lab=BLB124}
N 40 38040 60 38040 {}
C {lab_pin.sym} 60 38040 0 0 {name=l1727 lab=BLB125}
N 40 38060 60 38060 {}
C {lab_pin.sym} 60 38060 0 0 {name=l1728 lab=BLB126}
N 40 38080 60 38080 {}
C {lab_pin.sym} 60 38080 0 0 {name=l1729 lab=BLB127}
N 0 37880 0 37860 {}
C {lab_pin.sym} 0 37860 0 0 {name=l1730 lab=VDD}
N 0 38260 0 38280 {}
C {lab_pin.sym} 0 38280 0 0 {name=l1731 lab=VSS}
C {ipin.sym} -400 -200 0 0 {name=p1732 lab=A[7:0]}
C {ipin.sym} -400 -260 0 0 {name=p1733 lab=CEN}
C {ipin.sym} -400 -320 0 0 {name=p1734 lab=GWEN}
C {ipin.sym} -400 -380 0 0 {name=p1735 lab=CLK}
C {ipin.sym} -400 -440 0 0 {name=p1736 lab=D[31:0]}
C {ipin.sym} -400 -500 0 0 {name=p1737 lab=WEN[31:0]}
C {opin.sym} -700 -200 0 0 {name=p1738 lab=Q[31:0]}
C {iopin.sym} -1000 -200 0 0 {name=p1739 lab=VDD}
C {iopin.sym} -1000 -260 0 0 {name=p1740 lab=VSS}
