N -40 22760 -60 22760 {}
C {lab_pin.sym} -60 22760 0 0 {name=l18243 lab=WL114}
N 40 22840 60 22840 {}
C {lab_pin.sym} 60 22840 0 0 {name=l18244 lab=VDD}
N 40 22760 60 22760 {}
C {lab_pin.sym} 60 22760 0 0 {name=l18245 lab=VSS}
C {bitcell_6t.sym} 200 22800 0 0 {name=Xr114c1}
N 160 22840 140 22840 {}
C {lab_pin.sym} 140 22840 0 0 {name=l18246 lab=BL1}
N 160 22800 140 22800 {}
C {lab_pin.sym} 140 22800 0 0 {name=l18247 lab=BLB1}
N 160 22760 140 22760 {}
C {lab_pin.sym} 140 22760 0 0 {name=l18248 lab=WL114}
N 240 22840 260 22840 {}
C {lab_pin.sym} 260 22840 0 0 {name=l18249 lab=VDD}
N 240 22760 260 22760 {}
C {lab_pin.sym} 260 22760 0 0 {name=l18250 lab=VSS}
C {bitcell_6t.sym} 400 22800 0 0 {name=Xr114c2}
N 360 22840 340 22840 {}
C {lab_pin.sym} 340 22840 0 0 {name=l18251 lab=BL2}
N 360 22800 340 22800 {}
C {lab_pin.sym} 340 22800 0 0 {name=l18252 lab=BLB2}
N 360 22760 340 22760 {}
C {lab_pin.sym} 340 22760 0 0 {name=l18253 lab=WL114}
N 440 22840 460 22840 {}
C {lab_pin.sym} 460 22840 0 0 {name=l18254 lab=VDD}
N 440 22760 460 22760 {}
C {lab_pin.sym} 460 22760 0 0 {name=l18255 lab=VSS}
C {bitcell_6t.sym} 600 22800 0 0 {name=Xr114c3}
N 560 22840 540 22840 {}
C {lab_pin.sym} 540 22840 0 0 {name=l18256 lab=BL3}
N 560 22800 540 22800 {}
C {lab_pin.sym} 540 22800 0 0 {name=l18257 lab=BLB3}
N 560 22760 540 22760 {}
C {lab_pin.sym} 540 22760 0 0 {name=l18258 lab=WL114}
N 640 22840 660 22840 {}
C {lab_pin.sym} 660 22840 0 0 {name=l18259 lab=VDD}
N 640 22760 660 22760 {}
C {lab_pin.sym} 660 22760 0 0 {name=l18260 lab=VSS}
C {bitcell_6t.sym} 800 22800 0 0 {name=Xr114c4}
N 760 22840 740 22840 {}
C {lab_pin.sym} 740 22840 0 0 {name=l18261 lab=BL4}
N 760 22800 740 22800 {}
C {lab_pin.sym} 740 22800 0 0 {name=l18262 lab=BLB4}
N 760 22760 740 22760 {}
C {lab_pin.sym} 740 22760 0 0 {name=l18263 lab=WL114}
N 840 22840 860 22840 {}
C {lab_pin.sym} 860 22840 0 0 {name=l18264 lab=VDD}
N 840 22760 860 22760 {}
C {lab_pin.sym} 860 22760 0 0 {name=l18265 lab=VSS}
C {bitcell_6t.sym} 1000 22800 0 0 {name=Xr114c5}
N 960 22840 940 22840 {}
C {lab_pin.sym} 940 22840 0 0 {name=l18266 lab=BL5}
N 960 22800 940 22800 {}
C {lab_pin.sym} 940 22800 0 0 {name=l18267 lab=BLB5}
N 960 22760 940 22760 {}
C {lab_pin.sym} 940 22760 0 0 {name=l18268 lab=WL114}
N 1040 22840 1060 22840 {}
C {lab_pin.sym} 1060 22840 0 0 {name=l18269 lab=VDD}
N 1040 22760 1060 22760 {}
C {lab_pin.sym} 1060 22760 0 0 {name=l18270 lab=VSS}
C {bitcell_6t.sym} 1200 22800 0 0 {name=Xr114c6}
N 1160 22840 1140 22840 {}
C {lab_pin.sym} 1140 22840 0 0 {name=l18271 lab=BL6}
N 1160 22800 1140 22800 {}
C {lab_pin.sym} 1140 22800 0 0 {name=l18272 lab=BLB6}
N 1160 22760 1140 22760 {}
C {lab_pin.sym} 1140 22760 0 0 {name=l18273 lab=WL114}
N 1240 22840 1260 22840 {}
C {lab_pin.sym} 1260 22840 0 0 {name=l18274 lab=VDD}
N 1240 22760 1260 22760 {}
C {lab_pin.sym} 1260 22760 0 0 {name=l18275 lab=VSS}
C {bitcell_6t.sym} 1400 22800 0 0 {name=Xr114c7}
N 1360 22840 1340 22840 {}
C {lab_pin.sym} 1340 22840 0 0 {name=l18276 lab=BL7}
N 1360 22800 1340 22800 {}
C {lab_pin.sym} 1340 22800 0 0 {name=l18277 lab=BLB7}
N 1360 22760 1340 22760 {}
C {lab_pin.sym} 1340 22760 0 0 {name=l18278 lab=WL114}
N 1440 22840 1460 22840 {}
C {lab_pin.sym} 1460 22840 0 0 {name=l18279 lab=VDD}
N 1440 22760 1460 22760 {}
C {lab_pin.sym} 1460 22760 0 0 {name=l18280 lab=VSS}
C {bitcell_6t.sym} 1600 22800 0 0 {name=Xr114c8}
N 1560 22840 1540 22840 {}
C {lab_pin.sym} 1540 22840 0 0 {name=l18281 lab=BL8}
N 1560 22800 1540 22800 {}
C {lab_pin.sym} 1540 22800 0 0 {name=l18282 lab=BLB8}
N 1560 22760 1540 22760 {}
C {lab_pin.sym} 1540 22760 0 0 {name=l18283 lab=WL114}
N 1640 22840 1660 22840 {}
C {lab_pin.sym} 1660 22840 0 0 {name=l18284 lab=VDD}
N 1640 22760 1660 22760 {}
C {lab_pin.sym} 1660 22760 0 0 {name=l18285 lab=VSS}
C {bitcell_6t.sym} 1800 22800 0 0 {name=Xr114c9}
N 1760 22840 1740 22840 {}
C {lab_pin.sym} 1740 22840 0 0 {name=l18286 lab=BL9}
N 1760 22800 1740 22800 {}
C {lab_pin.sym} 1740 22800 0 0 {name=l18287 lab=BLB9}
N 1760 22760 1740 22760 {}
C {lab_pin.sym} 1740 22760 0 0 {name=l18288 lab=WL114}
N 1840 22840 1860 22840 {}
C {lab_pin.sym} 1860 22840 0 0 {name=l18289 lab=VDD}
N 1840 22760 1860 22760 {}
C {lab_pin.sym} 1860 22760 0 0 {name=l18290 lab=VSS}
C {bitcell_6t.sym} 2000 22800 0 0 {name=Xr114c10}
N 1960 22840 1940 22840 {}
C {lab_pin.sym} 1940 22840 0 0 {name=l18291 lab=BL10}
N 1960 22800 1940 22800 {}
C {lab_pin.sym} 1940 22800 0 0 {name=l18292 lab=BLB10}
N 1960 22760 1940 22760 {}
C {lab_pin.sym} 1940 22760 0 0 {name=l18293 lab=WL114}
N 2040 22840 2060 22840 {}
C {lab_pin.sym} 2060 22840 0 0 {name=l18294 lab=VDD}
N 2040 22760 2060 22760 {}
C {lab_pin.sym} 2060 22760 0 0 {name=l18295 lab=VSS}
C {bitcell_6t.sym} 2200 22800 0 0 {name=Xr114c11}
N 2160 22840 2140 22840 {}
C {lab_pin.sym} 2140 22840 0 0 {name=l18296 lab=BL11}
N 2160 22800 2140 22800 {}
C {lab_pin.sym} 2140 22800 0 0 {name=l18297 lab=BLB11}
N 2160 22760 2140 22760 {}
C {lab_pin.sym} 2140 22760 0 0 {name=l18298 lab=WL114}
N 2240 22840 2260 22840 {}
C {lab_pin.sym} 2260 22840 0 0 {name=l18299 lab=VDD}
N 2240 22760 2260 22760 {}
C {lab_pin.sym} 2260 22760 0 0 {name=l18300 lab=VSS}
C {bitcell_6t.sym} 2400 22800 0 0 {name=Xr114c12}
N 2360 22840 2340 22840 {}
C {lab_pin.sym} 2340 22840 0 0 {name=l18301 lab=BL12}
N 2360 22800 2340 22800 {}
C {lab_pin.sym} 2340 22800 0 0 {name=l18302 lab=BLB12}
N 2360 22760 2340 22760 {}
C {lab_pin.sym} 2340 22760 0 0 {name=l18303 lab=WL114}
N 2440 22840 2460 22840 {}
C {lab_pin.sym} 2460 22840 0 0 {name=l18304 lab=VDD}
N 2440 22760 2460 22760 {}
C {lab_pin.sym} 2460 22760 0 0 {name=l18305 lab=VSS}
C {bitcell_6t.sym} 2600 22800 0 0 {name=Xr114c13}
N 2560 22840 2540 22840 {}
C {lab_pin.sym} 2540 22840 0 0 {name=l18306 lab=BL13}
N 2560 22800 2540 22800 {}
C {lab_pin.sym} 2540 22800 0 0 {name=l18307 lab=BLB13}
N 2560 22760 2540 22760 {}
C {lab_pin.sym} 2540 22760 0 0 {name=l18308 lab=WL114}
N 2640 22840 2660 22840 {}
C {lab_pin.sym} 2660 22840 0 0 {name=l18309 lab=VDD}
N 2640 22760 2660 22760 {}
C {lab_pin.sym} 2660 22760 0 0 {name=l18310 lab=VSS}
C {bitcell_6t.sym} 2800 22800 0 0 {name=Xr114c14}
N 2760 22840 2740 22840 {}
C {lab_pin.sym} 2740 22840 0 0 {name=l18311 lab=BL14}
N 2760 22800 2740 22800 {}
C {lab_pin.sym} 2740 22800 0 0 {name=l18312 lab=BLB14}
N 2760 22760 2740 22760 {}
C {lab_pin.sym} 2740 22760 0 0 {name=l18313 lab=WL114}
N 2840 22840 2860 22840 {}
C {lab_pin.sym} 2860 22840 0 0 {name=l18314 lab=VDD}
N 2840 22760 2860 22760 {}
C {lab_pin.sym} 2860 22760 0 0 {name=l18315 lab=VSS}
C {bitcell_6t.sym} 3000 22800 0 0 {name=Xr114c15}
N 2960 22840 2940 22840 {}
C {lab_pin.sym} 2940 22840 0 0 {name=l18316 lab=BL15}
N 2960 22800 2940 22800 {}
C {lab_pin.sym} 2940 22800 0 0 {name=l18317 lab=BLB15}
N 2960 22760 2940 22760 {}
C {lab_pin.sym} 2940 22760 0 0 {name=l18318 lab=WL114}
N 3040 22840 3060 22840 {}
C {lab_pin.sym} 3060 22840 0 0 {name=l18319 lab=VDD}
N 3040 22760 3060 22760 {}
C {lab_pin.sym} 3060 22760 0 0 {name=l18320 lab=VSS}
C {bitcell_6t.sym} 3200 22800 0 0 {name=Xr114c16}
N 3160 22840 3140 22840 {}
C {lab_pin.sym} 3140 22840 0 0 {name=l18321 lab=BL16}
N 3160 22800 3140 22800 {}
C {lab_pin.sym} 3140 22800 0 0 {name=l18322 lab=BLB16}
N 3160 22760 3140 22760 {}
C {lab_pin.sym} 3140 22760 0 0 {name=l18323 lab=WL114}
N 3240 22840 3260 22840 {}
C {lab_pin.sym} 3260 22840 0 0 {name=l18324 lab=VDD}
N 3240 22760 3260 22760 {}
C {lab_pin.sym} 3260 22760 0 0 {name=l18325 lab=VSS}
C {bitcell_6t.sym} 3400 22800 0 0 {name=Xr114c17}
N 3360 22840 3340 22840 {}
C {lab_pin.sym} 3340 22840 0 0 {name=l18326 lab=BL17}
N 3360 22800 3340 22800 {}
C {lab_pin.sym} 3340 22800 0 0 {name=l18327 lab=BLB17}
N 3360 22760 3340 22760 {}
C {lab_pin.sym} 3340 22760 0 0 {name=l18328 lab=WL114}
N 3440 22840 3460 22840 {}
C {lab_pin.sym} 3460 22840 0 0 {name=l18329 lab=VDD}
N 3440 22760 3460 22760 {}
C {lab_pin.sym} 3460 22760 0 0 {name=l18330 lab=VSS}
C {bitcell_6t.sym} 3600 22800 0 0 {name=Xr114c18}
N 3560 22840 3540 22840 {}
C {lab_pin.sym} 3540 22840 0 0 {name=l18331 lab=BL18}
N 3560 22800 3540 22800 {}
C {lab_pin.sym} 3540 22800 0 0 {name=l18332 lab=BLB18}
N 3560 22760 3540 22760 {}
C {lab_pin.sym} 3540 22760 0 0 {name=l18333 lab=WL114}
N 3640 22840 3660 22840 {}
C {lab_pin.sym} 3660 22840 0 0 {name=l18334 lab=VDD}
N 3640 22760 3660 22760 {}
C {lab_pin.sym} 3660 22760 0 0 {name=l18335 lab=VSS}
C {bitcell_6t.sym} 3800 22800 0 0 {name=Xr114c19}
N 3760 22840 3740 22840 {}
C {lab_pin.sym} 3740 22840 0 0 {name=l18336 lab=BL19}
N 3760 22800 3740 22800 {}
C {lab_pin.sym} 3740 22800 0 0 {name=l18337 lab=BLB19}
N 3760 22760 3740 22760 {}
C {lab_pin.sym} 3740 22760 0 0 {name=l18338 lab=WL114}
N 3840 22840 3860 22840 {}
C {lab_pin.sym} 3860 22840 0 0 {name=l18339 lab=VDD}
N 3840 22760 3860 22760 {}
C {lab_pin.sym} 3860 22760 0 0 {name=l18340 lab=VSS}
C {bitcell_6t.sym} 4000 22800 0 0 {name=Xr114c20}
N 3960 22840 3940 22840 {}
C {lab_pin.sym} 3940 22840 0 0 {name=l18341 lab=BL20}
N 3960 22800 3940 22800 {}
C {lab_pin.sym} 3940 22800 0 0 {name=l18342 lab=BLB20}
N 3960 22760 3940 22760 {}
C {lab_pin.sym} 3940 22760 0 0 {name=l18343 lab=WL114}
N 4040 22840 4060 22840 {}
C {lab_pin.sym} 4060 22840 0 0 {name=l18344 lab=VDD}
N 4040 22760 4060 22760 {}
C {lab_pin.sym} 4060 22760 0 0 {name=l18345 lab=VSS}
C {bitcell_6t.sym} 4200 22800 0 0 {name=Xr114c21}
N 4160 22840 4140 22840 {}
C {lab_pin.sym} 4140 22840 0 0 {name=l18346 lab=BL21}
N 4160 22800 4140 22800 {}
C {lab_pin.sym} 4140 22800 0 0 {name=l18347 lab=BLB21}
N 4160 22760 4140 22760 {}
C {lab_pin.sym} 4140 22760 0 0 {name=l18348 lab=WL114}
N 4240 22840 4260 22840 {}
C {lab_pin.sym} 4260 22840 0 0 {name=l18349 lab=VDD}
N 4240 22760 4260 22760 {}
C {lab_pin.sym} 4260 22760 0 0 {name=l18350 lab=VSS}
C {bitcell_6t.sym} 4400 22800 0 0 {name=Xr114c22}
N 4360 22840 4340 22840 {}
C {lab_pin.sym} 4340 22840 0 0 {name=l18351 lab=BL22}
N 4360 22800 4340 22800 {}
C {lab_pin.sym} 4340 22800 0 0 {name=l18352 lab=BLB22}
N 4360 22760 4340 22760 {}
C {lab_pin.sym} 4340 22760 0 0 {name=l18353 lab=WL114}
N 4440 22840 4460 22840 {}
C {lab_pin.sym} 4460 22840 0 0 {name=l18354 lab=VDD}
N 4440 22760 4460 22760 {}
C {lab_pin.sym} 4460 22760 0 0 {name=l18355 lab=VSS}
C {bitcell_6t.sym} 4600 22800 0 0 {name=Xr114c23}
N 4560 22840 4540 22840 {}
C {lab_pin.sym} 4540 22840 0 0 {name=l18356 lab=BL23}
N 4560 22800 4540 22800 {}
C {lab_pin.sym} 4540 22800 0 0 {name=l18357 lab=BLB23}
N 4560 22760 4540 22760 {}
C {lab_pin.sym} 4540 22760 0 0 {name=l18358 lab=WL114}
N 4640 22840 4660 22840 {}
C {lab_pin.sym} 4660 22840 0 0 {name=l18359 lab=VDD}
N 4640 22760 4660 22760 {}
C {lab_pin.sym} 4660 22760 0 0 {name=l18360 lab=VSS}
C {bitcell_6t.sym} 4800 22800 0 0 {name=Xr114c24}
N 4760 22840 4740 22840 {}
C {lab_pin.sym} 4740 22840 0 0 {name=l18361 lab=BL24}
N 4760 22800 4740 22800 {}
C {lab_pin.sym} 4740 22800 0 0 {name=l18362 lab=BLB24}
N 4760 22760 4740 22760 {}
C {lab_pin.sym} 4740 22760 0 0 {name=l18363 lab=WL114}
N 4840 22840 4860 22840 {}
C {lab_pin.sym} 4860 22840 0 0 {name=l18364 lab=VDD}
N 4840 22760 4860 22760 {}
C {lab_pin.sym} 4860 22760 0 0 {name=l18365 lab=VSS}
C {bitcell_6t.sym} 5000 22800 0 0 {name=Xr114c25}
N 4960 22840 4940 22840 {}
C {lab_pin.sym} 4940 22840 0 0 {name=l18366 lab=BL25}
N 4960 22800 4940 22800 {}
C {lab_pin.sym} 4940 22800 0 0 {name=l18367 lab=BLB25}
N 4960 22760 4940 22760 {}
C {lab_pin.sym} 4940 22760 0 0 {name=l18368 lab=WL114}
N 5040 22840 5060 22840 {}
C {lab_pin.sym} 5060 22840 0 0 {name=l18369 lab=VDD}
N 5040 22760 5060 22760 {}
C {lab_pin.sym} 5060 22760 0 0 {name=l18370 lab=VSS}
C {bitcell_6t.sym} 5200 22800 0 0 {name=Xr114c26}
N 5160 22840 5140 22840 {}
C {lab_pin.sym} 5140 22840 0 0 {name=l18371 lab=BL26}
N 5160 22800 5140 22800 {}
C {lab_pin.sym} 5140 22800 0 0 {name=l18372 lab=BLB26}
N 5160 22760 5140 22760 {}
C {lab_pin.sym} 5140 22760 0 0 {name=l18373 lab=WL114}
N 5240 22840 5260 22840 {}
C {lab_pin.sym} 5260 22840 0 0 {name=l18374 lab=VDD}
N 5240 22760 5260 22760 {}
C {lab_pin.sym} 5260 22760 0 0 {name=l18375 lab=VSS}
C {bitcell_6t.sym} 5400 22800 0 0 {name=Xr114c27}
N 5360 22840 5340 22840 {}
C {lab_pin.sym} 5340 22840 0 0 {name=l18376 lab=BL27}
N 5360 22800 5340 22800 {}
C {lab_pin.sym} 5340 22800 0 0 {name=l18377 lab=BLB27}
N 5360 22760 5340 22760 {}
C {lab_pin.sym} 5340 22760 0 0 {name=l18378 lab=WL114}
N 5440 22840 5460 22840 {}
C {lab_pin.sym} 5460 22840 0 0 {name=l18379 lab=VDD}
N 5440 22760 5460 22760 {}
C {lab_pin.sym} 5460 22760 0 0 {name=l18380 lab=VSS}
C {bitcell_6t.sym} 5600 22800 0 0 {name=Xr114c28}
N 5560 22840 5540 22840 {}
C {lab_pin.sym} 5540 22840 0 0 {name=l18381 lab=BL28}
N 5560 22800 5540 22800 {}
C {lab_pin.sym} 5540 22800 0 0 {name=l18382 lab=BLB28}
N 5560 22760 5540 22760 {}
C {lab_pin.sym} 5540 22760 0 0 {name=l18383 lab=WL114}
N 5640 22840 5660 22840 {}
C {lab_pin.sym} 5660 22840 0 0 {name=l18384 lab=VDD}
N 5640 22760 5660 22760 {}
C {lab_pin.sym} 5660 22760 0 0 {name=l18385 lab=VSS}
C {bitcell_6t.sym} 5800 22800 0 0 {name=Xr114c29}
N 5760 22840 5740 22840 {}
C {lab_pin.sym} 5740 22840 0 0 {name=l18386 lab=BL29}
N 5760 22800 5740 22800 {}
C {lab_pin.sym} 5740 22800 0 0 {name=l18387 lab=BLB29}
N 5760 22760 5740 22760 {}
C {lab_pin.sym} 5740 22760 0 0 {name=l18388 lab=WL114}
N 5840 22840 5860 22840 {}
C {lab_pin.sym} 5860 22840 0 0 {name=l18389 lab=VDD}
N 5840 22760 5860 22760 {}
C {lab_pin.sym} 5860 22760 0 0 {name=l18390 lab=VSS}
C {bitcell_6t.sym} 6000 22800 0 0 {name=Xr114c30}
N 5960 22840 5940 22840 {}
C {lab_pin.sym} 5940 22840 0 0 {name=l18391 lab=BL30}
N 5960 22800 5940 22800 {}
C {lab_pin.sym} 5940 22800 0 0 {name=l18392 lab=BLB30}
N 5960 22760 5940 22760 {}
C {lab_pin.sym} 5940 22760 0 0 {name=l18393 lab=WL114}
N 6040 22840 6060 22840 {}
C {lab_pin.sym} 6060 22840 0 0 {name=l18394 lab=VDD}
N 6040 22760 6060 22760 {}
C {lab_pin.sym} 6060 22760 0 0 {name=l18395 lab=VSS}
C {bitcell_6t.sym} 6200 22800 0 0 {name=Xr114c31}
N 6160 22840 6140 22840 {}
C {lab_pin.sym} 6140 22840 0 0 {name=l18396 lab=BL31}
N 6160 22800 6140 22800 {}
C {lab_pin.sym} 6140 22800 0 0 {name=l18397 lab=BLB31}
N 6160 22760 6140 22760 {}
C {lab_pin.sym} 6140 22760 0 0 {name=l18398 lab=WL114}
N 6240 22840 6260 22840 {}
C {lab_pin.sym} 6260 22840 0 0 {name=l18399 lab=VDD}
N 6240 22760 6260 22760 {}
C {lab_pin.sym} 6260 22760 0 0 {name=l18400 lab=VSS}
C {bitcell_6t.sym} 0 23000 0 0 {name=Xr115c0}
N -40 23040 -60 23040 {}
C {lab_pin.sym} -60 23040 0 0 {name=l18401 lab=BL0}
N -40 23000 -60 23000 {}
C {lab_pin.sym} -60 23000 0 0 {name=l18402 lab=BLB0}
N -40 22960 -60 22960 {}
C {lab_pin.sym} -60 22960 0 0 {name=l18403 lab=WL115}
N 40 23040 60 23040 {}
C {lab_pin.sym} 60 23040 0 0 {name=l18404 lab=VDD}
N 40 22960 60 22960 {}
C {lab_pin.sym} 60 22960 0 0 {name=l18405 lab=VSS}
C {bitcell_6t.sym} 200 23000 0 0 {name=Xr115c1}
N 160 23040 140 23040 {}
C {lab_pin.sym} 140 23040 0 0 {name=l18406 lab=BL1}
N 160 23000 140 23000 {}
C {lab_pin.sym} 140 23000 0 0 {name=l18407 lab=BLB1}
N 160 22960 140 22960 {}
C {lab_pin.sym} 140 22960 0 0 {name=l18408 lab=WL115}
N 240 23040 260 23040 {}
C {lab_pin.sym} 260 23040 0 0 {name=l18409 lab=VDD}
N 240 22960 260 22960 {}
C {lab_pin.sym} 260 22960 0 0 {name=l18410 lab=VSS}
C {bitcell_6t.sym} 400 23000 0 0 {name=Xr115c2}
N 360 23040 340 23040 {}
C {lab_pin.sym} 340 23040 0 0 {name=l18411 lab=BL2}
N 360 23000 340 23000 {}
C {lab_pin.sym} 340 23000 0 0 {name=l18412 lab=BLB2}
N 360 22960 340 22960 {}
C {lab_pin.sym} 340 22960 0 0 {name=l18413 lab=WL115}
N 440 23040 460 23040 {}
C {lab_pin.sym} 460 23040 0 0 {name=l18414 lab=VDD}
N 440 22960 460 22960 {}
C {lab_pin.sym} 460 22960 0 0 {name=l18415 lab=VSS}
C {bitcell_6t.sym} 600 23000 0 0 {name=Xr115c3}
N 560 23040 540 23040 {}
C {lab_pin.sym} 540 23040 0 0 {name=l18416 lab=BL3}
N 560 23000 540 23000 {}
C {lab_pin.sym} 540 23000 0 0 {name=l18417 lab=BLB3}
N 560 22960 540 22960 {}
C {lab_pin.sym} 540 22960 0 0 {name=l18418 lab=WL115}
N 640 23040 660 23040 {}
C {lab_pin.sym} 660 23040 0 0 {name=l18419 lab=VDD}
N 640 22960 660 22960 {}
C {lab_pin.sym} 660 22960 0 0 {name=l18420 lab=VSS}
C {bitcell_6t.sym} 800 23000 0 0 {name=Xr115c4}
N 760 23040 740 23040 {}
C {lab_pin.sym} 740 23040 0 0 {name=l18421 lab=BL4}
N 760 23000 740 23000 {}
C {lab_pin.sym} 740 23000 0 0 {name=l18422 lab=BLB4}
N 760 22960 740 22960 {}
C {lab_pin.sym} 740 22960 0 0 {name=l18423 lab=WL115}
N 840 23040 860 23040 {}
C {lab_pin.sym} 860 23040 0 0 {name=l18424 lab=VDD}
N 840 22960 860 22960 {}
C {lab_pin.sym} 860 22960 0 0 {name=l18425 lab=VSS}
C {bitcell_6t.sym} 1000 23000 0 0 {name=Xr115c5}
N 960 23040 940 23040 {}
C {lab_pin.sym} 940 23040 0 0 {name=l18426 lab=BL5}
N 960 23000 940 23000 {}
C {lab_pin.sym} 940 23000 0 0 {name=l18427 lab=BLB5}
N 960 22960 940 22960 {}
C {lab_pin.sym} 940 22960 0 0 {name=l18428 lab=WL115}
N 1040 23040 1060 23040 {}
C {lab_pin.sym} 1060 23040 0 0 {name=l18429 lab=VDD}
N 1040 22960 1060 22960 {}
C {lab_pin.sym} 1060 22960 0 0 {name=l18430 lab=VSS}
C {bitcell_6t.sym} 1200 23000 0 0 {name=Xr115c6}
N 1160 23040 1140 23040 {}
C {lab_pin.sym} 1140 23040 0 0 {name=l18431 lab=BL6}
N 1160 23000 1140 23000 {}
C {lab_pin.sym} 1140 23000 0 0 {name=l18432 lab=BLB6}
N 1160 22960 1140 22960 {}
C {lab_pin.sym} 1140 22960 0 0 {name=l18433 lab=WL115}
N 1240 23040 1260 23040 {}
C {lab_pin.sym} 1260 23040 0 0 {name=l18434 lab=VDD}
N 1240 22960 1260 22960 {}
C {lab_pin.sym} 1260 22960 0 0 {name=l18435 lab=VSS}
C {bitcell_6t.sym} 1400 23000 0 0 {name=Xr115c7}
N 1360 23040 1340 23040 {}
C {lab_pin.sym} 1340 23040 0 0 {name=l18436 lab=BL7}
N 1360 23000 1340 23000 {}
C {lab_pin.sym} 1340 23000 0 0 {name=l18437 lab=BLB7}
N 1360 22960 1340 22960 {}
C {lab_pin.sym} 1340 22960 0 0 {name=l18438 lab=WL115}
N 1440 23040 1460 23040 {}
C {lab_pin.sym} 1460 23040 0 0 {name=l18439 lab=VDD}
N 1440 22960 1460 22960 {}
C {lab_pin.sym} 1460 22960 0 0 {name=l18440 lab=VSS}
C {bitcell_6t.sym} 1600 23000 0 0 {name=Xr115c8}
N 1560 23040 1540 23040 {}
C {lab_pin.sym} 1540 23040 0 0 {name=l18441 lab=BL8}
N 1560 23000 1540 23000 {}
C {lab_pin.sym} 1540 23000 0 0 {name=l18442 lab=BLB8}
N 1560 22960 1540 22960 {}
C {lab_pin.sym} 1540 22960 0 0 {name=l18443 lab=WL115}
N 1640 23040 1660 23040 {}
C {lab_pin.sym} 1660 23040 0 0 {name=l18444 lab=VDD}
N 1640 22960 1660 22960 {}
C {lab_pin.sym} 1660 22960 0 0 {name=l18445 lab=VSS}
C {bitcell_6t.sym} 1800 23000 0 0 {name=Xr115c9}
N 1760 23040 1740 23040 {}
C {lab_pin.sym} 1740 23040 0 0 {name=l18446 lab=BL9}
N 1760 23000 1740 23000 {}
C {lab_pin.sym} 1740 23000 0 0 {name=l18447 lab=BLB9}
N 1760 22960 1740 22960 {}
C {lab_pin.sym} 1740 22960 0 0 {name=l18448 lab=WL115}
N 1840 23040 1860 23040 {}
C {lab_pin.sym} 1860 23040 0 0 {name=l18449 lab=VDD}
N 1840 22960 1860 22960 {}
C {lab_pin.sym} 1860 22960 0 0 {name=l18450 lab=VSS}
C {bitcell_6t.sym} 2000 23000 0 0 {name=Xr115c10}
N 1960 23040 1940 23040 {}
C {lab_pin.sym} 1940 23040 0 0 {name=l18451 lab=BL10}
N 1960 23000 1940 23000 {}
C {lab_pin.sym} 1940 23000 0 0 {name=l18452 lab=BLB10}
N 1960 22960 1940 22960 {}
C {lab_pin.sym} 1940 22960 0 0 {name=l18453 lab=WL115}
N 2040 23040 2060 23040 {}
C {lab_pin.sym} 2060 23040 0 0 {name=l18454 lab=VDD}
N 2040 22960 2060 22960 {}
C {lab_pin.sym} 2060 22960 0 0 {name=l18455 lab=VSS}
C {bitcell_6t.sym} 2200 23000 0 0 {name=Xr115c11}
N 2160 23040 2140 23040 {}
C {lab_pin.sym} 2140 23040 0 0 {name=l18456 lab=BL11}
N 2160 23000 2140 23000 {}
C {lab_pin.sym} 2140 23000 0 0 {name=l18457 lab=BLB11}
N 2160 22960 2140 22960 {}
C {lab_pin.sym} 2140 22960 0 0 {name=l18458 lab=WL115}
N 2240 23040 2260 23040 {}
C {lab_pin.sym} 2260 23040 0 0 {name=l18459 lab=VDD}
N 2240 22960 2260 22960 {}
C {lab_pin.sym} 2260 22960 0 0 {name=l18460 lab=VSS}
C {bitcell_6t.sym} 2400 23000 0 0 {name=Xr115c12}
N 2360 23040 2340 23040 {}
C {lab_pin.sym} 2340 23040 0 0 {name=l18461 lab=BL12}
N 2360 23000 2340 23000 {}
C {lab_pin.sym} 2340 23000 0 0 {name=l18462 lab=BLB12}
N 2360 22960 2340 22960 {}
C {lab_pin.sym} 2340 22960 0 0 {name=l18463 lab=WL115}
N 2440 23040 2460 23040 {}
C {lab_pin.sym} 2460 23040 0 0 {name=l18464 lab=VDD}
N 2440 22960 2460 22960 {}
C {lab_pin.sym} 2460 22960 0 0 {name=l18465 lab=VSS}
C {bitcell_6t.sym} 2600 23000 0 0 {name=Xr115c13}
N 2560 23040 2540 23040 {}
C {lab_pin.sym} 2540 23040 0 0 {name=l18466 lab=BL13}
N 2560 23000 2540 23000 {}
C {lab_pin.sym} 2540 23000 0 0 {name=l18467 lab=BLB13}
N 2560 22960 2540 22960 {}
C {lab_pin.sym} 2540 22960 0 0 {name=l18468 lab=WL115}
N 2640 23040 2660 23040 {}
C {lab_pin.sym} 2660 23040 0 0 {name=l18469 lab=VDD}
N 2640 22960 2660 22960 {}
C {lab_pin.sym} 2660 22960 0 0 {name=l18470 lab=VSS}
C {bitcell_6t.sym} 2800 23000 0 0 {name=Xr115c14}
N 2760 23040 2740 23040 {}
C {lab_pin.sym} 2740 23040 0 0 {name=l18471 lab=BL14}
N 2760 23000 2740 23000 {}
C {lab_pin.sym} 2740 23000 0 0 {name=l18472 lab=BLB14}
N 2760 22960 2740 22960 {}
C {lab_pin.sym} 2740 22960 0 0 {name=l18473 lab=WL115}
N 2840 23040 2860 23040 {}
C {lab_pin.sym} 2860 23040 0 0 {name=l18474 lab=VDD}
N 2840 22960 2860 22960 {}
C {lab_pin.sym} 2860 22960 0 0 {name=l18475 lab=VSS}
C {bitcell_6t.sym} 3000 23000 0 0 {name=Xr115c15}
N 2960 23040 2940 23040 {}
C {lab_pin.sym} 2940 23040 0 0 {name=l18476 lab=BL15}
N 2960 23000 2940 23000 {}
C {lab_pin.sym} 2940 23000 0 0 {name=l18477 lab=BLB15}
N 2960 22960 2940 22960 {}
C {lab_pin.sym} 2940 22960 0 0 {name=l18478 lab=WL115}
N 3040 23040 3060 23040 {}
C {lab_pin.sym} 3060 23040 0 0 {name=l18479 lab=VDD}
N 3040 22960 3060 22960 {}
C {lab_pin.sym} 3060 22960 0 0 {name=l18480 lab=VSS}
C {bitcell_6t.sym} 3200 23000 0 0 {name=Xr115c16}
N 3160 23040 3140 23040 {}
C {lab_pin.sym} 3140 23040 0 0 {name=l18481 lab=BL16}
N 3160 23000 3140 23000 {}
C {lab_pin.sym} 3140 23000 0 0 {name=l18482 lab=BLB16}
N 3160 22960 3140 22960 {}
C {lab_pin.sym} 3140 22960 0 0 {name=l18483 lab=WL115}
N 3240 23040 3260 23040 {}
C {lab_pin.sym} 3260 23040 0 0 {name=l18484 lab=VDD}
N 3240 22960 3260 22960 {}
C {lab_pin.sym} 3260 22960 0 0 {name=l18485 lab=VSS}
C {bitcell_6t.sym} 3400 23000 0 0 {name=Xr115c17}
N 3360 23040 3340 23040 {}
C {lab_pin.sym} 3340 23040 0 0 {name=l18486 lab=BL17}
N 3360 23000 3340 23000 {}
C {lab_pin.sym} 3340 23000 0 0 {name=l18487 lab=BLB17}
N 3360 22960 3340 22960 {}
C {lab_pin.sym} 3340 22960 0 0 {name=l18488 lab=WL115}
N 3440 23040 3460 23040 {}
C {lab_pin.sym} 3460 23040 0 0 {name=l18489 lab=VDD}
N 3440 22960 3460 22960 {}
C {lab_pin.sym} 3460 22960 0 0 {name=l18490 lab=VSS}
C {bitcell_6t.sym} 3600 23000 0 0 {name=Xr115c18}
N 3560 23040 3540 23040 {}
C {lab_pin.sym} 3540 23040 0 0 {name=l18491 lab=BL18}
N 3560 23000 3540 23000 {}
C {lab_pin.sym} 3540 23000 0 0 {name=l18492 lab=BLB18}
N 3560 22960 3540 22960 {}
C {lab_pin.sym} 3540 22960 0 0 {name=l18493 lab=WL115}
N 3640 23040 3660 23040 {}
C {lab_pin.sym} 3660 23040 0 0 {name=l18494 lab=VDD}
N 3640 22960 3660 22960 {}
C {lab_pin.sym} 3660 22960 0 0 {name=l18495 lab=VSS}
C {bitcell_6t.sym} 3800 23000 0 0 {name=Xr115c19}
N 3760 23040 3740 23040 {}
C {lab_pin.sym} 3740 23040 0 0 {name=l18496 lab=BL19}
N 3760 23000 3740 23000 {}
C {lab_pin.sym} 3740 23000 0 0 {name=l18497 lab=BLB19}
N 3760 22960 3740 22960 {}
C {lab_pin.sym} 3740 22960 0 0 {name=l18498 lab=WL115}
N 3840 23040 3860 23040 {}
C {lab_pin.sym} 3860 23040 0 0 {name=l18499 lab=VDD}
N 3840 22960 3860 22960 {}
C {lab_pin.sym} 3860 22960 0 0 {name=l18500 lab=VSS}
C {bitcell_6t.sym} 4000 23000 0 0 {name=Xr115c20}
N 3960 23040 3940 23040 {}
C {lab_pin.sym} 3940 23040 0 0 {name=l18501 lab=BL20}
N 3960 23000 3940 23000 {}
C {lab_pin.sym} 3940 23000 0 0 {name=l18502 lab=BLB20}
N 3960 22960 3940 22960 {}
C {lab_pin.sym} 3940 22960 0 0 {name=l18503 lab=WL115}
N 4040 23040 4060 23040 {}
C {lab_pin.sym} 4060 23040 0 0 {name=l18504 lab=VDD}
N 4040 22960 4060 22960 {}
C {lab_pin.sym} 4060 22960 0 0 {name=l18505 lab=VSS}
C {bitcell_6t.sym} 4200 23000 0 0 {name=Xr115c21}
N 4160 23040 4140 23040 {}
C {lab_pin.sym} 4140 23040 0 0 {name=l18506 lab=BL21}
N 4160 23000 4140 23000 {}
C {lab_pin.sym} 4140 23000 0 0 {name=l18507 lab=BLB21}
N 4160 22960 4140 22960 {}
C {lab_pin.sym} 4140 22960 0 0 {name=l18508 lab=WL115}
N 4240 23040 4260 23040 {}
C {lab_pin.sym} 4260 23040 0 0 {name=l18509 lab=VDD}
N 4240 22960 4260 22960 {}
C {lab_pin.sym} 4260 22960 0 0 {name=l18510 lab=VSS}
C {bitcell_6t.sym} 4400 23000 0 0 {name=Xr115c22}
N 4360 23040 4340 23040 {}
C {lab_pin.sym} 4340 23040 0 0 {name=l18511 lab=BL22}
N 4360 23000 4340 23000 {}
C {lab_pin.sym} 4340 23000 0 0 {name=l18512 lab=BLB22}
N 4360 22960 4340 22960 {}
C {lab_pin.sym} 4340 22960 0 0 {name=l18513 lab=WL115}
N 4440 23040 4460 23040 {}
C {lab_pin.sym} 4460 23040 0 0 {name=l18514 lab=VDD}
N 4440 22960 4460 22960 {}
C {lab_pin.sym} 4460 22960 0 0 {name=l18515 lab=VSS}
C {bitcell_6t.sym} 4600 23000 0 0 {name=Xr115c23}
N 4560 23040 4540 23040 {}
C {lab_pin.sym} 4540 23040 0 0 {name=l18516 lab=BL23}
N 4560 23000 4540 23000 {}
C {lab_pin.sym} 4540 23000 0 0 {name=l18517 lab=BLB23}
N 4560 22960 4540 22960 {}
C {lab_pin.sym} 4540 22960 0 0 {name=l18518 lab=WL115}
N 4640 23040 4660 23040 {}
C {lab_pin.sym} 4660 23040 0 0 {name=l18519 lab=VDD}
N 4640 22960 4660 22960 {}
C {lab_pin.sym} 4660 22960 0 0 {name=l18520 lab=VSS}
C {bitcell_6t.sym} 4800 23000 0 0 {name=Xr115c24}
N 4760 23040 4740 23040 {}
C {lab_pin.sym} 4740 23040 0 0 {name=l18521 lab=BL24}
N 4760 23000 4740 23000 {}
C {lab_pin.sym} 4740 23000 0 0 {name=l18522 lab=BLB24}
N 4760 22960 4740 22960 {}
C {lab_pin.sym} 4740 22960 0 0 {name=l18523 lab=WL115}
N 4840 23040 4860 23040 {}
C {lab_pin.sym} 4860 23040 0 0 {name=l18524 lab=VDD}
N 4840 22960 4860 22960 {}
C {lab_pin.sym} 4860 22960 0 0 {name=l18525 lab=VSS}
C {bitcell_6t.sym} 5000 23000 0 0 {name=Xr115c25}
N 4960 23040 4940 23040 {}
C {lab_pin.sym} 4940 23040 0 0 {name=l18526 lab=BL25}
N 4960 23000 4940 23000 {}
C {lab_pin.sym} 4940 23000 0 0 {name=l18527 lab=BLB25}
N 4960 22960 4940 22960 {}
C {lab_pin.sym} 4940 22960 0 0 {name=l18528 lab=WL115}
N 5040 23040 5060 23040 {}
C {lab_pin.sym} 5060 23040 0 0 {name=l18529 lab=VDD}
N 5040 22960 5060 22960 {}
C {lab_pin.sym} 5060 22960 0 0 {name=l18530 lab=VSS}
C {bitcell_6t.sym} 5200 23000 0 0 {name=Xr115c26}
N 5160 23040 5140 23040 {}
C {lab_pin.sym} 5140 23040 0 0 {name=l18531 lab=BL26}
N 5160 23000 5140 23000 {}
C {lab_pin.sym} 5140 23000 0 0 {name=l18532 lab=BLB26}
N 5160 22960 5140 22960 {}
C {lab_pin.sym} 5140 22960 0 0 {name=l18533 lab=WL115}
N 5240 23040 5260 23040 {}
C {lab_pin.sym} 5260 23040 0 0 {name=l18534 lab=VDD}
N 5240 22960 5260 22960 {}
C {lab_pin.sym} 5260 22960 0 0 {name=l18535 lab=VSS}
C {bitcell_6t.sym} 5400 23000 0 0 {name=Xr115c27}
N 5360 23040 5340 23040 {}
C {lab_pin.sym} 5340 23040 0 0 {name=l18536 lab=BL27}
N 5360 23000 5340 23000 {}
C {lab_pin.sym} 5340 23000 0 0 {name=l18537 lab=BLB27}
N 5360 22960 5340 22960 {}
C {lab_pin.sym} 5340 22960 0 0 {name=l18538 lab=WL115}
N 5440 23040 5460 23040 {}
C {lab_pin.sym} 5460 23040 0 0 {name=l18539 lab=VDD}
N 5440 22960 5460 22960 {}
C {lab_pin.sym} 5460 22960 0 0 {name=l18540 lab=VSS}
C {bitcell_6t.sym} 5600 23000 0 0 {name=Xr115c28}
N 5560 23040 5540 23040 {}
C {lab_pin.sym} 5540 23040 0 0 {name=l18541 lab=BL28}
N 5560 23000 5540 23000 {}
C {lab_pin.sym} 5540 23000 0 0 {name=l18542 lab=BLB28}
N 5560 22960 5540 22960 {}
C {lab_pin.sym} 5540 22960 0 0 {name=l18543 lab=WL115}
N 5640 23040 5660 23040 {}
C {lab_pin.sym} 5660 23040 0 0 {name=l18544 lab=VDD}
N 5640 22960 5660 22960 {}
C {lab_pin.sym} 5660 22960 0 0 {name=l18545 lab=VSS}
C {bitcell_6t.sym} 5800 23000 0 0 {name=Xr115c29}
N 5760 23040 5740 23040 {}
C {lab_pin.sym} 5740 23040 0 0 {name=l18546 lab=BL29}
N 5760 23000 5740 23000 {}
C {lab_pin.sym} 5740 23000 0 0 {name=l18547 lab=BLB29}
N 5760 22960 5740 22960 {}
C {lab_pin.sym} 5740 22960 0 0 {name=l18548 lab=WL115}
N 5840 23040 5860 23040 {}
C {lab_pin.sym} 5860 23040 0 0 {name=l18549 lab=VDD}
N 5840 22960 5860 22960 {}
C {lab_pin.sym} 5860 22960 0 0 {name=l18550 lab=VSS}
C {bitcell_6t.sym} 6000 23000 0 0 {name=Xr115c30}
N 5960 23040 5940 23040 {}
C {lab_pin.sym} 5940 23040 0 0 {name=l18551 lab=BL30}
N 5960 23000 5940 23000 {}
C {lab_pin.sym} 5940 23000 0 0 {name=l18552 lab=BLB30}
N 5960 22960 5940 22960 {}
C {lab_pin.sym} 5940 22960 0 0 {name=l18553 lab=WL115}
N 6040 23040 6060 23040 {}
C {lab_pin.sym} 6060 23040 0 0 {name=l18554 lab=VDD}
N 6040 22960 6060 22960 {}
C {lab_pin.sym} 6060 22960 0 0 {name=l18555 lab=VSS}
C {bitcell_6t.sym} 6200 23000 0 0 {name=Xr115c31}
N 6160 23040 6140 23040 {}
C {lab_pin.sym} 6140 23040 0 0 {name=l18556 lab=BL31}
N 6160 23000 6140 23000 {}
C {lab_pin.sym} 6140 23000 0 0 {name=l18557 lab=BLB31}
N 6160 22960 6140 22960 {}
C {lab_pin.sym} 6140 22960 0 0 {name=l18558 lab=WL115}
N 6240 23040 6260 23040 {}
C {lab_pin.sym} 6260 23040 0 0 {name=l18559 lab=VDD}
N 6240 22960 6260 22960 {}
C {lab_pin.sym} 6260 22960 0 0 {name=l18560 lab=VSS}
C {bitcell_6t.sym} 0 23200 0 0 {name=Xr116c0}
N -40 23240 -60 23240 {}
C {lab_pin.sym} -60 23240 0 0 {name=l18561 lab=BL0}
N -40 23200 -60 23200 {}
C {lab_pin.sym} -60 23200 0 0 {name=l18562 lab=BLB0}
N -40 23160 -60 23160 {}
C {lab_pin.sym} -60 23160 0 0 {name=l18563 lab=WL116}
N 40 23240 60 23240 {}
C {lab_pin.sym} 60 23240 0 0 {name=l18564 lab=VDD}
N 40 23160 60 23160 {}
C {lab_pin.sym} 60 23160 0 0 {name=l18565 lab=VSS}
C {bitcell_6t.sym} 200 23200 0 0 {name=Xr116c1}
N 160 23240 140 23240 {}
C {lab_pin.sym} 140 23240 0 0 {name=l18566 lab=BL1}
N 160 23200 140 23200 {}
C {lab_pin.sym} 140 23200 0 0 {name=l18567 lab=BLB1}
N 160 23160 140 23160 {}
C {lab_pin.sym} 140 23160 0 0 {name=l18568 lab=WL116}
N 240 23240 260 23240 {}
C {lab_pin.sym} 260 23240 0 0 {name=l18569 lab=VDD}
N 240 23160 260 23160 {}
C {lab_pin.sym} 260 23160 0 0 {name=l18570 lab=VSS}
C {bitcell_6t.sym} 400 23200 0 0 {name=Xr116c2}
N 360 23240 340 23240 {}
C {lab_pin.sym} 340 23240 0 0 {name=l18571 lab=BL2}
N 360 23200 340 23200 {}
C {lab_pin.sym} 340 23200 0 0 {name=l18572 lab=BLB2}
N 360 23160 340 23160 {}
C {lab_pin.sym} 340 23160 0 0 {name=l18573 lab=WL116}
N 440 23240 460 23240 {}
C {lab_pin.sym} 460 23240 0 0 {name=l18574 lab=VDD}
N 440 23160 460 23160 {}
C {lab_pin.sym} 460 23160 0 0 {name=l18575 lab=VSS}
C {bitcell_6t.sym} 600 23200 0 0 {name=Xr116c3}
N 560 23240 540 23240 {}
C {lab_pin.sym} 540 23240 0 0 {name=l18576 lab=BL3}
N 560 23200 540 23200 {}
C {lab_pin.sym} 540 23200 0 0 {name=l18577 lab=BLB3}
N 560 23160 540 23160 {}
C {lab_pin.sym} 540 23160 0 0 {name=l18578 lab=WL116}
N 640 23240 660 23240 {}
C {lab_pin.sym} 660 23240 0 0 {name=l18579 lab=VDD}
N 640 23160 660 23160 {}
C {lab_pin.sym} 660 23160 0 0 {name=l18580 lab=VSS}
C {bitcell_6t.sym} 800 23200 0 0 {name=Xr116c4}
N 760 23240 740 23240 {}
C {lab_pin.sym} 740 23240 0 0 {name=l18581 lab=BL4}
N 760 23200 740 23200 {}
C {lab_pin.sym} 740 23200 0 0 {name=l18582 lab=BLB4}
N 760 23160 740 23160 {}
C {lab_pin.sym} 740 23160 0 0 {name=l18583 lab=WL116}
N 840 23240 860 23240 {}
C {lab_pin.sym} 860 23240 0 0 {name=l18584 lab=VDD}
N 840 23160 860 23160 {}
C {lab_pin.sym} 860 23160 0 0 {name=l18585 lab=VSS}
C {bitcell_6t.sym} 1000 23200 0 0 {name=Xr116c5}
N 960 23240 940 23240 {}
C {lab_pin.sym} 940 23240 0 0 {name=l18586 lab=BL5}
N 960 23200 940 23200 {}
C {lab_pin.sym} 940 23200 0 0 {name=l18587 lab=BLB5}
N 960 23160 940 23160 {}
C {lab_pin.sym} 940 23160 0 0 {name=l18588 lab=WL116}
N 1040 23240 1060 23240 {}
C {lab_pin.sym} 1060 23240 0 0 {name=l18589 lab=VDD}
N 1040 23160 1060 23160 {}
C {lab_pin.sym} 1060 23160 0 0 {name=l18590 lab=VSS}
C {bitcell_6t.sym} 1200 23200 0 0 {name=Xr116c6}
N 1160 23240 1140 23240 {}
C {lab_pin.sym} 1140 23240 0 0 {name=l18591 lab=BL6}
N 1160 23200 1140 23200 {}
C {lab_pin.sym} 1140 23200 0 0 {name=l18592 lab=BLB6}
N 1160 23160 1140 23160 {}
C {lab_pin.sym} 1140 23160 0 0 {name=l18593 lab=WL116}
N 1240 23240 1260 23240 {}
C {lab_pin.sym} 1260 23240 0 0 {name=l18594 lab=VDD}
N 1240 23160 1260 23160 {}
C {lab_pin.sym} 1260 23160 0 0 {name=l18595 lab=VSS}
C {bitcell_6t.sym} 1400 23200 0 0 {name=Xr116c7}
N 1360 23240 1340 23240 {}
C {lab_pin.sym} 1340 23240 0 0 {name=l18596 lab=BL7}
N 1360 23200 1340 23200 {}
C {lab_pin.sym} 1340 23200 0 0 {name=l18597 lab=BLB7}
N 1360 23160 1340 23160 {}
C {lab_pin.sym} 1340 23160 0 0 {name=l18598 lab=WL116}
N 1440 23240 1460 23240 {}
C {lab_pin.sym} 1460 23240 0 0 {name=l18599 lab=VDD}
N 1440 23160 1460 23160 {}
C {lab_pin.sym} 1460 23160 0 0 {name=l18600 lab=VSS}
C {bitcell_6t.sym} 1600 23200 0 0 {name=Xr116c8}
N 1560 23240 1540 23240 {}
C {lab_pin.sym} 1540 23240 0 0 {name=l18601 lab=BL8}
N 1560 23200 1540 23200 {}
C {lab_pin.sym} 1540 23200 0 0 {name=l18602 lab=BLB8}
N 1560 23160 1540 23160 {}
C {lab_pin.sym} 1540 23160 0 0 {name=l18603 lab=WL116}
N 1640 23240 1660 23240 {}
C {lab_pin.sym} 1660 23240 0 0 {name=l18604 lab=VDD}
N 1640 23160 1660 23160 {}
C {lab_pin.sym} 1660 23160 0 0 {name=l18605 lab=VSS}
C {bitcell_6t.sym} 1800 23200 0 0 {name=Xr116c9}
N 1760 23240 1740 23240 {}
C {lab_pin.sym} 1740 23240 0 0 {name=l18606 lab=BL9}
N 1760 23200 1740 23200 {}
C {lab_pin.sym} 1740 23200 0 0 {name=l18607 lab=BLB9}
N 1760 23160 1740 23160 {}
C {lab_pin.sym} 1740 23160 0 0 {name=l18608 lab=WL116}
N 1840 23240 1860 23240 {}
C {lab_pin.sym} 1860 23240 0 0 {name=l18609 lab=VDD}
N 1840 23160 1860 23160 {}
C {lab_pin.sym} 1860 23160 0 0 {name=l18610 lab=VSS}
C {bitcell_6t.sym} 2000 23200 0 0 {name=Xr116c10}
N 1960 23240 1940 23240 {}
C {lab_pin.sym} 1940 23240 0 0 {name=l18611 lab=BL10}
N 1960 23200 1940 23200 {}
C {lab_pin.sym} 1940 23200 0 0 {name=l18612 lab=BLB10}
N 1960 23160 1940 23160 {}
C {lab_pin.sym} 1940 23160 0 0 {name=l18613 lab=WL116}
N 2040 23240 2060 23240 {}
C {lab_pin.sym} 2060 23240 0 0 {name=l18614 lab=VDD}
N 2040 23160 2060 23160 {}
C {lab_pin.sym} 2060 23160 0 0 {name=l18615 lab=VSS}
C {bitcell_6t.sym} 2200 23200 0 0 {name=Xr116c11}
N 2160 23240 2140 23240 {}
C {lab_pin.sym} 2140 23240 0 0 {name=l18616 lab=BL11}
N 2160 23200 2140 23200 {}
C {lab_pin.sym} 2140 23200 0 0 {name=l18617 lab=BLB11}
N 2160 23160 2140 23160 {}
C {lab_pin.sym} 2140 23160 0 0 {name=l18618 lab=WL116}
N 2240 23240 2260 23240 {}
C {lab_pin.sym} 2260 23240 0 0 {name=l18619 lab=VDD}
N 2240 23160 2260 23160 {}
C {lab_pin.sym} 2260 23160 0 0 {name=l18620 lab=VSS}
C {bitcell_6t.sym} 2400 23200 0 0 {name=Xr116c12}
N 2360 23240 2340 23240 {}
C {lab_pin.sym} 2340 23240 0 0 {name=l18621 lab=BL12}
N 2360 23200 2340 23200 {}
C {lab_pin.sym} 2340 23200 0 0 {name=l18622 lab=BLB12}
N 2360 23160 2340 23160 {}
C {lab_pin.sym} 2340 23160 0 0 {name=l18623 lab=WL116}
N 2440 23240 2460 23240 {}
C {lab_pin.sym} 2460 23240 0 0 {name=l18624 lab=VDD}
N 2440 23160 2460 23160 {}
C {lab_pin.sym} 2460 23160 0 0 {name=l18625 lab=VSS}
C {bitcell_6t.sym} 2600 23200 0 0 {name=Xr116c13}
N 2560 23240 2540 23240 {}
C {lab_pin.sym} 2540 23240 0 0 {name=l18626 lab=BL13}
N 2560 23200 2540 23200 {}
C {lab_pin.sym} 2540 23200 0 0 {name=l18627 lab=BLB13}
N 2560 23160 2540 23160 {}
C {lab_pin.sym} 2540 23160 0 0 {name=l18628 lab=WL116}
N 2640 23240 2660 23240 {}
C {lab_pin.sym} 2660 23240 0 0 {name=l18629 lab=VDD}
N 2640 23160 2660 23160 {}
C {lab_pin.sym} 2660 23160 0 0 {name=l18630 lab=VSS}
C {bitcell_6t.sym} 2800 23200 0 0 {name=Xr116c14}
N 2760 23240 2740 23240 {}
C {lab_pin.sym} 2740 23240 0 0 {name=l18631 lab=BL14}
N 2760 23200 2740 23200 {}
C {lab_pin.sym} 2740 23200 0 0 {name=l18632 lab=BLB14}
N 2760 23160 2740 23160 {}
C {lab_pin.sym} 2740 23160 0 0 {name=l18633 lab=WL116}
N 2840 23240 2860 23240 {}
C {lab_pin.sym} 2860 23240 0 0 {name=l18634 lab=VDD}
N 2840 23160 2860 23160 {}
C {lab_pin.sym} 2860 23160 0 0 {name=l18635 lab=VSS}
C {bitcell_6t.sym} 3000 23200 0 0 {name=Xr116c15}
N 2960 23240 2940 23240 {}
C {lab_pin.sym} 2940 23240 0 0 {name=l18636 lab=BL15}
N 2960 23200 2940 23200 {}
C {lab_pin.sym} 2940 23200 0 0 {name=l18637 lab=BLB15}
N 2960 23160 2940 23160 {}
C {lab_pin.sym} 2940 23160 0 0 {name=l18638 lab=WL116}
N 3040 23240 3060 23240 {}
C {lab_pin.sym} 3060 23240 0 0 {name=l18639 lab=VDD}
N 3040 23160 3060 23160 {}
C {lab_pin.sym} 3060 23160 0 0 {name=l18640 lab=VSS}
C {bitcell_6t.sym} 3200 23200 0 0 {name=Xr116c16}
N 3160 23240 3140 23240 {}
C {lab_pin.sym} 3140 23240 0 0 {name=l18641 lab=BL16}
N 3160 23200 3140 23200 {}
C {lab_pin.sym} 3140 23200 0 0 {name=l18642 lab=BLB16}
N 3160 23160 3140 23160 {}
C {lab_pin.sym} 3140 23160 0 0 {name=l18643 lab=WL116}
N 3240 23240 3260 23240 {}
C {lab_pin.sym} 3260 23240 0 0 {name=l18644 lab=VDD}
N 3240 23160 3260 23160 {}
C {lab_pin.sym} 3260 23160 0 0 {name=l18645 lab=VSS}
C {bitcell_6t.sym} 3400 23200 0 0 {name=Xr116c17}
N 3360 23240 3340 23240 {}
C {lab_pin.sym} 3340 23240 0 0 {name=l18646 lab=BL17}
N 3360 23200 3340 23200 {}
C {lab_pin.sym} 3340 23200 0 0 {name=l18647 lab=BLB17}
N 3360 23160 3340 23160 {}
C {lab_pin.sym} 3340 23160 0 0 {name=l18648 lab=WL116}
N 3440 23240 3460 23240 {}
C {lab_pin.sym} 3460 23240 0 0 {name=l18649 lab=VDD}
N 3440 23160 3460 23160 {}
C {lab_pin.sym} 3460 23160 0 0 {name=l18650 lab=VSS}
C {bitcell_6t.sym} 3600 23200 0 0 {name=Xr116c18}
N 3560 23240 3540 23240 {}
C {lab_pin.sym} 3540 23240 0 0 {name=l18651 lab=BL18}
N 3560 23200 3540 23200 {}
C {lab_pin.sym} 3540 23200 0 0 {name=l18652 lab=BLB18}
N 3560 23160 3540 23160 {}
C {lab_pin.sym} 3540 23160 0 0 {name=l18653 lab=WL116}
N 3640 23240 3660 23240 {}
C {lab_pin.sym} 3660 23240 0 0 {name=l18654 lab=VDD}
N 3640 23160 3660 23160 {}
C {lab_pin.sym} 3660 23160 0 0 {name=l18655 lab=VSS}
C {bitcell_6t.sym} 3800 23200 0 0 {name=Xr116c19}
N 3760 23240 3740 23240 {}
C {lab_pin.sym} 3740 23240 0 0 {name=l18656 lab=BL19}
N 3760 23200 3740 23200 {}
C {lab_pin.sym} 3740 23200 0 0 {name=l18657 lab=BLB19}
N 3760 23160 3740 23160 {}
C {lab_pin.sym} 3740 23160 0 0 {name=l18658 lab=WL116}
N 3840 23240 3860 23240 {}
C {lab_pin.sym} 3860 23240 0 0 {name=l18659 lab=VDD}
N 3840 23160 3860 23160 {}
C {lab_pin.sym} 3860 23160 0 0 {name=l18660 lab=VSS}
C {bitcell_6t.sym} 4000 23200 0 0 {name=Xr116c20}
N 3960 23240 3940 23240 {}
C {lab_pin.sym} 3940 23240 0 0 {name=l18661 lab=BL20}
N 3960 23200 3940 23200 {}
C {lab_pin.sym} 3940 23200 0 0 {name=l18662 lab=BLB20}
N 3960 23160 3940 23160 {}
C {lab_pin.sym} 3940 23160 0 0 {name=l18663 lab=WL116}
N 4040 23240 4060 23240 {}
C {lab_pin.sym} 4060 23240 0 0 {name=l18664 lab=VDD}
N 4040 23160 4060 23160 {}
C {lab_pin.sym} 4060 23160 0 0 {name=l18665 lab=VSS}
C {bitcell_6t.sym} 4200 23200 0 0 {name=Xr116c21}
N 4160 23240 4140 23240 {}
C {lab_pin.sym} 4140 23240 0 0 {name=l18666 lab=BL21}
N 4160 23200 4140 23200 {}
C {lab_pin.sym} 4140 23200 0 0 {name=l18667 lab=BLB21}
N 4160 23160 4140 23160 {}
C {lab_pin.sym} 4140 23160 0 0 {name=l18668 lab=WL116}
N 4240 23240 4260 23240 {}
C {lab_pin.sym} 4260 23240 0 0 {name=l18669 lab=VDD}
N 4240 23160 4260 23160 {}
C {lab_pin.sym} 4260 23160 0 0 {name=l18670 lab=VSS}
C {bitcell_6t.sym} 4400 23200 0 0 {name=Xr116c22}
N 4360 23240 4340 23240 {}
C {lab_pin.sym} 4340 23240 0 0 {name=l18671 lab=BL22}
N 4360 23200 4340 23200 {}
C {lab_pin.sym} 4340 23200 0 0 {name=l18672 lab=BLB22}
N 4360 23160 4340 23160 {}
C {lab_pin.sym} 4340 23160 0 0 {name=l18673 lab=WL116}
N 4440 23240 4460 23240 {}
C {lab_pin.sym} 4460 23240 0 0 {name=l18674 lab=VDD}
N 4440 23160 4460 23160 {}
C {lab_pin.sym} 4460 23160 0 0 {name=l18675 lab=VSS}
C {bitcell_6t.sym} 4600 23200 0 0 {name=Xr116c23}
N 4560 23240 4540 23240 {}
C {lab_pin.sym} 4540 23240 0 0 {name=l18676 lab=BL23}
N 4560 23200 4540 23200 {}
C {lab_pin.sym} 4540 23200 0 0 {name=l18677 lab=BLB23}
N 4560 23160 4540 23160 {}
C {lab_pin.sym} 4540 23160 0 0 {name=l18678 lab=WL116}
N 4640 23240 4660 23240 {}
C {lab_pin.sym} 4660 23240 0 0 {name=l18679 lab=VDD}
N 4640 23160 4660 23160 {}
C {lab_pin.sym} 4660 23160 0 0 {name=l18680 lab=VSS}
C {bitcell_6t.sym} 4800 23200 0 0 {name=Xr116c24}
N 4760 23240 4740 23240 {}
C {lab_pin.sym} 4740 23240 0 0 {name=l18681 lab=BL24}
N 4760 23200 4740 23200 {}
C {lab_pin.sym} 4740 23200 0 0 {name=l18682 lab=BLB24}
N 4760 23160 4740 23160 {}
C {lab_pin.sym} 4740 23160 0 0 {name=l18683 lab=WL116}
N 4840 23240 4860 23240 {}
C {lab_pin.sym} 4860 23240 0 0 {name=l18684 lab=VDD}
N 4840 23160 4860 23160 {}
C {lab_pin.sym} 4860 23160 0 0 {name=l18685 lab=VSS}
C {bitcell_6t.sym} 5000 23200 0 0 {name=Xr116c25}
N 4960 23240 4940 23240 {}
C {lab_pin.sym} 4940 23240 0 0 {name=l18686 lab=BL25}
N 4960 23200 4940 23200 {}
C {lab_pin.sym} 4940 23200 0 0 {name=l18687 lab=BLB25}
N 4960 23160 4940 23160 {}
C {lab_pin.sym} 4940 23160 0 0 {name=l18688 lab=WL116}
N 5040 23240 5060 23240 {}
C {lab_pin.sym} 5060 23240 0 0 {name=l18689 lab=VDD}
N 5040 23160 5060 23160 {}
C {lab_pin.sym} 5060 23160 0 0 {name=l18690 lab=VSS}
C {bitcell_6t.sym} 5200 23200 0 0 {name=Xr116c26}
N 5160 23240 5140 23240 {}
C {lab_pin.sym} 5140 23240 0 0 {name=l18691 lab=BL26}
N 5160 23200 5140 23200 {}
C {lab_pin.sym} 5140 23200 0 0 {name=l18692 lab=BLB26}
N 5160 23160 5140 23160 {}
C {lab_pin.sym} 5140 23160 0 0 {name=l18693 lab=WL116}
N 5240 23240 5260 23240 {}
C {lab_pin.sym} 5260 23240 0 0 {name=l18694 lab=VDD}
N 5240 23160 5260 23160 {}
C {lab_pin.sym} 5260 23160 0 0 {name=l18695 lab=VSS}
C {bitcell_6t.sym} 5400 23200 0 0 {name=Xr116c27}
N 5360 23240 5340 23240 {}
C {lab_pin.sym} 5340 23240 0 0 {name=l18696 lab=BL27}
N 5360 23200 5340 23200 {}
C {lab_pin.sym} 5340 23200 0 0 {name=l18697 lab=BLB27}
N 5360 23160 5340 23160 {}
C {lab_pin.sym} 5340 23160 0 0 {name=l18698 lab=WL116}
N 5440 23240 5460 23240 {}
C {lab_pin.sym} 5460 23240 0 0 {name=l18699 lab=VDD}
N 5440 23160 5460 23160 {}
C {lab_pin.sym} 5460 23160 0 0 {name=l18700 lab=VSS}
C {bitcell_6t.sym} 5600 23200 0 0 {name=Xr116c28}
N 5560 23240 5540 23240 {}
C {lab_pin.sym} 5540 23240 0 0 {name=l18701 lab=BL28}
N 5560 23200 5540 23200 {}
C {lab_pin.sym} 5540 23200 0 0 {name=l18702 lab=BLB28}
N 5560 23160 5540 23160 {}
C {lab_pin.sym} 5540 23160 0 0 {name=l18703 lab=WL116}
N 5640 23240 5660 23240 {}
C {lab_pin.sym} 5660 23240 0 0 {name=l18704 lab=VDD}
N 5640 23160 5660 23160 {}
C {lab_pin.sym} 5660 23160 0 0 {name=l18705 lab=VSS}
C {bitcell_6t.sym} 5800 23200 0 0 {name=Xr116c29}
N 5760 23240 5740 23240 {}
C {lab_pin.sym} 5740 23240 0 0 {name=l18706 lab=BL29}
N 5760 23200 5740 23200 {}
C {lab_pin.sym} 5740 23200 0 0 {name=l18707 lab=BLB29}
N 5760 23160 5740 23160 {}
C {lab_pin.sym} 5740 23160 0 0 {name=l18708 lab=WL116}
N 5840 23240 5860 23240 {}
C {lab_pin.sym} 5860 23240 0 0 {name=l18709 lab=VDD}
N 5840 23160 5860 23160 {}
C {lab_pin.sym} 5860 23160 0 0 {name=l18710 lab=VSS}
C {bitcell_6t.sym} 6000 23200 0 0 {name=Xr116c30}
N 5960 23240 5940 23240 {}
C {lab_pin.sym} 5940 23240 0 0 {name=l18711 lab=BL30}
N 5960 23200 5940 23200 {}
C {lab_pin.sym} 5940 23200 0 0 {name=l18712 lab=BLB30}
N 5960 23160 5940 23160 {}
C {lab_pin.sym} 5940 23160 0 0 {name=l18713 lab=WL116}
N 6040 23240 6060 23240 {}
C {lab_pin.sym} 6060 23240 0 0 {name=l18714 lab=VDD}
N 6040 23160 6060 23160 {}
C {lab_pin.sym} 6060 23160 0 0 {name=l18715 lab=VSS}
C {bitcell_6t.sym} 6200 23200 0 0 {name=Xr116c31}
N 6160 23240 6140 23240 {}
C {lab_pin.sym} 6140 23240 0 0 {name=l18716 lab=BL31}
N 6160 23200 6140 23200 {}
C {lab_pin.sym} 6140 23200 0 0 {name=l18717 lab=BLB31}
N 6160 23160 6140 23160 {}
C {lab_pin.sym} 6140 23160 0 0 {name=l18718 lab=WL116}
N 6240 23240 6260 23240 {}
C {lab_pin.sym} 6260 23240 0 0 {name=l18719 lab=VDD}
N 6240 23160 6260 23160 {}
C {lab_pin.sym} 6260 23160 0 0 {name=l18720 lab=VSS}
C {bitcell_6t.sym} 0 23400 0 0 {name=Xr117c0}
N -40 23440 -60 23440 {}
C {lab_pin.sym} -60 23440 0 0 {name=l18721 lab=BL0}
N -40 23400 -60 23400 {}
C {lab_pin.sym} -60 23400 0 0 {name=l18722 lab=BLB0}
N -40 23360 -60 23360 {}
C {lab_pin.sym} -60 23360 0 0 {name=l18723 lab=WL117}
N 40 23440 60 23440 {}
C {lab_pin.sym} 60 23440 0 0 {name=l18724 lab=VDD}
N 40 23360 60 23360 {}
C {lab_pin.sym} 60 23360 0 0 {name=l18725 lab=VSS}
C {bitcell_6t.sym} 200 23400 0 0 {name=Xr117c1}
N 160 23440 140 23440 {}
C {lab_pin.sym} 140 23440 0 0 {name=l18726 lab=BL1}
N 160 23400 140 23400 {}
C {lab_pin.sym} 140 23400 0 0 {name=l18727 lab=BLB1}
N 160 23360 140 23360 {}
C {lab_pin.sym} 140 23360 0 0 {name=l18728 lab=WL117}
N 240 23440 260 23440 {}
C {lab_pin.sym} 260 23440 0 0 {name=l18729 lab=VDD}
N 240 23360 260 23360 {}
C {lab_pin.sym} 260 23360 0 0 {name=l18730 lab=VSS}
C {bitcell_6t.sym} 400 23400 0 0 {name=Xr117c2}
N 360 23440 340 23440 {}
C {lab_pin.sym} 340 23440 0 0 {name=l18731 lab=BL2}
N 360 23400 340 23400 {}
C {lab_pin.sym} 340 23400 0 0 {name=l18732 lab=BLB2}
N 360 23360 340 23360 {}
C {lab_pin.sym} 340 23360 0 0 {name=l18733 lab=WL117}
N 440 23440 460 23440 {}
C {lab_pin.sym} 460 23440 0 0 {name=l18734 lab=VDD}
N 440 23360 460 23360 {}
C {lab_pin.sym} 460 23360 0 0 {name=l18735 lab=VSS}
C {bitcell_6t.sym} 600 23400 0 0 {name=Xr117c3}
N 560 23440 540 23440 {}
C {lab_pin.sym} 540 23440 0 0 {name=l18736 lab=BL3}
N 560 23400 540 23400 {}
C {lab_pin.sym} 540 23400 0 0 {name=l18737 lab=BLB3}
N 560 23360 540 23360 {}
C {lab_pin.sym} 540 23360 0 0 {name=l18738 lab=WL117}
N 640 23440 660 23440 {}
C {lab_pin.sym} 660 23440 0 0 {name=l18739 lab=VDD}
N 640 23360 660 23360 {}
C {lab_pin.sym} 660 23360 0 0 {name=l18740 lab=VSS}
C {bitcell_6t.sym} 800 23400 0 0 {name=Xr117c4}
N 760 23440 740 23440 {}
C {lab_pin.sym} 740 23440 0 0 {name=l18741 lab=BL4}
N 760 23400 740 23400 {}
C {lab_pin.sym} 740 23400 0 0 {name=l18742 lab=BLB4}
N 760 23360 740 23360 {}
C {lab_pin.sym} 740 23360 0 0 {name=l18743 lab=WL117}
N 840 23440 860 23440 {}
C {lab_pin.sym} 860 23440 0 0 {name=l18744 lab=VDD}
N 840 23360 860 23360 {}
C {lab_pin.sym} 860 23360 0 0 {name=l18745 lab=VSS}
C {bitcell_6t.sym} 1000 23400 0 0 {name=Xr117c5}
N 960 23440 940 23440 {}
C {lab_pin.sym} 940 23440 0 0 {name=l18746 lab=BL5}
N 960 23400 940 23400 {}
C {lab_pin.sym} 940 23400 0 0 {name=l18747 lab=BLB5}
N 960 23360 940 23360 {}
C {lab_pin.sym} 940 23360 0 0 {name=l18748 lab=WL117}
N 1040 23440 1060 23440 {}
C {lab_pin.sym} 1060 23440 0 0 {name=l18749 lab=VDD}
N 1040 23360 1060 23360 {}
C {lab_pin.sym} 1060 23360 0 0 {name=l18750 lab=VSS}
C {bitcell_6t.sym} 1200 23400 0 0 {name=Xr117c6}
N 1160 23440 1140 23440 {}
C {lab_pin.sym} 1140 23440 0 0 {name=l18751 lab=BL6}
N 1160 23400 1140 23400 {}
C {lab_pin.sym} 1140 23400 0 0 {name=l18752 lab=BLB6}
N 1160 23360 1140 23360 {}
C {lab_pin.sym} 1140 23360 0 0 {name=l18753 lab=WL117}
N 1240 23440 1260 23440 {}
C {lab_pin.sym} 1260 23440 0 0 {name=l18754 lab=VDD}
N 1240 23360 1260 23360 {}
C {lab_pin.sym} 1260 23360 0 0 {name=l18755 lab=VSS}
C {bitcell_6t.sym} 1400 23400 0 0 {name=Xr117c7}
N 1360 23440 1340 23440 {}
C {lab_pin.sym} 1340 23440 0 0 {name=l18756 lab=BL7}
N 1360 23400 1340 23400 {}
C {lab_pin.sym} 1340 23400 0 0 {name=l18757 lab=BLB7}
N 1360 23360 1340 23360 {}
C {lab_pin.sym} 1340 23360 0 0 {name=l18758 lab=WL117}
N 1440 23440 1460 23440 {}
C {lab_pin.sym} 1460 23440 0 0 {name=l18759 lab=VDD}
N 1440 23360 1460 23360 {}
C {lab_pin.sym} 1460 23360 0 0 {name=l18760 lab=VSS}
C {bitcell_6t.sym} 1600 23400 0 0 {name=Xr117c8}
N 1560 23440 1540 23440 {}
C {lab_pin.sym} 1540 23440 0 0 {name=l18761 lab=BL8}
N 1560 23400 1540 23400 {}
C {lab_pin.sym} 1540 23400 0 0 {name=l18762 lab=BLB8}
N 1560 23360 1540 23360 {}
C {lab_pin.sym} 1540 23360 0 0 {name=l18763 lab=WL117}
N 1640 23440 1660 23440 {}
C {lab_pin.sym} 1660 23440 0 0 {name=l18764 lab=VDD}
N 1640 23360 1660 23360 {}
C {lab_pin.sym} 1660 23360 0 0 {name=l18765 lab=VSS}
C {bitcell_6t.sym} 1800 23400 0 0 {name=Xr117c9}
N 1760 23440 1740 23440 {}
C {lab_pin.sym} 1740 23440 0 0 {name=l18766 lab=BL9}
N 1760 23400 1740 23400 {}
C {lab_pin.sym} 1740 23400 0 0 {name=l18767 lab=BLB9}
N 1760 23360 1740 23360 {}
C {lab_pin.sym} 1740 23360 0 0 {name=l18768 lab=WL117}
N 1840 23440 1860 23440 {}
C {lab_pin.sym} 1860 23440 0 0 {name=l18769 lab=VDD}
N 1840 23360 1860 23360 {}
C {lab_pin.sym} 1860 23360 0 0 {name=l18770 lab=VSS}
C {bitcell_6t.sym} 2000 23400 0 0 {name=Xr117c10}
N 1960 23440 1940 23440 {}
C {lab_pin.sym} 1940 23440 0 0 {name=l18771 lab=BL10}
N 1960 23400 1940 23400 {}
C {lab_pin.sym} 1940 23400 0 0 {name=l18772 lab=BLB10}
N 1960 23360 1940 23360 {}
C {lab_pin.sym} 1940 23360 0 0 {name=l18773 lab=WL117}
N 2040 23440 2060 23440 {}
C {lab_pin.sym} 2060 23440 0 0 {name=l18774 lab=VDD}
N 2040 23360 2060 23360 {}
C {lab_pin.sym} 2060 23360 0 0 {name=l18775 lab=VSS}
C {bitcell_6t.sym} 2200 23400 0 0 {name=Xr117c11}
N 2160 23440 2140 23440 {}
C {lab_pin.sym} 2140 23440 0 0 {name=l18776 lab=BL11}
N 2160 23400 2140 23400 {}
C {lab_pin.sym} 2140 23400 0 0 {name=l18777 lab=BLB11}
N 2160 23360 2140 23360 {}
C {lab_pin.sym} 2140 23360 0 0 {name=l18778 lab=WL117}
N 2240 23440 2260 23440 {}
C {lab_pin.sym} 2260 23440 0 0 {name=l18779 lab=VDD}
N 2240 23360 2260 23360 {}
C {lab_pin.sym} 2260 23360 0 0 {name=l18780 lab=VSS}
C {bitcell_6t.sym} 2400 23400 0 0 {name=Xr117c12}
N 2360 23440 2340 23440 {}
C {lab_pin.sym} 2340 23440 0 0 {name=l18781 lab=BL12}
N 2360 23400 2340 23400 {}
C {lab_pin.sym} 2340 23400 0 0 {name=l18782 lab=BLB12}
N 2360 23360 2340 23360 {}
C {lab_pin.sym} 2340 23360 0 0 {name=l18783 lab=WL117}
N 2440 23440 2460 23440 {}
C {lab_pin.sym} 2460 23440 0 0 {name=l18784 lab=VDD}
N 2440 23360 2460 23360 {}
C {lab_pin.sym} 2460 23360 0 0 {name=l18785 lab=VSS}
C {bitcell_6t.sym} 2600 23400 0 0 {name=Xr117c13}
N 2560 23440 2540 23440 {}
C {lab_pin.sym} 2540 23440 0 0 {name=l18786 lab=BL13}
N 2560 23400 2540 23400 {}
C {lab_pin.sym} 2540 23400 0 0 {name=l18787 lab=BLB13}
N 2560 23360 2540 23360 {}
C {lab_pin.sym} 2540 23360 0 0 {name=l18788 lab=WL117}
N 2640 23440 2660 23440 {}
C {lab_pin.sym} 2660 23440 0 0 {name=l18789 lab=VDD}
N 2640 23360 2660 23360 {}
C {lab_pin.sym} 2660 23360 0 0 {name=l18790 lab=VSS}
C {bitcell_6t.sym} 2800 23400 0 0 {name=Xr117c14}
N 2760 23440 2740 23440 {}
C {lab_pin.sym} 2740 23440 0 0 {name=l18791 lab=BL14}
N 2760 23400 2740 23400 {}
C {lab_pin.sym} 2740 23400 0 0 {name=l18792 lab=BLB14}
N 2760 23360 2740 23360 {}
C {lab_pin.sym} 2740 23360 0 0 {name=l18793 lab=WL117}
N 2840 23440 2860 23440 {}
C {lab_pin.sym} 2860 23440 0 0 {name=l18794 lab=VDD}
N 2840 23360 2860 23360 {}
C {lab_pin.sym} 2860 23360 0 0 {name=l18795 lab=VSS}
C {bitcell_6t.sym} 3000 23400 0 0 {name=Xr117c15}
N 2960 23440 2940 23440 {}
C {lab_pin.sym} 2940 23440 0 0 {name=l18796 lab=BL15}
N 2960 23400 2940 23400 {}
C {lab_pin.sym} 2940 23400 0 0 {name=l18797 lab=BLB15}
N 2960 23360 2940 23360 {}
C {lab_pin.sym} 2940 23360 0 0 {name=l18798 lab=WL117}
N 3040 23440 3060 23440 {}
C {lab_pin.sym} 3060 23440 0 0 {name=l18799 lab=VDD}
N 3040 23360 3060 23360 {}
C {lab_pin.sym} 3060 23360 0 0 {name=l18800 lab=VSS}
C {bitcell_6t.sym} 3200 23400 0 0 {name=Xr117c16}
N 3160 23440 3140 23440 {}
C {lab_pin.sym} 3140 23440 0 0 {name=l18801 lab=BL16}
N 3160 23400 3140 23400 {}
C {lab_pin.sym} 3140 23400 0 0 {name=l18802 lab=BLB16}
N 3160 23360 3140 23360 {}
C {lab_pin.sym} 3140 23360 0 0 {name=l18803 lab=WL117}
N 3240 23440 3260 23440 {}
C {lab_pin.sym} 3260 23440 0 0 {name=l18804 lab=VDD}
N 3240 23360 3260 23360 {}
C {lab_pin.sym} 3260 23360 0 0 {name=l18805 lab=VSS}
C {bitcell_6t.sym} 3400 23400 0 0 {name=Xr117c17}
N 3360 23440 3340 23440 {}
C {lab_pin.sym} 3340 23440 0 0 {name=l18806 lab=BL17}
N 3360 23400 3340 23400 {}
C {lab_pin.sym} 3340 23400 0 0 {name=l18807 lab=BLB17}
N 3360 23360 3340 23360 {}
C {lab_pin.sym} 3340 23360 0 0 {name=l18808 lab=WL117}
N 3440 23440 3460 23440 {}
C {lab_pin.sym} 3460 23440 0 0 {name=l18809 lab=VDD}
N 3440 23360 3460 23360 {}
C {lab_pin.sym} 3460 23360 0 0 {name=l18810 lab=VSS}
C {bitcell_6t.sym} 3600 23400 0 0 {name=Xr117c18}
N 3560 23440 3540 23440 {}
C {lab_pin.sym} 3540 23440 0 0 {name=l18811 lab=BL18}
N 3560 23400 3540 23400 {}
C {lab_pin.sym} 3540 23400 0 0 {name=l18812 lab=BLB18}
N 3560 23360 3540 23360 {}
C {lab_pin.sym} 3540 23360 0 0 {name=l18813 lab=WL117}
N 3640 23440 3660 23440 {}
C {lab_pin.sym} 3660 23440 0 0 {name=l18814 lab=VDD}
N 3640 23360 3660 23360 {}
C {lab_pin.sym} 3660 23360 0 0 {name=l18815 lab=VSS}
C {bitcell_6t.sym} 3800 23400 0 0 {name=Xr117c19}
N 3760 23440 3740 23440 {}
C {lab_pin.sym} 3740 23440 0 0 {name=l18816 lab=BL19}
N 3760 23400 3740 23400 {}
C {lab_pin.sym} 3740 23400 0 0 {name=l18817 lab=BLB19}
N 3760 23360 3740 23360 {}
C {lab_pin.sym} 3740 23360 0 0 {name=l18818 lab=WL117}
N 3840 23440 3860 23440 {}
C {lab_pin.sym} 3860 23440 0 0 {name=l18819 lab=VDD}
N 3840 23360 3860 23360 {}
C {lab_pin.sym} 3860 23360 0 0 {name=l18820 lab=VSS}
C {bitcell_6t.sym} 4000 23400 0 0 {name=Xr117c20}
N 3960 23440 3940 23440 {}
C {lab_pin.sym} 3940 23440 0 0 {name=l18821 lab=BL20}
N 3960 23400 3940 23400 {}
C {lab_pin.sym} 3940 23400 0 0 {name=l18822 lab=BLB20}
N 3960 23360 3940 23360 {}
C {lab_pin.sym} 3940 23360 0 0 {name=l18823 lab=WL117}
N 4040 23440 4060 23440 {}
C {lab_pin.sym} 4060 23440 0 0 {name=l18824 lab=VDD}
N 4040 23360 4060 23360 {}
C {lab_pin.sym} 4060 23360 0 0 {name=l18825 lab=VSS}
C {bitcell_6t.sym} 4200 23400 0 0 {name=Xr117c21}
N 4160 23440 4140 23440 {}
C {lab_pin.sym} 4140 23440 0 0 {name=l18826 lab=BL21}
N 4160 23400 4140 23400 {}
C {lab_pin.sym} 4140 23400 0 0 {name=l18827 lab=BLB21}
N 4160 23360 4140 23360 {}
C {lab_pin.sym} 4140 23360 0 0 {name=l18828 lab=WL117}
N 4240 23440 4260 23440 {}
C {lab_pin.sym} 4260 23440 0 0 {name=l18829 lab=VDD}
N 4240 23360 4260 23360 {}
C {lab_pin.sym} 4260 23360 0 0 {name=l18830 lab=VSS}
C {bitcell_6t.sym} 4400 23400 0 0 {name=Xr117c22}
N 4360 23440 4340 23440 {}
C {lab_pin.sym} 4340 23440 0 0 {name=l18831 lab=BL22}
N 4360 23400 4340 23400 {}
C {lab_pin.sym} 4340 23400 0 0 {name=l18832 lab=BLB22}
N 4360 23360 4340 23360 {}
C {lab_pin.sym} 4340 23360 0 0 {name=l18833 lab=WL117}
N 4440 23440 4460 23440 {}
C {lab_pin.sym} 4460 23440 0 0 {name=l18834 lab=VDD}
N 4440 23360 4460 23360 {}
C {lab_pin.sym} 4460 23360 0 0 {name=l18835 lab=VSS}
C {bitcell_6t.sym} 4600 23400 0 0 {name=Xr117c23}
N 4560 23440 4540 23440 {}
C {lab_pin.sym} 4540 23440 0 0 {name=l18836 lab=BL23}
N 4560 23400 4540 23400 {}
C {lab_pin.sym} 4540 23400 0 0 {name=l18837 lab=BLB23}
N 4560 23360 4540 23360 {}
C {lab_pin.sym} 4540 23360 0 0 {name=l18838 lab=WL117}
N 4640 23440 4660 23440 {}
C {lab_pin.sym} 4660 23440 0 0 {name=l18839 lab=VDD}
N 4640 23360 4660 23360 {}
C {lab_pin.sym} 4660 23360 0 0 {name=l18840 lab=VSS}
C {bitcell_6t.sym} 4800 23400 0 0 {name=Xr117c24}
N 4760 23440 4740 23440 {}
C {lab_pin.sym} 4740 23440 0 0 {name=l18841 lab=BL24}
N 4760 23400 4740 23400 {}
C {lab_pin.sym} 4740 23400 0 0 {name=l18842 lab=BLB24}
N 4760 23360 4740 23360 {}
C {lab_pin.sym} 4740 23360 0 0 {name=l18843 lab=WL117}
N 4840 23440 4860 23440 {}
C {lab_pin.sym} 4860 23440 0 0 {name=l18844 lab=VDD}
N 4840 23360 4860 23360 {}
C {lab_pin.sym} 4860 23360 0 0 {name=l18845 lab=VSS}
C {bitcell_6t.sym} 5000 23400 0 0 {name=Xr117c25}
N 4960 23440 4940 23440 {}
C {lab_pin.sym} 4940 23440 0 0 {name=l18846 lab=BL25}
N 4960 23400 4940 23400 {}
C {lab_pin.sym} 4940 23400 0 0 {name=l18847 lab=BLB25}
N 4960 23360 4940 23360 {}
C {lab_pin.sym} 4940 23360 0 0 {name=l18848 lab=WL117}
N 5040 23440 5060 23440 {}
C {lab_pin.sym} 5060 23440 0 0 {name=l18849 lab=VDD}
N 5040 23360 5060 23360 {}
C {lab_pin.sym} 5060 23360 0 0 {name=l18850 lab=VSS}
C {bitcell_6t.sym} 5200 23400 0 0 {name=Xr117c26}
N 5160 23440 5140 23440 {}
C {lab_pin.sym} 5140 23440 0 0 {name=l18851 lab=BL26}
N 5160 23400 5140 23400 {}
C {lab_pin.sym} 5140 23400 0 0 {name=l18852 lab=BLB26}
N 5160 23360 5140 23360 {}
C {lab_pin.sym} 5140 23360 0 0 {name=l18853 lab=WL117}
N 5240 23440 5260 23440 {}
C {lab_pin.sym} 5260 23440 0 0 {name=l18854 lab=VDD}
N 5240 23360 5260 23360 {}
C {lab_pin.sym} 5260 23360 0 0 {name=l18855 lab=VSS}
C {bitcell_6t.sym} 5400 23400 0 0 {name=Xr117c27}
N 5360 23440 5340 23440 {}
C {lab_pin.sym} 5340 23440 0 0 {name=l18856 lab=BL27}
N 5360 23400 5340 23400 {}
C {lab_pin.sym} 5340 23400 0 0 {name=l18857 lab=BLB27}
N 5360 23360 5340 23360 {}
C {lab_pin.sym} 5340 23360 0 0 {name=l18858 lab=WL117}
N 5440 23440 5460 23440 {}
C {lab_pin.sym} 5460 23440 0 0 {name=l18859 lab=VDD}
N 5440 23360 5460 23360 {}
C {lab_pin.sym} 5460 23360 0 0 {name=l18860 lab=VSS}
C {bitcell_6t.sym} 5600 23400 0 0 {name=Xr117c28}
N 5560 23440 5540 23440 {}
C {lab_pin.sym} 5540 23440 0 0 {name=l18861 lab=BL28}
N 5560 23400 5540 23400 {}
C {lab_pin.sym} 5540 23400 0 0 {name=l18862 lab=BLB28}
N 5560 23360 5540 23360 {}
C {lab_pin.sym} 5540 23360 0 0 {name=l18863 lab=WL117}
N 5640 23440 5660 23440 {}
C {lab_pin.sym} 5660 23440 0 0 {name=l18864 lab=VDD}
N 5640 23360 5660 23360 {}
C {lab_pin.sym} 5660 23360 0 0 {name=l18865 lab=VSS}
C {bitcell_6t.sym} 5800 23400 0 0 {name=Xr117c29}
N 5760 23440 5740 23440 {}
C {lab_pin.sym} 5740 23440 0 0 {name=l18866 lab=BL29}
N 5760 23400 5740 23400 {}
C {lab_pin.sym} 5740 23400 0 0 {name=l18867 lab=BLB29}
N 5760 23360 5740 23360 {}
C {lab_pin.sym} 5740 23360 0 0 {name=l18868 lab=WL117}
N 5840 23440 5860 23440 {}
C {lab_pin.sym} 5860 23440 0 0 {name=l18869 lab=VDD}
N 5840 23360 5860 23360 {}
C {lab_pin.sym} 5860 23360 0 0 {name=l18870 lab=VSS}
C {bitcell_6t.sym} 6000 23400 0 0 {name=Xr117c30}
N 5960 23440 5940 23440 {}
C {lab_pin.sym} 5940 23440 0 0 {name=l18871 lab=BL30}
N 5960 23400 5940 23400 {}
C {lab_pin.sym} 5940 23400 0 0 {name=l18872 lab=BLB30}
N 5960 23360 5940 23360 {}
C {lab_pin.sym} 5940 23360 0 0 {name=l18873 lab=WL117}
N 6040 23440 6060 23440 {}
C {lab_pin.sym} 6060 23440 0 0 {name=l18874 lab=VDD}
N 6040 23360 6060 23360 {}
C {lab_pin.sym} 6060 23360 0 0 {name=l18875 lab=VSS}
C {bitcell_6t.sym} 6200 23400 0 0 {name=Xr117c31}
N 6160 23440 6140 23440 {}
C {lab_pin.sym} 6140 23440 0 0 {name=l18876 lab=BL31}
N 6160 23400 6140 23400 {}
C {lab_pin.sym} 6140 23400 0 0 {name=l18877 lab=BLB31}
N 6160 23360 6140 23360 {}
C {lab_pin.sym} 6140 23360 0 0 {name=l18878 lab=WL117}
N 6240 23440 6260 23440 {}
C {lab_pin.sym} 6260 23440 0 0 {name=l18879 lab=VDD}
N 6240 23360 6260 23360 {}
C {lab_pin.sym} 6260 23360 0 0 {name=l18880 lab=VSS}
C {bitcell_6t.sym} 0 23600 0 0 {name=Xr118c0}
N -40 23640 -60 23640 {}
C {lab_pin.sym} -60 23640 0 0 {name=l18881 lab=BL0}
N -40 23600 -60 23600 {}
C {lab_pin.sym} -60 23600 0 0 {name=l18882 lab=BLB0}
N -40 23560 -60 23560 {}
C {lab_pin.sym} -60 23560 0 0 {name=l18883 lab=WL118}
N 40 23640 60 23640 {}
C {lab_pin.sym} 60 23640 0 0 {name=l18884 lab=VDD}
N 40 23560 60 23560 {}
C {lab_pin.sym} 60 23560 0 0 {name=l18885 lab=VSS}
C {bitcell_6t.sym} 200 23600 0 0 {name=Xr118c1}
N 160 23640 140 23640 {}
C {lab_pin.sym} 140 23640 0 0 {name=l18886 lab=BL1}
N 160 23600 140 23600 {}
C {lab_pin.sym} 140 23600 0 0 {name=l18887 lab=BLB1}
N 160 23560 140 23560 {}
C {lab_pin.sym} 140 23560 0 0 {name=l18888 lab=WL118}
N 240 23640 260 23640 {}
C {lab_pin.sym} 260 23640 0 0 {name=l18889 lab=VDD}
N 240 23560 260 23560 {}
C {lab_pin.sym} 260 23560 0 0 {name=l18890 lab=VSS}
C {bitcell_6t.sym} 400 23600 0 0 {name=Xr118c2}
N 360 23640 340 23640 {}
C {lab_pin.sym} 340 23640 0 0 {name=l18891 lab=BL2}
N 360 23600 340 23600 {}
C {lab_pin.sym} 340 23600 0 0 {name=l18892 lab=BLB2}
N 360 23560 340 23560 {}
C {lab_pin.sym} 340 23560 0 0 {name=l18893 lab=WL118}
N 440 23640 460 23640 {}
C {lab_pin.sym} 460 23640 0 0 {name=l18894 lab=VDD}
N 440 23560 460 23560 {}
C {lab_pin.sym} 460 23560 0 0 {name=l18895 lab=VSS}
C {bitcell_6t.sym} 600 23600 0 0 {name=Xr118c3}
N 560 23640 540 23640 {}
C {lab_pin.sym} 540 23640 0 0 {name=l18896 lab=BL3}
N 560 23600 540 23600 {}
C {lab_pin.sym} 540 23600 0 0 {name=l18897 lab=BLB3}
N 560 23560 540 23560 {}
C {lab_pin.sym} 540 23560 0 0 {name=l18898 lab=WL118}
N 640 23640 660 23640 {}
C {lab_pin.sym} 660 23640 0 0 {name=l18899 lab=VDD}
N 640 23560 660 23560 {}
C {lab_pin.sym} 660 23560 0 0 {name=l18900 lab=VSS}
C {bitcell_6t.sym} 800 23600 0 0 {name=Xr118c4}
N 760 23640 740 23640 {}
C {lab_pin.sym} 740 23640 0 0 {name=l18901 lab=BL4}
N 760 23600 740 23600 {}
C {lab_pin.sym} 740 23600 0 0 {name=l18902 lab=BLB4}
N 760 23560 740 23560 {}
C {lab_pin.sym} 740 23560 0 0 {name=l18903 lab=WL118}
N 840 23640 860 23640 {}
C {lab_pin.sym} 860 23640 0 0 {name=l18904 lab=VDD}
N 840 23560 860 23560 {}
C {lab_pin.sym} 860 23560 0 0 {name=l18905 lab=VSS}
C {bitcell_6t.sym} 1000 23600 0 0 {name=Xr118c5}
N 960 23640 940 23640 {}
C {lab_pin.sym} 940 23640 0 0 {name=l18906 lab=BL5}
N 960 23600 940 23600 {}
C {lab_pin.sym} 940 23600 0 0 {name=l18907 lab=BLB5}
N 960 23560 940 23560 {}
C {lab_pin.sym} 940 23560 0 0 {name=l18908 lab=WL118}
N 1040 23640 1060 23640 {}
C {lab_pin.sym} 1060 23640 0 0 {name=l18909 lab=VDD}
N 1040 23560 1060 23560 {}
C {lab_pin.sym} 1060 23560 0 0 {name=l18910 lab=VSS}
C {bitcell_6t.sym} 1200 23600 0 0 {name=Xr118c6}
N 1160 23640 1140 23640 {}
C {lab_pin.sym} 1140 23640 0 0 {name=l18911 lab=BL6}
N 1160 23600 1140 23600 {}
C {lab_pin.sym} 1140 23600 0 0 {name=l18912 lab=BLB6}
N 1160 23560 1140 23560 {}
C {lab_pin.sym} 1140 23560 0 0 {name=l18913 lab=WL118}
N 1240 23640 1260 23640 {}
C {lab_pin.sym} 1260 23640 0 0 {name=l18914 lab=VDD}
N 1240 23560 1260 23560 {}
C {lab_pin.sym} 1260 23560 0 0 {name=l18915 lab=VSS}
C {bitcell_6t.sym} 1400 23600 0 0 {name=Xr118c7}
N 1360 23640 1340 23640 {}
C {lab_pin.sym} 1340 23640 0 0 {name=l18916 lab=BL7}
N 1360 23600 1340 23600 {}
C {lab_pin.sym} 1340 23600 0 0 {name=l18917 lab=BLB7}
N 1360 23560 1340 23560 {}
C {lab_pin.sym} 1340 23560 0 0 {name=l18918 lab=WL118}
N 1440 23640 1460 23640 {}
C {lab_pin.sym} 1460 23640 0 0 {name=l18919 lab=VDD}
N 1440 23560 1460 23560 {}
C {lab_pin.sym} 1460 23560 0 0 {name=l18920 lab=VSS}
C {bitcell_6t.sym} 1600 23600 0 0 {name=Xr118c8}
N 1560 23640 1540 23640 {}
C {lab_pin.sym} 1540 23640 0 0 {name=l18921 lab=BL8}
N 1560 23600 1540 23600 {}
C {lab_pin.sym} 1540 23600 0 0 {name=l18922 lab=BLB8}
N 1560 23560 1540 23560 {}
C {lab_pin.sym} 1540 23560 0 0 {name=l18923 lab=WL118}
N 1640 23640 1660 23640 {}
C {lab_pin.sym} 1660 23640 0 0 {name=l18924 lab=VDD}
N 1640 23560 1660 23560 {}
C {lab_pin.sym} 1660 23560 0 0 {name=l18925 lab=VSS}
C {bitcell_6t.sym} 1800 23600 0 0 {name=Xr118c9}
N 1760 23640 1740 23640 {}
C {lab_pin.sym} 1740 23640 0 0 {name=l18926 lab=BL9}
N 1760 23600 1740 23600 {}
C {lab_pin.sym} 1740 23600 0 0 {name=l18927 lab=BLB9}
N 1760 23560 1740 23560 {}
C {lab_pin.sym} 1740 23560 0 0 {name=l18928 lab=WL118}
N 1840 23640 1860 23640 {}
C {lab_pin.sym} 1860 23640 0 0 {name=l18929 lab=VDD}
N 1840 23560 1860 23560 {}
C {lab_pin.sym} 1860 23560 0 0 {name=l18930 lab=VSS}
C {bitcell_6t.sym} 2000 23600 0 0 {name=Xr118c10}
N 1960 23640 1940 23640 {}
C {lab_pin.sym} 1940 23640 0 0 {name=l18931 lab=BL10}
N 1960 23600 1940 23600 {}
C {lab_pin.sym} 1940 23600 0 0 {name=l18932 lab=BLB10}
N 1960 23560 1940 23560 {}
C {lab_pin.sym} 1940 23560 0 0 {name=l18933 lab=WL118}
N 2040 23640 2060 23640 {}
C {lab_pin.sym} 2060 23640 0 0 {name=l18934 lab=VDD}
N 2040 23560 2060 23560 {}
C {lab_pin.sym} 2060 23560 0 0 {name=l18935 lab=VSS}
C {bitcell_6t.sym} 2200 23600 0 0 {name=Xr118c11}
N 2160 23640 2140 23640 {}
C {lab_pin.sym} 2140 23640 0 0 {name=l18936 lab=BL11}
N 2160 23600 2140 23600 {}
C {lab_pin.sym} 2140 23600 0 0 {name=l18937 lab=BLB11}
N 2160 23560 2140 23560 {}
C {lab_pin.sym} 2140 23560 0 0 {name=l18938 lab=WL118}
N 2240 23640 2260 23640 {}
C {lab_pin.sym} 2260 23640 0 0 {name=l18939 lab=VDD}
N 2240 23560 2260 23560 {}
C {lab_pin.sym} 2260 23560 0 0 {name=l18940 lab=VSS}
C {bitcell_6t.sym} 2400 23600 0 0 {name=Xr118c12}
N 2360 23640 2340 23640 {}
C {lab_pin.sym} 2340 23640 0 0 {name=l18941 lab=BL12}
N 2360 23600 2340 23600 {}
C {lab_pin.sym} 2340 23600 0 0 {name=l18942 lab=BLB12}
N 2360 23560 2340 23560 {}
C {lab_pin.sym} 2340 23560 0 0 {name=l18943 lab=WL118}
N 2440 23640 2460 23640 {}
C {lab_pin.sym} 2460 23640 0 0 {name=l18944 lab=VDD}
N 2440 23560 2460 23560 {}
C {lab_pin.sym} 2460 23560 0 0 {name=l18945 lab=VSS}
C {bitcell_6t.sym} 2600 23600 0 0 {name=Xr118c13}
N 2560 23640 2540 23640 {}
C {lab_pin.sym} 2540 23640 0 0 {name=l18946 lab=BL13}
N 2560 23600 2540 23600 {}
C {lab_pin.sym} 2540 23600 0 0 {name=l18947 lab=BLB13}
N 2560 23560 2540 23560 {}
C {lab_pin.sym} 2540 23560 0 0 {name=l18948 lab=WL118}
N 2640 23640 2660 23640 {}
C {lab_pin.sym} 2660 23640 0 0 {name=l18949 lab=VDD}
N 2640 23560 2660 23560 {}
C {lab_pin.sym} 2660 23560 0 0 {name=l18950 lab=VSS}
C {bitcell_6t.sym} 2800 23600 0 0 {name=Xr118c14}
N 2760 23640 2740 23640 {}
C {lab_pin.sym} 2740 23640 0 0 {name=l18951 lab=BL14}
N 2760 23600 2740 23600 {}
C {lab_pin.sym} 2740 23600 0 0 {name=l18952 lab=BLB14}
N 2760 23560 2740 23560 {}
C {lab_pin.sym} 2740 23560 0 0 {name=l18953 lab=WL118}
N 2840 23640 2860 23640 {}
C {lab_pin.sym} 2860 23640 0 0 {name=l18954 lab=VDD}
N 2840 23560 2860 23560 {}
C {lab_pin.sym} 2860 23560 0 0 {name=l18955 lab=VSS}
C {bitcell_6t.sym} 3000 23600 0 0 {name=Xr118c15}
N 2960 23640 2940 23640 {}
C {lab_pin.sym} 2940 23640 0 0 {name=l18956 lab=BL15}
N 2960 23600 2940 23600 {}
C {lab_pin.sym} 2940 23600 0 0 {name=l18957 lab=BLB15}
N 2960 23560 2940 23560 {}
C {lab_pin.sym} 2940 23560 0 0 {name=l18958 lab=WL118}
N 3040 23640 3060 23640 {}
C {lab_pin.sym} 3060 23640 0 0 {name=l18959 lab=VDD}
N 3040 23560 3060 23560 {}
C {lab_pin.sym} 3060 23560 0 0 {name=l18960 lab=VSS}
C {bitcell_6t.sym} 3200 23600 0 0 {name=Xr118c16}
N 3160 23640 3140 23640 {}
C {lab_pin.sym} 3140 23640 0 0 {name=l18961 lab=BL16}
N 3160 23600 3140 23600 {}
C {lab_pin.sym} 3140 23600 0 0 {name=l18962 lab=BLB16}
N 3160 23560 3140 23560 {}
C {lab_pin.sym} 3140 23560 0 0 {name=l18963 lab=WL118}
N 3240 23640 3260 23640 {}
C {lab_pin.sym} 3260 23640 0 0 {name=l18964 lab=VDD}
N 3240 23560 3260 23560 {}
C {lab_pin.sym} 3260 23560 0 0 {name=l18965 lab=VSS}
C {bitcell_6t.sym} 3400 23600 0 0 {name=Xr118c17}
N 3360 23640 3340 23640 {}
C {lab_pin.sym} 3340 23640 0 0 {name=l18966 lab=BL17}
N 3360 23600 3340 23600 {}
C {lab_pin.sym} 3340 23600 0 0 {name=l18967 lab=BLB17}
N 3360 23560 3340 23560 {}
C {lab_pin.sym} 3340 23560 0 0 {name=l18968 lab=WL118}
N 3440 23640 3460 23640 {}
C {lab_pin.sym} 3460 23640 0 0 {name=l18969 lab=VDD}
N 3440 23560 3460 23560 {}
C {lab_pin.sym} 3460 23560 0 0 {name=l18970 lab=VSS}
C {bitcell_6t.sym} 3600 23600 0 0 {name=Xr118c18}
N 3560 23640 3540 23640 {}
C {lab_pin.sym} 3540 23640 0 0 {name=l18971 lab=BL18}
N 3560 23600 3540 23600 {}
C {lab_pin.sym} 3540 23600 0 0 {name=l18972 lab=BLB18}
N 3560 23560 3540 23560 {}
C {lab_pin.sym} 3540 23560 0 0 {name=l18973 lab=WL118}
N 3640 23640 3660 23640 {}
C {lab_pin.sym} 3660 23640 0 0 {name=l18974 lab=VDD}
N 3640 23560 3660 23560 {}
C {lab_pin.sym} 3660 23560 0 0 {name=l18975 lab=VSS}
C {bitcell_6t.sym} 3800 23600 0 0 {name=Xr118c19}
N 3760 23640 3740 23640 {}
C {lab_pin.sym} 3740 23640 0 0 {name=l18976 lab=BL19}
N 3760 23600 3740 23600 {}
C {lab_pin.sym} 3740 23600 0 0 {name=l18977 lab=BLB19}
N 3760 23560 3740 23560 {}
C {lab_pin.sym} 3740 23560 0 0 {name=l18978 lab=WL118}
N 3840 23640 3860 23640 {}
C {lab_pin.sym} 3860 23640 0 0 {name=l18979 lab=VDD}
N 3840 23560 3860 23560 {}
C {lab_pin.sym} 3860 23560 0 0 {name=l18980 lab=VSS}
C {bitcell_6t.sym} 4000 23600 0 0 {name=Xr118c20}
N 3960 23640 3940 23640 {}
C {lab_pin.sym} 3940 23640 0 0 {name=l18981 lab=BL20}
N 3960 23600 3940 23600 {}
C {lab_pin.sym} 3940 23600 0 0 {name=l18982 lab=BLB20}
N 3960 23560 3940 23560 {}
C {lab_pin.sym} 3940 23560 0 0 {name=l18983 lab=WL118}
N 4040 23640 4060 23640 {}
C {lab_pin.sym} 4060 23640 0 0 {name=l18984 lab=VDD}
N 4040 23560 4060 23560 {}
C {lab_pin.sym} 4060 23560 0 0 {name=l18985 lab=VSS}
C {bitcell_6t.sym} 4200 23600 0 0 {name=Xr118c21}
N 4160 23640 4140 23640 {}
C {lab_pin.sym} 4140 23640 0 0 {name=l18986 lab=BL21}
N 4160 23600 4140 23600 {}
C {lab_pin.sym} 4140 23600 0 0 {name=l18987 lab=BLB21}
N 4160 23560 4140 23560 {}
C {lab_pin.sym} 4140 23560 0 0 {name=l18988 lab=WL118}
N 4240 23640 4260 23640 {}
C {lab_pin.sym} 4260 23640 0 0 {name=l18989 lab=VDD}
N 4240 23560 4260 23560 {}
C {lab_pin.sym} 4260 23560 0 0 {name=l18990 lab=VSS}
C {bitcell_6t.sym} 4400 23600 0 0 {name=Xr118c22}
N 4360 23640 4340 23640 {}
C {lab_pin.sym} 4340 23640 0 0 {name=l18991 lab=BL22}
N 4360 23600 4340 23600 {}
C {lab_pin.sym} 4340 23600 0 0 {name=l18992 lab=BLB22}
N 4360 23560 4340 23560 {}
C {lab_pin.sym} 4340 23560 0 0 {name=l18993 lab=WL118}
N 4440 23640 4460 23640 {}
C {lab_pin.sym} 4460 23640 0 0 {name=l18994 lab=VDD}
N 4440 23560 4460 23560 {}
C {lab_pin.sym} 4460 23560 0 0 {name=l18995 lab=VSS}
C {bitcell_6t.sym} 4600 23600 0 0 {name=Xr118c23}
N 4560 23640 4540 23640 {}
C {lab_pin.sym} 4540 23640 0 0 {name=l18996 lab=BL23}
N 4560 23600 4540 23600 {}
C {lab_pin.sym} 4540 23600 0 0 {name=l18997 lab=BLB23}
N 4560 23560 4540 23560 {}
C {lab_pin.sym} 4540 23560 0 0 {name=l18998 lab=WL118}
N 4640 23640 4660 23640 {}
C {lab_pin.sym} 4660 23640 0 0 {name=l18999 lab=VDD}
N 4640 23560 4660 23560 {}
C {lab_pin.sym} 4660 23560 0 0 {name=l19000 lab=VSS}
C {bitcell_6t.sym} 4800 23600 0 0 {name=Xr118c24}
N 4760 23640 4740 23640 {}
C {lab_pin.sym} 4740 23640 0 0 {name=l19001 lab=BL24}
N 4760 23600 4740 23600 {}
C {lab_pin.sym} 4740 23600 0 0 {name=l19002 lab=BLB24}
N 4760 23560 4740 23560 {}
C {lab_pin.sym} 4740 23560 0 0 {name=l19003 lab=WL118}
N 4840 23640 4860 23640 {}
C {lab_pin.sym} 4860 23640 0 0 {name=l19004 lab=VDD}
N 4840 23560 4860 23560 {}
C {lab_pin.sym} 4860 23560 0 0 {name=l19005 lab=VSS}
C {bitcell_6t.sym} 5000 23600 0 0 {name=Xr118c25}
N 4960 23640 4940 23640 {}
C {lab_pin.sym} 4940 23640 0 0 {name=l19006 lab=BL25}
N 4960 23600 4940 23600 {}
C {lab_pin.sym} 4940 23600 0 0 {name=l19007 lab=BLB25}
N 4960 23560 4940 23560 {}
C {lab_pin.sym} 4940 23560 0 0 {name=l19008 lab=WL118}
N 5040 23640 5060 23640 {}
C {lab_pin.sym} 5060 23640 0 0 {name=l19009 lab=VDD}
N 5040 23560 5060 23560 {}
C {lab_pin.sym} 5060 23560 0 0 {name=l19010 lab=VSS}
C {bitcell_6t.sym} 5200 23600 0 0 {name=Xr118c26}
N 5160 23640 5140 23640 {}
C {lab_pin.sym} 5140 23640 0 0 {name=l19011 lab=BL26}
N 5160 23600 5140 23600 {}
C {lab_pin.sym} 5140 23600 0 0 {name=l19012 lab=BLB26}
N 5160 23560 5140 23560 {}
C {lab_pin.sym} 5140 23560 0 0 {name=l19013 lab=WL118}
N 5240 23640 5260 23640 {}
C {lab_pin.sym} 5260 23640 0 0 {name=l19014 lab=VDD}
N 5240 23560 5260 23560 {}
C {lab_pin.sym} 5260 23560 0 0 {name=l19015 lab=VSS}
C {bitcell_6t.sym} 5400 23600 0 0 {name=Xr118c27}
N 5360 23640 5340 23640 {}
C {lab_pin.sym} 5340 23640 0 0 {name=l19016 lab=BL27}
N 5360 23600 5340 23600 {}
C {lab_pin.sym} 5340 23600 0 0 {name=l19017 lab=BLB27}
N 5360 23560 5340 23560 {}
C {lab_pin.sym} 5340 23560 0 0 {name=l19018 lab=WL118}
N 5440 23640 5460 23640 {}
C {lab_pin.sym} 5460 23640 0 0 {name=l19019 lab=VDD}
N 5440 23560 5460 23560 {}
C {lab_pin.sym} 5460 23560 0 0 {name=l19020 lab=VSS}
C {bitcell_6t.sym} 5600 23600 0 0 {name=Xr118c28}
N 5560 23640 5540 23640 {}
C {lab_pin.sym} 5540 23640 0 0 {name=l19021 lab=BL28}
N 5560 23600 5540 23600 {}
C {lab_pin.sym} 5540 23600 0 0 {name=l19022 lab=BLB28}
N 5560 23560 5540 23560 {}
C {lab_pin.sym} 5540 23560 0 0 {name=l19023 lab=WL118}
N 5640 23640 5660 23640 {}
C {lab_pin.sym} 5660 23640 0 0 {name=l19024 lab=VDD}
N 5640 23560 5660 23560 {}
C {lab_pin.sym} 5660 23560 0 0 {name=l19025 lab=VSS}
C {bitcell_6t.sym} 5800 23600 0 0 {name=Xr118c29}
N 5760 23640 5740 23640 {}
C {lab_pin.sym} 5740 23640 0 0 {name=l19026 lab=BL29}
N 5760 23600 5740 23600 {}
C {lab_pin.sym} 5740 23600 0 0 {name=l19027 lab=BLB29}
N 5760 23560 5740 23560 {}
C {lab_pin.sym} 5740 23560 0 0 {name=l19028 lab=WL118}
N 5840 23640 5860 23640 {}
C {lab_pin.sym} 5860 23640 0 0 {name=l19029 lab=VDD}
N 5840 23560 5860 23560 {}
C {lab_pin.sym} 5860 23560 0 0 {name=l19030 lab=VSS}
C {bitcell_6t.sym} 6000 23600 0 0 {name=Xr118c30}
N 5960 23640 5940 23640 {}
C {lab_pin.sym} 5940 23640 0 0 {name=l19031 lab=BL30}
N 5960 23600 5940 23600 {}
C {lab_pin.sym} 5940 23600 0 0 {name=l19032 lab=BLB30}
N 5960 23560 5940 23560 {}
C {lab_pin.sym} 5940 23560 0 0 {name=l19033 lab=WL118}
N 6040 23640 6060 23640 {}
C {lab_pin.sym} 6060 23640 0 0 {name=l19034 lab=VDD}
N 6040 23560 6060 23560 {}
C {lab_pin.sym} 6060 23560 0 0 {name=l19035 lab=VSS}
C {bitcell_6t.sym} 6200 23600 0 0 {name=Xr118c31}
N 6160 23640 6140 23640 {}
C {lab_pin.sym} 6140 23640 0 0 {name=l19036 lab=BL31}
N 6160 23600 6140 23600 {}
C {lab_pin.sym} 6140 23600 0 0 {name=l19037 lab=BLB31}
N 6160 23560 6140 23560 {}
C {lab_pin.sym} 6140 23560 0 0 {name=l19038 lab=WL118}
N 6240 23640 6260 23640 {}
C {lab_pin.sym} 6260 23640 0 0 {name=l19039 lab=VDD}
N 6240 23560 6260 23560 {}
C {lab_pin.sym} 6260 23560 0 0 {name=l19040 lab=VSS}
C {bitcell_6t.sym} 0 23800 0 0 {name=Xr119c0}
N -40 23840 -60 23840 {}
C {lab_pin.sym} -60 23840 0 0 {name=l19041 lab=BL0}
N -40 23800 -60 23800 {}
C {lab_pin.sym} -60 23800 0 0 {name=l19042 lab=BLB0}
N -40 23760 -60 23760 {}
C {lab_pin.sym} -60 23760 0 0 {name=l19043 lab=WL119}
N 40 23840 60 23840 {}
C {lab_pin.sym} 60 23840 0 0 {name=l19044 lab=VDD}
N 40 23760 60 23760 {}
C {lab_pin.sym} 60 23760 0 0 {name=l19045 lab=VSS}
C {bitcell_6t.sym} 200 23800 0 0 {name=Xr119c1}
N 160 23840 140 23840 {}
C {lab_pin.sym} 140 23840 0 0 {name=l19046 lab=BL1}
N 160 23800 140 23800 {}
C {lab_pin.sym} 140 23800 0 0 {name=l19047 lab=BLB1}
N 160 23760 140 23760 {}
C {lab_pin.sym} 140 23760 0 0 {name=l19048 lab=WL119}
N 240 23840 260 23840 {}
C {lab_pin.sym} 260 23840 0 0 {name=l19049 lab=VDD}
N 240 23760 260 23760 {}
C {lab_pin.sym} 260 23760 0 0 {name=l19050 lab=VSS}
C {bitcell_6t.sym} 400 23800 0 0 {name=Xr119c2}
N 360 23840 340 23840 {}
C {lab_pin.sym} 340 23840 0 0 {name=l19051 lab=BL2}
N 360 23800 340 23800 {}
C {lab_pin.sym} 340 23800 0 0 {name=l19052 lab=BLB2}
N 360 23760 340 23760 {}
C {lab_pin.sym} 340 23760 0 0 {name=l19053 lab=WL119}
N 440 23840 460 23840 {}
C {lab_pin.sym} 460 23840 0 0 {name=l19054 lab=VDD}
N 440 23760 460 23760 {}
C {lab_pin.sym} 460 23760 0 0 {name=l19055 lab=VSS}
C {bitcell_6t.sym} 600 23800 0 0 {name=Xr119c3}
N 560 23840 540 23840 {}
C {lab_pin.sym} 540 23840 0 0 {name=l19056 lab=BL3}
N 560 23800 540 23800 {}
C {lab_pin.sym} 540 23800 0 0 {name=l19057 lab=BLB3}
N 560 23760 540 23760 {}
C {lab_pin.sym} 540 23760 0 0 {name=l19058 lab=WL119}
N 640 23840 660 23840 {}
C {lab_pin.sym} 660 23840 0 0 {name=l19059 lab=VDD}
N 640 23760 660 23760 {}
C {lab_pin.sym} 660 23760 0 0 {name=l19060 lab=VSS}
C {bitcell_6t.sym} 800 23800 0 0 {name=Xr119c4}
N 760 23840 740 23840 {}
C {lab_pin.sym} 740 23840 0 0 {name=l19061 lab=BL4}
N 760 23800 740 23800 {}
C {lab_pin.sym} 740 23800 0 0 {name=l19062 lab=BLB4}
N 760 23760 740 23760 {}
C {lab_pin.sym} 740 23760 0 0 {name=l19063 lab=WL119}
N 840 23840 860 23840 {}
C {lab_pin.sym} 860 23840 0 0 {name=l19064 lab=VDD}
N 840 23760 860 23760 {}
C {lab_pin.sym} 860 23760 0 0 {name=l19065 lab=VSS}
C {bitcell_6t.sym} 1000 23800 0 0 {name=Xr119c5}
N 960 23840 940 23840 {}
C {lab_pin.sym} 940 23840 0 0 {name=l19066 lab=BL5}
N 960 23800 940 23800 {}
C {lab_pin.sym} 940 23800 0 0 {name=l19067 lab=BLB5}
N 960 23760 940 23760 {}
C {lab_pin.sym} 940 23760 0 0 {name=l19068 lab=WL119}
N 1040 23840 1060 23840 {}
C {lab_pin.sym} 1060 23840 0 0 {name=l19069 lab=VDD}
N 1040 23760 1060 23760 {}
C {lab_pin.sym} 1060 23760 0 0 {name=l19070 lab=VSS}
C {bitcell_6t.sym} 1200 23800 0 0 {name=Xr119c6}
N 1160 23840 1140 23840 {}
C {lab_pin.sym} 1140 23840 0 0 {name=l19071 lab=BL6}
N 1160 23800 1140 23800 {}
C {lab_pin.sym} 1140 23800 0 0 {name=l19072 lab=BLB6}
N 1160 23760 1140 23760 {}
C {lab_pin.sym} 1140 23760 0 0 {name=l19073 lab=WL119}
N 1240 23840 1260 23840 {}
C {lab_pin.sym} 1260 23840 0 0 {name=l19074 lab=VDD}
N 1240 23760 1260 23760 {}
C {lab_pin.sym} 1260 23760 0 0 {name=l19075 lab=VSS}
C {bitcell_6t.sym} 1400 23800 0 0 {name=Xr119c7}
N 1360 23840 1340 23840 {}
C {lab_pin.sym} 1340 23840 0 0 {name=l19076 lab=BL7}
N 1360 23800 1340 23800 {}
C {lab_pin.sym} 1340 23800 0 0 {name=l19077 lab=BLB7}
N 1360 23760 1340 23760 {}
C {lab_pin.sym} 1340 23760 0 0 {name=l19078 lab=WL119}
N 1440 23840 1460 23840 {}
C {lab_pin.sym} 1460 23840 0 0 {name=l19079 lab=VDD}
N 1440 23760 1460 23760 {}
C {lab_pin.sym} 1460 23760 0 0 {name=l19080 lab=VSS}
C {bitcell_6t.sym} 1600 23800 0 0 {name=Xr119c8}
N 1560 23840 1540 23840 {}
C {lab_pin.sym} 1540 23840 0 0 {name=l19081 lab=BL8}
N 1560 23800 1540 23800 {}
C {lab_pin.sym} 1540 23800 0 0 {name=l19082 lab=BLB8}
N 1560 23760 1540 23760 {}
C {lab_pin.sym} 1540 23760 0 0 {name=l19083 lab=WL119}
N 1640 23840 1660 23840 {}
C {lab_pin.sym} 1660 23840 0 0 {name=l19084 lab=VDD}
N 1640 23760 1660 23760 {}
C {lab_pin.sym} 1660 23760 0 0 {name=l19085 lab=VSS}
C {bitcell_6t.sym} 1800 23800 0 0 {name=Xr119c9}
N 1760 23840 1740 23840 {}
C {lab_pin.sym} 1740 23840 0 0 {name=l19086 lab=BL9}
N 1760 23800 1740 23800 {}
C {lab_pin.sym} 1740 23800 0 0 {name=l19087 lab=BLB9}
N 1760 23760 1740 23760 {}
C {lab_pin.sym} 1740 23760 0 0 {name=l19088 lab=WL119}
N 1840 23840 1860 23840 {}
C {lab_pin.sym} 1860 23840 0 0 {name=l19089 lab=VDD}
N 1840 23760 1860 23760 {}
C {lab_pin.sym} 1860 23760 0 0 {name=l19090 lab=VSS}
C {bitcell_6t.sym} 2000 23800 0 0 {name=Xr119c10}
N 1960 23840 1940 23840 {}
C {lab_pin.sym} 1940 23840 0 0 {name=l19091 lab=BL10}
N 1960 23800 1940 23800 {}
C {lab_pin.sym} 1940 23800 0 0 {name=l19092 lab=BLB10}
N 1960 23760 1940 23760 {}
C {lab_pin.sym} 1940 23760 0 0 {name=l19093 lab=WL119}
N 2040 23840 2060 23840 {}
C {lab_pin.sym} 2060 23840 0 0 {name=l19094 lab=VDD}
N 2040 23760 2060 23760 {}
C {lab_pin.sym} 2060 23760 0 0 {name=l19095 lab=VSS}
C {bitcell_6t.sym} 2200 23800 0 0 {name=Xr119c11}
N 2160 23840 2140 23840 {}
C {lab_pin.sym} 2140 23840 0 0 {name=l19096 lab=BL11}
N 2160 23800 2140 23800 {}
C {lab_pin.sym} 2140 23800 0 0 {name=l19097 lab=BLB11}
N 2160 23760 2140 23760 {}
C {lab_pin.sym} 2140 23760 0 0 {name=l19098 lab=WL119}
N 2240 23840 2260 23840 {}
C {lab_pin.sym} 2260 23840 0 0 {name=l19099 lab=VDD}
N 2240 23760 2260 23760 {}
C {lab_pin.sym} 2260 23760 0 0 {name=l19100 lab=VSS}
C {bitcell_6t.sym} 2400 23800 0 0 {name=Xr119c12}
N 2360 23840 2340 23840 {}
C {lab_pin.sym} 2340 23840 0 0 {name=l19101 lab=BL12}
N 2360 23800 2340 23800 {}
C {lab_pin.sym} 2340 23800 0 0 {name=l19102 lab=BLB12}
N 2360 23760 2340 23760 {}
C {lab_pin.sym} 2340 23760 0 0 {name=l19103 lab=WL119}
N 2440 23840 2460 23840 {}
C {lab_pin.sym} 2460 23840 0 0 {name=l19104 lab=VDD}
N 2440 23760 2460 23760 {}
C {lab_pin.sym} 2460 23760 0 0 {name=l19105 lab=VSS}
C {bitcell_6t.sym} 2600 23800 0 0 {name=Xr119c13}
N 2560 23840 2540 23840 {}
C {lab_pin.sym} 2540 23840 0 0 {name=l19106 lab=BL13}
N 2560 23800 2540 23800 {}
C {lab_pin.sym} 2540 23800 0 0 {name=l19107 lab=BLB13}
N 2560 23760 2540 23760 {}
C {lab_pin.sym} 2540 23760 0 0 {name=l19108 lab=WL119}
N 2640 23840 2660 23840 {}
C {lab_pin.sym} 2660 23840 0 0 {name=l19109 lab=VDD}
N 2640 23760 2660 23760 {}
C {lab_pin.sym} 2660 23760 0 0 {name=l19110 lab=VSS}
C {bitcell_6t.sym} 2800 23800 0 0 {name=Xr119c14}
N 2760 23840 2740 23840 {}
C {lab_pin.sym} 2740 23840 0 0 {name=l19111 lab=BL14}
N 2760 23800 2740 23800 {}
C {lab_pin.sym} 2740 23800 0 0 {name=l19112 lab=BLB14}
N 2760 23760 2740 23760 {}
C {lab_pin.sym} 2740 23760 0 0 {name=l19113 lab=WL119}
N 2840 23840 2860 23840 {}
C {lab_pin.sym} 2860 23840 0 0 {name=l19114 lab=VDD}
N 2840 23760 2860 23760 {}
C {lab_pin.sym} 2860 23760 0 0 {name=l19115 lab=VSS}
C {bitcell_6t.sym} 3000 23800 0 0 {name=Xr119c15}
N 2960 23840 2940 23840 {}
C {lab_pin.sym} 2940 23840 0 0 {name=l19116 lab=BL15}
N 2960 23800 2940 23800 {}
C {lab_pin.sym} 2940 23800 0 0 {name=l19117 lab=BLB15}
N 2960 23760 2940 23760 {}
C {lab_pin.sym} 2940 23760 0 0 {name=l19118 lab=WL119}
N 3040 23840 3060 23840 {}
C {lab_pin.sym} 3060 23840 0 0 {name=l19119 lab=VDD}
N 3040 23760 3060 23760 {}
C {lab_pin.sym} 3060 23760 0 0 {name=l19120 lab=VSS}
C {bitcell_6t.sym} 3200 23800 0 0 {name=Xr119c16}
N 3160 23840 3140 23840 {}
C {lab_pin.sym} 3140 23840 0 0 {name=l19121 lab=BL16}
N 3160 23800 3140 23800 {}
C {lab_pin.sym} 3140 23800 0 0 {name=l19122 lab=BLB16}
N 3160 23760 3140 23760 {}
C {lab_pin.sym} 3140 23760 0 0 {name=l19123 lab=WL119}
N 3240 23840 3260 23840 {}
C {lab_pin.sym} 3260 23840 0 0 {name=l19124 lab=VDD}
N 3240 23760 3260 23760 {}
C {lab_pin.sym} 3260 23760 0 0 {name=l19125 lab=VSS}
C {bitcell_6t.sym} 3400 23800 0 0 {name=Xr119c17}
N 3360 23840 3340 23840 {}
C {lab_pin.sym} 3340 23840 0 0 {name=l19126 lab=BL17}
N 3360 23800 3340 23800 {}
C {lab_pin.sym} 3340 23800 0 0 {name=l19127 lab=BLB17}
N 3360 23760 3340 23760 {}
C {lab_pin.sym} 3340 23760 0 0 {name=l19128 lab=WL119}
N 3440 23840 3460 23840 {}
C {lab_pin.sym} 3460 23840 0 0 {name=l19129 lab=VDD}
N 3440 23760 3460 23760 {}
C {lab_pin.sym} 3460 23760 0 0 {name=l19130 lab=VSS}
C {bitcell_6t.sym} 3600 23800 0 0 {name=Xr119c18}
N 3560 23840 3540 23840 {}
C {lab_pin.sym} 3540 23840 0 0 {name=l19131 lab=BL18}
N 3560 23800 3540 23800 {}
C {lab_pin.sym} 3540 23800 0 0 {name=l19132 lab=BLB18}
N 3560 23760 3540 23760 {}
C {lab_pin.sym} 3540 23760 0 0 {name=l19133 lab=WL119}
N 3640 23840 3660 23840 {}
C {lab_pin.sym} 3660 23840 0 0 {name=l19134 lab=VDD}
N 3640 23760 3660 23760 {}
C {lab_pin.sym} 3660 23760 0 0 {name=l19135 lab=VSS}
C {bitcell_6t.sym} 3800 23800 0 0 {name=Xr119c19}
N 3760 23840 3740 23840 {}
C {lab_pin.sym} 3740 23840 0 0 {name=l19136 lab=BL19}
N 3760 23800 3740 23800 {}
C {lab_pin.sym} 3740 23800 0 0 {name=l19137 lab=BLB19}
N 3760 23760 3740 23760 {}
C {lab_pin.sym} 3740 23760 0 0 {name=l19138 lab=WL119}
N 3840 23840 3860 23840 {}
C {lab_pin.sym} 3860 23840 0 0 {name=l19139 lab=VDD}
N 3840 23760 3860 23760 {}
C {lab_pin.sym} 3860 23760 0 0 {name=l19140 lab=VSS}
C {bitcell_6t.sym} 4000 23800 0 0 {name=Xr119c20}
N 3960 23840 3940 23840 {}
C {lab_pin.sym} 3940 23840 0 0 {name=l19141 lab=BL20}
N 3960 23800 3940 23800 {}
C {lab_pin.sym} 3940 23800 0 0 {name=l19142 lab=BLB20}
N 3960 23760 3940 23760 {}
C {lab_pin.sym} 3940 23760 0 0 {name=l19143 lab=WL119}
N 4040 23840 4060 23840 {}
C {lab_pin.sym} 4060 23840 0 0 {name=l19144 lab=VDD}
N 4040 23760 4060 23760 {}
C {lab_pin.sym} 4060 23760 0 0 {name=l19145 lab=VSS}
C {bitcell_6t.sym} 4200 23800 0 0 {name=Xr119c21}
N 4160 23840 4140 23840 {}
C {lab_pin.sym} 4140 23840 0 0 {name=l19146 lab=BL21}
N 4160 23800 4140 23800 {}
C {lab_pin.sym} 4140 23800 0 0 {name=l19147 lab=BLB21}
N 4160 23760 4140 23760 {}
C {lab_pin.sym} 4140 23760 0 0 {name=l19148 lab=WL119}
N 4240 23840 4260 23840 {}
C {lab_pin.sym} 4260 23840 0 0 {name=l19149 lab=VDD}
N 4240 23760 4260 23760 {}
C {lab_pin.sym} 4260 23760 0 0 {name=l19150 lab=VSS}
C {bitcell_6t.sym} 4400 23800 0 0 {name=Xr119c22}
N 4360 23840 4340 23840 {}
C {lab_pin.sym} 4340 23840 0 0 {name=l19151 lab=BL22}
N 4360 23800 4340 23800 {}
C {lab_pin.sym} 4340 23800 0 0 {name=l19152 lab=BLB22}
N 4360 23760 4340 23760 {}
C {lab_pin.sym} 4340 23760 0 0 {name=l19153 lab=WL119}
N 4440 23840 4460 23840 {}
C {lab_pin.sym} 4460 23840 0 0 {name=l19154 lab=VDD}
N 4440 23760 4460 23760 {}
C {lab_pin.sym} 4460 23760 0 0 {name=l19155 lab=VSS}
C {bitcell_6t.sym} 4600 23800 0 0 {name=Xr119c23}
N 4560 23840 4540 23840 {}
C {lab_pin.sym} 4540 23840 0 0 {name=l19156 lab=BL23}
N 4560 23800 4540 23800 {}
C {lab_pin.sym} 4540 23800 0 0 {name=l19157 lab=BLB23}
N 4560 23760 4540 23760 {}
C {lab_pin.sym} 4540 23760 0 0 {name=l19158 lab=WL119}
N 4640 23840 4660 23840 {}
C {lab_pin.sym} 4660 23840 0 0 {name=l19159 lab=VDD}
N 4640 23760 4660 23760 {}
C {lab_pin.sym} 4660 23760 0 0 {name=l19160 lab=VSS}
C {bitcell_6t.sym} 4800 23800 0 0 {name=Xr119c24}
N 4760 23840 4740 23840 {}
C {lab_pin.sym} 4740 23840 0 0 {name=l19161 lab=BL24}
N 4760 23800 4740 23800 {}
C {lab_pin.sym} 4740 23800 0 0 {name=l19162 lab=BLB24}
N 4760 23760 4740 23760 {}
C {lab_pin.sym} 4740 23760 0 0 {name=l19163 lab=WL119}
N 4840 23840 4860 23840 {}
C {lab_pin.sym} 4860 23840 0 0 {name=l19164 lab=VDD}
N 4840 23760 4860 23760 {}
C {lab_pin.sym} 4860 23760 0 0 {name=l19165 lab=VSS}
C {bitcell_6t.sym} 5000 23800 0 0 {name=Xr119c25}
N 4960 23840 4940 23840 {}
C {lab_pin.sym} 4940 23840 0 0 {name=l19166 lab=BL25}
N 4960 23800 4940 23800 {}
C {lab_pin.sym} 4940 23800 0 0 {name=l19167 lab=BLB25}
N 4960 23760 4940 23760 {}
C {lab_pin.sym} 4940 23760 0 0 {name=l19168 lab=WL119}
N 5040 23840 5060 23840 {}
C {lab_pin.sym} 5060 23840 0 0 {name=l19169 lab=VDD}
N 5040 23760 5060 23760 {}
C {lab_pin.sym} 5060 23760 0 0 {name=l19170 lab=VSS}
C {bitcell_6t.sym} 5200 23800 0 0 {name=Xr119c26}
N 5160 23840 5140 23840 {}
C {lab_pin.sym} 5140 23840 0 0 {name=l19171 lab=BL26}
N 5160 23800 5140 23800 {}
C {lab_pin.sym} 5140 23800 0 0 {name=l19172 lab=BLB26}
N 5160 23760 5140 23760 {}
C {lab_pin.sym} 5140 23760 0 0 {name=l19173 lab=WL119}
N 5240 23840 5260 23840 {}
C {lab_pin.sym} 5260 23840 0 0 {name=l19174 lab=VDD}
N 5240 23760 5260 23760 {}
C {lab_pin.sym} 5260 23760 0 0 {name=l19175 lab=VSS}
C {bitcell_6t.sym} 5400 23800 0 0 {name=Xr119c27}
N 5360 23840 5340 23840 {}
C {lab_pin.sym} 5340 23840 0 0 {name=l19176 lab=BL27}
N 5360 23800 5340 23800 {}
C {lab_pin.sym} 5340 23800 0 0 {name=l19177 lab=BLB27}
N 5360 23760 5340 23760 {}
C {lab_pin.sym} 5340 23760 0 0 {name=l19178 lab=WL119}
N 5440 23840 5460 23840 {}
C {lab_pin.sym} 5460 23840 0 0 {name=l19179 lab=VDD}
N 5440 23760 5460 23760 {}
C {lab_pin.sym} 5460 23760 0 0 {name=l19180 lab=VSS}
C {bitcell_6t.sym} 5600 23800 0 0 {name=Xr119c28}
N 5560 23840 5540 23840 {}
C {lab_pin.sym} 5540 23840 0 0 {name=l19181 lab=BL28}
N 5560 23800 5540 23800 {}
C {lab_pin.sym} 5540 23800 0 0 {name=l19182 lab=BLB28}
N 5560 23760 5540 23760 {}
C {lab_pin.sym} 5540 23760 0 0 {name=l19183 lab=WL119}
N 5640 23840 5660 23840 {}
C {lab_pin.sym} 5660 23840 0 0 {name=l19184 lab=VDD}
N 5640 23760 5660 23760 {}
C {lab_pin.sym} 5660 23760 0 0 {name=l19185 lab=VSS}
C {bitcell_6t.sym} 5800 23800 0 0 {name=Xr119c29}
N 5760 23840 5740 23840 {}
C {lab_pin.sym} 5740 23840 0 0 {name=l19186 lab=BL29}
N 5760 23800 5740 23800 {}
C {lab_pin.sym} 5740 23800 0 0 {name=l19187 lab=BLB29}
N 5760 23760 5740 23760 {}
C {lab_pin.sym} 5740 23760 0 0 {name=l19188 lab=WL119}
N 5840 23840 5860 23840 {}
C {lab_pin.sym} 5860 23840 0 0 {name=l19189 lab=VDD}
N 5840 23760 5860 23760 {}
C {lab_pin.sym} 5860 23760 0 0 {name=l19190 lab=VSS}
C {bitcell_6t.sym} 6000 23800 0 0 {name=Xr119c30}
N 5960 23840 5940 23840 {}
C {lab_pin.sym} 5940 23840 0 0 {name=l19191 lab=BL30}
N 5960 23800 5940 23800 {}
C {lab_pin.sym} 5940 23800 0 0 {name=l19192 lab=BLB30}
N 5960 23760 5940 23760 {}
C {lab_pin.sym} 5940 23760 0 0 {name=l19193 lab=WL119}
N 6040 23840 6060 23840 {}
C {lab_pin.sym} 6060 23840 0 0 {name=l19194 lab=VDD}
N 6040 23760 6060 23760 {}
C {lab_pin.sym} 6060 23760 0 0 {name=l19195 lab=VSS}
C {bitcell_6t.sym} 6200 23800 0 0 {name=Xr119c31}
N 6160 23840 6140 23840 {}
C {lab_pin.sym} 6140 23840 0 0 {name=l19196 lab=BL31}
N 6160 23800 6140 23800 {}
C {lab_pin.sym} 6140 23800 0 0 {name=l19197 lab=BLB31}
N 6160 23760 6140 23760 {}
C {lab_pin.sym} 6140 23760 0 0 {name=l19198 lab=WL119}
N 6240 23840 6260 23840 {}
C {lab_pin.sym} 6260 23840 0 0 {name=l19199 lab=VDD}
N 6240 23760 6260 23760 {}
C {lab_pin.sym} 6260 23760 0 0 {name=l19200 lab=VSS}
C {bitcell_6t.sym} 0 24000 0 0 {name=Xr120c0}
N -40 24040 -60 24040 {}
C {lab_pin.sym} -60 24040 0 0 {name=l19201 lab=BL0}
N -40 24000 -60 24000 {}
C {lab_pin.sym} -60 24000 0 0 {name=l19202 lab=BLB0}
N -40 23960 -60 23960 {}
C {lab_pin.sym} -60 23960 0 0 {name=l19203 lab=WL120}
N 40 24040 60 24040 {}
C {lab_pin.sym} 60 24040 0 0 {name=l19204 lab=VDD}
N 40 23960 60 23960 {}
C {lab_pin.sym} 60 23960 0 0 {name=l19205 lab=VSS}
C {bitcell_6t.sym} 200 24000 0 0 {name=Xr120c1}
N 160 24040 140 24040 {}
C {lab_pin.sym} 140 24040 0 0 {name=l19206 lab=BL1}
N 160 24000 140 24000 {}
C {lab_pin.sym} 140 24000 0 0 {name=l19207 lab=BLB1}
N 160 23960 140 23960 {}
C {lab_pin.sym} 140 23960 0 0 {name=l19208 lab=WL120}
N 240 24040 260 24040 {}
C {lab_pin.sym} 260 24040 0 0 {name=l19209 lab=VDD}
N 240 23960 260 23960 {}
C {lab_pin.sym} 260 23960 0 0 {name=l19210 lab=VSS}
C {bitcell_6t.sym} 400 24000 0 0 {name=Xr120c2}
N 360 24040 340 24040 {}
C {lab_pin.sym} 340 24040 0 0 {name=l19211 lab=BL2}
N 360 24000 340 24000 {}
C {lab_pin.sym} 340 24000 0 0 {name=l19212 lab=BLB2}
N 360 23960 340 23960 {}
C {lab_pin.sym} 340 23960 0 0 {name=l19213 lab=WL120}
N 440 24040 460 24040 {}
C {lab_pin.sym} 460 24040 0 0 {name=l19214 lab=VDD}
N 440 23960 460 23960 {}
C {lab_pin.sym} 460 23960 0 0 {name=l19215 lab=VSS}
C {bitcell_6t.sym} 600 24000 0 0 {name=Xr120c3}
N 560 24040 540 24040 {}
C {lab_pin.sym} 540 24040 0 0 {name=l19216 lab=BL3}
N 560 24000 540 24000 {}
C {lab_pin.sym} 540 24000 0 0 {name=l19217 lab=BLB3}
N 560 23960 540 23960 {}
C {lab_pin.sym} 540 23960 0 0 {name=l19218 lab=WL120}
N 640 24040 660 24040 {}
C {lab_pin.sym} 660 24040 0 0 {name=l19219 lab=VDD}
N 640 23960 660 23960 {}
C {lab_pin.sym} 660 23960 0 0 {name=l19220 lab=VSS}
C {bitcell_6t.sym} 800 24000 0 0 {name=Xr120c4}
N 760 24040 740 24040 {}
C {lab_pin.sym} 740 24040 0 0 {name=l19221 lab=BL4}
N 760 24000 740 24000 {}
C {lab_pin.sym} 740 24000 0 0 {name=l19222 lab=BLB4}
N 760 23960 740 23960 {}
C {lab_pin.sym} 740 23960 0 0 {name=l19223 lab=WL120}
N 840 24040 860 24040 {}
C {lab_pin.sym} 860 24040 0 0 {name=l19224 lab=VDD}
N 840 23960 860 23960 {}
C {lab_pin.sym} 860 23960 0 0 {name=l19225 lab=VSS}
C {bitcell_6t.sym} 1000 24000 0 0 {name=Xr120c5}
N 960 24040 940 24040 {}
C {lab_pin.sym} 940 24040 0 0 {name=l19226 lab=BL5}
N 960 24000 940 24000 {}
C {lab_pin.sym} 940 24000 0 0 {name=l19227 lab=BLB5}
N 960 23960 940 23960 {}
C {lab_pin.sym} 940 23960 0 0 {name=l19228 lab=WL120}
N 1040 24040 1060 24040 {}
C {lab_pin.sym} 1060 24040 0 0 {name=l19229 lab=VDD}
N 1040 23960 1060 23960 {}
C {lab_pin.sym} 1060 23960 0 0 {name=l19230 lab=VSS}
C {bitcell_6t.sym} 1200 24000 0 0 {name=Xr120c6}
N 1160 24040 1140 24040 {}
C {lab_pin.sym} 1140 24040 0 0 {name=l19231 lab=BL6}
N 1160 24000 1140 24000 {}
C {lab_pin.sym} 1140 24000 0 0 {name=l19232 lab=BLB6}
N 1160 23960 1140 23960 {}
C {lab_pin.sym} 1140 23960 0 0 {name=l19233 lab=WL120}
N 1240 24040 1260 24040 {}
C {lab_pin.sym} 1260 24040 0 0 {name=l19234 lab=VDD}
N 1240 23960 1260 23960 {}
C {lab_pin.sym} 1260 23960 0 0 {name=l19235 lab=VSS}
C {bitcell_6t.sym} 1400 24000 0 0 {name=Xr120c7}
N 1360 24040 1340 24040 {}
C {lab_pin.sym} 1340 24040 0 0 {name=l19236 lab=BL7}
N 1360 24000 1340 24000 {}
C {lab_pin.sym} 1340 24000 0 0 {name=l19237 lab=BLB7}
N 1360 23960 1340 23960 {}
C {lab_pin.sym} 1340 23960 0 0 {name=l19238 lab=WL120}
N 1440 24040 1460 24040 {}
C {lab_pin.sym} 1460 24040 0 0 {name=l19239 lab=VDD}
N 1440 23960 1460 23960 {}
C {lab_pin.sym} 1460 23960 0 0 {name=l19240 lab=VSS}
C {bitcell_6t.sym} 1600 24000 0 0 {name=Xr120c8}
N 1560 24040 1540 24040 {}
C {lab_pin.sym} 1540 24040 0 0 {name=l19241 lab=BL8}
N 1560 24000 1540 24000 {}
C {lab_pin.sym} 1540 24000 0 0 {name=l19242 lab=BLB8}
N 1560 23960 1540 23960 {}
C {lab_pin.sym} 1540 23960 0 0 {name=l19243 lab=WL120}
N 1640 24040 1660 24040 {}
C {lab_pin.sym} 1660 24040 0 0 {name=l19244 lab=VDD}
N 1640 23960 1660 23960 {}
C {lab_pin.sym} 1660 23960 0 0 {name=l19245 lab=VSS}
C {bitcell_6t.sym} 1800 24000 0 0 {name=Xr120c9}
N 1760 24040 1740 24040 {}
C {lab_pin.sym} 1740 24040 0 0 {name=l19246 lab=BL9}
N 1760 24000 1740 24000 {}
C {lab_pin.sym} 1740 24000 0 0 {name=l19247 lab=BLB9}
N 1760 23960 1740 23960 {}
C {lab_pin.sym} 1740 23960 0 0 {name=l19248 lab=WL120}
N 1840 24040 1860 24040 {}
C {lab_pin.sym} 1860 24040 0 0 {name=l19249 lab=VDD}
N 1840 23960 1860 23960 {}
C {lab_pin.sym} 1860 23960 0 0 {name=l19250 lab=VSS}
C {bitcell_6t.sym} 2000 24000 0 0 {name=Xr120c10}
N 1960 24040 1940 24040 {}
C {lab_pin.sym} 1940 24040 0 0 {name=l19251 lab=BL10}
N 1960 24000 1940 24000 {}
C {lab_pin.sym} 1940 24000 0 0 {name=l19252 lab=BLB10}
N 1960 23960 1940 23960 {}
C {lab_pin.sym} 1940 23960 0 0 {name=l19253 lab=WL120}
N 2040 24040 2060 24040 {}
C {lab_pin.sym} 2060 24040 0 0 {name=l19254 lab=VDD}
N 2040 23960 2060 23960 {}
C {lab_pin.sym} 2060 23960 0 0 {name=l19255 lab=VSS}
C {bitcell_6t.sym} 2200 24000 0 0 {name=Xr120c11}
N 2160 24040 2140 24040 {}
C {lab_pin.sym} 2140 24040 0 0 {name=l19256 lab=BL11}
N 2160 24000 2140 24000 {}
C {lab_pin.sym} 2140 24000 0 0 {name=l19257 lab=BLB11}
N 2160 23960 2140 23960 {}
C {lab_pin.sym} 2140 23960 0 0 {name=l19258 lab=WL120}
N 2240 24040 2260 24040 {}
C {lab_pin.sym} 2260 24040 0 0 {name=l19259 lab=VDD}
N 2240 23960 2260 23960 {}
C {lab_pin.sym} 2260 23960 0 0 {name=l19260 lab=VSS}
C {bitcell_6t.sym} 2400 24000 0 0 {name=Xr120c12}
N 2360 24040 2340 24040 {}
C {lab_pin.sym} 2340 24040 0 0 {name=l19261 lab=BL12}
N 2360 24000 2340 24000 {}
C {lab_pin.sym} 2340 24000 0 0 {name=l19262 lab=BLB12}
N 2360 23960 2340 23960 {}
C {lab_pin.sym} 2340 23960 0 0 {name=l19263 lab=WL120}
N 2440 24040 2460 24040 {}
C {lab_pin.sym} 2460 24040 0 0 {name=l19264 lab=VDD}
N 2440 23960 2460 23960 {}
C {lab_pin.sym} 2460 23960 0 0 {name=l19265 lab=VSS}
C {bitcell_6t.sym} 2600 24000 0 0 {name=Xr120c13}
N 2560 24040 2540 24040 {}
C {lab_pin.sym} 2540 24040 0 0 {name=l19266 lab=BL13}
N 2560 24000 2540 24000 {}
C {lab_pin.sym} 2540 24000 0 0 {name=l19267 lab=BLB13}
N 2560 23960 2540 23960 {}
C {lab_pin.sym} 2540 23960 0 0 {name=l19268 lab=WL120}
N 2640 24040 2660 24040 {}
C {lab_pin.sym} 2660 24040 0 0 {name=l19269 lab=VDD}
N 2640 23960 2660 23960 {}
C {lab_pin.sym} 2660 23960 0 0 {name=l19270 lab=VSS}
C {bitcell_6t.sym} 2800 24000 0 0 {name=Xr120c14}
N 2760 24040 2740 24040 {}
C {lab_pin.sym} 2740 24040 0 0 {name=l19271 lab=BL14}
N 2760 24000 2740 24000 {}
C {lab_pin.sym} 2740 24000 0 0 {name=l19272 lab=BLB14}
N 2760 23960 2740 23960 {}
C {lab_pin.sym} 2740 23960 0 0 {name=l19273 lab=WL120}
N 2840 24040 2860 24040 {}
C {lab_pin.sym} 2860 24040 0 0 {name=l19274 lab=VDD}
N 2840 23960 2860 23960 {}
C {lab_pin.sym} 2860 23960 0 0 {name=l19275 lab=VSS}
C {bitcell_6t.sym} 3000 24000 0 0 {name=Xr120c15}
N 2960 24040 2940 24040 {}
C {lab_pin.sym} 2940 24040 0 0 {name=l19276 lab=BL15}
N 2960 24000 2940 24000 {}
C {lab_pin.sym} 2940 24000 0 0 {name=l19277 lab=BLB15}
N 2960 23960 2940 23960 {}
C {lab_pin.sym} 2940 23960 0 0 {name=l19278 lab=WL120}
N 3040 24040 3060 24040 {}
C {lab_pin.sym} 3060 24040 0 0 {name=l19279 lab=VDD}
N 3040 23960 3060 23960 {}
C {lab_pin.sym} 3060 23960 0 0 {name=l19280 lab=VSS}
C {bitcell_6t.sym} 3200 24000 0 0 {name=Xr120c16}
N 3160 24040 3140 24040 {}
C {lab_pin.sym} 3140 24040 0 0 {name=l19281 lab=BL16}
N 3160 24000 3140 24000 {}
C {lab_pin.sym} 3140 24000 0 0 {name=l19282 lab=BLB16}
N 3160 23960 3140 23960 {}
C {lab_pin.sym} 3140 23960 0 0 {name=l19283 lab=WL120}
N 3240 24040 3260 24040 {}
C {lab_pin.sym} 3260 24040 0 0 {name=l19284 lab=VDD}
N 3240 23960 3260 23960 {}
C {lab_pin.sym} 3260 23960 0 0 {name=l19285 lab=VSS}
C {bitcell_6t.sym} 3400 24000 0 0 {name=Xr120c17}
N 3360 24040 3340 24040 {}
C {lab_pin.sym} 3340 24040 0 0 {name=l19286 lab=BL17}
N 3360 24000 3340 24000 {}
C {lab_pin.sym} 3340 24000 0 0 {name=l19287 lab=BLB17}
N 3360 23960 3340 23960 {}
C {lab_pin.sym} 3340 23960 0 0 {name=l19288 lab=WL120}
N 3440 24040 3460 24040 {}
C {lab_pin.sym} 3460 24040 0 0 {name=l19289 lab=VDD}
N 3440 23960 3460 23960 {}
C {lab_pin.sym} 3460 23960 0 0 {name=l19290 lab=VSS}
C {bitcell_6t.sym} 3600 24000 0 0 {name=Xr120c18}
N 3560 24040 3540 24040 {}
C {lab_pin.sym} 3540 24040 0 0 {name=l19291 lab=BL18}
N 3560 24000 3540 24000 {}
C {lab_pin.sym} 3540 24000 0 0 {name=l19292 lab=BLB18}
N 3560 23960 3540 23960 {}
C {lab_pin.sym} 3540 23960 0 0 {name=l19293 lab=WL120}
N 3640 24040 3660 24040 {}
C {lab_pin.sym} 3660 24040 0 0 {name=l19294 lab=VDD}
N 3640 23960 3660 23960 {}
C {lab_pin.sym} 3660 23960 0 0 {name=l19295 lab=VSS}
C {bitcell_6t.sym} 3800 24000 0 0 {name=Xr120c19}
N 3760 24040 3740 24040 {}
C {lab_pin.sym} 3740 24040 0 0 {name=l19296 lab=BL19}
N 3760 24000 3740 24000 {}
C {lab_pin.sym} 3740 24000 0 0 {name=l19297 lab=BLB19}
N 3760 23960 3740 23960 {}
C {lab_pin.sym} 3740 23960 0 0 {name=l19298 lab=WL120}
N 3840 24040 3860 24040 {}
C {lab_pin.sym} 3860 24040 0 0 {name=l19299 lab=VDD}
N 3840 23960 3860 23960 {}
C {lab_pin.sym} 3860 23960 0 0 {name=l19300 lab=VSS}
C {bitcell_6t.sym} 4000 24000 0 0 {name=Xr120c20}
N 3960 24040 3940 24040 {}
C {lab_pin.sym} 3940 24040 0 0 {name=l19301 lab=BL20}
N 3960 24000 3940 24000 {}
C {lab_pin.sym} 3940 24000 0 0 {name=l19302 lab=BLB20}
N 3960 23960 3940 23960 {}
C {lab_pin.sym} 3940 23960 0 0 {name=l19303 lab=WL120}
N 4040 24040 4060 24040 {}
C {lab_pin.sym} 4060 24040 0 0 {name=l19304 lab=VDD}
N 4040 23960 4060 23960 {}
C {lab_pin.sym} 4060 23960 0 0 {name=l19305 lab=VSS}
C {bitcell_6t.sym} 4200 24000 0 0 {name=Xr120c21}
N 4160 24040 4140 24040 {}
C {lab_pin.sym} 4140 24040 0 0 {name=l19306 lab=BL21}
N 4160 24000 4140 24000 {}
C {lab_pin.sym} 4140 24000 0 0 {name=l19307 lab=BLB21}
N 4160 23960 4140 23960 {}
C {lab_pin.sym} 4140 23960 0 0 {name=l19308 lab=WL120}
N 4240 24040 4260 24040 {}
C {lab_pin.sym} 4260 24040 0 0 {name=l19309 lab=VDD}
N 4240 23960 4260 23960 {}
C {lab_pin.sym} 4260 23960 0 0 {name=l19310 lab=VSS}
C {bitcell_6t.sym} 4400 24000 0 0 {name=Xr120c22}
N 4360 24040 4340 24040 {}
C {lab_pin.sym} 4340 24040 0 0 {name=l19311 lab=BL22}
N 4360 24000 4340 24000 {}
C {lab_pin.sym} 4340 24000 0 0 {name=l19312 lab=BLB22}
N 4360 23960 4340 23960 {}
C {lab_pin.sym} 4340 23960 0 0 {name=l19313 lab=WL120}
N 4440 24040 4460 24040 {}
C {lab_pin.sym} 4460 24040 0 0 {name=l19314 lab=VDD}
N 4440 23960 4460 23960 {}
C {lab_pin.sym} 4460 23960 0 0 {name=l19315 lab=VSS}
C {bitcell_6t.sym} 4600 24000 0 0 {name=Xr120c23}
N 4560 24040 4540 24040 {}
C {lab_pin.sym} 4540 24040 0 0 {name=l19316 lab=BL23}
N 4560 24000 4540 24000 {}
C {lab_pin.sym} 4540 24000 0 0 {name=l19317 lab=BLB23}
N 4560 23960 4540 23960 {}
C {lab_pin.sym} 4540 23960 0 0 {name=l19318 lab=WL120}
N 4640 24040 4660 24040 {}
C {lab_pin.sym} 4660 24040 0 0 {name=l19319 lab=VDD}
N 4640 23960 4660 23960 {}
C {lab_pin.sym} 4660 23960 0 0 {name=l19320 lab=VSS}
C {bitcell_6t.sym} 4800 24000 0 0 {name=Xr120c24}
N 4760 24040 4740 24040 {}
C {lab_pin.sym} 4740 24040 0 0 {name=l19321 lab=BL24}
N 4760 24000 4740 24000 {}
C {lab_pin.sym} 4740 24000 0 0 {name=l19322 lab=BLB24}
N 4760 23960 4740 23960 {}
C {lab_pin.sym} 4740 23960 0 0 {name=l19323 lab=WL120}
N 4840 24040 4860 24040 {}
C {lab_pin.sym} 4860 24040 0 0 {name=l19324 lab=VDD}
N 4840 23960 4860 23960 {}
C {lab_pin.sym} 4860 23960 0 0 {name=l19325 lab=VSS}
C {bitcell_6t.sym} 5000 24000 0 0 {name=Xr120c25}
N 4960 24040 4940 24040 {}
C {lab_pin.sym} 4940 24040 0 0 {name=l19326 lab=BL25}
N 4960 24000 4940 24000 {}
C {lab_pin.sym} 4940 24000 0 0 {name=l19327 lab=BLB25}
N 4960 23960 4940 23960 {}
C {lab_pin.sym} 4940 23960 0 0 {name=l19328 lab=WL120}
N 5040 24040 5060 24040 {}
C {lab_pin.sym} 5060 24040 0 0 {name=l19329 lab=VDD}
N 5040 23960 5060 23960 {}
C {lab_pin.sym} 5060 23960 0 0 {name=l19330 lab=VSS}
C {bitcell_6t.sym} 5200 24000 0 0 {name=Xr120c26}
N 5160 24040 5140 24040 {}
C {lab_pin.sym} 5140 24040 0 0 {name=l19331 lab=BL26}
N 5160 24000 5140 24000 {}
C {lab_pin.sym} 5140 24000 0 0 {name=l19332 lab=BLB26}
N 5160 23960 5140 23960 {}
C {lab_pin.sym} 5140 23960 0 0 {name=l19333 lab=WL120}
N 5240 24040 5260 24040 {}
C {lab_pin.sym} 5260 24040 0 0 {name=l19334 lab=VDD}
N 5240 23960 5260 23960 {}
C {lab_pin.sym} 5260 23960 0 0 {name=l19335 lab=VSS}
C {bitcell_6t.sym} 5400 24000 0 0 {name=Xr120c27}
N 5360 24040 5340 24040 {}
C {lab_pin.sym} 5340 24040 0 0 {name=l19336 lab=BL27}
N 5360 24000 5340 24000 {}
C {lab_pin.sym} 5340 24000 0 0 {name=l19337 lab=BLB27}
N 5360 23960 5340 23960 {}
C {lab_pin.sym} 5340 23960 0 0 {name=l19338 lab=WL120}
N 5440 24040 5460 24040 {}
C {lab_pin.sym} 5460 24040 0 0 {name=l19339 lab=VDD}
N 5440 23960 5460 23960 {}
C {lab_pin.sym} 5460 23960 0 0 {name=l19340 lab=VSS}
C {bitcell_6t.sym} 5600 24000 0 0 {name=Xr120c28}
N 5560 24040 5540 24040 {}
C {lab_pin.sym} 5540 24040 0 0 {name=l19341 lab=BL28}
N 5560 24000 5540 24000 {}
C {lab_pin.sym} 5540 24000 0 0 {name=l19342 lab=BLB28}
N 5560 23960 5540 23960 {}
C {lab_pin.sym} 5540 23960 0 0 {name=l19343 lab=WL120}
N 5640 24040 5660 24040 {}
C {lab_pin.sym} 5660 24040 0 0 {name=l19344 lab=VDD}
N 5640 23960 5660 23960 {}
C {lab_pin.sym} 5660 23960 0 0 {name=l19345 lab=VSS}
C {bitcell_6t.sym} 5800 24000 0 0 {name=Xr120c29}
N 5760 24040 5740 24040 {}
C {lab_pin.sym} 5740 24040 0 0 {name=l19346 lab=BL29}
N 5760 24000 5740 24000 {}
C {lab_pin.sym} 5740 24000 0 0 {name=l19347 lab=BLB29}
N 5760 23960 5740 23960 {}
C {lab_pin.sym} 5740 23960 0 0 {name=l19348 lab=WL120}
N 5840 24040 5860 24040 {}
C {lab_pin.sym} 5860 24040 0 0 {name=l19349 lab=VDD}
N 5840 23960 5860 23960 {}
C {lab_pin.sym} 5860 23960 0 0 {name=l19350 lab=VSS}
C {bitcell_6t.sym} 6000 24000 0 0 {name=Xr120c30}
N 5960 24040 5940 24040 {}
C {lab_pin.sym} 5940 24040 0 0 {name=l19351 lab=BL30}
N 5960 24000 5940 24000 {}
C {lab_pin.sym} 5940 24000 0 0 {name=l19352 lab=BLB30}
N 5960 23960 5940 23960 {}
C {lab_pin.sym} 5940 23960 0 0 {name=l19353 lab=WL120}
N 6040 24040 6060 24040 {}
C {lab_pin.sym} 6060 24040 0 0 {name=l19354 lab=VDD}
N 6040 23960 6060 23960 {}
C {lab_pin.sym} 6060 23960 0 0 {name=l19355 lab=VSS}
C {bitcell_6t.sym} 6200 24000 0 0 {name=Xr120c31}
N 6160 24040 6140 24040 {}
C {lab_pin.sym} 6140 24040 0 0 {name=l19356 lab=BL31}
N 6160 24000 6140 24000 {}
C {lab_pin.sym} 6140 24000 0 0 {name=l19357 lab=BLB31}
N 6160 23960 6140 23960 {}
C {lab_pin.sym} 6140 23960 0 0 {name=l19358 lab=WL120}
N 6240 24040 6260 24040 {}
C {lab_pin.sym} 6260 24040 0 0 {name=l19359 lab=VDD}
N 6240 23960 6260 23960 {}
C {lab_pin.sym} 6260 23960 0 0 {name=l19360 lab=VSS}
C {bitcell_6t.sym} 0 24200 0 0 {name=Xr121c0}
N -40 24240 -60 24240 {}
C {lab_pin.sym} -60 24240 0 0 {name=l19361 lab=BL0}
N -40 24200 -60 24200 {}
C {lab_pin.sym} -60 24200 0 0 {name=l19362 lab=BLB0}
N -40 24160 -60 24160 {}
C {lab_pin.sym} -60 24160 0 0 {name=l19363 lab=WL121}
N 40 24240 60 24240 {}
C {lab_pin.sym} 60 24240 0 0 {name=l19364 lab=VDD}
N 40 24160 60 24160 {}
C {lab_pin.sym} 60 24160 0 0 {name=l19365 lab=VSS}
C {bitcell_6t.sym} 200 24200 0 0 {name=Xr121c1}
N 160 24240 140 24240 {}
C {lab_pin.sym} 140 24240 0 0 {name=l19366 lab=BL1}
N 160 24200 140 24200 {}
C {lab_pin.sym} 140 24200 0 0 {name=l19367 lab=BLB1}
N 160 24160 140 24160 {}
C {lab_pin.sym} 140 24160 0 0 {name=l19368 lab=WL121}
N 240 24240 260 24240 {}
C {lab_pin.sym} 260 24240 0 0 {name=l19369 lab=VDD}
N 240 24160 260 24160 {}
C {lab_pin.sym} 260 24160 0 0 {name=l19370 lab=VSS}
C {bitcell_6t.sym} 400 24200 0 0 {name=Xr121c2}
N 360 24240 340 24240 {}
C {lab_pin.sym} 340 24240 0 0 {name=l19371 lab=BL2}
N 360 24200 340 24200 {}
C {lab_pin.sym} 340 24200 0 0 {name=l19372 lab=BLB2}
N 360 24160 340 24160 {}
C {lab_pin.sym} 340 24160 0 0 {name=l19373 lab=WL121}
N 440 24240 460 24240 {}
C {lab_pin.sym} 460 24240 0 0 {name=l19374 lab=VDD}
N 440 24160 460 24160 {}
C {lab_pin.sym} 460 24160 0 0 {name=l19375 lab=VSS}
C {bitcell_6t.sym} 600 24200 0 0 {name=Xr121c3}
N 560 24240 540 24240 {}
C {lab_pin.sym} 540 24240 0 0 {name=l19376 lab=BL3}
N 560 24200 540 24200 {}
C {lab_pin.sym} 540 24200 0 0 {name=l19377 lab=BLB3}
N 560 24160 540 24160 {}
C {lab_pin.sym} 540 24160 0 0 {name=l19378 lab=WL121}
N 640 24240 660 24240 {}
C {lab_pin.sym} 660 24240 0 0 {name=l19379 lab=VDD}
N 640 24160 660 24160 {}
C {lab_pin.sym} 660 24160 0 0 {name=l19380 lab=VSS}
C {bitcell_6t.sym} 800 24200 0 0 {name=Xr121c4}
N 760 24240 740 24240 {}
C {lab_pin.sym} 740 24240 0 0 {name=l19381 lab=BL4}
N 760 24200 740 24200 {}
C {lab_pin.sym} 740 24200 0 0 {name=l19382 lab=BLB4}
N 760 24160 740 24160 {}
C {lab_pin.sym} 740 24160 0 0 {name=l19383 lab=WL121}
N 840 24240 860 24240 {}
C {lab_pin.sym} 860 24240 0 0 {name=l19384 lab=VDD}
N 840 24160 860 24160 {}
C {lab_pin.sym} 860 24160 0 0 {name=l19385 lab=VSS}
C {bitcell_6t.sym} 1000 24200 0 0 {name=Xr121c5}
N 960 24240 940 24240 {}
C {lab_pin.sym} 940 24240 0 0 {name=l19386 lab=BL5}
N 960 24200 940 24200 {}
C {lab_pin.sym} 940 24200 0 0 {name=l19387 lab=BLB5}
N 960 24160 940 24160 {}
C {lab_pin.sym} 940 24160 0 0 {name=l19388 lab=WL121}
N 1040 24240 1060 24240 {}
C {lab_pin.sym} 1060 24240 0 0 {name=l19389 lab=VDD}
N 1040 24160 1060 24160 {}
C {lab_pin.sym} 1060 24160 0 0 {name=l19390 lab=VSS}
C {bitcell_6t.sym} 1200 24200 0 0 {name=Xr121c6}
N 1160 24240 1140 24240 {}
C {lab_pin.sym} 1140 24240 0 0 {name=l19391 lab=BL6}
N 1160 24200 1140 24200 {}
C {lab_pin.sym} 1140 24200 0 0 {name=l19392 lab=BLB6}
N 1160 24160 1140 24160 {}
C {lab_pin.sym} 1140 24160 0 0 {name=l19393 lab=WL121}
N 1240 24240 1260 24240 {}
C {lab_pin.sym} 1260 24240 0 0 {name=l19394 lab=VDD}
N 1240 24160 1260 24160 {}
C {lab_pin.sym} 1260 24160 0 0 {name=l19395 lab=VSS}
C {bitcell_6t.sym} 1400 24200 0 0 {name=Xr121c7}
N 1360 24240 1340 24240 {}
C {lab_pin.sym} 1340 24240 0 0 {name=l19396 lab=BL7}
N 1360 24200 1340 24200 {}
C {lab_pin.sym} 1340 24200 0 0 {name=l19397 lab=BLB7}
N 1360 24160 1340 24160 {}
C {lab_pin.sym} 1340 24160 0 0 {name=l19398 lab=WL121}
N 1440 24240 1460 24240 {}
C {lab_pin.sym} 1460 24240 0 0 {name=l19399 lab=VDD}
N 1440 24160 1460 24160 {}
C {lab_pin.sym} 1460 24160 0 0 {name=l19400 lab=VSS}
C {bitcell_6t.sym} 1600 24200 0 0 {name=Xr121c8}
N 1560 24240 1540 24240 {}
C {lab_pin.sym} 1540 24240 0 0 {name=l19401 lab=BL8}
N 1560 24200 1540 24200 {}
C {lab_pin.sym} 1540 24200 0 0 {name=l19402 lab=BLB8}
N 1560 24160 1540 24160 {}
C {lab_pin.sym} 1540 24160 0 0 {name=l19403 lab=WL121}
N 1640 24240 1660 24240 {}
C {lab_pin.sym} 1660 24240 0 0 {name=l19404 lab=VDD}
N 1640 24160 1660 24160 {}
C {lab_pin.sym} 1660 24160 0 0 {name=l19405 lab=VSS}
C {bitcell_6t.sym} 1800 24200 0 0 {name=Xr121c9}
N 1760 24240 1740 24240 {}
C {lab_pin.sym} 1740 24240 0 0 {name=l19406 lab=BL9}
N 1760 24200 1740 24200 {}
C {lab_pin.sym} 1740 24200 0 0 {name=l19407 lab=BLB9}
N 1760 24160 1740 24160 {}
C {lab_pin.sym} 1740 24160 0 0 {name=l19408 lab=WL121}
N 1840 24240 1860 24240 {}
C {lab_pin.sym} 1860 24240 0 0 {name=l19409 lab=VDD}
N 1840 24160 1860 24160 {}
C {lab_pin.sym} 1860 24160 0 0 {name=l19410 lab=VSS}
C {bitcell_6t.sym} 2000 24200 0 0 {name=Xr121c10}
N 1960 24240 1940 24240 {}
C {lab_pin.sym} 1940 24240 0 0 {name=l19411 lab=BL10}
N 1960 24200 1940 24200 {}
C {lab_pin.sym} 1940 24200 0 0 {name=l19412 lab=BLB10}
N 1960 24160 1940 24160 {}
C {lab_pin.sym} 1940 24160 0 0 {name=l19413 lab=WL121}
N 2040 24240 2060 24240 {}
C {lab_pin.sym} 2060 24240 0 0 {name=l19414 lab=VDD}
N 2040 24160 2060 24160 {}
C {lab_pin.sym} 2060 24160 0 0 {name=l19415 lab=VSS}
C {bitcell_6t.sym} 2200 24200 0 0 {name=Xr121c11}
N 2160 24240 2140 24240 {}
C {lab_pin.sym} 2140 24240 0 0 {name=l19416 lab=BL11}
N 2160 24200 2140 24200 {}
C {lab_pin.sym} 2140 24200 0 0 {name=l19417 lab=BLB11}
N 2160 24160 2140 24160 {}
C {lab_pin.sym} 2140 24160 0 0 {name=l19418 lab=WL121}
N 2240 24240 2260 24240 {}
C {lab_pin.sym} 2260 24240 0 0 {name=l19419 lab=VDD}
N 2240 24160 2260 24160 {}
C {lab_pin.sym} 2260 24160 0 0 {name=l19420 lab=VSS}
C {bitcell_6t.sym} 2400 24200 0 0 {name=Xr121c12}
N 2360 24240 2340 24240 {}
C {lab_pin.sym} 2340 24240 0 0 {name=l19421 lab=BL12}
N 2360 24200 2340 24200 {}
C {lab_pin.sym} 2340 24200 0 0 {name=l19422 lab=BLB12}
N 2360 24160 2340 24160 {}
C {lab_pin.sym} 2340 24160 0 0 {name=l19423 lab=WL121}
N 2440 24240 2460 24240 {}
C {lab_pin.sym} 2460 24240 0 0 {name=l19424 lab=VDD}
N 2440 24160 2460 24160 {}
C {lab_pin.sym} 2460 24160 0 0 {name=l19425 lab=VSS}
C {bitcell_6t.sym} 2600 24200 0 0 {name=Xr121c13}
N 2560 24240 2540 24240 {}
C {lab_pin.sym} 2540 24240 0 0 {name=l19426 lab=BL13}
N 2560 24200 2540 24200 {}
C {lab_pin.sym} 2540 24200 0 0 {name=l19427 lab=BLB13}
N 2560 24160 2540 24160 {}
C {lab_pin.sym} 2540 24160 0 0 {name=l19428 lab=WL121}
N 2640 24240 2660 24240 {}
C {lab_pin.sym} 2660 24240 0 0 {name=l19429 lab=VDD}
N 2640 24160 2660 24160 {}
C {lab_pin.sym} 2660 24160 0 0 {name=l19430 lab=VSS}
C {bitcell_6t.sym} 2800 24200 0 0 {name=Xr121c14}
N 2760 24240 2740 24240 {}
C {lab_pin.sym} 2740 24240 0 0 {name=l19431 lab=BL14}
N 2760 24200 2740 24200 {}
C {lab_pin.sym} 2740 24200 0 0 {name=l19432 lab=BLB14}
N 2760 24160 2740 24160 {}
C {lab_pin.sym} 2740 24160 0 0 {name=l19433 lab=WL121}
N 2840 24240 2860 24240 {}
C {lab_pin.sym} 2860 24240 0 0 {name=l19434 lab=VDD}
N 2840 24160 2860 24160 {}
C {lab_pin.sym} 2860 24160 0 0 {name=l19435 lab=VSS}
C {bitcell_6t.sym} 3000 24200 0 0 {name=Xr121c15}
N 2960 24240 2940 24240 {}
C {lab_pin.sym} 2940 24240 0 0 {name=l19436 lab=BL15}
N 2960 24200 2940 24200 {}
C {lab_pin.sym} 2940 24200 0 0 {name=l19437 lab=BLB15}
N 2960 24160 2940 24160 {}
C {lab_pin.sym} 2940 24160 0 0 {name=l19438 lab=WL121}
N 3040 24240 3060 24240 {}
C {lab_pin.sym} 3060 24240 0 0 {name=l19439 lab=VDD}
N 3040 24160 3060 24160 {}
C {lab_pin.sym} 3060 24160 0 0 {name=l19440 lab=VSS}
C {bitcell_6t.sym} 3200 24200 0 0 {name=Xr121c16}
N 3160 24240 3140 24240 {}
C {lab_pin.sym} 3140 24240 0 0 {name=l19441 lab=BL16}
N 3160 24200 3140 24200 {}
C {lab_pin.sym} 3140 24200 0 0 {name=l19442 lab=BLB16}
N 3160 24160 3140 24160 {}
C {lab_pin.sym} 3140 24160 0 0 {name=l19443 lab=WL121}
N 3240 24240 3260 24240 {}
C {lab_pin.sym} 3260 24240 0 0 {name=l19444 lab=VDD}
N 3240 24160 3260 24160 {}
C {lab_pin.sym} 3260 24160 0 0 {name=l19445 lab=VSS}
C {bitcell_6t.sym} 3400 24200 0 0 {name=Xr121c17}
N 3360 24240 3340 24240 {}
C {lab_pin.sym} 3340 24240 0 0 {name=l19446 lab=BL17}
N 3360 24200 3340 24200 {}
C {lab_pin.sym} 3340 24200 0 0 {name=l19447 lab=BLB17}
N 3360 24160 3340 24160 {}
C {lab_pin.sym} 3340 24160 0 0 {name=l19448 lab=WL121}
N 3440 24240 3460 24240 {}
C {lab_pin.sym} 3460 24240 0 0 {name=l19449 lab=VDD}
N 3440 24160 3460 24160 {}
C {lab_pin.sym} 3460 24160 0 0 {name=l19450 lab=VSS}
C {bitcell_6t.sym} 3600 24200 0 0 {name=Xr121c18}
N 3560 24240 3540 24240 {}
C {lab_pin.sym} 3540 24240 0 0 {name=l19451 lab=BL18}
N 3560 24200 3540 24200 {}
C {lab_pin.sym} 3540 24200 0 0 {name=l19452 lab=BLB18}
N 3560 24160 3540 24160 {}
C {lab_pin.sym} 3540 24160 0 0 {name=l19453 lab=WL121}
N 3640 24240 3660 24240 {}
C {lab_pin.sym} 3660 24240 0 0 {name=l19454 lab=VDD}
N 3640 24160 3660 24160 {}
C {lab_pin.sym} 3660 24160 0 0 {name=l19455 lab=VSS}
C {bitcell_6t.sym} 3800 24200 0 0 {name=Xr121c19}
N 3760 24240 3740 24240 {}
C {lab_pin.sym} 3740 24240 0 0 {name=l19456 lab=BL19}
N 3760 24200 3740 24200 {}
C {lab_pin.sym} 3740 24200 0 0 {name=l19457 lab=BLB19}
N 3760 24160 3740 24160 {}
C {lab_pin.sym} 3740 24160 0 0 {name=l19458 lab=WL121}
N 3840 24240 3860 24240 {}
C {lab_pin.sym} 3860 24240 0 0 {name=l19459 lab=VDD}
N 3840 24160 3860 24160 {}
C {lab_pin.sym} 3860 24160 0 0 {name=l19460 lab=VSS}
C {bitcell_6t.sym} 4000 24200 0 0 {name=Xr121c20}
N 3960 24240 3940 24240 {}
C {lab_pin.sym} 3940 24240 0 0 {name=l19461 lab=BL20}
N 3960 24200 3940 24200 {}
C {lab_pin.sym} 3940 24200 0 0 {name=l19462 lab=BLB20}
N 3960 24160 3940 24160 {}
C {lab_pin.sym} 3940 24160 0 0 {name=l19463 lab=WL121}
N 4040 24240 4060 24240 {}
C {lab_pin.sym} 4060 24240 0 0 {name=l19464 lab=VDD}
N 4040 24160 4060 24160 {}
C {lab_pin.sym} 4060 24160 0 0 {name=l19465 lab=VSS}
C {bitcell_6t.sym} 4200 24200 0 0 {name=Xr121c21}
N 4160 24240 4140 24240 {}
C {lab_pin.sym} 4140 24240 0 0 {name=l19466 lab=BL21}
N 4160 24200 4140 24200 {}
C {lab_pin.sym} 4140 24200 0 0 {name=l19467 lab=BLB21}
N 4160 24160 4140 24160 {}
C {lab_pin.sym} 4140 24160 0 0 {name=l19468 lab=WL121}
N 4240 24240 4260 24240 {}
C {lab_pin.sym} 4260 24240 0 0 {name=l19469 lab=VDD}
N 4240 24160 4260 24160 {}
C {lab_pin.sym} 4260 24160 0 0 {name=l19470 lab=VSS}
C {bitcell_6t.sym} 4400 24200 0 0 {name=Xr121c22}
N 4360 24240 4340 24240 {}
C {lab_pin.sym} 4340 24240 0 0 {name=l19471 lab=BL22}
N 4360 24200 4340 24200 {}
C {lab_pin.sym} 4340 24200 0 0 {name=l19472 lab=BLB22}
N 4360 24160 4340 24160 {}
C {lab_pin.sym} 4340 24160 0 0 {name=l19473 lab=WL121}
N 4440 24240 4460 24240 {}
C {lab_pin.sym} 4460 24240 0 0 {name=l19474 lab=VDD}
N 4440 24160 4460 24160 {}
C {lab_pin.sym} 4460 24160 0 0 {name=l19475 lab=VSS}
C {bitcell_6t.sym} 4600 24200 0 0 {name=Xr121c23}
N 4560 24240 4540 24240 {}
C {lab_pin.sym} 4540 24240 0 0 {name=l19476 lab=BL23}
N 4560 24200 4540 24200 {}
C {lab_pin.sym} 4540 24200 0 0 {name=l19477 lab=BLB23}
N 4560 24160 4540 24160 {}
C {lab_pin.sym} 4540 24160 0 0 {name=l19478 lab=WL121}
N 4640 24240 4660 24240 {}
C {lab_pin.sym} 4660 24240 0 0 {name=l19479 lab=VDD}
N 4640 24160 4660 24160 {}
C {lab_pin.sym} 4660 24160 0 0 {name=l19480 lab=VSS}
C {bitcell_6t.sym} 4800 24200 0 0 {name=Xr121c24}
N 4760 24240 4740 24240 {}
C {lab_pin.sym} 4740 24240 0 0 {name=l19481 lab=BL24}
N 4760 24200 4740 24200 {}
C {lab_pin.sym} 4740 24200 0 0 {name=l19482 lab=BLB24}
N 4760 24160 4740 24160 {}
C {lab_pin.sym} 4740 24160 0 0 {name=l19483 lab=WL121}
N 4840 24240 4860 24240 {}
C {lab_pin.sym} 4860 24240 0 0 {name=l19484 lab=VDD}
N 4840 24160 4860 24160 {}
C {lab_pin.sym} 4860 24160 0 0 {name=l19485 lab=VSS}
C {bitcell_6t.sym} 5000 24200 0 0 {name=Xr121c25}
N 4960 24240 4940 24240 {}
C {lab_pin.sym} 4940 24240 0 0 {name=l19486 lab=BL25}
N 4960 24200 4940 24200 {}
C {lab_pin.sym} 4940 24200 0 0 {name=l19487 lab=BLB25}
N 4960 24160 4940 24160 {}
C {lab_pin.sym} 4940 24160 0 0 {name=l19488 lab=WL121}
N 5040 24240 5060 24240 {}
C {lab_pin.sym} 5060 24240 0 0 {name=l19489 lab=VDD}
N 5040 24160 5060 24160 {}
C {lab_pin.sym} 5060 24160 0 0 {name=l19490 lab=VSS}
C {bitcell_6t.sym} 5200 24200 0 0 {name=Xr121c26}
N 5160 24240 5140 24240 {}
C {lab_pin.sym} 5140 24240 0 0 {name=l19491 lab=BL26}
N 5160 24200 5140 24200 {}
C {lab_pin.sym} 5140 24200 0 0 {name=l19492 lab=BLB26}
N 5160 24160 5140 24160 {}
C {lab_pin.sym} 5140 24160 0 0 {name=l19493 lab=WL121}
N 5240 24240 5260 24240 {}
C {lab_pin.sym} 5260 24240 0 0 {name=l19494 lab=VDD}
N 5240 24160 5260 24160 {}
C {lab_pin.sym} 5260 24160 0 0 {name=l19495 lab=VSS}
C {bitcell_6t.sym} 5400 24200 0 0 {name=Xr121c27}
N 5360 24240 5340 24240 {}
C {lab_pin.sym} 5340 24240 0 0 {name=l19496 lab=BL27}
N 5360 24200 5340 24200 {}
C {lab_pin.sym} 5340 24200 0 0 {name=l19497 lab=BLB27}
N 5360 24160 5340 24160 {}
C {lab_pin.sym} 5340 24160 0 0 {name=l19498 lab=WL121}
N 5440 24240 5460 24240 {}
C {lab_pin.sym} 5460 24240 0 0 {name=l19499 lab=VDD}
N 5440 24160 5460 24160 {}
C {lab_pin.sym} 5460 24160 0 0 {name=l19500 lab=VSS}
C {bitcell_6t.sym} 5600 24200 0 0 {name=Xr121c28}
N 5560 24240 5540 24240 {}
C {lab_pin.sym} 5540 24240 0 0 {name=l19501 lab=BL28}
N 5560 24200 5540 24200 {}
C {lab_pin.sym} 5540 24200 0 0 {name=l19502 lab=BLB28}
N 5560 24160 5540 24160 {}
C {lab_pin.sym} 5540 24160 0 0 {name=l19503 lab=WL121}
N 5640 24240 5660 24240 {}
C {lab_pin.sym} 5660 24240 0 0 {name=l19504 lab=VDD}
N 5640 24160 5660 24160 {}
C {lab_pin.sym} 5660 24160 0 0 {name=l19505 lab=VSS}
C {bitcell_6t.sym} 5800 24200 0 0 {name=Xr121c29}
N 5760 24240 5740 24240 {}
C {lab_pin.sym} 5740 24240 0 0 {name=l19506 lab=BL29}
N 5760 24200 5740 24200 {}
C {lab_pin.sym} 5740 24200 0 0 {name=l19507 lab=BLB29}
N 5760 24160 5740 24160 {}
C {lab_pin.sym} 5740 24160 0 0 {name=l19508 lab=WL121}
N 5840 24240 5860 24240 {}
C {lab_pin.sym} 5860 24240 0 0 {name=l19509 lab=VDD}
N 5840 24160 5860 24160 {}
C {lab_pin.sym} 5860 24160 0 0 {name=l19510 lab=VSS}
C {bitcell_6t.sym} 6000 24200 0 0 {name=Xr121c30}
N 5960 24240 5940 24240 {}
C {lab_pin.sym} 5940 24240 0 0 {name=l19511 lab=BL30}
N 5960 24200 5940 24200 {}
C {lab_pin.sym} 5940 24200 0 0 {name=l19512 lab=BLB30}
N 5960 24160 5940 24160 {}
C {lab_pin.sym} 5940 24160 0 0 {name=l19513 lab=WL121}
N 6040 24240 6060 24240 {}
C {lab_pin.sym} 6060 24240 0 0 {name=l19514 lab=VDD}
N 6040 24160 6060 24160 {}
C {lab_pin.sym} 6060 24160 0 0 {name=l19515 lab=VSS}
C {bitcell_6t.sym} 6200 24200 0 0 {name=Xr121c31}
N 6160 24240 6140 24240 {}
C {lab_pin.sym} 6140 24240 0 0 {name=l19516 lab=BL31}
N 6160 24200 6140 24200 {}
C {lab_pin.sym} 6140 24200 0 0 {name=l19517 lab=BLB31}
N 6160 24160 6140 24160 {}
C {lab_pin.sym} 6140 24160 0 0 {name=l19518 lab=WL121}
N 6240 24240 6260 24240 {}
C {lab_pin.sym} 6260 24240 0 0 {name=l19519 lab=VDD}
N 6240 24160 6260 24160 {}
C {lab_pin.sym} 6260 24160 0 0 {name=l19520 lab=VSS}
C {bitcell_6t.sym} 0 24400 0 0 {name=Xr122c0}
N -40 24440 -60 24440 {}
C {lab_pin.sym} -60 24440 0 0 {name=l19521 lab=BL0}
N -40 24400 -60 24400 {}
C {lab_pin.sym} -60 24400 0 0 {name=l19522 lab=BLB0}
N -40 24360 -60 24360 {}
C {lab_pin.sym} -60 24360 0 0 {name=l19523 lab=WL122}
N 40 24440 60 24440 {}
C {lab_pin.sym} 60 24440 0 0 {name=l19524 lab=VDD}
N 40 24360 60 24360 {}
C {lab_pin.sym} 60 24360 0 0 {name=l19525 lab=VSS}
C {bitcell_6t.sym} 200 24400 0 0 {name=Xr122c1}
N 160 24440 140 24440 {}
C {lab_pin.sym} 140 24440 0 0 {name=l19526 lab=BL1}
N 160 24400 140 24400 {}
C {lab_pin.sym} 140 24400 0 0 {name=l19527 lab=BLB1}
N 160 24360 140 24360 {}
C {lab_pin.sym} 140 24360 0 0 {name=l19528 lab=WL122}
N 240 24440 260 24440 {}
C {lab_pin.sym} 260 24440 0 0 {name=l19529 lab=VDD}
N 240 24360 260 24360 {}
C {lab_pin.sym} 260 24360 0 0 {name=l19530 lab=VSS}
C {bitcell_6t.sym} 400 24400 0 0 {name=Xr122c2}
N 360 24440 340 24440 {}
C {lab_pin.sym} 340 24440 0 0 {name=l19531 lab=BL2}
N 360 24400 340 24400 {}
C {lab_pin.sym} 340 24400 0 0 {name=l19532 lab=BLB2}
N 360 24360 340 24360 {}
C {lab_pin.sym} 340 24360 0 0 {name=l19533 lab=WL122}
N 440 24440 460 24440 {}
C {lab_pin.sym} 460 24440 0 0 {name=l19534 lab=VDD}
N 440 24360 460 24360 {}
C {lab_pin.sym} 460 24360 0 0 {name=l19535 lab=VSS}
C {bitcell_6t.sym} 600 24400 0 0 {name=Xr122c3}
N 560 24440 540 24440 {}
C {lab_pin.sym} 540 24440 0 0 {name=l19536 lab=BL3}
N 560 24400 540 24400 {}
C {lab_pin.sym} 540 24400 0 0 {name=l19537 lab=BLB3}
N 560 24360 540 24360 {}
C {lab_pin.sym} 540 24360 0 0 {name=l19538 lab=WL122}
N 640 24440 660 24440 {}
C {lab_pin.sym} 660 24440 0 0 {name=l19539 lab=VDD}
N 640 24360 660 24360 {}
C {lab_pin.sym} 660 24360 0 0 {name=l19540 lab=VSS}
C {bitcell_6t.sym} 800 24400 0 0 {name=Xr122c4}
N 760 24440 740 24440 {}
C {lab_pin.sym} 740 24440 0 0 {name=l19541 lab=BL4}
N 760 24400 740 24400 {}
C {lab_pin.sym} 740 24400 0 0 {name=l19542 lab=BLB4}
N 760 24360 740 24360 {}
C {lab_pin.sym} 740 24360 0 0 {name=l19543 lab=WL122}
N 840 24440 860 24440 {}
C {lab_pin.sym} 860 24440 0 0 {name=l19544 lab=VDD}
N 840 24360 860 24360 {}
C {lab_pin.sym} 860 24360 0 0 {name=l19545 lab=VSS}
C {bitcell_6t.sym} 1000 24400 0 0 {name=Xr122c5}
N 960 24440 940 24440 {}
C {lab_pin.sym} 940 24440 0 0 {name=l19546 lab=BL5}
N 960 24400 940 24400 {}
C {lab_pin.sym} 940 24400 0 0 {name=l19547 lab=BLB5}
N 960 24360 940 24360 {}
C {lab_pin.sym} 940 24360 0 0 {name=l19548 lab=WL122}
N 1040 24440 1060 24440 {}
C {lab_pin.sym} 1060 24440 0 0 {name=l19549 lab=VDD}
N 1040 24360 1060 24360 {}
C {lab_pin.sym} 1060 24360 0 0 {name=l19550 lab=VSS}
C {bitcell_6t.sym} 1200 24400 0 0 {name=Xr122c6}
N 1160 24440 1140 24440 {}
C {lab_pin.sym} 1140 24440 0 0 {name=l19551 lab=BL6}
N 1160 24400 1140 24400 {}
C {lab_pin.sym} 1140 24400 0 0 {name=l19552 lab=BLB6}
N 1160 24360 1140 24360 {}
C {lab_pin.sym} 1140 24360 0 0 {name=l19553 lab=WL122}
N 1240 24440 1260 24440 {}
C {lab_pin.sym} 1260 24440 0 0 {name=l19554 lab=VDD}
N 1240 24360 1260 24360 {}
C {lab_pin.sym} 1260 24360 0 0 {name=l19555 lab=VSS}
C {bitcell_6t.sym} 1400 24400 0 0 {name=Xr122c7}
N 1360 24440 1340 24440 {}
C {lab_pin.sym} 1340 24440 0 0 {name=l19556 lab=BL7}
N 1360 24400 1340 24400 {}
C {lab_pin.sym} 1340 24400 0 0 {name=l19557 lab=BLB7}
N 1360 24360 1340 24360 {}
C {lab_pin.sym} 1340 24360 0 0 {name=l19558 lab=WL122}
N 1440 24440 1460 24440 {}
C {lab_pin.sym} 1460 24440 0 0 {name=l19559 lab=VDD}
N 1440 24360 1460 24360 {}
C {lab_pin.sym} 1460 24360 0 0 {name=l19560 lab=VSS}
C {bitcell_6t.sym} 1600 24400 0 0 {name=Xr122c8}
N 1560 24440 1540 24440 {}
C {lab_pin.sym} 1540 24440 0 0 {name=l19561 lab=BL8}
N 1560 24400 1540 24400 {}
C {lab_pin.sym} 1540 24400 0 0 {name=l19562 lab=BLB8}
N 1560 24360 1540 24360 {}
C {lab_pin.sym} 1540 24360 0 0 {name=l19563 lab=WL122}
N 1640 24440 1660 24440 {}
C {lab_pin.sym} 1660 24440 0 0 {name=l19564 lab=VDD}
N 1640 24360 1660 24360 {}
C {lab_pin.sym} 1660 24360 0 0 {name=l19565 lab=VSS}
C {bitcell_6t.sym} 1800 24400 0 0 {name=Xr122c9}
N 1760 24440 1740 24440 {}
C {lab_pin.sym} 1740 24440 0 0 {name=l19566 lab=BL9}
N 1760 24400 1740 24400 {}
C {lab_pin.sym} 1740 24400 0 0 {name=l19567 lab=BLB9}
N 1760 24360 1740 24360 {}
C {lab_pin.sym} 1740 24360 0 0 {name=l19568 lab=WL122}
N 1840 24440 1860 24440 {}
C {lab_pin.sym} 1860 24440 0 0 {name=l19569 lab=VDD}
N 1840 24360 1860 24360 {}
C {lab_pin.sym} 1860 24360 0 0 {name=l19570 lab=VSS}
C {bitcell_6t.sym} 2000 24400 0 0 {name=Xr122c10}
N 1960 24440 1940 24440 {}
C {lab_pin.sym} 1940 24440 0 0 {name=l19571 lab=BL10}
N 1960 24400 1940 24400 {}
C {lab_pin.sym} 1940 24400 0 0 {name=l19572 lab=BLB10}
N 1960 24360 1940 24360 {}
C {lab_pin.sym} 1940 24360 0 0 {name=l19573 lab=WL122}
N 2040 24440 2060 24440 {}
C {lab_pin.sym} 2060 24440 0 0 {name=l19574 lab=VDD}
N 2040 24360 2060 24360 {}
C {lab_pin.sym} 2060 24360 0 0 {name=l19575 lab=VSS}
C {bitcell_6t.sym} 2200 24400 0 0 {name=Xr122c11}
N 2160 24440 2140 24440 {}
C {lab_pin.sym} 2140 24440 0 0 {name=l19576 lab=BL11}
N 2160 24400 2140 24400 {}
C {lab_pin.sym} 2140 24400 0 0 {name=l19577 lab=BLB11}
N 2160 24360 2140 24360 {}
C {lab_pin.sym} 2140 24360 0 0 {name=l19578 lab=WL122}
N 2240 24440 2260 24440 {}
C {lab_pin.sym} 2260 24440 0 0 {name=l19579 lab=VDD}
N 2240 24360 2260 24360 {}
C {lab_pin.sym} 2260 24360 0 0 {name=l19580 lab=VSS}
C {bitcell_6t.sym} 2400 24400 0 0 {name=Xr122c12}
N 2360 24440 2340 24440 {}
C {lab_pin.sym} 2340 24440 0 0 {name=l19581 lab=BL12}
N 2360 24400 2340 24400 {}
C {lab_pin.sym} 2340 24400 0 0 {name=l19582 lab=BLB12}
N 2360 24360 2340 24360 {}
C {lab_pin.sym} 2340 24360 0 0 {name=l19583 lab=WL122}
N 2440 24440 2460 24440 {}
C {lab_pin.sym} 2460 24440 0 0 {name=l19584 lab=VDD}
N 2440 24360 2460 24360 {}
C {lab_pin.sym} 2460 24360 0 0 {name=l19585 lab=VSS}
C {bitcell_6t.sym} 2600 24400 0 0 {name=Xr122c13}
N 2560 24440 2540 24440 {}
C {lab_pin.sym} 2540 24440 0 0 {name=l19586 lab=BL13}
N 2560 24400 2540 24400 {}
C {lab_pin.sym} 2540 24400 0 0 {name=l19587 lab=BLB13}
N 2560 24360 2540 24360 {}
C {lab_pin.sym} 2540 24360 0 0 {name=l19588 lab=WL122}
N 2640 24440 2660 24440 {}
C {lab_pin.sym} 2660 24440 0 0 {name=l19589 lab=VDD}
N 2640 24360 2660 24360 {}
C {lab_pin.sym} 2660 24360 0 0 {name=l19590 lab=VSS}
C {bitcell_6t.sym} 2800 24400 0 0 {name=Xr122c14}
N 2760 24440 2740 24440 {}
C {lab_pin.sym} 2740 24440 0 0 {name=l19591 lab=BL14}
N 2760 24400 2740 24400 {}
C {lab_pin.sym} 2740 24400 0 0 {name=l19592 lab=BLB14}
N 2760 24360 2740 24360 {}
C {lab_pin.sym} 2740 24360 0 0 {name=l19593 lab=WL122}
N 2840 24440 2860 24440 {}
C {lab_pin.sym} 2860 24440 0 0 {name=l19594 lab=VDD}
N 2840 24360 2860 24360 {}
C {lab_pin.sym} 2860 24360 0 0 {name=l19595 lab=VSS}
C {bitcell_6t.sym} 3000 24400 0 0 {name=Xr122c15}
N 2960 24440 2940 24440 {}
C {lab_pin.sym} 2940 24440 0 0 {name=l19596 lab=BL15}
N 2960 24400 2940 24400 {}
C {lab_pin.sym} 2940 24400 0 0 {name=l19597 lab=BLB15}
N 2960 24360 2940 24360 {}
C {lab_pin.sym} 2940 24360 0 0 {name=l19598 lab=WL122}
N 3040 24440 3060 24440 {}
C {lab_pin.sym} 3060 24440 0 0 {name=l19599 lab=VDD}
N 3040 24360 3060 24360 {}
C {lab_pin.sym} 3060 24360 0 0 {name=l19600 lab=VSS}
C {bitcell_6t.sym} 3200 24400 0 0 {name=Xr122c16}
N 3160 24440 3140 24440 {}
C {lab_pin.sym} 3140 24440 0 0 {name=l19601 lab=BL16}
N 3160 24400 3140 24400 {}
C {lab_pin.sym} 3140 24400 0 0 {name=l19602 lab=BLB16}
N 3160 24360 3140 24360 {}
C {lab_pin.sym} 3140 24360 0 0 {name=l19603 lab=WL122}
N 3240 24440 3260 24440 {}
C {lab_pin.sym} 3260 24440 0 0 {name=l19604 lab=VDD}
N 3240 24360 3260 24360 {}
C {lab_pin.sym} 3260 24360 0 0 {name=l19605 lab=VSS}
C {bitcell_6t.sym} 3400 24400 0 0 {name=Xr122c17}
N 3360 24440 3340 24440 {}
C {lab_pin.sym} 3340 24440 0 0 {name=l19606 lab=BL17}
N 3360 24400 3340 24400 {}
C {lab_pin.sym} 3340 24400 0 0 {name=l19607 lab=BLB17}
N 3360 24360 3340 24360 {}
C {lab_pin.sym} 3340 24360 0 0 {name=l19608 lab=WL122}
N 3440 24440 3460 24440 {}
C {lab_pin.sym} 3460 24440 0 0 {name=l19609 lab=VDD}
N 3440 24360 3460 24360 {}
C {lab_pin.sym} 3460 24360 0 0 {name=l19610 lab=VSS}
C {bitcell_6t.sym} 3600 24400 0 0 {name=Xr122c18}
N 3560 24440 3540 24440 {}
C {lab_pin.sym} 3540 24440 0 0 {name=l19611 lab=BL18}
N 3560 24400 3540 24400 {}
C {lab_pin.sym} 3540 24400 0 0 {name=l19612 lab=BLB18}
N 3560 24360 3540 24360 {}
C {lab_pin.sym} 3540 24360 0 0 {name=l19613 lab=WL122}
N 3640 24440 3660 24440 {}
C {lab_pin.sym} 3660 24440 0 0 {name=l19614 lab=VDD}
N 3640 24360 3660 24360 {}
C {lab_pin.sym} 3660 24360 0 0 {name=l19615 lab=VSS}
C {bitcell_6t.sym} 3800 24400 0 0 {name=Xr122c19}
N 3760 24440 3740 24440 {}
C {lab_pin.sym} 3740 24440 0 0 {name=l19616 lab=BL19}
N 3760 24400 3740 24400 {}
C {lab_pin.sym} 3740 24400 0 0 {name=l19617 lab=BLB19}
N 3760 24360 3740 24360 {}
C {lab_pin.sym} 3740 24360 0 0 {name=l19618 lab=WL122}
N 3840 24440 3860 24440 {}
C {lab_pin.sym} 3860 24440 0 0 {name=l19619 lab=VDD}
N 3840 24360 3860 24360 {}
C {lab_pin.sym} 3860 24360 0 0 {name=l19620 lab=VSS}
C {bitcell_6t.sym} 4000 24400 0 0 {name=Xr122c20}
N 3960 24440 3940 24440 {}
C {lab_pin.sym} 3940 24440 0 0 {name=l19621 lab=BL20}
N 3960 24400 3940 24400 {}
C {lab_pin.sym} 3940 24400 0 0 {name=l19622 lab=BLB20}
N 3960 24360 3940 24360 {}
C {lab_pin.sym} 3940 24360 0 0 {name=l19623 lab=WL122}
N 4040 24440 4060 24440 {}
C {lab_pin.sym} 4060 24440 0 0 {name=l19624 lab=VDD}
N 4040 24360 4060 24360 {}
C {lab_pin.sym} 4060 24360 0 0 {name=l19625 lab=VSS}
C {bitcell_6t.sym} 4200 24400 0 0 {name=Xr122c21}
N 4160 24440 4140 24440 {}
C {lab_pin.sym} 4140 24440 0 0 {name=l19626 lab=BL21}
N 4160 24400 4140 24400 {}
C {lab_pin.sym} 4140 24400 0 0 {name=l19627 lab=BLB21}
N 4160 24360 4140 24360 {}
C {lab_pin.sym} 4140 24360 0 0 {name=l19628 lab=WL122}
N 4240 24440 4260 24440 {}
C {lab_pin.sym} 4260 24440 0 0 {name=l19629 lab=VDD}
N 4240 24360 4260 24360 {}
C {lab_pin.sym} 4260 24360 0 0 {name=l19630 lab=VSS}
C {bitcell_6t.sym} 4400 24400 0 0 {name=Xr122c22}
N 4360 24440 4340 24440 {}
C {lab_pin.sym} 4340 24440 0 0 {name=l19631 lab=BL22}
N 4360 24400 4340 24400 {}
C {lab_pin.sym} 4340 24400 0 0 {name=l19632 lab=BLB22}
N 4360 24360 4340 24360 {}
C {lab_pin.sym} 4340 24360 0 0 {name=l19633 lab=WL122}
N 4440 24440 4460 24440 {}
C {lab_pin.sym} 4460 24440 0 0 {name=l19634 lab=VDD}
N 4440 24360 4460 24360 {}
C {lab_pin.sym} 4460 24360 0 0 {name=l19635 lab=VSS}
C {bitcell_6t.sym} 4600 24400 0 0 {name=Xr122c23}
N 4560 24440 4540 24440 {}
C {lab_pin.sym} 4540 24440 0 0 {name=l19636 lab=BL23}
N 4560 24400 4540 24400 {}
C {lab_pin.sym} 4540 24400 0 0 {name=l19637 lab=BLB23}
N 4560 24360 4540 24360 {}
C {lab_pin.sym} 4540 24360 0 0 {name=l19638 lab=WL122}
N 4640 24440 4660 24440 {}
C {lab_pin.sym} 4660 24440 0 0 {name=l19639 lab=VDD}
N 4640 24360 4660 24360 {}
C {lab_pin.sym} 4660 24360 0 0 {name=l19640 lab=VSS}
C {bitcell_6t.sym} 4800 24400 0 0 {name=Xr122c24}
N 4760 24440 4740 24440 {}
C {lab_pin.sym} 4740 24440 0 0 {name=l19641 lab=BL24}
N 4760 24400 4740 24400 {}
C {lab_pin.sym} 4740 24400 0 0 {name=l19642 lab=BLB24}
N 4760 24360 4740 24360 {}
C {lab_pin.sym} 4740 24360 0 0 {name=l19643 lab=WL122}
N 4840 24440 4860 24440 {}
C {lab_pin.sym} 4860 24440 0 0 {name=l19644 lab=VDD}
N 4840 24360 4860 24360 {}
C {lab_pin.sym} 4860 24360 0 0 {name=l19645 lab=VSS}
C {bitcell_6t.sym} 5000 24400 0 0 {name=Xr122c25}
N 4960 24440 4940 24440 {}
C {lab_pin.sym} 4940 24440 0 0 {name=l19646 lab=BL25}
N 4960 24400 4940 24400 {}
C {lab_pin.sym} 4940 24400 0 0 {name=l19647 lab=BLB25}
N 4960 24360 4940 24360 {}
C {lab_pin.sym} 4940 24360 0 0 {name=l19648 lab=WL122}
N 5040 24440 5060 24440 {}
C {lab_pin.sym} 5060 24440 0 0 {name=l19649 lab=VDD}
N 5040 24360 5060 24360 {}
C {lab_pin.sym} 5060 24360 0 0 {name=l19650 lab=VSS}
C {bitcell_6t.sym} 5200 24400 0 0 {name=Xr122c26}
N 5160 24440 5140 24440 {}
C {lab_pin.sym} 5140 24440 0 0 {name=l19651 lab=BL26}
N 5160 24400 5140 24400 {}
C {lab_pin.sym} 5140 24400 0 0 {name=l19652 lab=BLB26}
N 5160 24360 5140 24360 {}
C {lab_pin.sym} 5140 24360 0 0 {name=l19653 lab=WL122}
N 5240 24440 5260 24440 {}
C {lab_pin.sym} 5260 24440 0 0 {name=l19654 lab=VDD}
N 5240 24360 5260 24360 {}
C {lab_pin.sym} 5260 24360 0 0 {name=l19655 lab=VSS}
C {bitcell_6t.sym} 5400 24400 0 0 {name=Xr122c27}
N 5360 24440 5340 24440 {}
C {lab_pin.sym} 5340 24440 0 0 {name=l19656 lab=BL27}
N 5360 24400 5340 24400 {}
C {lab_pin.sym} 5340 24400 0 0 {name=l19657 lab=BLB27}
N 5360 24360 5340 24360 {}
C {lab_pin.sym} 5340 24360 0 0 {name=l19658 lab=WL122}
N 5440 24440 5460 24440 {}
C {lab_pin.sym} 5460 24440 0 0 {name=l19659 lab=VDD}
N 5440 24360 5460 24360 {}
C {lab_pin.sym} 5460 24360 0 0 {name=l19660 lab=VSS}
C {bitcell_6t.sym} 5600 24400 0 0 {name=Xr122c28}
N 5560 24440 5540 24440 {}
C {lab_pin.sym} 5540 24440 0 0 {name=l19661 lab=BL28}
N 5560 24400 5540 24400 {}
C {lab_pin.sym} 5540 24400 0 0 {name=l19662 lab=BLB28}
N 5560 24360 5540 24360 {}
C {lab_pin.sym} 5540 24360 0 0 {name=l19663 lab=WL122}
N 5640 24440 5660 24440 {}
C {lab_pin.sym} 5660 24440 0 0 {name=l19664 lab=VDD}
N 5640 24360 5660 24360 {}
C {lab_pin.sym} 5660 24360 0 0 {name=l19665 lab=VSS}
C {bitcell_6t.sym} 5800 24400 0 0 {name=Xr122c29}
N 5760 24440 5740 24440 {}
C {lab_pin.sym} 5740 24440 0 0 {name=l19666 lab=BL29}
N 5760 24400 5740 24400 {}
C {lab_pin.sym} 5740 24400 0 0 {name=l19667 lab=BLB29}
N 5760 24360 5740 24360 {}
C {lab_pin.sym} 5740 24360 0 0 {name=l19668 lab=WL122}
N 5840 24440 5860 24440 {}
C {lab_pin.sym} 5860 24440 0 0 {name=l19669 lab=VDD}
N 5840 24360 5860 24360 {}
C {lab_pin.sym} 5860 24360 0 0 {name=l19670 lab=VSS}
C {bitcell_6t.sym} 6000 24400 0 0 {name=Xr122c30}
N 5960 24440 5940 24440 {}
C {lab_pin.sym} 5940 24440 0 0 {name=l19671 lab=BL30}
N 5960 24400 5940 24400 {}
C {lab_pin.sym} 5940 24400 0 0 {name=l19672 lab=BLB30}
N 5960 24360 5940 24360 {}
C {lab_pin.sym} 5940 24360 0 0 {name=l19673 lab=WL122}
N 6040 24440 6060 24440 {}
C {lab_pin.sym} 6060 24440 0 0 {name=l19674 lab=VDD}
N 6040 24360 6060 24360 {}
C {lab_pin.sym} 6060 24360 0 0 {name=l19675 lab=VSS}
C {bitcell_6t.sym} 6200 24400 0 0 {name=Xr122c31}
N 6160 24440 6140 24440 {}
C {lab_pin.sym} 6140 24440 0 0 {name=l19676 lab=BL31}
N 6160 24400 6140 24400 {}
C {lab_pin.sym} 6140 24400 0 0 {name=l19677 lab=BLB31}
N 6160 24360 6140 24360 {}
C {lab_pin.sym} 6140 24360 0 0 {name=l19678 lab=WL122}
N 6240 24440 6260 24440 {}
C {lab_pin.sym} 6260 24440 0 0 {name=l19679 lab=VDD}
N 6240 24360 6260 24360 {}
C {lab_pin.sym} 6260 24360 0 0 {name=l19680 lab=VSS}
C {bitcell_6t.sym} 0 24600 0 0 {name=Xr123c0}
N -40 24640 -60 24640 {}
C {lab_pin.sym} -60 24640 0 0 {name=l19681 lab=BL0}
N -40 24600 -60 24600 {}
C {lab_pin.sym} -60 24600 0 0 {name=l19682 lab=BLB0}
N -40 24560 -60 24560 {}
C {lab_pin.sym} -60 24560 0 0 {name=l19683 lab=WL123}
N 40 24640 60 24640 {}
C {lab_pin.sym} 60 24640 0 0 {name=l19684 lab=VDD}
N 40 24560 60 24560 {}
C {lab_pin.sym} 60 24560 0 0 {name=l19685 lab=VSS}
C {bitcell_6t.sym} 200 24600 0 0 {name=Xr123c1}
N 160 24640 140 24640 {}
C {lab_pin.sym} 140 24640 0 0 {name=l19686 lab=BL1}
N 160 24600 140 24600 {}
C {lab_pin.sym} 140 24600 0 0 {name=l19687 lab=BLB1}
N 160 24560 140 24560 {}
C {lab_pin.sym} 140 24560 0 0 {name=l19688 lab=WL123}
N 240 24640 260 24640 {}
C {lab_pin.sym} 260 24640 0 0 {name=l19689 lab=VDD}
N 240 24560 260 24560 {}
C {lab_pin.sym} 260 24560 0 0 {name=l19690 lab=VSS}
C {bitcell_6t.sym} 400 24600 0 0 {name=Xr123c2}
N 360 24640 340 24640 {}
C {lab_pin.sym} 340 24640 0 0 {name=l19691 lab=BL2}
N 360 24600 340 24600 {}
C {lab_pin.sym} 340 24600 0 0 {name=l19692 lab=BLB2}
N 360 24560 340 24560 {}
C {lab_pin.sym} 340 24560 0 0 {name=l19693 lab=WL123}
N 440 24640 460 24640 {}
C {lab_pin.sym} 460 24640 0 0 {name=l19694 lab=VDD}
N 440 24560 460 24560 {}
C {lab_pin.sym} 460 24560 0 0 {name=l19695 lab=VSS}
C {bitcell_6t.sym} 600 24600 0 0 {name=Xr123c3}
N 560 24640 540 24640 {}
C {lab_pin.sym} 540 24640 0 0 {name=l19696 lab=BL3}
N 560 24600 540 24600 {}
C {lab_pin.sym} 540 24600 0 0 {name=l19697 lab=BLB3}
N 560 24560 540 24560 {}
C {lab_pin.sym} 540 24560 0 0 {name=l19698 lab=WL123}
N 640 24640 660 24640 {}
C {lab_pin.sym} 660 24640 0 0 {name=l19699 lab=VDD}
N 640 24560 660 24560 {}
C {lab_pin.sym} 660 24560 0 0 {name=l19700 lab=VSS}
C {bitcell_6t.sym} 800 24600 0 0 {name=Xr123c4}
N 760 24640 740 24640 {}
C {lab_pin.sym} 740 24640 0 0 {name=l19701 lab=BL4}
N 760 24600 740 24600 {}
C {lab_pin.sym} 740 24600 0 0 {name=l19702 lab=BLB4}
N 760 24560 740 24560 {}
C {lab_pin.sym} 740 24560 0 0 {name=l19703 lab=WL123}
N 840 24640 860 24640 {}
C {lab_pin.sym} 860 24640 0 0 {name=l19704 lab=VDD}
N 840 24560 860 24560 {}
C {lab_pin.sym} 860 24560 0 0 {name=l19705 lab=VSS}
C {bitcell_6t.sym} 1000 24600 0 0 {name=Xr123c5}
N 960 24640 940 24640 {}
C {lab_pin.sym} 940 24640 0 0 {name=l19706 lab=BL5}
N 960 24600 940 24600 {}
C {lab_pin.sym} 940 24600 0 0 {name=l19707 lab=BLB5}
N 960 24560 940 24560 {}
C {lab_pin.sym} 940 24560 0 0 {name=l19708 lab=WL123}
N 1040 24640 1060 24640 {}
C {lab_pin.sym} 1060 24640 0 0 {name=l19709 lab=VDD}
N 1040 24560 1060 24560 {}
C {lab_pin.sym} 1060 24560 0 0 {name=l19710 lab=VSS}
C {bitcell_6t.sym} 1200 24600 0 0 {name=Xr123c6}
N 1160 24640 1140 24640 {}
C {lab_pin.sym} 1140 24640 0 0 {name=l19711 lab=BL6}
N 1160 24600 1140 24600 {}
C {lab_pin.sym} 1140 24600 0 0 {name=l19712 lab=BLB6}
N 1160 24560 1140 24560 {}
C {lab_pin.sym} 1140 24560 0 0 {name=l19713 lab=WL123}
N 1240 24640 1260 24640 {}
C {lab_pin.sym} 1260 24640 0 0 {name=l19714 lab=VDD}
N 1240 24560 1260 24560 {}
C {lab_pin.sym} 1260 24560 0 0 {name=l19715 lab=VSS}
C {bitcell_6t.sym} 1400 24600 0 0 {name=Xr123c7}
N 1360 24640 1340 24640 {}
C {lab_pin.sym} 1340 24640 0 0 {name=l19716 lab=BL7}
N 1360 24600 1340 24600 {}
C {lab_pin.sym} 1340 24600 0 0 {name=l19717 lab=BLB7}
N 1360 24560 1340 24560 {}
C {lab_pin.sym} 1340 24560 0 0 {name=l19718 lab=WL123}
N 1440 24640 1460 24640 {}
C {lab_pin.sym} 1460 24640 0 0 {name=l19719 lab=VDD}
N 1440 24560 1460 24560 {}
C {lab_pin.sym} 1460 24560 0 0 {name=l19720 lab=VSS}
C {bitcell_6t.sym} 1600 24600 0 0 {name=Xr123c8}
N 1560 24640 1540 24640 {}
C {lab_pin.sym} 1540 24640 0 0 {name=l19721 lab=BL8}
N 1560 24600 1540 24600 {}
C {lab_pin.sym} 1540 24600 0 0 {name=l19722 lab=BLB8}
N 1560 24560 1540 24560 {}
C {lab_pin.sym} 1540 24560 0 0 {name=l19723 lab=WL123}
N 1640 24640 1660 24640 {}
C {lab_pin.sym} 1660 24640 0 0 {name=l19724 lab=VDD}
N 1640 24560 1660 24560 {}
C {lab_pin.sym} 1660 24560 0 0 {name=l19725 lab=VSS}
C {bitcell_6t.sym} 1800 24600 0 0 {name=Xr123c9}
N 1760 24640 1740 24640 {}
C {lab_pin.sym} 1740 24640 0 0 {name=l19726 lab=BL9}
N 1760 24600 1740 24600 {}
C {lab_pin.sym} 1740 24600 0 0 {name=l19727 lab=BLB9}
N 1760 24560 1740 24560 {}
C {lab_pin.sym} 1740 24560 0 0 {name=l19728 lab=WL123}
N 1840 24640 1860 24640 {}
C {lab_pin.sym} 1860 24640 0 0 {name=l19729 lab=VDD}
N 1840 24560 1860 24560 {}
C {lab_pin.sym} 1860 24560 0 0 {name=l19730 lab=VSS}
C {bitcell_6t.sym} 2000 24600 0 0 {name=Xr123c10}
N 1960 24640 1940 24640 {}
C {lab_pin.sym} 1940 24640 0 0 {name=l19731 lab=BL10}
N 1960 24600 1940 24600 {}
C {lab_pin.sym} 1940 24600 0 0 {name=l19732 lab=BLB10}
N 1960 24560 1940 24560 {}
C {lab_pin.sym} 1940 24560 0 0 {name=l19733 lab=WL123}
N 2040 24640 2060 24640 {}
C {lab_pin.sym} 2060 24640 0 0 {name=l19734 lab=VDD}
N 2040 24560 2060 24560 {}
C {lab_pin.sym} 2060 24560 0 0 {name=l19735 lab=VSS}
C {bitcell_6t.sym} 2200 24600 0 0 {name=Xr123c11}
N 2160 24640 2140 24640 {}
C {lab_pin.sym} 2140 24640 0 0 {name=l19736 lab=BL11}
N 2160 24600 2140 24600 {}
C {lab_pin.sym} 2140 24600 0 0 {name=l19737 lab=BLB11}
N 2160 24560 2140 24560 {}
C {lab_pin.sym} 2140 24560 0 0 {name=l19738 lab=WL123}
N 2240 24640 2260 24640 {}
C {lab_pin.sym} 2260 24640 0 0 {name=l19739 lab=VDD}
N 2240 24560 2260 24560 {}
C {lab_pin.sym} 2260 24560 0 0 {name=l19740 lab=VSS}
C {bitcell_6t.sym} 2400 24600 0 0 {name=Xr123c12}
N 2360 24640 2340 24640 {}
C {lab_pin.sym} 2340 24640 0 0 {name=l19741 lab=BL12}
N 2360 24600 2340 24600 {}
C {lab_pin.sym} 2340 24600 0 0 {name=l19742 lab=BLB12}
N 2360 24560 2340 24560 {}
C {lab_pin.sym} 2340 24560 0 0 {name=l19743 lab=WL123}
N 2440 24640 2460 24640 {}
C {lab_pin.sym} 2460 24640 0 0 {name=l19744 lab=VDD}
N 2440 24560 2460 24560 {}
C {lab_pin.sym} 2460 24560 0 0 {name=l19745 lab=VSS}
C {bitcell_6t.sym} 2600 24600 0 0 {name=Xr123c13}
N 2560 24640 2540 24640 {}
C {lab_pin.sym} 2540 24640 0 0 {name=l19746 lab=BL13}
N 2560 24600 2540 24600 {}
C {lab_pin.sym} 2540 24600 0 0 {name=l19747 lab=BLB13}
N 2560 24560 2540 24560 {}
C {lab_pin.sym} 2540 24560 0 0 {name=l19748 lab=WL123}
N 2640 24640 2660 24640 {}
C {lab_pin.sym} 2660 24640 0 0 {name=l19749 lab=VDD}
N 2640 24560 2660 24560 {}
C {lab_pin.sym} 2660 24560 0 0 {name=l19750 lab=VSS}
C {bitcell_6t.sym} 2800 24600 0 0 {name=Xr123c14}
N 2760 24640 2740 24640 {}
C {lab_pin.sym} 2740 24640 0 0 {name=l19751 lab=BL14}
N 2760 24600 2740 24600 {}
C {lab_pin.sym} 2740 24600 0 0 {name=l19752 lab=BLB14}
N 2760 24560 2740 24560 {}
C {lab_pin.sym} 2740 24560 0 0 {name=l19753 lab=WL123}
N 2840 24640 2860 24640 {}
C {lab_pin.sym} 2860 24640 0 0 {name=l19754 lab=VDD}
N 2840 24560 2860 24560 {}
C {lab_pin.sym} 2860 24560 0 0 {name=l19755 lab=VSS}
C {bitcell_6t.sym} 3000 24600 0 0 {name=Xr123c15}
N 2960 24640 2940 24640 {}
C {lab_pin.sym} 2940 24640 0 0 {name=l19756 lab=BL15}
N 2960 24600 2940 24600 {}
C {lab_pin.sym} 2940 24600 0 0 {name=l19757 lab=BLB15}
N 2960 24560 2940 24560 {}
C {lab_pin.sym} 2940 24560 0 0 {name=l19758 lab=WL123}
N 3040 24640 3060 24640 {}
C {lab_pin.sym} 3060 24640 0 0 {name=l19759 lab=VDD}
N 3040 24560 3060 24560 {}
C {lab_pin.sym} 3060 24560 0 0 {name=l19760 lab=VSS}
C {bitcell_6t.sym} 3200 24600 0 0 {name=Xr123c16}
N 3160 24640 3140 24640 {}
C {lab_pin.sym} 3140 24640 0 0 {name=l19761 lab=BL16}
N 3160 24600 3140 24600 {}
C {lab_pin.sym} 3140 24600 0 0 {name=l19762 lab=BLB16}
N 3160 24560 3140 24560 {}
C {lab_pin.sym} 3140 24560 0 0 {name=l19763 lab=WL123}
N 3240 24640 3260 24640 {}
C {lab_pin.sym} 3260 24640 0 0 {name=l19764 lab=VDD}
N 3240 24560 3260 24560 {}
C {lab_pin.sym} 3260 24560 0 0 {name=l19765 lab=VSS}
C {bitcell_6t.sym} 3400 24600 0 0 {name=Xr123c17}
N 3360 24640 3340 24640 {}
C {lab_pin.sym} 3340 24640 0 0 {name=l19766 lab=BL17}
N 3360 24600 3340 24600 {}
C {lab_pin.sym} 3340 24600 0 0 {name=l19767 lab=BLB17}
N 3360 24560 3340 24560 {}
C {lab_pin.sym} 3340 24560 0 0 {name=l19768 lab=WL123}
N 3440 24640 3460 24640 {}
C {lab_pin.sym} 3460 24640 0 0 {name=l19769 lab=VDD}
N 3440 24560 3460 24560 {}
C {lab_pin.sym} 3460 24560 0 0 {name=l19770 lab=VSS}
C {bitcell_6t.sym} 3600 24600 0 0 {name=Xr123c18}
N 3560 24640 3540 24640 {}
C {lab_pin.sym} 3540 24640 0 0 {name=l19771 lab=BL18}
N 3560 24600 3540 24600 {}
C {lab_pin.sym} 3540 24600 0 0 {name=l19772 lab=BLB18}
N 3560 24560 3540 24560 {}
C {lab_pin.sym} 3540 24560 0 0 {name=l19773 lab=WL123}
N 3640 24640 3660 24640 {}
C {lab_pin.sym} 3660 24640 0 0 {name=l19774 lab=VDD}
N 3640 24560 3660 24560 {}
C {lab_pin.sym} 3660 24560 0 0 {name=l19775 lab=VSS}
C {bitcell_6t.sym} 3800 24600 0 0 {name=Xr123c19}
N 3760 24640 3740 24640 {}
C {lab_pin.sym} 3740 24640 0 0 {name=l19776 lab=BL19}
N 3760 24600 3740 24600 {}
C {lab_pin.sym} 3740 24600 0 0 {name=l19777 lab=BLB19}
N 3760 24560 3740 24560 {}
C {lab_pin.sym} 3740 24560 0 0 {name=l19778 lab=WL123}
N 3840 24640 3860 24640 {}
C {lab_pin.sym} 3860 24640 0 0 {name=l19779 lab=VDD}
N 3840 24560 3860 24560 {}
C {lab_pin.sym} 3860 24560 0 0 {name=l19780 lab=VSS}
C {bitcell_6t.sym} 4000 24600 0 0 {name=Xr123c20}
N 3960 24640 3940 24640 {}
C {lab_pin.sym} 3940 24640 0 0 {name=l19781 lab=BL20}
N 3960 24600 3940 24600 {}
C {lab_pin.sym} 3940 24600 0 0 {name=l19782 lab=BLB20}
N 3960 24560 3940 24560 {}
C {lab_pin.sym} 3940 24560 0 0 {name=l19783 lab=WL123}
N 4040 24640 4060 24640 {}
C {lab_pin.sym} 4060 24640 0 0 {name=l19784 lab=VDD}
N 4040 24560 4060 24560 {}
C {lab_pin.sym} 4060 24560 0 0 {name=l19785 lab=VSS}
C {bitcell_6t.sym} 4200 24600 0 0 {name=Xr123c21}
N 4160 24640 4140 24640 {}
C {lab_pin.sym} 4140 24640 0 0 {name=l19786 lab=BL21}
N 4160 24600 4140 24600 {}
C {lab_pin.sym} 4140 24600 0 0 {name=l19787 lab=BLB21}
N 4160 24560 4140 24560 {}
C {lab_pin.sym} 4140 24560 0 0 {name=l19788 lab=WL123}
N 4240 24640 4260 24640 {}
C {lab_pin.sym} 4260 24640 0 0 {name=l19789 lab=VDD}
N 4240 24560 4260 24560 {}
C {lab_pin.sym} 4260 24560 0 0 {name=l19790 lab=VSS}
C {bitcell_6t.sym} 4400 24600 0 0 {name=Xr123c22}
N 4360 24640 4340 24640 {}
C {lab_pin.sym} 4340 24640 0 0 {name=l19791 lab=BL22}
N 4360 24600 4340 24600 {}
C {lab_pin.sym} 4340 24600 0 0 {name=l19792 lab=BLB22}
N 4360 24560 4340 24560 {}
C {lab_pin.sym} 4340 24560 0 0 {name=l19793 lab=WL123}
N 4440 24640 4460 24640 {}
C {lab_pin.sym} 4460 24640 0 0 {name=l19794 lab=VDD}
N 4440 24560 4460 24560 {}
C {lab_pin.sym} 4460 24560 0 0 {name=l19795 lab=VSS}
C {bitcell_6t.sym} 4600 24600 0 0 {name=Xr123c23}
N 4560 24640 4540 24640 {}
C {lab_pin.sym} 4540 24640 0 0 {name=l19796 lab=BL23}
N 4560 24600 4540 24600 {}
C {lab_pin.sym} 4540 24600 0 0 {name=l19797 lab=BLB23}
N 4560 24560 4540 24560 {}
C {lab_pin.sym} 4540 24560 0 0 {name=l19798 lab=WL123}
N 4640 24640 4660 24640 {}
C {lab_pin.sym} 4660 24640 0 0 {name=l19799 lab=VDD}
N 4640 24560 4660 24560 {}
C {lab_pin.sym} 4660 24560 0 0 {name=l19800 lab=VSS}
C {bitcell_6t.sym} 4800 24600 0 0 {name=Xr123c24}
N 4760 24640 4740 24640 {}
C {lab_pin.sym} 4740 24640 0 0 {name=l19801 lab=BL24}
N 4760 24600 4740 24600 {}
C {lab_pin.sym} 4740 24600 0 0 {name=l19802 lab=BLB24}
N 4760 24560 4740 24560 {}
C {lab_pin.sym} 4740 24560 0 0 {name=l19803 lab=WL123}
N 4840 24640 4860 24640 {}
C {lab_pin.sym} 4860 24640 0 0 {name=l19804 lab=VDD}
N 4840 24560 4860 24560 {}
C {lab_pin.sym} 4860 24560 0 0 {name=l19805 lab=VSS}
C {bitcell_6t.sym} 5000 24600 0 0 {name=Xr123c25}
N 4960 24640 4940 24640 {}
C {lab_pin.sym} 4940 24640 0 0 {name=l19806 lab=BL25}
N 4960 24600 4940 24600 {}
C {lab_pin.sym} 4940 24600 0 0 {name=l19807 lab=BLB25}
N 4960 24560 4940 24560 {}
C {lab_pin.sym} 4940 24560 0 0 {name=l19808 lab=WL123}
N 5040 24640 5060 24640 {}
C {lab_pin.sym} 5060 24640 0 0 {name=l19809 lab=VDD}
N 5040 24560 5060 24560 {}
C {lab_pin.sym} 5060 24560 0 0 {name=l19810 lab=VSS}
C {bitcell_6t.sym} 5200 24600 0 0 {name=Xr123c26}
N 5160 24640 5140 24640 {}
C {lab_pin.sym} 5140 24640 0 0 {name=l19811 lab=BL26}
N 5160 24600 5140 24600 {}
C {lab_pin.sym} 5140 24600 0 0 {name=l19812 lab=BLB26}
N 5160 24560 5140 24560 {}
C {lab_pin.sym} 5140 24560 0 0 {name=l19813 lab=WL123}
N 5240 24640 5260 24640 {}
C {lab_pin.sym} 5260 24640 0 0 {name=l19814 lab=VDD}
N 5240 24560 5260 24560 {}
C {lab_pin.sym} 5260 24560 0 0 {name=l19815 lab=VSS}
C {bitcell_6t.sym} 5400 24600 0 0 {name=Xr123c27}
N 5360 24640 5340 24640 {}
C {lab_pin.sym} 5340 24640 0 0 {name=l19816 lab=BL27}
N 5360 24600 5340 24600 {}
C {lab_pin.sym} 5340 24600 0 0 {name=l19817 lab=BLB27}
N 5360 24560 5340 24560 {}
C {lab_pin.sym} 5340 24560 0 0 {name=l19818 lab=WL123}
N 5440 24640 5460 24640 {}
C {lab_pin.sym} 5460 24640 0 0 {name=l19819 lab=VDD}
N 5440 24560 5460 24560 {}
C {lab_pin.sym} 5460 24560 0 0 {name=l19820 lab=VSS}
C {bitcell_6t.sym} 5600 24600 0 0 {name=Xr123c28}
N 5560 24640 5540 24640 {}
C {lab_pin.sym} 5540 24640 0 0 {name=l19821 lab=BL28}
N 5560 24600 5540 24600 {}
C {lab_pin.sym} 5540 24600 0 0 {name=l19822 lab=BLB28}
N 5560 24560 5540 24560 {}
C {lab_pin.sym} 5540 24560 0 0 {name=l19823 lab=WL123}
N 5640 24640 5660 24640 {}
C {lab_pin.sym} 5660 24640 0 0 {name=l19824 lab=VDD}
N 5640 24560 5660 24560 {}
C {lab_pin.sym} 5660 24560 0 0 {name=l19825 lab=VSS}
C {bitcell_6t.sym} 5800 24600 0 0 {name=Xr123c29}
N 5760 24640 5740 24640 {}
C {lab_pin.sym} 5740 24640 0 0 {name=l19826 lab=BL29}
N 5760 24600 5740 24600 {}
C {lab_pin.sym} 5740 24600 0 0 {name=l19827 lab=BLB29}
N 5760 24560 5740 24560 {}
C {lab_pin.sym} 5740 24560 0 0 {name=l19828 lab=WL123}
N 5840 24640 5860 24640 {}
C {lab_pin.sym} 5860 24640 0 0 {name=l19829 lab=VDD}
N 5840 24560 5860 24560 {}
C {lab_pin.sym} 5860 24560 0 0 {name=l19830 lab=VSS}
C {bitcell_6t.sym} 6000 24600 0 0 {name=Xr123c30}
N 5960 24640 5940 24640 {}
C {lab_pin.sym} 5940 24640 0 0 {name=l19831 lab=BL30}
N 5960 24600 5940 24600 {}
C {lab_pin.sym} 5940 24600 0 0 {name=l19832 lab=BLB30}
N 5960 24560 5940 24560 {}
C {lab_pin.sym} 5940 24560 0 0 {name=l19833 lab=WL123}
N 6040 24640 6060 24640 {}
C {lab_pin.sym} 6060 24640 0 0 {name=l19834 lab=VDD}
N 6040 24560 6060 24560 {}
C {lab_pin.sym} 6060 24560 0 0 {name=l19835 lab=VSS}
C {bitcell_6t.sym} 6200 24600 0 0 {name=Xr123c31}
N 6160 24640 6140 24640 {}
C {lab_pin.sym} 6140 24640 0 0 {name=l19836 lab=BL31}
N 6160 24600 6140 24600 {}
C {lab_pin.sym} 6140 24600 0 0 {name=l19837 lab=BLB31}
N 6160 24560 6140 24560 {}
C {lab_pin.sym} 6140 24560 0 0 {name=l19838 lab=WL123}
N 6240 24640 6260 24640 {}
C {lab_pin.sym} 6260 24640 0 0 {name=l19839 lab=VDD}
N 6240 24560 6260 24560 {}
C {lab_pin.sym} 6260 24560 0 0 {name=l19840 lab=VSS}
C {bitcell_6t.sym} 0 24800 0 0 {name=Xr124c0}
N -40 24840 -60 24840 {}
C {lab_pin.sym} -60 24840 0 0 {name=l19841 lab=BL0}
N -40 24800 -60 24800 {}
C {lab_pin.sym} -60 24800 0 0 {name=l19842 lab=BLB0}
N -40 24760 -60 24760 {}
C {lab_pin.sym} -60 24760 0 0 {name=l19843 lab=WL124}
N 40 24840 60 24840 {}
C {lab_pin.sym} 60 24840 0 0 {name=l19844 lab=VDD}
N 40 24760 60 24760 {}
C {lab_pin.sym} 60 24760 0 0 {name=l19845 lab=VSS}
C {bitcell_6t.sym} 200 24800 0 0 {name=Xr124c1}
N 160 24840 140 24840 {}
C {lab_pin.sym} 140 24840 0 0 {name=l19846 lab=BL1}
N 160 24800 140 24800 {}
C {lab_pin.sym} 140 24800 0 0 {name=l19847 lab=BLB1}
N 160 24760 140 24760 {}
C {lab_pin.sym} 140 24760 0 0 {name=l19848 lab=WL124}
N 240 24840 260 24840 {}
C {lab_pin.sym} 260 24840 0 0 {name=l19849 lab=VDD}
N 240 24760 260 24760 {}
C {lab_pin.sym} 260 24760 0 0 {name=l19850 lab=VSS}
C {bitcell_6t.sym} 400 24800 0 0 {name=Xr124c2}
N 360 24840 340 24840 {}
C {lab_pin.sym} 340 24840 0 0 {name=l19851 lab=BL2}
N 360 24800 340 24800 {}
C {lab_pin.sym} 340 24800 0 0 {name=l19852 lab=BLB2}
N 360 24760 340 24760 {}
C {lab_pin.sym} 340 24760 0 0 {name=l19853 lab=WL124}
N 440 24840 460 24840 {}
C {lab_pin.sym} 460 24840 0 0 {name=l19854 lab=VDD}
N 440 24760 460 24760 {}
C {lab_pin.sym} 460 24760 0 0 {name=l19855 lab=VSS}
C {bitcell_6t.sym} 600 24800 0 0 {name=Xr124c3}
N 560 24840 540 24840 {}
C {lab_pin.sym} 540 24840 0 0 {name=l19856 lab=BL3}
N 560 24800 540 24800 {}
C {lab_pin.sym} 540 24800 0 0 {name=l19857 lab=BLB3}
N 560 24760 540 24760 {}
C {lab_pin.sym} 540 24760 0 0 {name=l19858 lab=WL124}
N 640 24840 660 24840 {}
C {lab_pin.sym} 660 24840 0 0 {name=l19859 lab=VDD}
N 640 24760 660 24760 {}
C {lab_pin.sym} 660 24760 0 0 {name=l19860 lab=VSS}
C {bitcell_6t.sym} 800 24800 0 0 {name=Xr124c4}
N 760 24840 740 24840 {}
C {lab_pin.sym} 740 24840 0 0 {name=l19861 lab=BL4}
N 760 24800 740 24800 {}
C {lab_pin.sym} 740 24800 0 0 {name=l19862 lab=BLB4}
N 760 24760 740 24760 {}
C {lab_pin.sym} 740 24760 0 0 {name=l19863 lab=WL124}
N 840 24840 860 24840 {}
C {lab_pin.sym} 860 24840 0 0 {name=l19864 lab=VDD}
N 840 24760 860 24760 {}
C {lab_pin.sym} 860 24760 0 0 {name=l19865 lab=VSS}
C {bitcell_6t.sym} 1000 24800 0 0 {name=Xr124c5}
N 960 24840 940 24840 {}
C {lab_pin.sym} 940 24840 0 0 {name=l19866 lab=BL5}
N 960 24800 940 24800 {}
C {lab_pin.sym} 940 24800 0 0 {name=l19867 lab=BLB5}
N 960 24760 940 24760 {}
C {lab_pin.sym} 940 24760 0 0 {name=l19868 lab=WL124}
N 1040 24840 1060 24840 {}
C {lab_pin.sym} 1060 24840 0 0 {name=l19869 lab=VDD}
N 1040 24760 1060 24760 {}
C {lab_pin.sym} 1060 24760 0 0 {name=l19870 lab=VSS}
C {bitcell_6t.sym} 1200 24800 0 0 {name=Xr124c6}
N 1160 24840 1140 24840 {}
C {lab_pin.sym} 1140 24840 0 0 {name=l19871 lab=BL6}
N 1160 24800 1140 24800 {}
C {lab_pin.sym} 1140 24800 0 0 {name=l19872 lab=BLB6}
N 1160 24760 1140 24760 {}
C {lab_pin.sym} 1140 24760 0 0 {name=l19873 lab=WL124}
N 1240 24840 1260 24840 {}
C {lab_pin.sym} 1260 24840 0 0 {name=l19874 lab=VDD}
N 1240 24760 1260 24760 {}
C {lab_pin.sym} 1260 24760 0 0 {name=l19875 lab=VSS}
C {bitcell_6t.sym} 1400 24800 0 0 {name=Xr124c7}
N 1360 24840 1340 24840 {}
C {lab_pin.sym} 1340 24840 0 0 {name=l19876 lab=BL7}
N 1360 24800 1340 24800 {}
C {lab_pin.sym} 1340 24800 0 0 {name=l19877 lab=BLB7}
N 1360 24760 1340 24760 {}
C {lab_pin.sym} 1340 24760 0 0 {name=l19878 lab=WL124}
N 1440 24840 1460 24840 {}
C {lab_pin.sym} 1460 24840 0 0 {name=l19879 lab=VDD}
N 1440 24760 1460 24760 {}
C {lab_pin.sym} 1460 24760 0 0 {name=l19880 lab=VSS}
C {bitcell_6t.sym} 1600 24800 0 0 {name=Xr124c8}
N 1560 24840 1540 24840 {}
C {lab_pin.sym} 1540 24840 0 0 {name=l19881 lab=BL8}
N 1560 24800 1540 24800 {}
C {lab_pin.sym} 1540 24800 0 0 {name=l19882 lab=BLB8}
N 1560 24760 1540 24760 {}
C {lab_pin.sym} 1540 24760 0 0 {name=l19883 lab=WL124}
N 1640 24840 1660 24840 {}
C {lab_pin.sym} 1660 24840 0 0 {name=l19884 lab=VDD}
N 1640 24760 1660 24760 {}
C {lab_pin.sym} 1660 24760 0 0 {name=l19885 lab=VSS}
C {bitcell_6t.sym} 1800 24800 0 0 {name=Xr124c9}
N 1760 24840 1740 24840 {}
C {lab_pin.sym} 1740 24840 0 0 {name=l19886 lab=BL9}
N 1760 24800 1740 24800 {}
C {lab_pin.sym} 1740 24800 0 0 {name=l19887 lab=BLB9}
N 1760 24760 1740 24760 {}
C {lab_pin.sym} 1740 24760 0 0 {name=l19888 lab=WL124}
N 1840 24840 1860 24840 {}
C {lab_pin.sym} 1860 24840 0 0 {name=l19889 lab=VDD}
N 1840 24760 1860 24760 {}
C {lab_pin.sym} 1860 24760 0 0 {name=l19890 lab=VSS}
C {bitcell_6t.sym} 2000 24800 0 0 {name=Xr124c10}
N 1960 24840 1940 24840 {}
C {lab_pin.sym} 1940 24840 0 0 {name=l19891 lab=BL10}
N 1960 24800 1940 24800 {}
C {lab_pin.sym} 1940 24800 0 0 {name=l19892 lab=BLB10}
N 1960 24760 1940 24760 {}
C {lab_pin.sym} 1940 24760 0 0 {name=l19893 lab=WL124}
N 2040 24840 2060 24840 {}
C {lab_pin.sym} 2060 24840 0 0 {name=l19894 lab=VDD}
N 2040 24760 2060 24760 {}
C {lab_pin.sym} 2060 24760 0 0 {name=l19895 lab=VSS}
C {bitcell_6t.sym} 2200 24800 0 0 {name=Xr124c11}
N 2160 24840 2140 24840 {}
C {lab_pin.sym} 2140 24840 0 0 {name=l19896 lab=BL11}
N 2160 24800 2140 24800 {}
C {lab_pin.sym} 2140 24800 0 0 {name=l19897 lab=BLB11}
N 2160 24760 2140 24760 {}
C {lab_pin.sym} 2140 24760 0 0 {name=l19898 lab=WL124}
N 2240 24840 2260 24840 {}
C {lab_pin.sym} 2260 24840 0 0 {name=l19899 lab=VDD}
N 2240 24760 2260 24760 {}
C {lab_pin.sym} 2260 24760 0 0 {name=l19900 lab=VSS}
C {bitcell_6t.sym} 2400 24800 0 0 {name=Xr124c12}
N 2360 24840 2340 24840 {}
C {lab_pin.sym} 2340 24840 0 0 {name=l19901 lab=BL12}
N 2360 24800 2340 24800 {}
C {lab_pin.sym} 2340 24800 0 0 {name=l19902 lab=BLB12}
N 2360 24760 2340 24760 {}
C {lab_pin.sym} 2340 24760 0 0 {name=l19903 lab=WL124}
N 2440 24840 2460 24840 {}
C {lab_pin.sym} 2460 24840 0 0 {name=l19904 lab=VDD}
N 2440 24760 2460 24760 {}
C {lab_pin.sym} 2460 24760 0 0 {name=l19905 lab=VSS}
C {bitcell_6t.sym} 2600 24800 0 0 {name=Xr124c13}
N 2560 24840 2540 24840 {}
C {lab_pin.sym} 2540 24840 0 0 {name=l19906 lab=BL13}
N 2560 24800 2540 24800 {}
C {lab_pin.sym} 2540 24800 0 0 {name=l19907 lab=BLB13}
N 2560 24760 2540 24760 {}
C {lab_pin.sym} 2540 24760 0 0 {name=l19908 lab=WL124}
N 2640 24840 2660 24840 {}
C {lab_pin.sym} 2660 24840 0 0 {name=l19909 lab=VDD}
N 2640 24760 2660 24760 {}
C {lab_pin.sym} 2660 24760 0 0 {name=l19910 lab=VSS}
C {bitcell_6t.sym} 2800 24800 0 0 {name=Xr124c14}
N 2760 24840 2740 24840 {}
C {lab_pin.sym} 2740 24840 0 0 {name=l19911 lab=BL14}
N 2760 24800 2740 24800 {}
C {lab_pin.sym} 2740 24800 0 0 {name=l19912 lab=BLB14}
N 2760 24760 2740 24760 {}
C {lab_pin.sym} 2740 24760 0 0 {name=l19913 lab=WL124}
N 2840 24840 2860 24840 {}
C {lab_pin.sym} 2860 24840 0 0 {name=l19914 lab=VDD}
N 2840 24760 2860 24760 {}
C {lab_pin.sym} 2860 24760 0 0 {name=l19915 lab=VSS}
C {bitcell_6t.sym} 3000 24800 0 0 {name=Xr124c15}
N 2960 24840 2940 24840 {}
C {lab_pin.sym} 2940 24840 0 0 {name=l19916 lab=BL15}
N 2960 24800 2940 24800 {}
C {lab_pin.sym} 2940 24800 0 0 {name=l19917 lab=BLB15}
N 2960 24760 2940 24760 {}
C {lab_pin.sym} 2940 24760 0 0 {name=l19918 lab=WL124}
N 3040 24840 3060 24840 {}
C {lab_pin.sym} 3060 24840 0 0 {name=l19919 lab=VDD}
N 3040 24760 3060 24760 {}
C {lab_pin.sym} 3060 24760 0 0 {name=l19920 lab=VSS}
C {bitcell_6t.sym} 3200 24800 0 0 {name=Xr124c16}
N 3160 24840 3140 24840 {}
C {lab_pin.sym} 3140 24840 0 0 {name=l19921 lab=BL16}
N 3160 24800 3140 24800 {}
C {lab_pin.sym} 3140 24800 0 0 {name=l19922 lab=BLB16}
N 3160 24760 3140 24760 {}
C {lab_pin.sym} 3140 24760 0 0 {name=l19923 lab=WL124}
N 3240 24840 3260 24840 {}
C {lab_pin.sym} 3260 24840 0 0 {name=l19924 lab=VDD}
N 3240 24760 3260 24760 {}
C {lab_pin.sym} 3260 24760 0 0 {name=l19925 lab=VSS}
C {bitcell_6t.sym} 3400 24800 0 0 {name=Xr124c17}
N 3360 24840 3340 24840 {}
C {lab_pin.sym} 3340 24840 0 0 {name=l19926 lab=BL17}
N 3360 24800 3340 24800 {}
C {lab_pin.sym} 3340 24800 0 0 {name=l19927 lab=BLB17}
N 3360 24760 3340 24760 {}
C {lab_pin.sym} 3340 24760 0 0 {name=l19928 lab=WL124}
N 3440 24840 3460 24840 {}
C {lab_pin.sym} 3460 24840 0 0 {name=l19929 lab=VDD}
N 3440 24760 3460 24760 {}
C {lab_pin.sym} 3460 24760 0 0 {name=l19930 lab=VSS}
C {bitcell_6t.sym} 3600 24800 0 0 {name=Xr124c18}
N 3560 24840 3540 24840 {}
C {lab_pin.sym} 3540 24840 0 0 {name=l19931 lab=BL18}
N 3560 24800 3540 24800 {}
C {lab_pin.sym} 3540 24800 0 0 {name=l19932 lab=BLB18}
N 3560 24760 3540 24760 {}
C {lab_pin.sym} 3540 24760 0 0 {name=l19933 lab=WL124}
N 3640 24840 3660 24840 {}
C {lab_pin.sym} 3660 24840 0 0 {name=l19934 lab=VDD}
N 3640 24760 3660 24760 {}
C {lab_pin.sym} 3660 24760 0 0 {name=l19935 lab=VSS}
C {bitcell_6t.sym} 3800 24800 0 0 {name=Xr124c19}
N 3760 24840 3740 24840 {}
C {lab_pin.sym} 3740 24840 0 0 {name=l19936 lab=BL19}
N 3760 24800 3740 24800 {}
C {lab_pin.sym} 3740 24800 0 0 {name=l19937 lab=BLB19}
N 3760 24760 3740 24760 {}
C {lab_pin.sym} 3740 24760 0 0 {name=l19938 lab=WL124}
N 3840 24840 3860 24840 {}
C {lab_pin.sym} 3860 24840 0 0 {name=l19939 lab=VDD}
N 3840 24760 3860 24760 {}
C {lab_pin.sym} 3860 24760 0 0 {name=l19940 lab=VSS}
C {bitcell_6t.sym} 4000 24800 0 0 {name=Xr124c20}
N 3960 24840 3940 24840 {}
C {lab_pin.sym} 3940 24840 0 0 {name=l19941 lab=BL20}
N 3960 24800 3940 24800 {}
C {lab_pin.sym} 3940 24800 0 0 {name=l19942 lab=BLB20}
N 3960 24760 3940 24760 {}
C {lab_pin.sym} 3940 24760 0 0 {name=l19943 lab=WL124}
N 4040 24840 4060 24840 {}
C {lab_pin.sym} 4060 24840 0 0 {name=l19944 lab=VDD}
N 4040 24760 4060 24760 {}
C {lab_pin.sym} 4060 24760 0 0 {name=l19945 lab=VSS}
C {bitcell_6t.sym} 4200 24800 0 0 {name=Xr124c21}
N 4160 24840 4140 24840 {}
C {lab_pin.sym} 4140 24840 0 0 {name=l19946 lab=BL21}
N 4160 24800 4140 24800 {}
C {lab_pin.sym} 4140 24800 0 0 {name=l19947 lab=BLB21}
N 4160 24760 4140 24760 {}
C {lab_pin.sym} 4140 24760 0 0 {name=l19948 lab=WL124}
N 4240 24840 4260 24840 {}
C {lab_pin.sym} 4260 24840 0 0 {name=l19949 lab=VDD}
N 4240 24760 4260 24760 {}
C {lab_pin.sym} 4260 24760 0 0 {name=l19950 lab=VSS}
C {bitcell_6t.sym} 4400 24800 0 0 {name=Xr124c22}
N 4360 24840 4340 24840 {}
C {lab_pin.sym} 4340 24840 0 0 {name=l19951 lab=BL22}
N 4360 24800 4340 24800 {}
C {lab_pin.sym} 4340 24800 0 0 {name=l19952 lab=BLB22}
N 4360 24760 4340 24760 {}
C {lab_pin.sym} 4340 24760 0 0 {name=l19953 lab=WL124}
N 4440 24840 4460 24840 {}
C {lab_pin.sym} 4460 24840 0 0 {name=l19954 lab=VDD}
N 4440 24760 4460 24760 {}
C {lab_pin.sym} 4460 24760 0 0 {name=l19955 lab=VSS}
C {bitcell_6t.sym} 4600 24800 0 0 {name=Xr124c23}
N 4560 24840 4540 24840 {}
C {lab_pin.sym} 4540 24840 0 0 {name=l19956 lab=BL23}
N 4560 24800 4540 24800 {}
C {lab_pin.sym} 4540 24800 0 0 {name=l19957 lab=BLB23}
N 4560 24760 4540 24760 {}
C {lab_pin.sym} 4540 24760 0 0 {name=l19958 lab=WL124}
N 4640 24840 4660 24840 {}
C {lab_pin.sym} 4660 24840 0 0 {name=l19959 lab=VDD}
N 4640 24760 4660 24760 {}
C {lab_pin.sym} 4660 24760 0 0 {name=l19960 lab=VSS}
C {bitcell_6t.sym} 4800 24800 0 0 {name=Xr124c24}
N 4760 24840 4740 24840 {}
C {lab_pin.sym} 4740 24840 0 0 {name=l19961 lab=BL24}
N 4760 24800 4740 24800 {}
C {lab_pin.sym} 4740 24800 0 0 {name=l19962 lab=BLB24}
N 4760 24760 4740 24760 {}
C {lab_pin.sym} 4740 24760 0 0 {name=l19963 lab=WL124}
N 4840 24840 4860 24840 {}
C {lab_pin.sym} 4860 24840 0 0 {name=l19964 lab=VDD}
N 4840 24760 4860 24760 {}
C {lab_pin.sym} 4860 24760 0 0 {name=l19965 lab=VSS}
C {bitcell_6t.sym} 5000 24800 0 0 {name=Xr124c25}
N 4960 24840 4940 24840 {}
C {lab_pin.sym} 4940 24840 0 0 {name=l19966 lab=BL25}
N 4960 24800 4940 24800 {}
C {lab_pin.sym} 4940 24800 0 0 {name=l19967 lab=BLB25}
N 4960 24760 4940 24760 {}
C {lab_pin.sym} 4940 24760 0 0 {name=l19968 lab=WL124}
N 5040 24840 5060 24840 {}
C {lab_pin.sym} 5060 24840 0 0 {name=l19969 lab=VDD}
N 5040 24760 5060 24760 {}
C {lab_pin.sym} 5060 24760 0 0 {name=l19970 lab=VSS}
C {bitcell_6t.sym} 5200 24800 0 0 {name=Xr124c26}
N 5160 24840 5140 24840 {}
C {lab_pin.sym} 5140 24840 0 0 {name=l19971 lab=BL26}
N 5160 24800 5140 24800 {}
C {lab_pin.sym} 5140 24800 0 0 {name=l19972 lab=BLB26}
N 5160 24760 5140 24760 {}
C {lab_pin.sym} 5140 24760 0 0 {name=l19973 lab=WL124}
N 5240 24840 5260 24840 {}
C {lab_pin.sym} 5260 24840 0 0 {name=l19974 lab=VDD}
N 5240 24760 5260 24760 {}
C {lab_pin.sym} 5260 24760 0 0 {name=l19975 lab=VSS}
C {bitcell_6t.sym} 5400 24800 0 0 {name=Xr124c27}
N 5360 24840 5340 24840 {}
C {lab_pin.sym} 5340 24840 0 0 {name=l19976 lab=BL27}
N 5360 24800 5340 24800 {}
C {lab_pin.sym} 5340 24800 0 0 {name=l19977 lab=BLB27}
N 5360 24760 5340 24760 {}
C {lab_pin.sym} 5340 24760 0 0 {name=l19978 lab=WL124}
N 5440 24840 5460 24840 {}
C {lab_pin.sym} 5460 24840 0 0 {name=l19979 lab=VDD}
N 5440 24760 5460 24760 {}
C {lab_pin.sym} 5460 24760 0 0 {name=l19980 lab=VSS}
C {bitcell_6t.sym} 5600 24800 0 0 {name=Xr124c28}
N 5560 24840 5540 24840 {}
C {lab_pin.sym} 5540 24840 0 0 {name=l19981 lab=BL28}
N 5560 24800 5540 24800 {}
C {lab_pin.sym} 5540 24800 0 0 {name=l19982 lab=BLB28}
N 5560 24760 5540 24760 {}
C {lab_pin.sym} 5540 24760 0 0 {name=l19983 lab=WL124}
N 5640 24840 5660 24840 {}
C {lab_pin.sym} 5660 24840 0 0 {name=l19984 lab=VDD}
N 5640 24760 5660 24760 {}
C {lab_pin.sym} 5660 24760 0 0 {name=l19985 lab=VSS}
C {bitcell_6t.sym} 5800 24800 0 0 {name=Xr124c29}
N 5760 24840 5740 24840 {}
C {lab_pin.sym} 5740 24840 0 0 {name=l19986 lab=BL29}
N 5760 24800 5740 24800 {}
C {lab_pin.sym} 5740 24800 0 0 {name=l19987 lab=BLB29}
N 5760 24760 5740 24760 {}
C {lab_pin.sym} 5740 24760 0 0 {name=l19988 lab=WL124}
N 5840 24840 5860 24840 {}
C {lab_pin.sym} 5860 24840 0 0 {name=l19989 lab=VDD}
N 5840 24760 5860 24760 {}
C {lab_pin.sym} 5860 24760 0 0 {name=l19990 lab=VSS}
C {bitcell_6t.sym} 6000 24800 0 0 {name=Xr124c30}
N 5960 24840 5940 24840 {}
C {lab_pin.sym} 5940 24840 0 0 {name=l19991 lab=BL30}
N 5960 24800 5940 24800 {}
C {lab_pin.sym} 5940 24800 0 0 {name=l19992 lab=BLB30}
N 5960 24760 5940 24760 {}
C {lab_pin.sym} 5940 24760 0 0 {name=l19993 lab=WL124}
N 6040 24840 6060 24840 {}
C {lab_pin.sym} 6060 24840 0 0 {name=l19994 lab=VDD}
N 6040 24760 6060 24760 {}
C {lab_pin.sym} 6060 24760 0 0 {name=l19995 lab=VSS}
C {bitcell_6t.sym} 6200 24800 0 0 {name=Xr124c31}
N 6160 24840 6140 24840 {}
C {lab_pin.sym} 6140 24840 0 0 {name=l19996 lab=BL31}
N 6160 24800 6140 24800 {}
C {lab_pin.sym} 6140 24800 0 0 {name=l19997 lab=BLB31}
N 6160 24760 6140 24760 {}
C {lab_pin.sym} 6140 24760 0 0 {name=l19998 lab=WL124}
N 6240 24840 6260 24840 {}
C {lab_pin.sym} 6260 24840 0 0 {name=l19999 lab=VDD}
N 6240 24760 6260 24760 {}
C {lab_pin.sym} 6260 24760 0 0 {name=l20000 lab=VSS}
C {bitcell_6t.sym} 0 25000 0 0 {name=Xr125c0}
N -40 25040 -60 25040 {}
C {lab_pin.sym} -60 25040 0 0 {name=l20001 lab=BL0}
N -40 25000 -60 25000 {}
C {lab_pin.sym} -60 25000 0 0 {name=l20002 lab=BLB0}
N -40 24960 -60 24960 {}
C {lab_pin.sym} -60 24960 0 0 {name=l20003 lab=WL125}
N 40 25040 60 25040 {}
C {lab_pin.sym} 60 25040 0 0 {name=l20004 lab=VDD}
N 40 24960 60 24960 {}
C {lab_pin.sym} 60 24960 0 0 {name=l20005 lab=VSS}
C {bitcell_6t.sym} 200 25000 0 0 {name=Xr125c1}
N 160 25040 140 25040 {}
C {lab_pin.sym} 140 25040 0 0 {name=l20006 lab=BL1}
N 160 25000 140 25000 {}
C {lab_pin.sym} 140 25000 0 0 {name=l20007 lab=BLB1}
N 160 24960 140 24960 {}
C {lab_pin.sym} 140 24960 0 0 {name=l20008 lab=WL125}
N 240 25040 260 25040 {}
C {lab_pin.sym} 260 25040 0 0 {name=l20009 lab=VDD}
N 240 24960 260 24960 {}
C {lab_pin.sym} 260 24960 0 0 {name=l20010 lab=VSS}
C {bitcell_6t.sym} 400 25000 0 0 {name=Xr125c2}
N 360 25040 340 25040 {}
C {lab_pin.sym} 340 25040 0 0 {name=l20011 lab=BL2}
N 360 25000 340 25000 {}
C {lab_pin.sym} 340 25000 0 0 {name=l20012 lab=BLB2}
N 360 24960 340 24960 {}
C {lab_pin.sym} 340 24960 0 0 {name=l20013 lab=WL125}
N 440 25040 460 25040 {}
C {lab_pin.sym} 460 25040 0 0 {name=l20014 lab=VDD}
N 440 24960 460 24960 {}
C {lab_pin.sym} 460 24960 0 0 {name=l20015 lab=VSS}
C {bitcell_6t.sym} 600 25000 0 0 {name=Xr125c3}
N 560 25040 540 25040 {}
C {lab_pin.sym} 540 25040 0 0 {name=l20016 lab=BL3}
N 560 25000 540 25000 {}
C {lab_pin.sym} 540 25000 0 0 {name=l20017 lab=BLB3}
N 560 24960 540 24960 {}
C {lab_pin.sym} 540 24960 0 0 {name=l20018 lab=WL125}
N 640 25040 660 25040 {}
C {lab_pin.sym} 660 25040 0 0 {name=l20019 lab=VDD}
N 640 24960 660 24960 {}
C {lab_pin.sym} 660 24960 0 0 {name=l20020 lab=VSS}
C {bitcell_6t.sym} 800 25000 0 0 {name=Xr125c4}
N 760 25040 740 25040 {}
C {lab_pin.sym} 740 25040 0 0 {name=l20021 lab=BL4}
N 760 25000 740 25000 {}
C {lab_pin.sym} 740 25000 0 0 {name=l20022 lab=BLB4}
N 760 24960 740 24960 {}
C {lab_pin.sym} 740 24960 0 0 {name=l20023 lab=WL125}
N 840 25040 860 25040 {}
C {lab_pin.sym} 860 25040 0 0 {name=l20024 lab=VDD}
N 840 24960 860 24960 {}
C {lab_pin.sym} 860 24960 0 0 {name=l20025 lab=VSS}
C {bitcell_6t.sym} 1000 25000 0 0 {name=Xr125c5}
N 960 25040 940 25040 {}
C {lab_pin.sym} 940 25040 0 0 {name=l20026 lab=BL5}
N 960 25000 940 25000 {}
C {lab_pin.sym} 940 25000 0 0 {name=l20027 lab=BLB5}
N 960 24960 940 24960 {}
C {lab_pin.sym} 940 24960 0 0 {name=l20028 lab=WL125}
N 1040 25040 1060 25040 {}
C {lab_pin.sym} 1060 25040 0 0 {name=l20029 lab=VDD}
N 1040 24960 1060 24960 {}
C {lab_pin.sym} 1060 24960 0 0 {name=l20030 lab=VSS}
C {bitcell_6t.sym} 1200 25000 0 0 {name=Xr125c6}
N 1160 25040 1140 25040 {}
C {lab_pin.sym} 1140 25040 0 0 {name=l20031 lab=BL6}
N 1160 25000 1140 25000 {}
C {lab_pin.sym} 1140 25000 0 0 {name=l20032 lab=BLB6}
N 1160 24960 1140 24960 {}
C {lab_pin.sym} 1140 24960 0 0 {name=l20033 lab=WL125}
N 1240 25040 1260 25040 {}
C {lab_pin.sym} 1260 25040 0 0 {name=l20034 lab=VDD}
N 1240 24960 1260 24960 {}
C {lab_pin.sym} 1260 24960 0 0 {name=l20035 lab=VSS}
C {bitcell_6t.sym} 1400 25000 0 0 {name=Xr125c7}
N 1360 25040 1340 25040 {}
C {lab_pin.sym} 1340 25040 0 0 {name=l20036 lab=BL7}
N 1360 25000 1340 25000 {}
C {lab_pin.sym} 1340 25000 0 0 {name=l20037 lab=BLB7}
N 1360 24960 1340 24960 {}
C {lab_pin.sym} 1340 24960 0 0 {name=l20038 lab=WL125}
N 1440 25040 1460 25040 {}
C {lab_pin.sym} 1460 25040 0 0 {name=l20039 lab=VDD}
N 1440 24960 1460 24960 {}
C {lab_pin.sym} 1460 24960 0 0 {name=l20040 lab=VSS}
C {bitcell_6t.sym} 1600 25000 0 0 {name=Xr125c8}
N 1560 25040 1540 25040 {}
C {lab_pin.sym} 1540 25040 0 0 {name=l20041 lab=BL8}
N 1560 25000 1540 25000 {}
C {lab_pin.sym} 1540 25000 0 0 {name=l20042 lab=BLB8}
N 1560 24960 1540 24960 {}
C {lab_pin.sym} 1540 24960 0 0 {name=l20043 lab=WL125}
N 1640 25040 1660 25040 {}
C {lab_pin.sym} 1660 25040 0 0 {name=l20044 lab=VDD}
N 1640 24960 1660 24960 {}
C {lab_pin.sym} 1660 24960 0 0 {name=l20045 lab=VSS}
C {bitcell_6t.sym} 1800 25000 0 0 {name=Xr125c9}
N 1760 25040 1740 25040 {}
C {lab_pin.sym} 1740 25040 0 0 {name=l20046 lab=BL9}
N 1760 25000 1740 25000 {}
C {lab_pin.sym} 1740 25000 0 0 {name=l20047 lab=BLB9}
N 1760 24960 1740 24960 {}
C {lab_pin.sym} 1740 24960 0 0 {name=l20048 lab=WL125}
N 1840 25040 1860 25040 {}
C {lab_pin.sym} 1860 25040 0 0 {name=l20049 lab=VDD}
N 1840 24960 1860 24960 {}
C {lab_pin.sym} 1860 24960 0 0 {name=l20050 lab=VSS}
C {bitcell_6t.sym} 2000 25000 0 0 {name=Xr125c10}
N 1960 25040 1940 25040 {}
C {lab_pin.sym} 1940 25040 0 0 {name=l20051 lab=BL10}
N 1960 25000 1940 25000 {}
C {lab_pin.sym} 1940 25000 0 0 {name=l20052 lab=BLB10}
N 1960 24960 1940 24960 {}
C {lab_pin.sym} 1940 24960 0 0 {name=l20053 lab=WL125}
N 2040 25040 2060 25040 {}
C {lab_pin.sym} 2060 25040 0 0 {name=l20054 lab=VDD}
N 2040 24960 2060 24960 {}
C {lab_pin.sym} 2060 24960 0 0 {name=l20055 lab=VSS}
C {bitcell_6t.sym} 2200 25000 0 0 {name=Xr125c11}
N 2160 25040 2140 25040 {}
C {lab_pin.sym} 2140 25040 0 0 {name=l20056 lab=BL11}
N 2160 25000 2140 25000 {}
C {lab_pin.sym} 2140 25000 0 0 {name=l20057 lab=BLB11}
N 2160 24960 2140 24960 {}
C {lab_pin.sym} 2140 24960 0 0 {name=l20058 lab=WL125}
N 2240 25040 2260 25040 {}
C {lab_pin.sym} 2260 25040 0 0 {name=l20059 lab=VDD}
N 2240 24960 2260 24960 {}
C {lab_pin.sym} 2260 24960 0 0 {name=l20060 lab=VSS}
C {bitcell_6t.sym} 2400 25000 0 0 {name=Xr125c12}
N 2360 25040 2340 25040 {}
C {lab_pin.sym} 2340 25040 0 0 {name=l20061 lab=BL12}
N 2360 25000 2340 25000 {}
C {lab_pin.sym} 2340 25000 0 0 {name=l20062 lab=BLB12}
N 2360 24960 2340 24960 {}
C {lab_pin.sym} 2340 24960 0 0 {name=l20063 lab=WL125}
N 2440 25040 2460 25040 {}
C {lab_pin.sym} 2460 25040 0 0 {name=l20064 lab=VDD}
N 2440 24960 2460 24960 {}
C {lab_pin.sym} 2460 24960 0 0 {name=l20065 lab=VSS}
C {bitcell_6t.sym} 2600 25000 0 0 {name=Xr125c13}
N 2560 25040 2540 25040 {}
C {lab_pin.sym} 2540 25040 0 0 {name=l20066 lab=BL13}
N 2560 25000 2540 25000 {}
C {lab_pin.sym} 2540 25000 0 0 {name=l20067 lab=BLB13}
N 2560 24960 2540 24960 {}
C {lab_pin.sym} 2540 24960 0 0 {name=l20068 lab=WL125}
N 2640 25040 2660 25040 {}
C {lab_pin.sym} 2660 25040 0 0 {name=l20069 lab=VDD}
N 2640 24960 2660 24960 {}
C {lab_pin.sym} 2660 24960 0 0 {name=l20070 lab=VSS}
C {bitcell_6t.sym} 2800 25000 0 0 {name=Xr125c14}
N 2760 25040 2740 25040 {}
C {lab_pin.sym} 2740 25040 0 0 {name=l20071 lab=BL14}
N 2760 25000 2740 25000 {}
C {lab_pin.sym} 2740 25000 0 0 {name=l20072 lab=BLB14}
N 2760 24960 2740 24960 {}
C {lab_pin.sym} 2740 24960 0 0 {name=l20073 lab=WL125}
N 2840 25040 2860 25040 {}
C {lab_pin.sym} 2860 25040 0 0 {name=l20074 lab=VDD}
N 2840 24960 2860 24960 {}
C {lab_pin.sym} 2860 24960 0 0 {name=l20075 lab=VSS}
C {bitcell_6t.sym} 3000 25000 0 0 {name=Xr125c15}
N 2960 25040 2940 25040 {}
C {lab_pin.sym} 2940 25040 0 0 {name=l20076 lab=BL15}
N 2960 25000 2940 25000 {}
C {lab_pin.sym} 2940 25000 0 0 {name=l20077 lab=BLB15}
N 2960 24960 2940 24960 {}
C {lab_pin.sym} 2940 24960 0 0 {name=l20078 lab=WL125}
N 3040 25040 3060 25040 {}
C {lab_pin.sym} 3060 25040 0 0 {name=l20079 lab=VDD}
N 3040 24960 3060 24960 {}
C {lab_pin.sym} 3060 24960 0 0 {name=l20080 lab=VSS}
C {bitcell_6t.sym} 3200 25000 0 0 {name=Xr125c16}
N 3160 25040 3140 25040 {}
C {lab_pin.sym} 3140 25040 0 0 {name=l20081 lab=BL16}
N 3160 25000 3140 25000 {}
C {lab_pin.sym} 3140 25000 0 0 {name=l20082 lab=BLB16}
N 3160 24960 3140 24960 {}
C {lab_pin.sym} 3140 24960 0 0 {name=l20083 lab=WL125}
N 3240 25040 3260 25040 {}
C {lab_pin.sym} 3260 25040 0 0 {name=l20084 lab=VDD}
N 3240 24960 3260 24960 {}
C {lab_pin.sym} 3260 24960 0 0 {name=l20085 lab=VSS}
C {bitcell_6t.sym} 3400 25000 0 0 {name=Xr125c17}
N 3360 25040 3340 25040 {}
C {lab_pin.sym} 3340 25040 0 0 {name=l20086 lab=BL17}
N 3360 25000 3340 25000 {}
C {lab_pin.sym} 3340 25000 0 0 {name=l20087 lab=BLB17}
N 3360 24960 3340 24960 {}
C {lab_pin.sym} 3340 24960 0 0 {name=l20088 lab=WL125}
N 3440 25040 3460 25040 {}
C {lab_pin.sym} 3460 25040 0 0 {name=l20089 lab=VDD}
N 3440 24960 3460 24960 {}
C {lab_pin.sym} 3460 24960 0 0 {name=l20090 lab=VSS}
C {bitcell_6t.sym} 3600 25000 0 0 {name=Xr125c18}
N 3560 25040 3540 25040 {}
C {lab_pin.sym} 3540 25040 0 0 {name=l20091 lab=BL18}
N 3560 25000 3540 25000 {}
C {lab_pin.sym} 3540 25000 0 0 {name=l20092 lab=BLB18}
N 3560 24960 3540 24960 {}
C {lab_pin.sym} 3540 24960 0 0 {name=l20093 lab=WL125}
N 3640 25040 3660 25040 {}
C {lab_pin.sym} 3660 25040 0 0 {name=l20094 lab=VDD}
N 3640 24960 3660 24960 {}
C {lab_pin.sym} 3660 24960 0 0 {name=l20095 lab=VSS}
C {bitcell_6t.sym} 3800 25000 0 0 {name=Xr125c19}
N 3760 25040 3740 25040 {}
C {lab_pin.sym} 3740 25040 0 0 {name=l20096 lab=BL19}
N 3760 25000 3740 25000 {}
C {lab_pin.sym} 3740 25000 0 0 {name=l20097 lab=BLB19}
N 3760 24960 3740 24960 {}
C {lab_pin.sym} 3740 24960 0 0 {name=l20098 lab=WL125}
N 3840 25040 3860 25040 {}
C {lab_pin.sym} 3860 25040 0 0 {name=l20099 lab=VDD}
N 3840 24960 3860 24960 {}
C {lab_pin.sym} 3860 24960 0 0 {name=l20100 lab=VSS}
C {bitcell_6t.sym} 4000 25000 0 0 {name=Xr125c20}
N 3960 25040 3940 25040 {}
C {lab_pin.sym} 3940 25040 0 0 {name=l20101 lab=BL20}
N 3960 25000 3940 25000 {}
C {lab_pin.sym} 3940 25000 0 0 {name=l20102 lab=BLB20}
N 3960 24960 3940 24960 {}
C {lab_pin.sym} 3940 24960 0 0 {name=l20103 lab=WL125}
N 4040 25040 4060 25040 {}
C {lab_pin.sym} 4060 25040 0 0 {name=l20104 lab=VDD}
N 4040 24960 4060 24960 {}
C {lab_pin.sym} 4060 24960 0 0 {name=l20105 lab=VSS}
C {bitcell_6t.sym} 4200 25000 0 0 {name=Xr125c21}
N 4160 25040 4140 25040 {}
C {lab_pin.sym} 4140 25040 0 0 {name=l20106 lab=BL21}
N 4160 25000 4140 25000 {}
C {lab_pin.sym} 4140 25000 0 0 {name=l20107 lab=BLB21}
N 4160 24960 4140 24960 {}
C {lab_pin.sym} 4140 24960 0 0 {name=l20108 lab=WL125}
N 4240 25040 4260 25040 {}
C {lab_pin.sym} 4260 25040 0 0 {name=l20109 lab=VDD}
N 4240 24960 4260 24960 {}
C {lab_pin.sym} 4260 24960 0 0 {name=l20110 lab=VSS}
C {bitcell_6t.sym} 4400 25000 0 0 {name=Xr125c22}
N 4360 25040 4340 25040 {}
C {lab_pin.sym} 4340 25040 0 0 {name=l20111 lab=BL22}
N 4360 25000 4340 25000 {}
C {lab_pin.sym} 4340 25000 0 0 {name=l20112 lab=BLB22}
N 4360 24960 4340 24960 {}
C {lab_pin.sym} 4340 24960 0 0 {name=l20113 lab=WL125}
N 4440 25040 4460 25040 {}
C {lab_pin.sym} 4460 25040 0 0 {name=l20114 lab=VDD}
N 4440 24960 4460 24960 {}
C {lab_pin.sym} 4460 24960 0 0 {name=l20115 lab=VSS}
C {bitcell_6t.sym} 4600 25000 0 0 {name=Xr125c23}
N 4560 25040 4540 25040 {}
C {lab_pin.sym} 4540 25040 0 0 {name=l20116 lab=BL23}
N 4560 25000 4540 25000 {}
C {lab_pin.sym} 4540 25000 0 0 {name=l20117 lab=BLB23}
N 4560 24960 4540 24960 {}
C {lab_pin.sym} 4540 24960 0 0 {name=l20118 lab=WL125}
N 4640 25040 4660 25040 {}
C {lab_pin.sym} 4660 25040 0 0 {name=l20119 lab=VDD}
N 4640 24960 4660 24960 {}
C {lab_pin.sym} 4660 24960 0 0 {name=l20120 lab=VSS}
C {bitcell_6t.sym} 4800 25000 0 0 {name=Xr125c24}
N 4760 25040 4740 25040 {}
C {lab_pin.sym} 4740 25040 0 0 {name=l20121 lab=BL24}
N 4760 25000 4740 25000 {}
C {lab_pin.sym} 4740 25000 0 0 {name=l20122 lab=BLB24}
N 4760 24960 4740 24960 {}
C {lab_pin.sym} 4740 24960 0 0 {name=l20123 lab=WL125}
N 4840 25040 4860 25040 {}
C {lab_pin.sym} 4860 25040 0 0 {name=l20124 lab=VDD}
N 4840 24960 4860 24960 {}
C {lab_pin.sym} 4860 24960 0 0 {name=l20125 lab=VSS}
C {bitcell_6t.sym} 5000 25000 0 0 {name=Xr125c25}
N 4960 25040 4940 25040 {}
C {lab_pin.sym} 4940 25040 0 0 {name=l20126 lab=BL25}
N 4960 25000 4940 25000 {}
C {lab_pin.sym} 4940 25000 0 0 {name=l20127 lab=BLB25}
N 4960 24960 4940 24960 {}
C {lab_pin.sym} 4940 24960 0 0 {name=l20128 lab=WL125}
N 5040 25040 5060 25040 {}
C {lab_pin.sym} 5060 25040 0 0 {name=l20129 lab=VDD}
N 5040 24960 5060 24960 {}
C {lab_pin.sym} 5060 24960 0 0 {name=l20130 lab=VSS}
C {bitcell_6t.sym} 5200 25000 0 0 {name=Xr125c26}
N 5160 25040 5140 25040 {}
C {lab_pin.sym} 5140 25040 0 0 {name=l20131 lab=BL26}
N 5160 25000 5140 25000 {}
C {lab_pin.sym} 5140 25000 0 0 {name=l20132 lab=BLB26}
N 5160 24960 5140 24960 {}
C {lab_pin.sym} 5140 24960 0 0 {name=l20133 lab=WL125}
N 5240 25040 5260 25040 {}
C {lab_pin.sym} 5260 25040 0 0 {name=l20134 lab=VDD}
N 5240 24960 5260 24960 {}
C {lab_pin.sym} 5260 24960 0 0 {name=l20135 lab=VSS}
C {bitcell_6t.sym} 5400 25000 0 0 {name=Xr125c27}
N 5360 25040 5340 25040 {}
C {lab_pin.sym} 5340 25040 0 0 {name=l20136 lab=BL27}
N 5360 25000 5340 25000 {}
C {lab_pin.sym} 5340 25000 0 0 {name=l20137 lab=BLB27}
N 5360 24960 5340 24960 {}
C {lab_pin.sym} 5340 24960 0 0 {name=l20138 lab=WL125}
N 5440 25040 5460 25040 {}
C {lab_pin.sym} 5460 25040 0 0 {name=l20139 lab=VDD}
N 5440 24960 5460 24960 {}
C {lab_pin.sym} 5460 24960 0 0 {name=l20140 lab=VSS}
C {bitcell_6t.sym} 5600 25000 0 0 {name=Xr125c28}
N 5560 25040 5540 25040 {}
C {lab_pin.sym} 5540 25040 0 0 {name=l20141 lab=BL28}
N 5560 25000 5540 25000 {}
C {lab_pin.sym} 5540 25000 0 0 {name=l20142 lab=BLB28}
N 5560 24960 5540 24960 {}
C {lab_pin.sym} 5540 24960 0 0 {name=l20143 lab=WL125}
N 5640 25040 5660 25040 {}
C {lab_pin.sym} 5660 25040 0 0 {name=l20144 lab=VDD}
N 5640 24960 5660 24960 {}
C {lab_pin.sym} 5660 24960 0 0 {name=l20145 lab=VSS}
C {bitcell_6t.sym} 5800 25000 0 0 {name=Xr125c29}
N 5760 25040 5740 25040 {}
C {lab_pin.sym} 5740 25040 0 0 {name=l20146 lab=BL29}
N 5760 25000 5740 25000 {}
C {lab_pin.sym} 5740 25000 0 0 {name=l20147 lab=BLB29}
N 5760 24960 5740 24960 {}
C {lab_pin.sym} 5740 24960 0 0 {name=l20148 lab=WL125}
N 5840 25040 5860 25040 {}
C {lab_pin.sym} 5860 25040 0 0 {name=l20149 lab=VDD}
N 5840 24960 5860 24960 {}
C {lab_pin.sym} 5860 24960 0 0 {name=l20150 lab=VSS}
C {bitcell_6t.sym} 6000 25000 0 0 {name=Xr125c30}
N 5960 25040 5940 25040 {}
C {lab_pin.sym} 5940 25040 0 0 {name=l20151 lab=BL30}
N 5960 25000 5940 25000 {}
C {lab_pin.sym} 5940 25000 0 0 {name=l20152 lab=BLB30}
N 5960 24960 5940 24960 {}
C {lab_pin.sym} 5940 24960 0 0 {name=l20153 lab=WL125}
N 6040 25040 6060 25040 {}
C {lab_pin.sym} 6060 25040 0 0 {name=l20154 lab=VDD}
N 6040 24960 6060 24960 {}
C {lab_pin.sym} 6060 24960 0 0 {name=l20155 lab=VSS}
C {bitcell_6t.sym} 6200 25000 0 0 {name=Xr125c31}
N 6160 25040 6140 25040 {}
C {lab_pin.sym} 6140 25040 0 0 {name=l20156 lab=BL31}
N 6160 25000 6140 25000 {}
C {lab_pin.sym} 6140 25000 0 0 {name=l20157 lab=BLB31}
N 6160 24960 6140 24960 {}
C {lab_pin.sym} 6140 24960 0 0 {name=l20158 lab=WL125}
N 6240 25040 6260 25040 {}
C {lab_pin.sym} 6260 25040 0 0 {name=l20159 lab=VDD}
N 6240 24960 6260 24960 {}
C {lab_pin.sym} 6260 24960 0 0 {name=l20160 lab=VSS}
C {bitcell_6t.sym} 0 25200 0 0 {name=Xr126c0}
N -40 25240 -60 25240 {}
C {lab_pin.sym} -60 25240 0 0 {name=l20161 lab=BL0}
N -40 25200 -60 25200 {}
C {lab_pin.sym} -60 25200 0 0 {name=l20162 lab=BLB0}
N -40 25160 -60 25160 {}
C {lab_pin.sym} -60 25160 0 0 {name=l20163 lab=WL126}
N 40 25240 60 25240 {}
C {lab_pin.sym} 60 25240 0 0 {name=l20164 lab=VDD}
N 40 25160 60 25160 {}
C {lab_pin.sym} 60 25160 0 0 {name=l20165 lab=VSS}
C {bitcell_6t.sym} 200 25200 0 0 {name=Xr126c1}
N 160 25240 140 25240 {}
C {lab_pin.sym} 140 25240 0 0 {name=l20166 lab=BL1}
N 160 25200 140 25200 {}
C {lab_pin.sym} 140 25200 0 0 {name=l20167 lab=BLB1}
N 160 25160 140 25160 {}
C {lab_pin.sym} 140 25160 0 0 {name=l20168 lab=WL126}
N 240 25240 260 25240 {}
C {lab_pin.sym} 260 25240 0 0 {name=l20169 lab=VDD}
N 240 25160 260 25160 {}
C {lab_pin.sym} 260 25160 0 0 {name=l20170 lab=VSS}
C {bitcell_6t.sym} 400 25200 0 0 {name=Xr126c2}
N 360 25240 340 25240 {}
C {lab_pin.sym} 340 25240 0 0 {name=l20171 lab=BL2}
N 360 25200 340 25200 {}
C {lab_pin.sym} 340 25200 0 0 {name=l20172 lab=BLB2}
N 360 25160 340 25160 {}
C {lab_pin.sym} 340 25160 0 0 {name=l20173 lab=WL126}
N 440 25240 460 25240 {}
C {lab_pin.sym} 460 25240 0 0 {name=l20174 lab=VDD}
N 440 25160 460 25160 {}
C {lab_pin.sym} 460 25160 0 0 {name=l20175 lab=VSS}
C {bitcell_6t.sym} 600 25200 0 0 {name=Xr126c3}
N 560 25240 540 25240 {}
C {lab_pin.sym} 540 25240 0 0 {name=l20176 lab=BL3}
N 560 25200 540 25200 {}
C {lab_pin.sym} 540 25200 0 0 {name=l20177 lab=BLB3}
N 560 25160 540 25160 {}
C {lab_pin.sym} 540 25160 0 0 {name=l20178 lab=WL126}
N 640 25240 660 25240 {}
C {lab_pin.sym} 660 25240 0 0 {name=l20179 lab=VDD}
N 640 25160 660 25160 {}
C {lab_pin.sym} 660 25160 0 0 {name=l20180 lab=VSS}
C {bitcell_6t.sym} 800 25200 0 0 {name=Xr126c4}
N 760 25240 740 25240 {}
C {lab_pin.sym} 740 25240 0 0 {name=l20181 lab=BL4}
N 760 25200 740 25200 {}
C {lab_pin.sym} 740 25200 0 0 {name=l20182 lab=BLB4}
N 760 25160 740 25160 {}
C {lab_pin.sym} 740 25160 0 0 {name=l20183 lab=WL126}
N 840 25240 860 25240 {}
C {lab_pin.sym} 860 25240 0 0 {name=l20184 lab=VDD}
N 840 25160 860 25160 {}
C {lab_pin.sym} 860 25160 0 0 {name=l20185 lab=VSS}
C {bitcell_6t.sym} 1000 25200 0 0 {name=Xr126c5}
N 960 25240 940 25240 {}
C {lab_pin.sym} 940 25240 0 0 {name=l20186 lab=BL5}
N 960 25200 940 25200 {}
C {lab_pin.sym} 940 25200 0 0 {name=l20187 lab=BLB5}
N 960 25160 940 25160 {}
C {lab_pin.sym} 940 25160 0 0 {name=l20188 lab=WL126}
N 1040 25240 1060 25240 {}
C {lab_pin.sym} 1060 25240 0 0 {name=l20189 lab=VDD}
N 1040 25160 1060 25160 {}
C {lab_pin.sym} 1060 25160 0 0 {name=l20190 lab=VSS}
C {bitcell_6t.sym} 1200 25200 0 0 {name=Xr126c6}
N 1160 25240 1140 25240 {}
C {lab_pin.sym} 1140 25240 0 0 {name=l20191 lab=BL6}
N 1160 25200 1140 25200 {}
C {lab_pin.sym} 1140 25200 0 0 {name=l20192 lab=BLB6}
N 1160 25160 1140 25160 {}
C {lab_pin.sym} 1140 25160 0 0 {name=l20193 lab=WL126}
N 1240 25240 1260 25240 {}
C {lab_pin.sym} 1260 25240 0 0 {name=l20194 lab=VDD}
N 1240 25160 1260 25160 {}
C {lab_pin.sym} 1260 25160 0 0 {name=l20195 lab=VSS}
C {bitcell_6t.sym} 1400 25200 0 0 {name=Xr126c7}
N 1360 25240 1340 25240 {}
C {lab_pin.sym} 1340 25240 0 0 {name=l20196 lab=BL7}
N 1360 25200 1340 25200 {}
C {lab_pin.sym} 1340 25200 0 0 {name=l20197 lab=BLB7}
N 1360 25160 1340 25160 {}
C {lab_pin.sym} 1340 25160 0 0 {name=l20198 lab=WL126}
N 1440 25240 1460 25240 {}
C {lab_pin.sym} 1460 25240 0 0 {name=l20199 lab=VDD}
N 1440 25160 1460 25160 {}
C {lab_pin.sym} 1460 25160 0 0 {name=l20200 lab=VSS}
C {bitcell_6t.sym} 1600 25200 0 0 {name=Xr126c8}
N 1560 25240 1540 25240 {}
C {lab_pin.sym} 1540 25240 0 0 {name=l20201 lab=BL8}
N 1560 25200 1540 25200 {}
C {lab_pin.sym} 1540 25200 0 0 {name=l20202 lab=BLB8}
N 1560 25160 1540 25160 {}
C {lab_pin.sym} 1540 25160 0 0 {name=l20203 lab=WL126}
N 1640 25240 1660 25240 {}
C {lab_pin.sym} 1660 25240 0 0 {name=l20204 lab=VDD}
N 1640 25160 1660 25160 {}
C {lab_pin.sym} 1660 25160 0 0 {name=l20205 lab=VSS}
C {bitcell_6t.sym} 1800 25200 0 0 {name=Xr126c9}
N 1760 25240 1740 25240 {}
C {lab_pin.sym} 1740 25240 0 0 {name=l20206 lab=BL9}
N 1760 25200 1740 25200 {}
C {lab_pin.sym} 1740 25200 0 0 {name=l20207 lab=BLB9}
N 1760 25160 1740 25160 {}
C {lab_pin.sym} 1740 25160 0 0 {name=l20208 lab=WL126}
N 1840 25240 1860 25240 {}
C {lab_pin.sym} 1860 25240 0 0 {name=l20209 lab=VDD}
N 1840 25160 1860 25160 {}
C {lab_pin.sym} 1860 25160 0 0 {name=l20210 lab=VSS}
C {bitcell_6t.sym} 2000 25200 0 0 {name=Xr126c10}
N 1960 25240 1940 25240 {}
C {lab_pin.sym} 1940 25240 0 0 {name=l20211 lab=BL10}
N 1960 25200 1940 25200 {}
C {lab_pin.sym} 1940 25200 0 0 {name=l20212 lab=BLB10}
N 1960 25160 1940 25160 {}
C {lab_pin.sym} 1940 25160 0 0 {name=l20213 lab=WL126}
N 2040 25240 2060 25240 {}
C {lab_pin.sym} 2060 25240 0 0 {name=l20214 lab=VDD}
N 2040 25160 2060 25160 {}
C {lab_pin.sym} 2060 25160 0 0 {name=l20215 lab=VSS}
C {bitcell_6t.sym} 2200 25200 0 0 {name=Xr126c11}
N 2160 25240 2140 25240 {}
C {lab_pin.sym} 2140 25240 0 0 {name=l20216 lab=BL11}
N 2160 25200 2140 25200 {}
C {lab_pin.sym} 2140 25200 0 0 {name=l20217 lab=BLB11}
N 2160 25160 2140 25160 {}
C {lab_pin.sym} 2140 25160 0 0 {name=l20218 lab=WL126}
N 2240 25240 2260 25240 {}
C {lab_pin.sym} 2260 25240 0 0 {name=l20219 lab=VDD}
N 2240 25160 2260 25160 {}
C {lab_pin.sym} 2260 25160 0 0 {name=l20220 lab=VSS}
C {bitcell_6t.sym} 2400 25200 0 0 {name=Xr126c12}
N 2360 25240 2340 25240 {}
C {lab_pin.sym} 2340 25240 0 0 {name=l20221 lab=BL12}
N 2360 25200 2340 25200 {}
C {lab_pin.sym} 2340 25200 0 0 {name=l20222 lab=BLB12}
N 2360 25160 2340 25160 {}
C {lab_pin.sym} 2340 25160 0 0 {name=l20223 lab=WL126}
N 2440 25240 2460 25240 {}
C {lab_pin.sym} 2460 25240 0 0 {name=l20224 lab=VDD}
N 2440 25160 2460 25160 {}
C {lab_pin.sym} 2460 25160 0 0 {name=l20225 lab=VSS}
C {bitcell_6t.sym} 2600 25200 0 0 {name=Xr126c13}
N 2560 25240 2540 25240 {}
C {lab_pin.sym} 2540 25240 0 0 {name=l20226 lab=BL13}
N 2560 25200 2540 25200 {}
C {lab_pin.sym} 2540 25200 0 0 {name=l20227 lab=BLB13}
N 2560 25160 2540 25160 {}
C {lab_pin.sym} 2540 25160 0 0 {name=l20228 lab=WL126}
N 2640 25240 2660 25240 {}
C {lab_pin.sym} 2660 25240 0 0 {name=l20229 lab=VDD}
N 2640 25160 2660 25160 {}
C {lab_pin.sym} 2660 25160 0 0 {name=l20230 lab=VSS}
C {bitcell_6t.sym} 2800 25200 0 0 {name=Xr126c14}
N 2760 25240 2740 25240 {}
C {lab_pin.sym} 2740 25240 0 0 {name=l20231 lab=BL14}
N 2760 25200 2740 25200 {}
C {lab_pin.sym} 2740 25200 0 0 {name=l20232 lab=BLB14}
N 2760 25160 2740 25160 {}
C {lab_pin.sym} 2740 25160 0 0 {name=l20233 lab=WL126}
N 2840 25240 2860 25240 {}
C {lab_pin.sym} 2860 25240 0 0 {name=l20234 lab=VDD}
N 2840 25160 2860 25160 {}
C {lab_pin.sym} 2860 25160 0 0 {name=l20235 lab=VSS}
C {bitcell_6t.sym} 3000 25200 0 0 {name=Xr126c15}
N 2960 25240 2940 25240 {}
C {lab_pin.sym} 2940 25240 0 0 {name=l20236 lab=BL15}
N 2960 25200 2940 25200 {}
C {lab_pin.sym} 2940 25200 0 0 {name=l20237 lab=BLB15}
N 2960 25160 2940 25160 {}
C {lab_pin.sym} 2940 25160 0 0 {name=l20238 lab=WL126}
N 3040 25240 3060 25240 {}
C {lab_pin.sym} 3060 25240 0 0 {name=l20239 lab=VDD}
N 3040 25160 3060 25160 {}
C {lab_pin.sym} 3060 25160 0 0 {name=l20240 lab=VSS}
C {bitcell_6t.sym} 3200 25200 0 0 {name=Xr126c16}
N 3160 25240 3140 25240 {}
C {lab_pin.sym} 3140 25240 0 0 {name=l20241 lab=BL16}
N 3160 25200 3140 25200 {}
C {lab_pin.sym} 3140 25200 0 0 {name=l20242 lab=BLB16}
N 3160 25160 3140 25160 {}
C {lab_pin.sym} 3140 25160 0 0 {name=l20243 lab=WL126}
N 3240 25240 3260 25240 {}
C {lab_pin.sym} 3260 25240 0 0 {name=l20244 lab=VDD}
N 3240 25160 3260 25160 {}
C {lab_pin.sym} 3260 25160 0 0 {name=l20245 lab=VSS}
C {bitcell_6t.sym} 3400 25200 0 0 {name=Xr126c17}
N 3360 25240 3340 25240 {}
C {lab_pin.sym} 3340 25240 0 0 {name=l20246 lab=BL17}
N 3360 25200 3340 25200 {}
C {lab_pin.sym} 3340 25200 0 0 {name=l20247 lab=BLB17}
N 3360 25160 3340 25160 {}
C {lab_pin.sym} 3340 25160 0 0 {name=l20248 lab=WL126}
N 3440 25240 3460 25240 {}
C {lab_pin.sym} 3460 25240 0 0 {name=l20249 lab=VDD}
N 3440 25160 3460 25160 {}
C {lab_pin.sym} 3460 25160 0 0 {name=l20250 lab=VSS}
C {bitcell_6t.sym} 3600 25200 0 0 {name=Xr126c18}
N 3560 25240 3540 25240 {}
C {lab_pin.sym} 3540 25240 0 0 {name=l20251 lab=BL18}
N 3560 25200 3540 25200 {}
C {lab_pin.sym} 3540 25200 0 0 {name=l20252 lab=BLB18}
N 3560 25160 3540 25160 {}
C {lab_pin.sym} 3540 25160 0 0 {name=l20253 lab=WL126}
N 3640 25240 3660 25240 {}
C {lab_pin.sym} 3660 25240 0 0 {name=l20254 lab=VDD}
N 3640 25160 3660 25160 {}
C {lab_pin.sym} 3660 25160 0 0 {name=l20255 lab=VSS}
C {bitcell_6t.sym} 3800 25200 0 0 {name=Xr126c19}
N 3760 25240 3740 25240 {}
C {lab_pin.sym} 3740 25240 0 0 {name=l20256 lab=BL19}
N 3760 25200 3740 25200 {}
C {lab_pin.sym} 3740 25200 0 0 {name=l20257 lab=BLB19}
N 3760 25160 3740 25160 {}
C {lab_pin.sym} 3740 25160 0 0 {name=l20258 lab=WL126}
N 3840 25240 3860 25240 {}
C {lab_pin.sym} 3860 25240 0 0 {name=l20259 lab=VDD}
N 3840 25160 3860 25160 {}
C {lab_pin.sym} 3860 25160 0 0 {name=l20260 lab=VSS}
C {bitcell_6t.sym} 4000 25200 0 0 {name=Xr126c20}
N 3960 25240 3940 25240 {}
C {lab_pin.sym} 3940 25240 0 0 {name=l20261 lab=BL20}
N 3960 25200 3940 25200 {}
C {lab_pin.sym} 3940 25200 0 0 {name=l20262 lab=BLB20}
N 3960 25160 3940 25160 {}
C {lab_pin.sym} 3940 25160 0 0 {name=l20263 lab=WL126}
N 4040 25240 4060 25240 {}
C {lab_pin.sym} 4060 25240 0 0 {name=l20264 lab=VDD}
N 4040 25160 4060 25160 {}
C {lab_pin.sym} 4060 25160 0 0 {name=l20265 lab=VSS}
C {bitcell_6t.sym} 4200 25200 0 0 {name=Xr126c21}
N 4160 25240 4140 25240 {}
C {lab_pin.sym} 4140 25240 0 0 {name=l20266 lab=BL21}
N 4160 25200 4140 25200 {}
C {lab_pin.sym} 4140 25200 0 0 {name=l20267 lab=BLB21}
N 4160 25160 4140 25160 {}
C {lab_pin.sym} 4140 25160 0 0 {name=l20268 lab=WL126}
N 4240 25240 4260 25240 {}
C {lab_pin.sym} 4260 25240 0 0 {name=l20269 lab=VDD}
N 4240 25160 4260 25160 {}
C {lab_pin.sym} 4260 25160 0 0 {name=l20270 lab=VSS}
C {bitcell_6t.sym} 4400 25200 0 0 {name=Xr126c22}
N 4360 25240 4340 25240 {}
C {lab_pin.sym} 4340 25240 0 0 {name=l20271 lab=BL22}
N 4360 25200 4340 25200 {}
C {lab_pin.sym} 4340 25200 0 0 {name=l20272 lab=BLB22}
N 4360 25160 4340 25160 {}
C {lab_pin.sym} 4340 25160 0 0 {name=l20273 lab=WL126}
N 4440 25240 4460 25240 {}
C {lab_pin.sym} 4460 25240 0 0 {name=l20274 lab=VDD}
N 4440 25160 4460 25160 {}
C {lab_pin.sym} 4460 25160 0 0 {name=l20275 lab=VSS}
C {bitcell_6t.sym} 4600 25200 0 0 {name=Xr126c23}
N 4560 25240 4540 25240 {}
C {lab_pin.sym} 4540 25240 0 0 {name=l20276 lab=BL23}
N 4560 25200 4540 25200 {}
C {lab_pin.sym} 4540 25200 0 0 {name=l20277 lab=BLB23}
N 4560 25160 4540 25160 {}
C {lab_pin.sym} 4540 25160 0 0 {name=l20278 lab=WL126}
N 4640 25240 4660 25240 {}
C {lab_pin.sym} 4660 25240 0 0 {name=l20279 lab=VDD}
N 4640 25160 4660 25160 {}
C {lab_pin.sym} 4660 25160 0 0 {name=l20280 lab=VSS}
C {bitcell_6t.sym} 4800 25200 0 0 {name=Xr126c24}
N 4760 25240 4740 25240 {}
C {lab_pin.sym} 4740 25240 0 0 {name=l20281 lab=BL24}
N 4760 25200 4740 25200 {}
C {lab_pin.sym} 4740 25200 0 0 {name=l20282 lab=BLB24}
N 4760 25160 4740 25160 {}
C {lab_pin.sym} 4740 25160 0 0 {name=l20283 lab=WL126}
N 4840 25240 4860 25240 {}
C {lab_pin.sym} 4860 25240 0 0 {name=l20284 lab=VDD}
N 4840 25160 4860 25160 {}
C {lab_pin.sym} 4860 25160 0 0 {name=l20285 lab=VSS}
C {bitcell_6t.sym} 5000 25200 0 0 {name=Xr126c25}
N 4960 25240 4940 25240 {}
C {lab_pin.sym} 4940 25240 0 0 {name=l20286 lab=BL25}
N 4960 25200 4940 25200 {}
C {lab_pin.sym} 4940 25200 0 0 {name=l20287 lab=BLB25}
N 4960 25160 4940 25160 {}
C {lab_pin.sym} 4940 25160 0 0 {name=l20288 lab=WL126}
N 5040 25240 5060 25240 {}
C {lab_pin.sym} 5060 25240 0 0 {name=l20289 lab=VDD}
N 5040 25160 5060 25160 {}
C {lab_pin.sym} 5060 25160 0 0 {name=l20290 lab=VSS}
C {bitcell_6t.sym} 5200 25200 0 0 {name=Xr126c26}
N 5160 25240 5140 25240 {}
C {lab_pin.sym} 5140 25240 0 0 {name=l20291 lab=BL26}
N 5160 25200 5140 25200 {}
C {lab_pin.sym} 5140 25200 0 0 {name=l20292 lab=BLB26}
N 5160 25160 5140 25160 {}
C {lab_pin.sym} 5140 25160 0 0 {name=l20293 lab=WL126}
N 5240 25240 5260 25240 {}
C {lab_pin.sym} 5260 25240 0 0 {name=l20294 lab=VDD}
N 5240 25160 5260 25160 {}
C {lab_pin.sym} 5260 25160 0 0 {name=l20295 lab=VSS}
C {bitcell_6t.sym} 5400 25200 0 0 {name=Xr126c27}
N 5360 25240 5340 25240 {}
C {lab_pin.sym} 5340 25240 0 0 {name=l20296 lab=BL27}
N 5360 25200 5340 25200 {}
C {lab_pin.sym} 5340 25200 0 0 {name=l20297 lab=BLB27}
N 5360 25160 5340 25160 {}
C {lab_pin.sym} 5340 25160 0 0 {name=l20298 lab=WL126}
N 5440 25240 5460 25240 {}
C {lab_pin.sym} 5460 25240 0 0 {name=l20299 lab=VDD}
N 5440 25160 5460 25160 {}
C {lab_pin.sym} 5460 25160 0 0 {name=l20300 lab=VSS}
C {bitcell_6t.sym} 5600 25200 0 0 {name=Xr126c28}
N 5560 25240 5540 25240 {}
C {lab_pin.sym} 5540 25240 0 0 {name=l20301 lab=BL28}
N 5560 25200 5540 25200 {}
C {lab_pin.sym} 5540 25200 0 0 {name=l20302 lab=BLB28}
N 5560 25160 5540 25160 {}
C {lab_pin.sym} 5540 25160 0 0 {name=l20303 lab=WL126}
N 5640 25240 5660 25240 {}
C {lab_pin.sym} 5660 25240 0 0 {name=l20304 lab=VDD}
N 5640 25160 5660 25160 {}
C {lab_pin.sym} 5660 25160 0 0 {name=l20305 lab=VSS}
C {bitcell_6t.sym} 5800 25200 0 0 {name=Xr126c29}
N 5760 25240 5740 25240 {}
C {lab_pin.sym} 5740 25240 0 0 {name=l20306 lab=BL29}
N 5760 25200 5740 25200 {}
C {lab_pin.sym} 5740 25200 0 0 {name=l20307 lab=BLB29}
N 5760 25160 5740 25160 {}
C {lab_pin.sym} 5740 25160 0 0 {name=l20308 lab=WL126}
N 5840 25240 5860 25240 {}
C {lab_pin.sym} 5860 25240 0 0 {name=l20309 lab=VDD}
N 5840 25160 5860 25160 {}
C {lab_pin.sym} 5860 25160 0 0 {name=l20310 lab=VSS}
C {bitcell_6t.sym} 6000 25200 0 0 {name=Xr126c30}
N 5960 25240 5940 25240 {}
C {lab_pin.sym} 5940 25240 0 0 {name=l20311 lab=BL30}
N 5960 25200 5940 25200 {}
C {lab_pin.sym} 5940 25200 0 0 {name=l20312 lab=BLB30}
N 5960 25160 5940 25160 {}
C {lab_pin.sym} 5940 25160 0 0 {name=l20313 lab=WL126}
N 6040 25240 6060 25240 {}
C {lab_pin.sym} 6060 25240 0 0 {name=l20314 lab=VDD}
N 6040 25160 6060 25160 {}
C {lab_pin.sym} 6060 25160 0 0 {name=l20315 lab=VSS}
C {bitcell_6t.sym} 6200 25200 0 0 {name=Xr126c31}
N 6160 25240 6140 25240 {}
C {lab_pin.sym} 6140 25240 0 0 {name=l20316 lab=BL31}
N 6160 25200 6140 25200 {}
C {lab_pin.sym} 6140 25200 0 0 {name=l20317 lab=BLB31}
N 6160 25160 6140 25160 {}
C {lab_pin.sym} 6140 25160 0 0 {name=l20318 lab=WL126}
N 6240 25240 6260 25240 {}
C {lab_pin.sym} 6260 25240 0 0 {name=l20319 lab=VDD}
N 6240 25160 6260 25160 {}
C {lab_pin.sym} 6260 25160 0 0 {name=l20320 lab=VSS}
C {bitcell_6t.sym} 0 25400 0 0 {name=Xr127c0}
N -40 25440 -60 25440 {}
C {lab_pin.sym} -60 25440 0 0 {name=l20321 lab=BL0}
N -40 25400 -60 25400 {}
C {lab_pin.sym} -60 25400 0 0 {name=l20322 lab=BLB0}
N -40 25360 -60 25360 {}
C {lab_pin.sym} -60 25360 0 0 {name=l20323 lab=WL127}
N 40 25440 60 25440 {}
C {lab_pin.sym} 60 25440 0 0 {name=l20324 lab=VDD}
N 40 25360 60 25360 {}
C {lab_pin.sym} 60 25360 0 0 {name=l20325 lab=VSS}
C {bitcell_6t.sym} 200 25400 0 0 {name=Xr127c1}
N 160 25440 140 25440 {}
C {lab_pin.sym} 140 25440 0 0 {name=l20326 lab=BL1}
N 160 25400 140 25400 {}
C {lab_pin.sym} 140 25400 0 0 {name=l20327 lab=BLB1}
N 160 25360 140 25360 {}
C {lab_pin.sym} 140 25360 0 0 {name=l20328 lab=WL127}
N 240 25440 260 25440 {}
C {lab_pin.sym} 260 25440 0 0 {name=l20329 lab=VDD}
N 240 25360 260 25360 {}
C {lab_pin.sym} 260 25360 0 0 {name=l20330 lab=VSS}
C {bitcell_6t.sym} 400 25400 0 0 {name=Xr127c2}
N 360 25440 340 25440 {}
C {lab_pin.sym} 340 25440 0 0 {name=l20331 lab=BL2}
N 360 25400 340 25400 {}
C {lab_pin.sym} 340 25400 0 0 {name=l20332 lab=BLB2}
N 360 25360 340 25360 {}
C {lab_pin.sym} 340 25360 0 0 {name=l20333 lab=WL127}
N 440 25440 460 25440 {}
C {lab_pin.sym} 460 25440 0 0 {name=l20334 lab=VDD}
N 440 25360 460 25360 {}
C {lab_pin.sym} 460 25360 0 0 {name=l20335 lab=VSS}
C {bitcell_6t.sym} 600 25400 0 0 {name=Xr127c3}
N 560 25440 540 25440 {}
C {lab_pin.sym} 540 25440 0 0 {name=l20336 lab=BL3}
N 560 25400 540 25400 {}
C {lab_pin.sym} 540 25400 0 0 {name=l20337 lab=BLB3}
N 560 25360 540 25360 {}
C {lab_pin.sym} 540 25360 0 0 {name=l20338 lab=WL127}
N 640 25440 660 25440 {}
C {lab_pin.sym} 660 25440 0 0 {name=l20339 lab=VDD}
N 640 25360 660 25360 {}
C {lab_pin.sym} 660 25360 0 0 {name=l20340 lab=VSS}
C {bitcell_6t.sym} 800 25400 0 0 {name=Xr127c4}
N 760 25440 740 25440 {}
C {lab_pin.sym} 740 25440 0 0 {name=l20341 lab=BL4}
N 760 25400 740 25400 {}
C {lab_pin.sym} 740 25400 0 0 {name=l20342 lab=BLB4}
N 760 25360 740 25360 {}
C {lab_pin.sym} 740 25360 0 0 {name=l20343 lab=WL127}
N 840 25440 860 25440 {}
C {lab_pin.sym} 860 25440 0 0 {name=l20344 lab=VDD}
N 840 25360 860 25360 {}
C {lab_pin.sym} 860 25360 0 0 {name=l20345 lab=VSS}
C {bitcell_6t.sym} 1000 25400 0 0 {name=Xr127c5}
N 960 25440 940 25440 {}
C {lab_pin.sym} 940 25440 0 0 {name=l20346 lab=BL5}
N 960 25400 940 25400 {}
C {lab_pin.sym} 940 25400 0 0 {name=l20347 lab=BLB5}
N 960 25360 940 25360 {}
C {lab_pin.sym} 940 25360 0 0 {name=l20348 lab=WL127}
N 1040 25440 1060 25440 {}
C {lab_pin.sym} 1060 25440 0 0 {name=l20349 lab=VDD}
N 1040 25360 1060 25360 {}
C {lab_pin.sym} 1060 25360 0 0 {name=l20350 lab=VSS}
C {bitcell_6t.sym} 1200 25400 0 0 {name=Xr127c6}
N 1160 25440 1140 25440 {}
C {lab_pin.sym} 1140 25440 0 0 {name=l20351 lab=BL6}
N 1160 25400 1140 25400 {}
C {lab_pin.sym} 1140 25400 0 0 {name=l20352 lab=BLB6}
N 1160 25360 1140 25360 {}
C {lab_pin.sym} 1140 25360 0 0 {name=l20353 lab=WL127}
N 1240 25440 1260 25440 {}
C {lab_pin.sym} 1260 25440 0 0 {name=l20354 lab=VDD}
N 1240 25360 1260 25360 {}
C {lab_pin.sym} 1260 25360 0 0 {name=l20355 lab=VSS}
C {bitcell_6t.sym} 1400 25400 0 0 {name=Xr127c7}
N 1360 25440 1340 25440 {}
C {lab_pin.sym} 1340 25440 0 0 {name=l20356 lab=BL7}
N 1360 25400 1340 25400 {}
C {lab_pin.sym} 1340 25400 0 0 {name=l20357 lab=BLB7}
N 1360 25360 1340 25360 {}
C {lab_pin.sym} 1340 25360 0 0 {name=l20358 lab=WL127}
N 1440 25440 1460 25440 {}
C {lab_pin.sym} 1460 25440 0 0 {name=l20359 lab=VDD}
N 1440 25360 1460 25360 {}
C {lab_pin.sym} 1460 25360 0 0 {name=l20360 lab=VSS}
C {bitcell_6t.sym} 1600 25400 0 0 {name=Xr127c8}
N 1560 25440 1540 25440 {}
C {lab_pin.sym} 1540 25440 0 0 {name=l20361 lab=BL8}
N 1560 25400 1540 25400 {}
C {lab_pin.sym} 1540 25400 0 0 {name=l20362 lab=BLB8}
N 1560 25360 1540 25360 {}
C {lab_pin.sym} 1540 25360 0 0 {name=l20363 lab=WL127}
N 1640 25440 1660 25440 {}
C {lab_pin.sym} 1660 25440 0 0 {name=l20364 lab=VDD}
N 1640 25360 1660 25360 {}
C {lab_pin.sym} 1660 25360 0 0 {name=l20365 lab=VSS}
C {bitcell_6t.sym} 1800 25400 0 0 {name=Xr127c9}
N 1760 25440 1740 25440 {}
C {lab_pin.sym} 1740 25440 0 0 {name=l20366 lab=BL9}
N 1760 25400 1740 25400 {}
C {lab_pin.sym} 1740 25400 0 0 {name=l20367 lab=BLB9}
N 1760 25360 1740 25360 {}
C {lab_pin.sym} 1740 25360 0 0 {name=l20368 lab=WL127}
N 1840 25440 1860 25440 {}
C {lab_pin.sym} 1860 25440 0 0 {name=l20369 lab=VDD}
N 1840 25360 1860 25360 {}
C {lab_pin.sym} 1860 25360 0 0 {name=l20370 lab=VSS}
C {bitcell_6t.sym} 2000 25400 0 0 {name=Xr127c10}
N 1960 25440 1940 25440 {}
C {lab_pin.sym} 1940 25440 0 0 {name=l20371 lab=BL10}
N 1960 25400 1940 25400 {}
C {lab_pin.sym} 1940 25400 0 0 {name=l20372 lab=BLB10}
N 1960 25360 1940 25360 {}
C {lab_pin.sym} 1940 25360 0 0 {name=l20373 lab=WL127}
N 2040 25440 2060 25440 {}
C {lab_pin.sym} 2060 25440 0 0 {name=l20374 lab=VDD}
N 2040 25360 2060 25360 {}
C {lab_pin.sym} 2060 25360 0 0 {name=l20375 lab=VSS}
C {bitcell_6t.sym} 2200 25400 0 0 {name=Xr127c11}
N 2160 25440 2140 25440 {}
C {lab_pin.sym} 2140 25440 0 0 {name=l20376 lab=BL11}
N 2160 25400 2140 25400 {}
C {lab_pin.sym} 2140 25400 0 0 {name=l20377 lab=BLB11}
N 2160 25360 2140 25360 {}
C {lab_pin.sym} 2140 25360 0 0 {name=l20378 lab=WL127}
N 2240 25440 2260 25440 {}
C {lab_pin.sym} 2260 25440 0 0 {name=l20379 lab=VDD}
N 2240 25360 2260 25360 {}
C {lab_pin.sym} 2260 25360 0 0 {name=l20380 lab=VSS}
C {bitcell_6t.sym} 2400 25400 0 0 {name=Xr127c12}
N 2360 25440 2340 25440 {}
C {lab_pin.sym} 2340 25440 0 0 {name=l20381 lab=BL12}
N 2360 25400 2340 25400 {}
C {lab_pin.sym} 2340 25400 0 0 {name=l20382 lab=BLB12}
N 2360 25360 2340 25360 {}
C {lab_pin.sym} 2340 25360 0 0 {name=l20383 lab=WL127}
N 2440 25440 2460 25440 {}
C {lab_pin.sym} 2460 25440 0 0 {name=l20384 lab=VDD}
N 2440 25360 2460 25360 {}
C {lab_pin.sym} 2460 25360 0 0 {name=l20385 lab=VSS}
C {bitcell_6t.sym} 2600 25400 0 0 {name=Xr127c13}
N 2560 25440 2540 25440 {}
C {lab_pin.sym} 2540 25440 0 0 {name=l20386 lab=BL13}
N 2560 25400 2540 25400 {}
C {lab_pin.sym} 2540 25400 0 0 {name=l20387 lab=BLB13}
N 2560 25360 2540 25360 {}
C {lab_pin.sym} 2540 25360 0 0 {name=l20388 lab=WL127}
N 2640 25440 2660 25440 {}
C {lab_pin.sym} 2660 25440 0 0 {name=l20389 lab=VDD}
N 2640 25360 2660 25360 {}
C {lab_pin.sym} 2660 25360 0 0 {name=l20390 lab=VSS}
C {bitcell_6t.sym} 2800 25400 0 0 {name=Xr127c14}
N 2760 25440 2740 25440 {}
C {lab_pin.sym} 2740 25440 0 0 {name=l20391 lab=BL14}
N 2760 25400 2740 25400 {}
C {lab_pin.sym} 2740 25400 0 0 {name=l20392 lab=BLB14}
N 2760 25360 2740 25360 {}
C {lab_pin.sym} 2740 25360 0 0 {name=l20393 lab=WL127}
N 2840 25440 2860 25440 {}
C {lab_pin.sym} 2860 25440 0 0 {name=l20394 lab=VDD}
N 2840 25360 2860 25360 {}
C {lab_pin.sym} 2860 25360 0 0 {name=l20395 lab=VSS}
C {bitcell_6t.sym} 3000 25400 0 0 {name=Xr127c15}
N 2960 25440 2940 25440 {}
C {lab_pin.sym} 2940 25440 0 0 {name=l20396 lab=BL15}
N 2960 25400 2940 25400 {}
C {lab_pin.sym} 2940 25400 0 0 {name=l20397 lab=BLB15}
N 2960 25360 2940 25360 {}
C {lab_pin.sym} 2940 25360 0 0 {name=l20398 lab=WL127}
N 3040 25440 3060 25440 {}
C {lab_pin.sym} 3060 25440 0 0 {name=l20399 lab=VDD}
N 3040 25360 3060 25360 {}
C {lab_pin.sym} 3060 25360 0 0 {name=l20400 lab=VSS}
C {bitcell_6t.sym} 3200 25400 0 0 {name=Xr127c16}
N 3160 25440 3140 25440 {}
C {lab_pin.sym} 3140 25440 0 0 {name=l20401 lab=BL16}
N 3160 25400 3140 25400 {}
C {lab_pin.sym} 3140 25400 0 0 {name=l20402 lab=BLB16}
N 3160 25360 3140 25360 {}
C {lab_pin.sym} 3140 25360 0 0 {name=l20403 lab=WL127}
N 3240 25440 3260 25440 {}
C {lab_pin.sym} 3260 25440 0 0 {name=l20404 lab=VDD}
N 3240 25360 3260 25360 {}
C {lab_pin.sym} 3260 25360 0 0 {name=l20405 lab=VSS}
C {bitcell_6t.sym} 3400 25400 0 0 {name=Xr127c17}
N 3360 25440 3340 25440 {}
C {lab_pin.sym} 3340 25440 0 0 {name=l20406 lab=BL17}
N 3360 25400 3340 25400 {}
C {lab_pin.sym} 3340 25400 0 0 {name=l20407 lab=BLB17}
N 3360 25360 3340 25360 {}
C {lab_pin.sym} 3340 25360 0 0 {name=l20408 lab=WL127}
N 3440 25440 3460 25440 {}
C {lab_pin.sym} 3460 25440 0 0 {name=l20409 lab=VDD}
N 3440 25360 3460 25360 {}
C {lab_pin.sym} 3460 25360 0 0 {name=l20410 lab=VSS}
C {bitcell_6t.sym} 3600 25400 0 0 {name=Xr127c18}
N 3560 25440 3540 25440 {}
C {lab_pin.sym} 3540 25440 0 0 {name=l20411 lab=BL18}
N 3560 25400 3540 25400 {}
C {lab_pin.sym} 3540 25400 0 0 {name=l20412 lab=BLB18}
N 3560 25360 3540 25360 {}
C {lab_pin.sym} 3540 25360 0 0 {name=l20413 lab=WL127}
N 3640 25440 3660 25440 {}
C {lab_pin.sym} 3660 25440 0 0 {name=l20414 lab=VDD}
N 3640 25360 3660 25360 {}
C {lab_pin.sym} 3660 25360 0 0 {name=l20415 lab=VSS}
C {bitcell_6t.sym} 3800 25400 0 0 {name=Xr127c19}
N 3760 25440 3740 25440 {}
C {lab_pin.sym} 3740 25440 0 0 {name=l20416 lab=BL19}
N 3760 25400 3740 25400 {}
C {lab_pin.sym} 3740 25400 0 0 {name=l20417 lab=BLB19}
N 3760 25360 3740 25360 {}
C {lab_pin.sym} 3740 25360 0 0 {name=l20418 lab=WL127}
N 3840 25440 3860 25440 {}
C {lab_pin.sym} 3860 25440 0 0 {name=l20419 lab=VDD}
N 3840 25360 3860 25360 {}
C {lab_pin.sym} 3860 25360 0 0 {name=l20420 lab=VSS}
C {bitcell_6t.sym} 4000 25400 0 0 {name=Xr127c20}
N 3960 25440 3940 25440 {}
C {lab_pin.sym} 3940 25440 0 0 {name=l20421 lab=BL20}
N 3960 25400 3940 25400 {}
C {lab_pin.sym} 3940 25400 0 0 {name=l20422 lab=BLB20}
N 3960 25360 3940 25360 {}
C {lab_pin.sym} 3940 25360 0 0 {name=l20423 lab=WL127}
N 4040 25440 4060 25440 {}
C {lab_pin.sym} 4060 25440 0 0 {name=l20424 lab=VDD}
N 4040 25360 4060 25360 {}
C {lab_pin.sym} 4060 25360 0 0 {name=l20425 lab=VSS}
C {bitcell_6t.sym} 4200 25400 0 0 {name=Xr127c21}
N 4160 25440 4140 25440 {}
C {lab_pin.sym} 4140 25440 0 0 {name=l20426 lab=BL21}
N 4160 25400 4140 25400 {}
C {lab_pin.sym} 4140 25400 0 0 {name=l20427 lab=BLB21}
N 4160 25360 4140 25360 {}
C {lab_pin.sym} 4140 25360 0 0 {name=l20428 lab=WL127}
N 4240 25440 4260 25440 {}
C {lab_pin.sym} 4260 25440 0 0 {name=l20429 lab=VDD}
N 4240 25360 4260 25360 {}
C {lab_pin.sym} 4260 25360 0 0 {name=l20430 lab=VSS}
C {bitcell_6t.sym} 4400 25400 0 0 {name=Xr127c22}
N 4360 25440 4340 25440 {}
C {lab_pin.sym} 4340 25440 0 0 {name=l20431 lab=BL22}
N 4360 25400 4340 25400 {}
C {lab_pin.sym} 4340 25400 0 0 {name=l20432 lab=BLB22}
N 4360 25360 4340 25360 {}
C {lab_pin.sym} 4340 25360 0 0 {name=l20433 lab=WL127}
N 4440 25440 4460 25440 {}
C {lab_pin.sym} 4460 25440 0 0 {name=l20434 lab=VDD}
N 4440 25360 4460 25360 {}
C {lab_pin.sym} 4460 25360 0 0 {name=l20435 lab=VSS}
C {bitcell_6t.sym} 4600 25400 0 0 {name=Xr127c23}
N 4560 25440 4540 25440 {}
C {lab_pin.sym} 4540 25440 0 0 {name=l20436 lab=BL23}
N 4560 25400 4540 25400 {}
C {lab_pin.sym} 4540 25400 0 0 {name=l20437 lab=BLB23}
N 4560 25360 4540 25360 {}
C {lab_pin.sym} 4540 25360 0 0 {name=l20438 lab=WL127}
N 4640 25440 4660 25440 {}
C {lab_pin.sym} 4660 25440 0 0 {name=l20439 lab=VDD}
N 4640 25360 4660 25360 {}
C {lab_pin.sym} 4660 25360 0 0 {name=l20440 lab=VSS}
C {bitcell_6t.sym} 4800 25400 0 0 {name=Xr127c24}
N 4760 25440 4740 25440 {}
C {lab_pin.sym} 4740 25440 0 0 {name=l20441 lab=BL24}
N 4760 25400 4740 25400 {}
C {lab_pin.sym} 4740 25400 0 0 {name=l20442 lab=BLB24}
N 4760 25360 4740 25360 {}
C {lab_pin.sym} 4740 25360 0 0 {name=l20443 lab=WL127}
N 4840 25440 4860 25440 {}
C {lab_pin.sym} 4860 25440 0 0 {name=l20444 lab=VDD}
N 4840 25360 4860 25360 {}
C {lab_pin.sym} 4860 25360 0 0 {name=l20445 lab=VSS}
C {bitcell_6t.sym} 5000 25400 0 0 {name=Xr127c25}
N 4960 25440 4940 25440 {}
C {lab_pin.sym} 4940 25440 0 0 {name=l20446 lab=BL25}
N 4960 25400 4940 25400 {}
C {lab_pin.sym} 4940 25400 0 0 {name=l20447 lab=BLB25}
N 4960 25360 4940 25360 {}
C {lab_pin.sym} 4940 25360 0 0 {name=l20448 lab=WL127}
N 5040 25440 5060 25440 {}
C {lab_pin.sym} 5060 25440 0 0 {name=l20449 lab=VDD}
N 5040 25360 5060 25360 {}
C {lab_pin.sym} 5060 25360 0 0 {name=l20450 lab=VSS}
C {bitcell_6t.sym} 5200 25400 0 0 {name=Xr127c26}
N 5160 25440 5140 25440 {}
C {lab_pin.sym} 5140 25440 0 0 {name=l20451 lab=BL26}
N 5160 25400 5140 25400 {}
C {lab_pin.sym} 5140 25400 0 0 {name=l20452 lab=BLB26}
N 5160 25360 5140 25360 {}
C {lab_pin.sym} 5140 25360 0 0 {name=l20453 lab=WL127}
N 5240 25440 5260 25440 {}
C {lab_pin.sym} 5260 25440 0 0 {name=l20454 lab=VDD}
N 5240 25360 5260 25360 {}
C {lab_pin.sym} 5260 25360 0 0 {name=l20455 lab=VSS}
C {bitcell_6t.sym} 5400 25400 0 0 {name=Xr127c27}
N 5360 25440 5340 25440 {}
C {lab_pin.sym} 5340 25440 0 0 {name=l20456 lab=BL27}
N 5360 25400 5340 25400 {}
C {lab_pin.sym} 5340 25400 0 0 {name=l20457 lab=BLB27}
N 5360 25360 5340 25360 {}
C {lab_pin.sym} 5340 25360 0 0 {name=l20458 lab=WL127}
N 5440 25440 5460 25440 {}
C {lab_pin.sym} 5460 25440 0 0 {name=l20459 lab=VDD}
N 5440 25360 5460 25360 {}
C {lab_pin.sym} 5460 25360 0 0 {name=l20460 lab=VSS}
C {bitcell_6t.sym} 5600 25400 0 0 {name=Xr127c28}
N 5560 25440 5540 25440 {}
C {lab_pin.sym} 5540 25440 0 0 {name=l20461 lab=BL28}
N 5560 25400 5540 25400 {}
C {lab_pin.sym} 5540 25400 0 0 {name=l20462 lab=BLB28}
N 5560 25360 5540 25360 {}
C {lab_pin.sym} 5540 25360 0 0 {name=l20463 lab=WL127}
N 5640 25440 5660 25440 {}
C {lab_pin.sym} 5660 25440 0 0 {name=l20464 lab=VDD}
N 5640 25360 5660 25360 {}
C {lab_pin.sym} 5660 25360 0 0 {name=l20465 lab=VSS}
C {bitcell_6t.sym} 5800 25400 0 0 {name=Xr127c29}
N 5760 25440 5740 25440 {}
C {lab_pin.sym} 5740 25440 0 0 {name=l20466 lab=BL29}
N 5760 25400 5740 25400 {}
C {lab_pin.sym} 5740 25400 0 0 {name=l20467 lab=BLB29}
N 5760 25360 5740 25360 {}
C {lab_pin.sym} 5740 25360 0 0 {name=l20468 lab=WL127}
N 5840 25440 5860 25440 {}
C {lab_pin.sym} 5860 25440 0 0 {name=l20469 lab=VDD}
N 5840 25360 5860 25360 {}
C {lab_pin.sym} 5860 25360 0 0 {name=l20470 lab=VSS}
C {bitcell_6t.sym} 6000 25400 0 0 {name=Xr127c30}
N 5960 25440 5940 25440 {}
C {lab_pin.sym} 5940 25440 0 0 {name=l20471 lab=BL30}
N 5960 25400 5940 25400 {}
C {lab_pin.sym} 5940 25400 0 0 {name=l20472 lab=BLB30}
N 5960 25360 5940 25360 {}
C {lab_pin.sym} 5940 25360 0 0 {name=l20473 lab=WL127}
N 6040 25440 6060 25440 {}
C {lab_pin.sym} 6060 25440 0 0 {name=l20474 lab=VDD}
N 6040 25360 6060 25360 {}
C {lab_pin.sym} 6060 25360 0 0 {name=l20475 lab=VSS}
C {bitcell_6t.sym} 6200 25400 0 0 {name=Xr127c31}
N 6160 25440 6140 25440 {}
C {lab_pin.sym} 6140 25440 0 0 {name=l20476 lab=BL31}
N 6160 25400 6140 25400 {}
C {lab_pin.sym} 6140 25400 0 0 {name=l20477 lab=BLB31}
N 6160 25360 6140 25360 {}
C {lab_pin.sym} 6140 25360 0 0 {name=l20478 lab=WL127}
N 6240 25440 6260 25440 {}
C {lab_pin.sym} 6260 25440 0 0 {name=l20479 lab=VDD}
N 6240 25360 6260 25360 {}
C {lab_pin.sym} 6260 25360 0 0 {name=l20480 lab=VSS}
C {bitcell_6t.sym} 0 25600 0 0 {name=Xr128c0}
N -40 25640 -60 25640 {}
C {lab_pin.sym} -60 25640 0 0 {name=l20481 lab=BL0}
N -40 25600 -60 25600 {}
C {lab_pin.sym} -60 25600 0 0 {name=l20482 lab=BLB0}
N -40 25560 -60 25560 {}
C {lab_pin.sym} -60 25560 0 0 {name=l20483 lab=WL128}
N 40 25640 60 25640 {}
C {lab_pin.sym} 60 25640 0 0 {name=l20484 lab=VDD}
N 40 25560 60 25560 {}
C {lab_pin.sym} 60 25560 0 0 {name=l20485 lab=VSS}
C {bitcell_6t.sym} 200 25600 0 0 {name=Xr128c1}
N 160 25640 140 25640 {}
C {lab_pin.sym} 140 25640 0 0 {name=l20486 lab=BL1}
N 160 25600 140 25600 {}
C {lab_pin.sym} 140 25600 0 0 {name=l20487 lab=BLB1}
N 160 25560 140 25560 {}
C {lab_pin.sym} 140 25560 0 0 {name=l20488 lab=WL128}
N 240 25640 260 25640 {}
C {lab_pin.sym} 260 25640 0 0 {name=l20489 lab=VDD}
N 240 25560 260 25560 {}
C {lab_pin.sym} 260 25560 0 0 {name=l20490 lab=VSS}
C {bitcell_6t.sym} 400 25600 0 0 {name=Xr128c2}
N 360 25640 340 25640 {}
C {lab_pin.sym} 340 25640 0 0 {name=l20491 lab=BL2}
N 360 25600 340 25600 {}
C {lab_pin.sym} 340 25600 0 0 {name=l20492 lab=BLB2}
N 360 25560 340 25560 {}
C {lab_pin.sym} 340 25560 0 0 {name=l20493 lab=WL128}
N 440 25640 460 25640 {}
C {lab_pin.sym} 460 25640 0 0 {name=l20494 lab=VDD}
N 440 25560 460 25560 {}
C {lab_pin.sym} 460 25560 0 0 {name=l20495 lab=VSS}
C {bitcell_6t.sym} 600 25600 0 0 {name=Xr128c3}
N 560 25640 540 25640 {}
C {lab_pin.sym} 540 25640 0 0 {name=l20496 lab=BL3}
N 560 25600 540 25600 {}
C {lab_pin.sym} 540 25600 0 0 {name=l20497 lab=BLB3}
N 560 25560 540 25560 {}
C {lab_pin.sym} 540 25560 0 0 {name=l20498 lab=WL128}
N 640 25640 660 25640 {}
C {lab_pin.sym} 660 25640 0 0 {name=l20499 lab=VDD}
N 640 25560 660 25560 {}
C {lab_pin.sym} 660 25560 0 0 {name=l20500 lab=VSS}
C {bitcell_6t.sym} 800 25600 0 0 {name=Xr128c4}
N 760 25640 740 25640 {}
C {lab_pin.sym} 740 25640 0 0 {name=l20501 lab=BL4}
N 760 25600 740 25600 {}
C {lab_pin.sym} 740 25600 0 0 {name=l20502 lab=BLB4}
N 760 25560 740 25560 {}
C {lab_pin.sym} 740 25560 0 0 {name=l20503 lab=WL128}
N 840 25640 860 25640 {}
C {lab_pin.sym} 860 25640 0 0 {name=l20504 lab=VDD}
N 840 25560 860 25560 {}
C {lab_pin.sym} 860 25560 0 0 {name=l20505 lab=VSS}
C {bitcell_6t.sym} 1000 25600 0 0 {name=Xr128c5}
N 960 25640 940 25640 {}
C {lab_pin.sym} 940 25640 0 0 {name=l20506 lab=BL5}
N 960 25600 940 25600 {}
C {lab_pin.sym} 940 25600 0 0 {name=l20507 lab=BLB5}
N 960 25560 940 25560 {}
C {lab_pin.sym} 940 25560 0 0 {name=l20508 lab=WL128}
N 1040 25640 1060 25640 {}
C {lab_pin.sym} 1060 25640 0 0 {name=l20509 lab=VDD}
N 1040 25560 1060 25560 {}
C {lab_pin.sym} 1060 25560 0 0 {name=l20510 lab=VSS}
C {bitcell_6t.sym} 1200 25600 0 0 {name=Xr128c6}
N 1160 25640 1140 25640 {}
C {lab_pin.sym} 1140 25640 0 0 {name=l20511 lab=BL6}
N 1160 25600 1140 25600 {}
C {lab_pin.sym} 1140 25600 0 0 {name=l20512 lab=BLB6}
N 1160 25560 1140 25560 {}
C {lab_pin.sym} 1140 25560 0 0 {name=l20513 lab=WL128}
N 1240 25640 1260 25640 {}
C {lab_pin.sym} 1260 25640 0 0 {name=l20514 lab=VDD}
N 1240 25560 1260 25560 {}
C {lab_pin.sym} 1260 25560 0 0 {name=l20515 lab=VSS}
C {bitcell_6t.sym} 1400 25600 0 0 {name=Xr128c7}
N 1360 25640 1340 25640 {}
C {lab_pin.sym} 1340 25640 0 0 {name=l20516 lab=BL7}
N 1360 25600 1340 25600 {}
C {lab_pin.sym} 1340 25600 0 0 {name=l20517 lab=BLB7}
N 1360 25560 1340 25560 {}
C {lab_pin.sym} 1340 25560 0 0 {name=l20518 lab=WL128}
N 1440 25640 1460 25640 {}
C {lab_pin.sym} 1460 25640 0 0 {name=l20519 lab=VDD}
N 1440 25560 1460 25560 {}
C {lab_pin.sym} 1460 25560 0 0 {name=l20520 lab=VSS}
C {bitcell_6t.sym} 1600 25600 0 0 {name=Xr128c8}
N 1560 25640 1540 25640 {}
C {lab_pin.sym} 1540 25640 0 0 {name=l20521 lab=BL8}
N 1560 25600 1540 25600 {}
C {lab_pin.sym} 1540 25600 0 0 {name=l20522 lab=BLB8}
N 1560 25560 1540 25560 {}
C {lab_pin.sym} 1540 25560 0 0 {name=l20523 lab=WL128}
N 1640 25640 1660 25640 {}
C {lab_pin.sym} 1660 25640 0 0 {name=l20524 lab=VDD}
N 1640 25560 1660 25560 {}
C {lab_pin.sym} 1660 25560 0 0 {name=l20525 lab=VSS}
C {bitcell_6t.sym} 1800 25600 0 0 {name=Xr128c9}
N 1760 25640 1740 25640 {}
C {lab_pin.sym} 1740 25640 0 0 {name=l20526 lab=BL9}
N 1760 25600 1740 25600 {}
C {lab_pin.sym} 1740 25600 0 0 {name=l20527 lab=BLB9}
N 1760 25560 1740 25560 {}
C {lab_pin.sym} 1740 25560 0 0 {name=l20528 lab=WL128}
N 1840 25640 1860 25640 {}
C {lab_pin.sym} 1860 25640 0 0 {name=l20529 lab=VDD}
N 1840 25560 1860 25560 {}
C {lab_pin.sym} 1860 25560 0 0 {name=l20530 lab=VSS}
C {bitcell_6t.sym} 2000 25600 0 0 {name=Xr128c10}
N 1960 25640 1940 25640 {}
C {lab_pin.sym} 1940 25640 0 0 {name=l20531 lab=BL10}
N 1960 25600 1940 25600 {}
C {lab_pin.sym} 1940 25600 0 0 {name=l20532 lab=BLB10}
N 1960 25560 1940 25560 {}
C {lab_pin.sym} 1940 25560 0 0 {name=l20533 lab=WL128}
N 2040 25640 2060 25640 {}
C {lab_pin.sym} 2060 25640 0 0 {name=l20534 lab=VDD}
N 2040 25560 2060 25560 {}
C {lab_pin.sym} 2060 25560 0 0 {name=l20535 lab=VSS}
C {bitcell_6t.sym} 2200 25600 0 0 {name=Xr128c11}
N 2160 25640 2140 25640 {}
C {lab_pin.sym} 2140 25640 0 0 {name=l20536 lab=BL11}
N 2160 25600 2140 25600 {}
C {lab_pin.sym} 2140 25600 0 0 {name=l20537 lab=BLB11}
N 2160 25560 2140 25560 {}
C {lab_pin.sym} 2140 25560 0 0 {name=l20538 lab=WL128}
N 2240 25640 2260 25640 {}
C {lab_pin.sym} 2260 25640 0 0 {name=l20539 lab=VDD}
N 2240 25560 2260 25560 {}
C {lab_pin.sym} 2260 25560 0 0 {name=l20540 lab=VSS}
C {bitcell_6t.sym} 2400 25600 0 0 {name=Xr128c12}
N 2360 25640 2340 25640 {}
C {lab_pin.sym} 2340 25640 0 0 {name=l20541 lab=BL12}
N 2360 25600 2340 25600 {}
C {lab_pin.sym} 2340 25600 0 0 {name=l20542 lab=BLB12}
N 2360 25560 2340 25560 {}
C {lab_pin.sym} 2340 25560 0 0 {name=l20543 lab=WL128}
N 2440 25640 2460 25640 {}
C {lab_pin.sym} 2460 25640 0 0 {name=l20544 lab=VDD}
N 2440 25560 2460 25560 {}
C {lab_pin.sym} 2460 25560 0 0 {name=l20545 lab=VSS}
C {bitcell_6t.sym} 2600 25600 0 0 {name=Xr128c13}
N 2560 25640 2540 25640 {}
C {lab_pin.sym} 2540 25640 0 0 {name=l20546 lab=BL13}
N 2560 25600 2540 25600 {}
C {lab_pin.sym} 2540 25600 0 0 {name=l20547 lab=BLB13}
N 2560 25560 2540 25560 {}
C {lab_pin.sym} 2540 25560 0 0 {name=l20548 lab=WL128}
N 2640 25640 2660 25640 {}
C {lab_pin.sym} 2660 25640 0 0 {name=l20549 lab=VDD}
N 2640 25560 2660 25560 {}
C {lab_pin.sym} 2660 25560 0 0 {name=l20550 lab=VSS}
C {bitcell_6t.sym} 2800 25600 0 0 {name=Xr128c14}
N 2760 25640 2740 25640 {}
C {lab_pin.sym} 2740 25640 0 0 {name=l20551 lab=BL14}
N 2760 25600 2740 25600 {}
C {lab_pin.sym} 2740 25600 0 0 {name=l20552 lab=BLB14}
N 2760 25560 2740 25560 {}
C {lab_pin.sym} 2740 25560 0 0 {name=l20553 lab=WL128}
N 2840 25640 2860 25640 {}
C {lab_pin.sym} 2860 25640 0 0 {name=l20554 lab=VDD}
N 2840 25560 2860 25560 {}
C {lab_pin.sym} 2860 25560 0 0 {name=l20555 lab=VSS}
C {bitcell_6t.sym} 3000 25600 0 0 {name=Xr128c15}
N 2960 25640 2940 25640 {}
C {lab_pin.sym} 2940 25640 0 0 {name=l20556 lab=BL15}
N 2960 25600 2940 25600 {}
C {lab_pin.sym} 2940 25600 0 0 {name=l20557 lab=BLB15}
N 2960 25560 2940 25560 {}
C {lab_pin.sym} 2940 25560 0 0 {name=l20558 lab=WL128}
N 3040 25640 3060 25640 {}
C {lab_pin.sym} 3060 25640 0 0 {name=l20559 lab=VDD}
N 3040 25560 3060 25560 {}
C {lab_pin.sym} 3060 25560 0 0 {name=l20560 lab=VSS}
C {bitcell_6t.sym} 3200 25600 0 0 {name=Xr128c16}
N 3160 25640 3140 25640 {}
C {lab_pin.sym} 3140 25640 0 0 {name=l20561 lab=BL16}
N 3160 25600 3140 25600 {}
C {lab_pin.sym} 3140 25600 0 0 {name=l20562 lab=BLB16}
N 3160 25560 3140 25560 {}
C {lab_pin.sym} 3140 25560 0 0 {name=l20563 lab=WL128}
N 3240 25640 3260 25640 {}
C {lab_pin.sym} 3260 25640 0 0 {name=l20564 lab=VDD}
N 3240 25560 3260 25560 {}
C {lab_pin.sym} 3260 25560 0 0 {name=l20565 lab=VSS}
C {bitcell_6t.sym} 3400 25600 0 0 {name=Xr128c17}
N 3360 25640 3340 25640 {}
C {lab_pin.sym} 3340 25640 0 0 {name=l20566 lab=BL17}
N 3360 25600 3340 25600 {}
C {lab_pin.sym} 3340 25600 0 0 {name=l20567 lab=BLB17}
N 3360 25560 3340 25560 {}
C {lab_pin.sym} 3340 25560 0 0 {name=l20568 lab=WL128}
N 3440 25640 3460 25640 {}
C {lab_pin.sym} 3460 25640 0 0 {name=l20569 lab=VDD}
N 3440 25560 3460 25560 {}
C {lab_pin.sym} 3460 25560 0 0 {name=l20570 lab=VSS}
C {bitcell_6t.sym} 3600 25600 0 0 {name=Xr128c18}
N 3560 25640 3540 25640 {}
C {lab_pin.sym} 3540 25640 0 0 {name=l20571 lab=BL18}
N 3560 25600 3540 25600 {}
C {lab_pin.sym} 3540 25600 0 0 {name=l20572 lab=BLB18}
N 3560 25560 3540 25560 {}
C {lab_pin.sym} 3540 25560 0 0 {name=l20573 lab=WL128}
N 3640 25640 3660 25640 {}
C {lab_pin.sym} 3660 25640 0 0 {name=l20574 lab=VDD}
N 3640 25560 3660 25560 {}
C {lab_pin.sym} 3660 25560 0 0 {name=l20575 lab=VSS}
C {bitcell_6t.sym} 3800 25600 0 0 {name=Xr128c19}
N 3760 25640 3740 25640 {}
C {lab_pin.sym} 3740 25640 0 0 {name=l20576 lab=BL19}
N 3760 25600 3740 25600 {}
C {lab_pin.sym} 3740 25600 0 0 {name=l20577 lab=BLB19}
N 3760 25560 3740 25560 {}
C {lab_pin.sym} 3740 25560 0 0 {name=l20578 lab=WL128}
N 3840 25640 3860 25640 {}
C {lab_pin.sym} 3860 25640 0 0 {name=l20579 lab=VDD}
N 3840 25560 3860 25560 {}
C {lab_pin.sym} 3860 25560 0 0 {name=l20580 lab=VSS}
C {bitcell_6t.sym} 4000 25600 0 0 {name=Xr128c20}
N 3960 25640 3940 25640 {}
C {lab_pin.sym} 3940 25640 0 0 {name=l20581 lab=BL20}
N 3960 25600 3940 25600 {}
C {lab_pin.sym} 3940 25600 0 0 {name=l20582 lab=BLB20}
N 3960 25560 3940 25560 {}
C {lab_pin.sym} 3940 25560 0 0 {name=l20583 lab=WL128}
N 4040 25640 4060 25640 {}
C {lab_pin.sym} 4060 25640 0 0 {name=l20584 lab=VDD}
N 4040 25560 4060 25560 {}
C {lab_pin.sym} 4060 25560 0 0 {name=l20585 lab=VSS}
C {bitcell_6t.sym} 4200 25600 0 0 {name=Xr128c21}
N 4160 25640 4140 25640 {}
C {lab_pin.sym} 4140 25640 0 0 {name=l20586 lab=BL21}
N 4160 25600 4140 25600 {}
C {lab_pin.sym} 4140 25600 0 0 {name=l20587 lab=BLB21}
N 4160 25560 4140 25560 {}
C {lab_pin.sym} 4140 25560 0 0 {name=l20588 lab=WL128}
N 4240 25640 4260 25640 {}
C {lab_pin.sym} 4260 25640 0 0 {name=l20589 lab=VDD}
N 4240 25560 4260 25560 {}
C {lab_pin.sym} 4260 25560 0 0 {name=l20590 lab=VSS}
C {bitcell_6t.sym} 4400 25600 0 0 {name=Xr128c22}
N 4360 25640 4340 25640 {}
C {lab_pin.sym} 4340 25640 0 0 {name=l20591 lab=BL22}
N 4360 25600 4340 25600 {}
C {lab_pin.sym} 4340 25600 0 0 {name=l20592 lab=BLB22}
N 4360 25560 4340 25560 {}
C {lab_pin.sym} 4340 25560 0 0 {name=l20593 lab=WL128}
N 4440 25640 4460 25640 {}
C {lab_pin.sym} 4460 25640 0 0 {name=l20594 lab=VDD}
N 4440 25560 4460 25560 {}
C {lab_pin.sym} 4460 25560 0 0 {name=l20595 lab=VSS}
C {bitcell_6t.sym} 4600 25600 0 0 {name=Xr128c23}
N 4560 25640 4540 25640 {}
C {lab_pin.sym} 4540 25640 0 0 {name=l20596 lab=BL23}
N 4560 25600 4540 25600 {}
C {lab_pin.sym} 4540 25600 0 0 {name=l20597 lab=BLB23}
N 4560 25560 4540 25560 {}
C {lab_pin.sym} 4540 25560 0 0 {name=l20598 lab=WL128}
N 4640 25640 4660 25640 {}
C {lab_pin.sym} 4660 25640 0 0 {name=l20599 lab=VDD}
N 4640 25560 4660 25560 {}
C {lab_pin.sym} 4660 25560 0 0 {name=l20600 lab=VSS}
C {bitcell_6t.sym} 4800 25600 0 0 {name=Xr128c24}
N 4760 25640 4740 25640 {}
C {lab_pin.sym} 4740 25640 0 0 {name=l20601 lab=BL24}
N 4760 25600 4740 25600 {}
C {lab_pin.sym} 4740 25600 0 0 {name=l20602 lab=BLB24}
N 4760 25560 4740 25560 {}
C {lab_pin.sym} 4740 25560 0 0 {name=l20603 lab=WL128}
N 4840 25640 4860 25640 {}
C {lab_pin.sym} 4860 25640 0 0 {name=l20604 lab=VDD}
N 4840 25560 4860 25560 {}
C {lab_pin.sym} 4860 25560 0 0 {name=l20605 lab=VSS}
C {bitcell_6t.sym} 5000 25600 0 0 {name=Xr128c25}
N 4960 25640 4940 25640 {}
C {lab_pin.sym} 4940 25640 0 0 {name=l20606 lab=BL25}
N 4960 25600 4940 25600 {}
C {lab_pin.sym} 4940 25600 0 0 {name=l20607 lab=BLB25}
N 4960 25560 4940 25560 {}
C {lab_pin.sym} 4940 25560 0 0 {name=l20608 lab=WL128}
N 5040 25640 5060 25640 {}
C {lab_pin.sym} 5060 25640 0 0 {name=l20609 lab=VDD}
N 5040 25560 5060 25560 {}
C {lab_pin.sym} 5060 25560 0 0 {name=l20610 lab=VSS}
C {bitcell_6t.sym} 5200 25600 0 0 {name=Xr128c26}
N 5160 25640 5140 25640 {}
C {lab_pin.sym} 5140 25640 0 0 {name=l20611 lab=BL26}
N 5160 25600 5140 25600 {}
C {lab_pin.sym} 5140 25600 0 0 {name=l20612 lab=BLB26}
N 5160 25560 5140 25560 {}
C {lab_pin.sym} 5140 25560 0 0 {name=l20613 lab=WL128}
N 5240 25640 5260 25640 {}
C {lab_pin.sym} 5260 25640 0 0 {name=l20614 lab=VDD}
N 5240 25560 5260 25560 {}
C {lab_pin.sym} 5260 25560 0 0 {name=l20615 lab=VSS}
C {bitcell_6t.sym} 5400 25600 0 0 {name=Xr128c27}
N 5360 25640 5340 25640 {}
C {lab_pin.sym} 5340 25640 0 0 {name=l20616 lab=BL27}
N 5360 25600 5340 25600 {}
C {lab_pin.sym} 5340 25600 0 0 {name=l20617 lab=BLB27}
N 5360 25560 5340 25560 {}
C {lab_pin.sym} 5340 25560 0 0 {name=l20618 lab=WL128}
N 5440 25640 5460 25640 {}
C {lab_pin.sym} 5460 25640 0 0 {name=l20619 lab=VDD}
N 5440 25560 5460 25560 {}
C {lab_pin.sym} 5460 25560 0 0 {name=l20620 lab=VSS}
C {bitcell_6t.sym} 5600 25600 0 0 {name=Xr128c28}
N 5560 25640 5540 25640 {}
C {lab_pin.sym} 5540 25640 0 0 {name=l20621 lab=BL28}
N 5560 25600 5540 25600 {}
C {lab_pin.sym} 5540 25600 0 0 {name=l20622 lab=BLB28}
N 5560 25560 5540 25560 {}
C {lab_pin.sym} 5540 25560 0 0 {name=l20623 lab=WL128}
N 5640 25640 5660 25640 {}
C {lab_pin.sym} 5660 25640 0 0 {name=l20624 lab=VDD}
N 5640 25560 5660 25560 {}
C {lab_pin.sym} 5660 25560 0 0 {name=l20625 lab=VSS}
C {bitcell_6t.sym} 5800 25600 0 0 {name=Xr128c29}
N 5760 25640 5740 25640 {}
C {lab_pin.sym} 5740 25640 0 0 {name=l20626 lab=BL29}
N 5760 25600 5740 25600 {}
C {lab_pin.sym} 5740 25600 0 0 {name=l20627 lab=BLB29}
N 5760 25560 5740 25560 {}
C {lab_pin.sym} 5740 25560 0 0 {name=l20628 lab=WL128}
N 5840 25640 5860 25640 {}
C {lab_pin.sym} 5860 25640 0 0 {name=l20629 lab=VDD}
N 5840 25560 5860 25560 {}
C {lab_pin.sym} 5860 25560 0 0 {name=l20630 lab=VSS}
C {bitcell_6t.sym} 6000 25600 0 0 {name=Xr128c30}
N 5960 25640 5940 25640 {}
C {lab_pin.sym} 5940 25640 0 0 {name=l20631 lab=BL30}
N 5960 25600 5940 25600 {}
C {lab_pin.sym} 5940 25600 0 0 {name=l20632 lab=BLB30}
N 5960 25560 5940 25560 {}
C {lab_pin.sym} 5940 25560 0 0 {name=l20633 lab=WL128}
N 6040 25640 6060 25640 {}
C {lab_pin.sym} 6060 25640 0 0 {name=l20634 lab=VDD}
N 6040 25560 6060 25560 {}
C {lab_pin.sym} 6060 25560 0 0 {name=l20635 lab=VSS}
C {bitcell_6t.sym} 6200 25600 0 0 {name=Xr128c31}
N 6160 25640 6140 25640 {}
C {lab_pin.sym} 6140 25640 0 0 {name=l20636 lab=BL31}
N 6160 25600 6140 25600 {}
C {lab_pin.sym} 6140 25600 0 0 {name=l20637 lab=BLB31}
N 6160 25560 6140 25560 {}
C {lab_pin.sym} 6140 25560 0 0 {name=l20638 lab=WL128}
N 6240 25640 6260 25640 {}
C {lab_pin.sym} 6260 25640 0 0 {name=l20639 lab=VDD}
N 6240 25560 6260 25560 {}
C {lab_pin.sym} 6260 25560 0 0 {name=l20640 lab=VSS}
C {bitcell_6t.sym} 0 25800 0 0 {name=Xr129c0}
N -40 25840 -60 25840 {}
C {lab_pin.sym} -60 25840 0 0 {name=l20641 lab=BL0}
N -40 25800 -60 25800 {}
C {lab_pin.sym} -60 25800 0 0 {name=l20642 lab=BLB0}
N -40 25760 -60 25760 {}
C {lab_pin.sym} -60 25760 0 0 {name=l20643 lab=WL129}
N 40 25840 60 25840 {}
C {lab_pin.sym} 60 25840 0 0 {name=l20644 lab=VDD}
N 40 25760 60 25760 {}
C {lab_pin.sym} 60 25760 0 0 {name=l20645 lab=VSS}
C {bitcell_6t.sym} 200 25800 0 0 {name=Xr129c1}
N 160 25840 140 25840 {}
C {lab_pin.sym} 140 25840 0 0 {name=l20646 lab=BL1}
N 160 25800 140 25800 {}
C {lab_pin.sym} 140 25800 0 0 {name=l20647 lab=BLB1}
N 160 25760 140 25760 {}
C {lab_pin.sym} 140 25760 0 0 {name=l20648 lab=WL129}
N 240 25840 260 25840 {}
C {lab_pin.sym} 260 25840 0 0 {name=l20649 lab=VDD}
N 240 25760 260 25760 {}
C {lab_pin.sym} 260 25760 0 0 {name=l20650 lab=VSS}
C {bitcell_6t.sym} 400 25800 0 0 {name=Xr129c2}
N 360 25840 340 25840 {}
C {lab_pin.sym} 340 25840 0 0 {name=l20651 lab=BL2}
N 360 25800 340 25800 {}
C {lab_pin.sym} 340 25800 0 0 {name=l20652 lab=BLB2}
N 360 25760 340 25760 {}
C {lab_pin.sym} 340 25760 0 0 {name=l20653 lab=WL129}
N 440 25840 460 25840 {}
C {lab_pin.sym} 460 25840 0 0 {name=l20654 lab=VDD}
N 440 25760 460 25760 {}
C {lab_pin.sym} 460 25760 0 0 {name=l20655 lab=VSS}
C {bitcell_6t.sym} 600 25800 0 0 {name=Xr129c3}
N 560 25840 540 25840 {}
C {lab_pin.sym} 540 25840 0 0 {name=l20656 lab=BL3}
N 560 25800 540 25800 {}
C {lab_pin.sym} 540 25800 0 0 {name=l20657 lab=BLB3}
N 560 25760 540 25760 {}
C {lab_pin.sym} 540 25760 0 0 {name=l20658 lab=WL129}
N 640 25840 660 25840 {}
C {lab_pin.sym} 660 25840 0 0 {name=l20659 lab=VDD}
N 640 25760 660 25760 {}
C {lab_pin.sym} 660 25760 0 0 {name=l20660 lab=VSS}
C {bitcell_6t.sym} 800 25800 0 0 {name=Xr129c4}
N 760 25840 740 25840 {}
C {lab_pin.sym} 740 25840 0 0 {name=l20661 lab=BL4}
N 760 25800 740 25800 {}
C {lab_pin.sym} 740 25800 0 0 {name=l20662 lab=BLB4}
N 760 25760 740 25760 {}
C {lab_pin.sym} 740 25760 0 0 {name=l20663 lab=WL129}
N 840 25840 860 25840 {}
C {lab_pin.sym} 860 25840 0 0 {name=l20664 lab=VDD}
N 840 25760 860 25760 {}
C {lab_pin.sym} 860 25760 0 0 {name=l20665 lab=VSS}
C {bitcell_6t.sym} 1000 25800 0 0 {name=Xr129c5}
N 960 25840 940 25840 {}
C {lab_pin.sym} 940 25840 0 0 {name=l20666 lab=BL5}
N 960 25800 940 25800 {}
C {lab_pin.sym} 940 25800 0 0 {name=l20667 lab=BLB5}
N 960 25760 940 25760 {}
C {lab_pin.sym} 940 25760 0 0 {name=l20668 lab=WL129}
N 1040 25840 1060 25840 {}
C {lab_pin.sym} 1060 25840 0 0 {name=l20669 lab=VDD}
N 1040 25760 1060 25760 {}
C {lab_pin.sym} 1060 25760 0 0 {name=l20670 lab=VSS}
C {bitcell_6t.sym} 1200 25800 0 0 {name=Xr129c6}
N 1160 25840 1140 25840 {}
C {lab_pin.sym} 1140 25840 0 0 {name=l20671 lab=BL6}
N 1160 25800 1140 25800 {}
C {lab_pin.sym} 1140 25800 0 0 {name=l20672 lab=BLB6}
N 1160 25760 1140 25760 {}
C {lab_pin.sym} 1140 25760 0 0 {name=l20673 lab=WL129}
N 1240 25840 1260 25840 {}
C {lab_pin.sym} 1260 25840 0 0 {name=l20674 lab=VDD}
N 1240 25760 1260 25760 {}
C {lab_pin.sym} 1260 25760 0 0 {name=l20675 lab=VSS}
C {bitcell_6t.sym} 1400 25800 0 0 {name=Xr129c7}
N 1360 25840 1340 25840 {}
C {lab_pin.sym} 1340 25840 0 0 {name=l20676 lab=BL7}
N 1360 25800 1340 25800 {}
C {lab_pin.sym} 1340 25800 0 0 {name=l20677 lab=BLB7}
N 1360 25760 1340 25760 {}
C {lab_pin.sym} 1340 25760 0 0 {name=l20678 lab=WL129}
N 1440 25840 1460 25840 {}
C {lab_pin.sym} 1460 25840 0 0 {name=l20679 lab=VDD}
N 1440 25760 1460 25760 {}
C {lab_pin.sym} 1460 25760 0 0 {name=l20680 lab=VSS}
C {bitcell_6t.sym} 1600 25800 0 0 {name=Xr129c8}
N 1560 25840 1540 25840 {}
C {lab_pin.sym} 1540 25840 0 0 {name=l20681 lab=BL8}
N 1560 25800 1540 25800 {}
C {lab_pin.sym} 1540 25800 0 0 {name=l20682 lab=BLB8}
N 1560 25760 1540 25760 {}
C {lab_pin.sym} 1540 25760 0 0 {name=l20683 lab=WL129}
N 1640 25840 1660 25840 {}
C {lab_pin.sym} 1660 25840 0 0 {name=l20684 lab=VDD}
N 1640 25760 1660 25760 {}
C {lab_pin.sym} 1660 25760 0 0 {name=l20685 lab=VSS}
C {bitcell_6t.sym} 1800 25800 0 0 {name=Xr129c9}
N 1760 25840 1740 25840 {}
C {lab_pin.sym} 1740 25840 0 0 {name=l20686 lab=BL9}
N 1760 25800 1740 25800 {}
C {lab_pin.sym} 1740 25800 0 0 {name=l20687 lab=BLB9}
N 1760 25760 1740 25760 {}
C {lab_pin.sym} 1740 25760 0 0 {name=l20688 lab=WL129}
N 1840 25840 1860 25840 {}
C {lab_pin.sym} 1860 25840 0 0 {name=l20689 lab=VDD}
N 1840 25760 1860 25760 {}
C {lab_pin.sym} 1860 25760 0 0 {name=l20690 lab=VSS}
C {bitcell_6t.sym} 2000 25800 0 0 {name=Xr129c10}
N 1960 25840 1940 25840 {}
C {lab_pin.sym} 1940 25840 0 0 {name=l20691 lab=BL10}
N 1960 25800 1940 25800 {}
C {lab_pin.sym} 1940 25800 0 0 {name=l20692 lab=BLB10}
N 1960 25760 1940 25760 {}
C {lab_pin.sym} 1940 25760 0 0 {name=l20693 lab=WL129}
N 2040 25840 2060 25840 {}
C {lab_pin.sym} 2060 25840 0 0 {name=l20694 lab=VDD}
N 2040 25760 2060 25760 {}
C {lab_pin.sym} 2060 25760 0 0 {name=l20695 lab=VSS}
C {bitcell_6t.sym} 2200 25800 0 0 {name=Xr129c11}
N 2160 25840 2140 25840 {}
C {lab_pin.sym} 2140 25840 0 0 {name=l20696 lab=BL11}
N 2160 25800 2140 25800 {}
C {lab_pin.sym} 2140 25800 0 0 {name=l20697 lab=BLB11}
N 2160 25760 2140 25760 {}
C {lab_pin.sym} 2140 25760 0 0 {name=l20698 lab=WL129}
N 2240 25840 2260 25840 {}
C {lab_pin.sym} 2260 25840 0 0 {name=l20699 lab=VDD}
N 2240 25760 2260 25760 {}
C {lab_pin.sym} 2260 25760 0 0 {name=l20700 lab=VSS}
C {bitcell_6t.sym} 2400 25800 0 0 {name=Xr129c12}
N 2360 25840 2340 25840 {}
C {lab_pin.sym} 2340 25840 0 0 {name=l20701 lab=BL12}
N 2360 25800 2340 25800 {}
C {lab_pin.sym} 2340 25800 0 0 {name=l20702 lab=BLB12}
N 2360 25760 2340 25760 {}
C {lab_pin.sym} 2340 25760 0 0 {name=l20703 lab=WL129}
N 2440 25840 2460 25840 {}
C {lab_pin.sym} 2460 25840 0 0 {name=l20704 lab=VDD}
N 2440 25760 2460 25760 {}
C {lab_pin.sym} 2460 25760 0 0 {name=l20705 lab=VSS}
C {bitcell_6t.sym} 2600 25800 0 0 {name=Xr129c13}
N 2560 25840 2540 25840 {}
C {lab_pin.sym} 2540 25840 0 0 {name=l20706 lab=BL13}
N 2560 25800 2540 25800 {}
C {lab_pin.sym} 2540 25800 0 0 {name=l20707 lab=BLB13}
N 2560 25760 2540 25760 {}
C {lab_pin.sym} 2540 25760 0 0 {name=l20708 lab=WL129}
N 2640 25840 2660 25840 {}
C {lab_pin.sym} 2660 25840 0 0 {name=l20709 lab=VDD}
N 2640 25760 2660 25760 {}
C {lab_pin.sym} 2660 25760 0 0 {name=l20710 lab=VSS}
C {bitcell_6t.sym} 2800 25800 0 0 {name=Xr129c14}
N 2760 25840 2740 25840 {}
C {lab_pin.sym} 2740 25840 0 0 {name=l20711 lab=BL14}
N 2760 25800 2740 25800 {}
C {lab_pin.sym} 2740 25800 0 0 {name=l20712 lab=BLB14}
N 2760 25760 2740 25760 {}
C {lab_pin.sym} 2740 25760 0 0 {name=l20713 lab=WL129}
N 2840 25840 2860 25840 {}
C {lab_pin.sym} 2860 25840 0 0 {name=l20714 lab=VDD}
N 2840 25760 2860 25760 {}
C {lab_pin.sym} 2860 25760 0 0 {name=l20715 lab=VSS}
C {bitcell_6t.sym} 3000 25800 0 0 {name=Xr129c15}
N 2960 25840 2940 25840 {}
C {lab_pin.sym} 2940 25840 0 0 {name=l20716 lab=BL15}
N 2960 25800 2940 25800 {}
C {lab_pin.sym} 2940 25800 0 0 {name=l20717 lab=BLB15}
N 2960 25760 2940 25760 {}
C {lab_pin.sym} 2940 25760 0 0 {name=l20718 lab=WL129}
N 3040 25840 3060 25840 {}
C {lab_pin.sym} 3060 25840 0 0 {name=l20719 lab=VDD}
N 3040 25760 3060 25760 {}
C {lab_pin.sym} 3060 25760 0 0 {name=l20720 lab=VSS}
C {bitcell_6t.sym} 3200 25800 0 0 {name=Xr129c16}
N 3160 25840 3140 25840 {}
C {lab_pin.sym} 3140 25840 0 0 {name=l20721 lab=BL16}
N 3160 25800 3140 25800 {}
C {lab_pin.sym} 3140 25800 0 0 {name=l20722 lab=BLB16}
N 3160 25760 3140 25760 {}
C {lab_pin.sym} 3140 25760 0 0 {name=l20723 lab=WL129}
N 3240 25840 3260 25840 {}
C {lab_pin.sym} 3260 25840 0 0 {name=l20724 lab=VDD}
N 3240 25760 3260 25760 {}
C {lab_pin.sym} 3260 25760 0 0 {name=l20725 lab=VSS}
C {bitcell_6t.sym} 3400 25800 0 0 {name=Xr129c17}
N 3360 25840 3340 25840 {}
C {lab_pin.sym} 3340 25840 0 0 {name=l20726 lab=BL17}
N 3360 25800 3340 25800 {}
C {lab_pin.sym} 3340 25800 0 0 {name=l20727 lab=BLB17}
N 3360 25760 3340 25760 {}
C {lab_pin.sym} 3340 25760 0 0 {name=l20728 lab=WL129}
N 3440 25840 3460 25840 {}
C {lab_pin.sym} 3460 25840 0 0 {name=l20729 lab=VDD}
N 3440 25760 3460 25760 {}
C {lab_pin.sym} 3460 25760 0 0 {name=l20730 lab=VSS}
C {bitcell_6t.sym} 3600 25800 0 0 {name=Xr129c18}
N 3560 25840 3540 25840 {}
C {lab_pin.sym} 3540 25840 0 0 {name=l20731 lab=BL18}
N 3560 25800 3540 25800 {}
C {lab_pin.sym} 3540 25800 0 0 {name=l20732 lab=BLB18}
N 3560 25760 3540 25760 {}
C {lab_pin.sym} 3540 25760 0 0 {name=l20733 lab=WL129}
N 3640 25840 3660 25840 {}
C {lab_pin.sym} 3660 25840 0 0 {name=l20734 lab=VDD}
N 3640 25760 3660 25760 {}
C {lab_pin.sym} 3660 25760 0 0 {name=l20735 lab=VSS}
C {bitcell_6t.sym} 3800 25800 0 0 {name=Xr129c19}
N 3760 25840 3740 25840 {}
C {lab_pin.sym} 3740 25840 0 0 {name=l20736 lab=BL19}
N 3760 25800 3740 25800 {}
C {lab_pin.sym} 3740 25800 0 0 {name=l20737 lab=BLB19}
N 3760 25760 3740 25760 {}
C {lab_pin.sym} 3740 25760 0 0 {name=l20738 lab=WL129}
N 3840 25840 3860 25840 {}
C {lab_pin.sym} 3860 25840 0 0 {name=l20739 lab=VDD}
N 3840 25760 3860 25760 {}
C {lab_pin.sym} 3860 25760 0 0 {name=l20740 lab=VSS}
C {bitcell_6t.sym} 4000 25800 0 0 {name=Xr129c20}
N 3960 25840 3940 25840 {}
C {lab_pin.sym} 3940 25840 0 0 {name=l20741 lab=BL20}
N 3960 25800 3940 25800 {}
C {lab_pin.sym} 3940 25800 0 0 {name=l20742 lab=BLB20}
N 3960 25760 3940 25760 {}
C {lab_pin.sym} 3940 25760 0 0 {name=l20743 lab=WL129}
N 4040 25840 4060 25840 {}
C {lab_pin.sym} 4060 25840 0 0 {name=l20744 lab=VDD}
N 4040 25760 4060 25760 {}
C {lab_pin.sym} 4060 25760 0 0 {name=l20745 lab=VSS}
C {bitcell_6t.sym} 4200 25800 0 0 {name=Xr129c21}
N 4160 25840 4140 25840 {}
C {lab_pin.sym} 4140 25840 0 0 {name=l20746 lab=BL21}
N 4160 25800 4140 25800 {}
C {lab_pin.sym} 4140 25800 0 0 {name=l20747 lab=BLB21}
N 4160 25760 4140 25760 {}
C {lab_pin.sym} 4140 25760 0 0 {name=l20748 lab=WL129}
N 4240 25840 4260 25840 {}
C {lab_pin.sym} 4260 25840 0 0 {name=l20749 lab=VDD}
N 4240 25760 4260 25760 {}
C {lab_pin.sym} 4260 25760 0 0 {name=l20750 lab=VSS}
C {bitcell_6t.sym} 4400 25800 0 0 {name=Xr129c22}
N 4360 25840 4340 25840 {}
C {lab_pin.sym} 4340 25840 0 0 {name=l20751 lab=BL22}
N 4360 25800 4340 25800 {}
C {lab_pin.sym} 4340 25800 0 0 {name=l20752 lab=BLB22}
N 4360 25760 4340 25760 {}
C {lab_pin.sym} 4340 25760 0 0 {name=l20753 lab=WL129}
N 4440 25840 4460 25840 {}
C {lab_pin.sym} 4460 25840 0 0 {name=l20754 lab=VDD}
N 4440 25760 4460 25760 {}
C {lab_pin.sym} 4460 25760 0 0 {name=l20755 lab=VSS}
C {bitcell_6t.sym} 4600 25800 0 0 {name=Xr129c23}
N 4560 25840 4540 25840 {}
C {lab_pin.sym} 4540 25840 0 0 {name=l20756 lab=BL23}
N 4560 25800 4540 25800 {}
C {lab_pin.sym} 4540 25800 0 0 {name=l20757 lab=BLB23}
N 4560 25760 4540 25760 {}
C {lab_pin.sym} 4540 25760 0 0 {name=l20758 lab=WL129}
N 4640 25840 4660 25840 {}
C {lab_pin.sym} 4660 25840 0 0 {name=l20759 lab=VDD}
N 4640 25760 4660 25760 {}
C {lab_pin.sym} 4660 25760 0 0 {name=l20760 lab=VSS}
C {bitcell_6t.sym} 4800 25800 0 0 {name=Xr129c24}
N 4760 25840 4740 25840 {}
C {lab_pin.sym} 4740 25840 0 0 {name=l20761 lab=BL24}
N 4760 25800 4740 25800 {}
C {lab_pin.sym} 4740 25800 0 0 {name=l20762 lab=BLB24}
N 4760 25760 4740 25760 {}
C {lab_pin.sym} 4740 25760 0 0 {name=l20763 lab=WL129}
N 4840 25840 4860 25840 {}
C {lab_pin.sym} 4860 25840 0 0 {name=l20764 lab=VDD}
N 4840 25760 4860 25760 {}
C {lab_pin.sym} 4860 25760 0 0 {name=l20765 lab=VSS}
C {bitcell_6t.sym} 5000 25800 0 0 {name=Xr129c25}
N 4960 25840 4940 25840 {}
C {lab_pin.sym} 4940 25840 0 0 {name=l20766 lab=BL25}
N 4960 25800 4940 25800 {}
C {lab_pin.sym} 4940 25800 0 0 {name=l20767 lab=BLB25}
N 4960 25760 4940 25760 {}
C {lab_pin.sym} 4940 25760 0 0 {name=l20768 lab=WL129}
N 5040 25840 5060 25840 {}
C {lab_pin.sym} 5060 25840 0 0 {name=l20769 lab=VDD}
N 5040 25760 5060 25760 {}
C {lab_pin.sym} 5060 25760 0 0 {name=l20770 lab=VSS}
C {bitcell_6t.sym} 5200 25800 0 0 {name=Xr129c26}
N 5160 25840 5140 25840 {}
C {lab_pin.sym} 5140 25840 0 0 {name=l20771 lab=BL26}
N 5160 25800 5140 25800 {}
C {lab_pin.sym} 5140 25800 0 0 {name=l20772 lab=BLB26}
N 5160 25760 5140 25760 {}
C {lab_pin.sym} 5140 25760 0 0 {name=l20773 lab=WL129}
N 5240 25840 5260 25840 {}
C {lab_pin.sym} 5260 25840 0 0 {name=l20774 lab=VDD}
N 5240 25760 5260 25760 {}
C {lab_pin.sym} 5260 25760 0 0 {name=l20775 lab=VSS}
C {bitcell_6t.sym} 5400 25800 0 0 {name=Xr129c27}
N 5360 25840 5340 25840 {}
C {lab_pin.sym} 5340 25840 0 0 {name=l20776 lab=BL27}
N 5360 25800 5340 25800 {}
C {lab_pin.sym} 5340 25800 0 0 {name=l20777 lab=BLB27}
N 5360 25760 5340 25760 {}
C {lab_pin.sym} 5340 25760 0 0 {name=l20778 lab=WL129}
N 5440 25840 5460 25840 {}
C {lab_pin.sym} 5460 25840 0 0 {name=l20779 lab=VDD}
N 5440 25760 5460 25760 {}
C {lab_pin.sym} 5460 25760 0 0 {name=l20780 lab=VSS}
C {bitcell_6t.sym} 5600 25800 0 0 {name=Xr129c28}
N 5560 25840 5540 25840 {}
C {lab_pin.sym} 5540 25840 0 0 {name=l20781 lab=BL28}
N 5560 25800 5540 25800 {}
C {lab_pin.sym} 5540 25800 0 0 {name=l20782 lab=BLB28}
N 5560 25760 5540 25760 {}
C {lab_pin.sym} 5540 25760 0 0 {name=l20783 lab=WL129}
N 5640 25840 5660 25840 {}
C {lab_pin.sym} 5660 25840 0 0 {name=l20784 lab=VDD}
N 5640 25760 5660 25760 {}
C {lab_pin.sym} 5660 25760 0 0 {name=l20785 lab=VSS}
C {bitcell_6t.sym} 5800 25800 0 0 {name=Xr129c29}
N 5760 25840 5740 25840 {}
C {lab_pin.sym} 5740 25840 0 0 {name=l20786 lab=BL29}
N 5760 25800 5740 25800 {}
C {lab_pin.sym} 5740 25800 0 0 {name=l20787 lab=BLB29}
N 5760 25760 5740 25760 {}
C {lab_pin.sym} 5740 25760 0 0 {name=l20788 lab=WL129}
N 5840 25840 5860 25840 {}
C {lab_pin.sym} 5860 25840 0 0 {name=l20789 lab=VDD}
N 5840 25760 5860 25760 {}
C {lab_pin.sym} 5860 25760 0 0 {name=l20790 lab=VSS}
C {bitcell_6t.sym} 6000 25800 0 0 {name=Xr129c30}
N 5960 25840 5940 25840 {}
C {lab_pin.sym} 5940 25840 0 0 {name=l20791 lab=BL30}
N 5960 25800 5940 25800 {}
C {lab_pin.sym} 5940 25800 0 0 {name=l20792 lab=BLB30}
N 5960 25760 5940 25760 {}
C {lab_pin.sym} 5940 25760 0 0 {name=l20793 lab=WL129}
N 6040 25840 6060 25840 {}
C {lab_pin.sym} 6060 25840 0 0 {name=l20794 lab=VDD}
N 6040 25760 6060 25760 {}
C {lab_pin.sym} 6060 25760 0 0 {name=l20795 lab=VSS}
C {bitcell_6t.sym} 6200 25800 0 0 {name=Xr129c31}
N 6160 25840 6140 25840 {}
C {lab_pin.sym} 6140 25840 0 0 {name=l20796 lab=BL31}
N 6160 25800 6140 25800 {}
C {lab_pin.sym} 6140 25800 0 0 {name=l20797 lab=BLB31}
N 6160 25760 6140 25760 {}
C {lab_pin.sym} 6140 25760 0 0 {name=l20798 lab=WL129}
N 6240 25840 6260 25840 {}
C {lab_pin.sym} 6260 25840 0 0 {name=l20799 lab=VDD}
N 6240 25760 6260 25760 {}
C {lab_pin.sym} 6260 25760 0 0 {name=l20800 lab=VSS}
C {bitcell_6t.sym} 0 26000 0 0 {name=Xr130c0}
N -40 26040 -60 26040 {}
C {lab_pin.sym} -60 26040 0 0 {name=l20801 lab=BL0}
N -40 26000 -60 26000 {}
C {lab_pin.sym} -60 26000 0 0 {name=l20802 lab=BLB0}
N -40 25960 -60 25960 {}
C {lab_pin.sym} -60 25960 0 0 {name=l20803 lab=WL130}
N 40 26040 60 26040 {}
C {lab_pin.sym} 60 26040 0 0 {name=l20804 lab=VDD}
N 40 25960 60 25960 {}
C {lab_pin.sym} 60 25960 0 0 {name=l20805 lab=VSS}
C {bitcell_6t.sym} 200 26000 0 0 {name=Xr130c1}
N 160 26040 140 26040 {}
C {lab_pin.sym} 140 26040 0 0 {name=l20806 lab=BL1}
N 160 26000 140 26000 {}
C {lab_pin.sym} 140 26000 0 0 {name=l20807 lab=BLB1}
N 160 25960 140 25960 {}
C {lab_pin.sym} 140 25960 0 0 {name=l20808 lab=WL130}
N 240 26040 260 26040 {}
C {lab_pin.sym} 260 26040 0 0 {name=l20809 lab=VDD}
N 240 25960 260 25960 {}
C {lab_pin.sym} 260 25960 0 0 {name=l20810 lab=VSS}
C {bitcell_6t.sym} 400 26000 0 0 {name=Xr130c2}
N 360 26040 340 26040 {}
C {lab_pin.sym} 340 26040 0 0 {name=l20811 lab=BL2}
N 360 26000 340 26000 {}
C {lab_pin.sym} 340 26000 0 0 {name=l20812 lab=BLB2}
N 360 25960 340 25960 {}
C {lab_pin.sym} 340 25960 0 0 {name=l20813 lab=WL130}
N 440 26040 460 26040 {}
C {lab_pin.sym} 460 26040 0 0 {name=l20814 lab=VDD}
N 440 25960 460 25960 {}
C {lab_pin.sym} 460 25960 0 0 {name=l20815 lab=VSS}
C {bitcell_6t.sym} 600 26000 0 0 {name=Xr130c3}
N 560 26040 540 26040 {}
C {lab_pin.sym} 540 26040 0 0 {name=l20816 lab=BL3}
N 560 26000 540 26000 {}
C {lab_pin.sym} 540 26000 0 0 {name=l20817 lab=BLB3}
N 560 25960 540 25960 {}
C {lab_pin.sym} 540 25960 0 0 {name=l20818 lab=WL130}
N 640 26040 660 26040 {}
C {lab_pin.sym} 660 26040 0 0 {name=l20819 lab=VDD}
N 640 25960 660 25960 {}
C {lab_pin.sym} 660 25960 0 0 {name=l20820 lab=VSS}
C {bitcell_6t.sym} 800 26000 0 0 {name=Xr130c4}
N 760 26040 740 26040 {}
C {lab_pin.sym} 740 26040 0 0 {name=l20821 lab=BL4}
N 760 26000 740 26000 {}
C {lab_pin.sym} 740 26000 0 0 {name=l20822 lab=BLB4}
N 760 25960 740 25960 {}
C {lab_pin.sym} 740 25960 0 0 {name=l20823 lab=WL130}
N 840 26040 860 26040 {}
C {lab_pin.sym} 860 26040 0 0 {name=l20824 lab=VDD}
N 840 25960 860 25960 {}
C {lab_pin.sym} 860 25960 0 0 {name=l20825 lab=VSS}
C {bitcell_6t.sym} 1000 26000 0 0 {name=Xr130c5}
N 960 26040 940 26040 {}
C {lab_pin.sym} 940 26040 0 0 {name=l20826 lab=BL5}
N 960 26000 940 26000 {}
C {lab_pin.sym} 940 26000 0 0 {name=l20827 lab=BLB5}
N 960 25960 940 25960 {}
C {lab_pin.sym} 940 25960 0 0 {name=l20828 lab=WL130}
N 1040 26040 1060 26040 {}
C {lab_pin.sym} 1060 26040 0 0 {name=l20829 lab=VDD}
N 1040 25960 1060 25960 {}
C {lab_pin.sym} 1060 25960 0 0 {name=l20830 lab=VSS}
C {bitcell_6t.sym} 1200 26000 0 0 {name=Xr130c6}
N 1160 26040 1140 26040 {}
C {lab_pin.sym} 1140 26040 0 0 {name=l20831 lab=BL6}
N 1160 26000 1140 26000 {}
C {lab_pin.sym} 1140 26000 0 0 {name=l20832 lab=BLB6}
N 1160 25960 1140 25960 {}
C {lab_pin.sym} 1140 25960 0 0 {name=l20833 lab=WL130}
N 1240 26040 1260 26040 {}
C {lab_pin.sym} 1260 26040 0 0 {name=l20834 lab=VDD}
N 1240 25960 1260 25960 {}
C {lab_pin.sym} 1260 25960 0 0 {name=l20835 lab=VSS}
C {bitcell_6t.sym} 1400 26000 0 0 {name=Xr130c7}
N 1360 26040 1340 26040 {}
C {lab_pin.sym} 1340 26040 0 0 {name=l20836 lab=BL7}
N 1360 26000 1340 26000 {}
C {lab_pin.sym} 1340 26000 0 0 {name=l20837 lab=BLB7}
N 1360 25960 1340 25960 {}
C {lab_pin.sym} 1340 25960 0 0 {name=l20838 lab=WL130}
N 1440 26040 1460 26040 {}
C {lab_pin.sym} 1460 26040 0 0 {name=l20839 lab=VDD}
N 1440 25960 1460 25960 {}
C {lab_pin.sym} 1460 25960 0 0 {name=l20840 lab=VSS}
C {bitcell_6t.sym} 1600 26000 0 0 {name=Xr130c8}
N 1560 26040 1540 26040 {}
C {lab_pin.sym} 1540 26040 0 0 {name=l20841 lab=BL8}
N 1560 26000 1540 26000 {}
C {lab_pin.sym} 1540 26000 0 0 {name=l20842 lab=BLB8}
N 1560 25960 1540 25960 {}
C {lab_pin.sym} 1540 25960 0 0 {name=l20843 lab=WL130}
N 1640 26040 1660 26040 {}
C {lab_pin.sym} 1660 26040 0 0 {name=l20844 lab=VDD}
N 1640 25960 1660 25960 {}
C {lab_pin.sym} 1660 25960 0 0 {name=l20845 lab=VSS}
C {bitcell_6t.sym} 1800 26000 0 0 {name=Xr130c9}
N 1760 26040 1740 26040 {}
C {lab_pin.sym} 1740 26040 0 0 {name=l20846 lab=BL9}
N 1760 26000 1740 26000 {}
C {lab_pin.sym} 1740 26000 0 0 {name=l20847 lab=BLB9}
N 1760 25960 1740 25960 {}
C {lab_pin.sym} 1740 25960 0 0 {name=l20848 lab=WL130}
N 1840 26040 1860 26040 {}
C {lab_pin.sym} 1860 26040 0 0 {name=l20849 lab=VDD}
N 1840 25960 1860 25960 {}
C {lab_pin.sym} 1860 25960 0 0 {name=l20850 lab=VSS}
C {bitcell_6t.sym} 2000 26000 0 0 {name=Xr130c10}
N 1960 26040 1940 26040 {}
C {lab_pin.sym} 1940 26040 0 0 {name=l20851 lab=BL10}
N 1960 26000 1940 26000 {}
C {lab_pin.sym} 1940 26000 0 0 {name=l20852 lab=BLB10}
N 1960 25960 1940 25960 {}
C {lab_pin.sym} 1940 25960 0 0 {name=l20853 lab=WL130}
N 2040 26040 2060 26040 {}
C {lab_pin.sym} 2060 26040 0 0 {name=l20854 lab=VDD}
N 2040 25960 2060 25960 {}
C {lab_pin.sym} 2060 25960 0 0 {name=l20855 lab=VSS}
C {bitcell_6t.sym} 2200 26000 0 0 {name=Xr130c11}
N 2160 26040 2140 26040 {}
C {lab_pin.sym} 2140 26040 0 0 {name=l20856 lab=BL11}
N 2160 26000 2140 26000 {}
C {lab_pin.sym} 2140 26000 0 0 {name=l20857 lab=BLB11}
N 2160 25960 2140 25960 {}
C {lab_pin.sym} 2140 25960 0 0 {name=l20858 lab=WL130}
N 2240 26040 2260 26040 {}
C {lab_pin.sym} 2260 26040 0 0 {name=l20859 lab=VDD}
N 2240 25960 2260 25960 {}
C {lab_pin.sym} 2260 25960 0 0 {name=l20860 lab=VSS}
C {bitcell_6t.sym} 2400 26000 0 0 {name=Xr130c12}
N 2360 26040 2340 26040 {}
C {lab_pin.sym} 2340 26040 0 0 {name=l20861 lab=BL12}
N 2360 26000 2340 26000 {}
C {lab_pin.sym} 2340 26000 0 0 {name=l20862 lab=BLB12}
N 2360 25960 2340 25960 {}
C {lab_pin.sym} 2340 25960 0 0 {name=l20863 lab=WL130}
N 2440 26040 2460 26040 {}
C {lab_pin.sym} 2460 26040 0 0 {name=l20864 lab=VDD}
N 2440 25960 2460 25960 {}
C {lab_pin.sym} 2460 25960 0 0 {name=l20865 lab=VSS}
C {bitcell_6t.sym} 2600 26000 0 0 {name=Xr130c13}
N 2560 26040 2540 26040 {}
C {lab_pin.sym} 2540 26040 0 0 {name=l20866 lab=BL13}
N 2560 26000 2540 26000 {}
C {lab_pin.sym} 2540 26000 0 0 {name=l20867 lab=BLB13}
N 2560 25960 2540 25960 {}
C {lab_pin.sym} 2540 25960 0 0 {name=l20868 lab=WL130}
N 2640 26040 2660 26040 {}
C {lab_pin.sym} 2660 26040 0 0 {name=l20869 lab=VDD}
N 2640 25960 2660 25960 {}
C {lab_pin.sym} 2660 25960 0 0 {name=l20870 lab=VSS}
C {bitcell_6t.sym} 2800 26000 0 0 {name=Xr130c14}
N 2760 26040 2740 26040 {}
C {lab_pin.sym} 2740 26040 0 0 {name=l20871 lab=BL14}
N 2760 26000 2740 26000 {}
C {lab_pin.sym} 2740 26000 0 0 {name=l20872 lab=BLB14}
N 2760 25960 2740 25960 {}
C {lab_pin.sym} 2740 25960 0 0 {name=l20873 lab=WL130}
N 2840 26040 2860 26040 {}
C {lab_pin.sym} 2860 26040 0 0 {name=l20874 lab=VDD}
N 2840 25960 2860 25960 {}
C {lab_pin.sym} 2860 25960 0 0 {name=l20875 lab=VSS}
C {bitcell_6t.sym} 3000 26000 0 0 {name=Xr130c15}
N 2960 26040 2940 26040 {}
C {lab_pin.sym} 2940 26040 0 0 {name=l20876 lab=BL15}
N 2960 26000 2940 26000 {}
C {lab_pin.sym} 2940 26000 0 0 {name=l20877 lab=BLB15}
N 2960 25960 2940 25960 {}
C {lab_pin.sym} 2940 25960 0 0 {name=l20878 lab=WL130}
N 3040 26040 3060 26040 {}
C {lab_pin.sym} 3060 26040 0 0 {name=l20879 lab=VDD}
N 3040 25960 3060 25960 {}
C {lab_pin.sym} 3060 25960 0 0 {name=l20880 lab=VSS}
C {bitcell_6t.sym} 3200 26000 0 0 {name=Xr130c16}
N 3160 26040 3140 26040 {}
C {lab_pin.sym} 3140 26040 0 0 {name=l20881 lab=BL16}
N 3160 26000 3140 26000 {}
C {lab_pin.sym} 3140 26000 0 0 {name=l20882 lab=BLB16}
N 3160 25960 3140 25960 {}
C {lab_pin.sym} 3140 25960 0 0 {name=l20883 lab=WL130}
N 3240 26040 3260 26040 {}
C {lab_pin.sym} 3260 26040 0 0 {name=l20884 lab=VDD}
N 3240 25960 3260 25960 {}
C {lab_pin.sym} 3260 25960 0 0 {name=l20885 lab=VSS}
C {bitcell_6t.sym} 3400 26000 0 0 {name=Xr130c17}
N 3360 26040 3340 26040 {}
C {lab_pin.sym} 3340 26040 0 0 {name=l20886 lab=BL17}
N 3360 26000 3340 26000 {}
C {lab_pin.sym} 3340 26000 0 0 {name=l20887 lab=BLB17}
N 3360 25960 3340 25960 {}
C {lab_pin.sym} 3340 25960 0 0 {name=l20888 lab=WL130}
N 3440 26040 3460 26040 {}
C {lab_pin.sym} 3460 26040 0 0 {name=l20889 lab=VDD}
N 3440 25960 3460 25960 {}
C {lab_pin.sym} 3460 25960 0 0 {name=l20890 lab=VSS}
C {bitcell_6t.sym} 3600 26000 0 0 {name=Xr130c18}
N 3560 26040 3540 26040 {}
C {lab_pin.sym} 3540 26040 0 0 {name=l20891 lab=BL18}
N 3560 26000 3540 26000 {}
C {lab_pin.sym} 3540 26000 0 0 {name=l20892 lab=BLB18}
N 3560 25960 3540 25960 {}
C {lab_pin.sym} 3540 25960 0 0 {name=l20893 lab=WL130}
N 3640 26040 3660 26040 {}
C {lab_pin.sym} 3660 26040 0 0 {name=l20894 lab=VDD}
N 3640 25960 3660 25960 {}
C {lab_pin.sym} 3660 25960 0 0 {name=l20895 lab=VSS}
C {bitcell_6t.sym} 3800 26000 0 0 {name=Xr130c19}
N 3760 26040 3740 26040 {}
C {lab_pin.sym} 3740 26040 0 0 {name=l20896 lab=BL19}
N 3760 26000 3740 26000 {}
C {lab_pin.sym} 3740 26000 0 0 {name=l20897 lab=BLB19}
N 3760 25960 3740 25960 {}
C {lab_pin.sym} 3740 25960 0 0 {name=l20898 lab=WL130}
N 3840 26040 3860 26040 {}
C {lab_pin.sym} 3860 26040 0 0 {name=l20899 lab=VDD}
N 3840 25960 3860 25960 {}
C {lab_pin.sym} 3860 25960 0 0 {name=l20900 lab=VSS}
C {bitcell_6t.sym} 4000 26000 0 0 {name=Xr130c20}
N 3960 26040 3940 26040 {}
C {lab_pin.sym} 3940 26040 0 0 {name=l20901 lab=BL20}
N 3960 26000 3940 26000 {}
C {lab_pin.sym} 3940 26000 0 0 {name=l20902 lab=BLB20}
N 3960 25960 3940 25960 {}
C {lab_pin.sym} 3940 25960 0 0 {name=l20903 lab=WL130}
N 4040 26040 4060 26040 {}
C {lab_pin.sym} 4060 26040 0 0 {name=l20904 lab=VDD}
N 4040 25960 4060 25960 {}
C {lab_pin.sym} 4060 25960 0 0 {name=l20905 lab=VSS}
C {bitcell_6t.sym} 4200 26000 0 0 {name=Xr130c21}
N 4160 26040 4140 26040 {}
C {lab_pin.sym} 4140 26040 0 0 {name=l20906 lab=BL21}
N 4160 26000 4140 26000 {}
C {lab_pin.sym} 4140 26000 0 0 {name=l20907 lab=BLB21}
N 4160 25960 4140 25960 {}
C {lab_pin.sym} 4140 25960 0 0 {name=l20908 lab=WL130}
N 4240 26040 4260 26040 {}
C {lab_pin.sym} 4260 26040 0 0 {name=l20909 lab=VDD}
N 4240 25960 4260 25960 {}
C {lab_pin.sym} 4260 25960 0 0 {name=l20910 lab=VSS}
C {bitcell_6t.sym} 4400 26000 0 0 {name=Xr130c22}
N 4360 26040 4340 26040 {}
C {lab_pin.sym} 4340 26040 0 0 {name=l20911 lab=BL22}
N 4360 26000 4340 26000 {}
C {lab_pin.sym} 4340 26000 0 0 {name=l20912 lab=BLB22}
N 4360 25960 4340 25960 {}
C {lab_pin.sym} 4340 25960 0 0 {name=l20913 lab=WL130}
N 4440 26040 4460 26040 {}
C {lab_pin.sym} 4460 26040 0 0 {name=l20914 lab=VDD}
N 4440 25960 4460 25960 {}
C {lab_pin.sym} 4460 25960 0 0 {name=l20915 lab=VSS}
C {bitcell_6t.sym} 4600 26000 0 0 {name=Xr130c23}
N 4560 26040 4540 26040 {}
C {lab_pin.sym} 4540 26040 0 0 {name=l20916 lab=BL23}
N 4560 26000 4540 26000 {}
C {lab_pin.sym} 4540 26000 0 0 {name=l20917 lab=BLB23}
N 4560 25960 4540 25960 {}
C {lab_pin.sym} 4540 25960 0 0 {name=l20918 lab=WL130}
N 4640 26040 4660 26040 {}
C {lab_pin.sym} 4660 26040 0 0 {name=l20919 lab=VDD}
N 4640 25960 4660 25960 {}
C {lab_pin.sym} 4660 25960 0 0 {name=l20920 lab=VSS}
C {bitcell_6t.sym} 4800 26000 0 0 {name=Xr130c24}
N 4760 26040 4740 26040 {}
C {lab_pin.sym} 4740 26040 0 0 {name=l20921 lab=BL24}
N 4760 26000 4740 26000 {}
C {lab_pin.sym} 4740 26000 0 0 {name=l20922 lab=BLB24}
N 4760 25960 4740 25960 {}
C {lab_pin.sym} 4740 25960 0 0 {name=l20923 lab=WL130}
N 4840 26040 4860 26040 {}
C {lab_pin.sym} 4860 26040 0 0 {name=l20924 lab=VDD}
N 4840 25960 4860 25960 {}
C {lab_pin.sym} 4860 25960 0 0 {name=l20925 lab=VSS}
C {bitcell_6t.sym} 5000 26000 0 0 {name=Xr130c25}
N 4960 26040 4940 26040 {}
C {lab_pin.sym} 4940 26040 0 0 {name=l20926 lab=BL25}
N 4960 26000 4940 26000 {}
C {lab_pin.sym} 4940 26000 0 0 {name=l20927 lab=BLB25}
N 4960 25960 4940 25960 {}
C {lab_pin.sym} 4940 25960 0 0 {name=l20928 lab=WL130}
N 5040 26040 5060 26040 {}
C {lab_pin.sym} 5060 26040 0 0 {name=l20929 lab=VDD}
N 5040 25960 5060 25960 {}
C {lab_pin.sym} 5060 25960 0 0 {name=l20930 lab=VSS}
C {bitcell_6t.sym} 5200 26000 0 0 {name=Xr130c26}
N 5160 26040 5140 26040 {}
C {lab_pin.sym} 5140 26040 0 0 {name=l20931 lab=BL26}
N 5160 26000 5140 26000 {}
C {lab_pin.sym} 5140 26000 0 0 {name=l20932 lab=BLB26}
N 5160 25960 5140 25960 {}
C {lab_pin.sym} 5140 25960 0 0 {name=l20933 lab=WL130}
N 5240 26040 5260 26040 {}
C {lab_pin.sym} 5260 26040 0 0 {name=l20934 lab=VDD}
N 5240 25960 5260 25960 {}
C {lab_pin.sym} 5260 25960 0 0 {name=l20935 lab=VSS}
C {bitcell_6t.sym} 5400 26000 0 0 {name=Xr130c27}
N 5360 26040 5340 26040 {}
C {lab_pin.sym} 5340 26040 0 0 {name=l20936 lab=BL27}
N 5360 26000 5340 26000 {}
C {lab_pin.sym} 5340 26000 0 0 {name=l20937 lab=BLB27}
N 5360 25960 5340 25960 {}
C {lab_pin.sym} 5340 25960 0 0 {name=l20938 lab=WL130}
N 5440 26040 5460 26040 {}
C {lab_pin.sym} 5460 26040 0 0 {name=l20939 lab=VDD}
N 5440 25960 5460 25960 {}
C {lab_pin.sym} 5460 25960 0 0 {name=l20940 lab=VSS}
C {bitcell_6t.sym} 5600 26000 0 0 {name=Xr130c28}
N 5560 26040 5540 26040 {}
C {lab_pin.sym} 5540 26040 0 0 {name=l20941 lab=BL28}
N 5560 26000 5540 26000 {}
C {lab_pin.sym} 5540 26000 0 0 {name=l20942 lab=BLB28}
N 5560 25960 5540 25960 {}
C {lab_pin.sym} 5540 25960 0 0 {name=l20943 lab=WL130}
N 5640 26040 5660 26040 {}
C {lab_pin.sym} 5660 26040 0 0 {name=l20944 lab=VDD}
N 5640 25960 5660 25960 {}
C {lab_pin.sym} 5660 25960 0 0 {name=l20945 lab=VSS}
C {bitcell_6t.sym} 5800 26000 0 0 {name=Xr130c29}
N 5760 26040 5740 26040 {}
C {lab_pin.sym} 5740 26040 0 0 {name=l20946 lab=BL29}
N 5760 26000 5740 26000 {}
C {lab_pin.sym} 5740 26000 0 0 {name=l20947 lab=BLB29}
N 5760 25960 5740 25960 {}
C {lab_pin.sym} 5740 25960 0 0 {name=l20948 lab=WL130}
N 5840 26040 5860 26040 {}
C {lab_pin.sym} 5860 26040 0 0 {name=l20949 lab=VDD}
N 5840 25960 5860 25960 {}
C {lab_pin.sym} 5860 25960 0 0 {name=l20950 lab=VSS}
C {bitcell_6t.sym} 6000 26000 0 0 {name=Xr130c30}
N 5960 26040 5940 26040 {}
C {lab_pin.sym} 5940 26040 0 0 {name=l20951 lab=BL30}
N 5960 26000 5940 26000 {}
C {lab_pin.sym} 5940 26000 0 0 {name=l20952 lab=BLB30}
N 5960 25960 5940 25960 {}
C {lab_pin.sym} 5940 25960 0 0 {name=l20953 lab=WL130}
N 6040 26040 6060 26040 {}
C {lab_pin.sym} 6060 26040 0 0 {name=l20954 lab=VDD}
N 6040 25960 6060 25960 {}
C {lab_pin.sym} 6060 25960 0 0 {name=l20955 lab=VSS}
C {bitcell_6t.sym} 6200 26000 0 0 {name=Xr130c31}
N 6160 26040 6140 26040 {}
C {lab_pin.sym} 6140 26040 0 0 {name=l20956 lab=BL31}
N 6160 26000 6140 26000 {}
C {lab_pin.sym} 6140 26000 0 0 {name=l20957 lab=BLB31}
N 6160 25960 6140 25960 {}
C {lab_pin.sym} 6140 25960 0 0 {name=l20958 lab=WL130}
N 6240 26040 6260 26040 {}
C {lab_pin.sym} 6260 26040 0 0 {name=l20959 lab=VDD}
N 6240 25960 6260 25960 {}
C {lab_pin.sym} 6260 25960 0 0 {name=l20960 lab=VSS}
C {bitcell_6t.sym} 0 26200 0 0 {name=Xr131c0}
N -40 26240 -60 26240 {}
C {lab_pin.sym} -60 26240 0 0 {name=l20961 lab=BL0}
N -40 26200 -60 26200 {}
C {lab_pin.sym} -60 26200 0 0 {name=l20962 lab=BLB0}
N -40 26160 -60 26160 {}
C {lab_pin.sym} -60 26160 0 0 {name=l20963 lab=WL131}
N 40 26240 60 26240 {}
C {lab_pin.sym} 60 26240 0 0 {name=l20964 lab=VDD}
N 40 26160 60 26160 {}
C {lab_pin.sym} 60 26160 0 0 {name=l20965 lab=VSS}
C {bitcell_6t.sym} 200 26200 0 0 {name=Xr131c1}
N 160 26240 140 26240 {}
C {lab_pin.sym} 140 26240 0 0 {name=l20966 lab=BL1}
N 160 26200 140 26200 {}
C {lab_pin.sym} 140 26200 0 0 {name=l20967 lab=BLB1}
N 160 26160 140 26160 {}
C {lab_pin.sym} 140 26160 0 0 {name=l20968 lab=WL131}
N 240 26240 260 26240 {}
C {lab_pin.sym} 260 26240 0 0 {name=l20969 lab=VDD}
N 240 26160 260 26160 {}
C {lab_pin.sym} 260 26160 0 0 {name=l20970 lab=VSS}
C {bitcell_6t.sym} 400 26200 0 0 {name=Xr131c2}
N 360 26240 340 26240 {}
C {lab_pin.sym} 340 26240 0 0 {name=l20971 lab=BL2}
N 360 26200 340 26200 {}
C {lab_pin.sym} 340 26200 0 0 {name=l20972 lab=BLB2}
N 360 26160 340 26160 {}
C {lab_pin.sym} 340 26160 0 0 {name=l20973 lab=WL131}
N 440 26240 460 26240 {}
C {lab_pin.sym} 460 26240 0 0 {name=l20974 lab=VDD}
N 440 26160 460 26160 {}
C {lab_pin.sym} 460 26160 0 0 {name=l20975 lab=VSS}
C {bitcell_6t.sym} 600 26200 0 0 {name=Xr131c3}
N 560 26240 540 26240 {}
C {lab_pin.sym} 540 26240 0 0 {name=l20976 lab=BL3}
N 560 26200 540 26200 {}
C {lab_pin.sym} 540 26200 0 0 {name=l20977 lab=BLB3}
N 560 26160 540 26160 {}
C {lab_pin.sym} 540 26160 0 0 {name=l20978 lab=WL131}
N 640 26240 660 26240 {}
C {lab_pin.sym} 660 26240 0 0 {name=l20979 lab=VDD}
N 640 26160 660 26160 {}
C {lab_pin.sym} 660 26160 0 0 {name=l20980 lab=VSS}
C {bitcell_6t.sym} 800 26200 0 0 {name=Xr131c4}
N 760 26240 740 26240 {}
C {lab_pin.sym} 740 26240 0 0 {name=l20981 lab=BL4}
N 760 26200 740 26200 {}
C {lab_pin.sym} 740 26200 0 0 {name=l20982 lab=BLB4}
N 760 26160 740 26160 {}
C {lab_pin.sym} 740 26160 0 0 {name=l20983 lab=WL131}
N 840 26240 860 26240 {}
C {lab_pin.sym} 860 26240 0 0 {name=l20984 lab=VDD}
N 840 26160 860 26160 {}
C {lab_pin.sym} 860 26160 0 0 {name=l20985 lab=VSS}
C {bitcell_6t.sym} 1000 26200 0 0 {name=Xr131c5}
N 960 26240 940 26240 {}
C {lab_pin.sym} 940 26240 0 0 {name=l20986 lab=BL5}
N 960 26200 940 26200 {}
C {lab_pin.sym} 940 26200 0 0 {name=l20987 lab=BLB5}
N 960 26160 940 26160 {}
C {lab_pin.sym} 940 26160 0 0 {name=l20988 lab=WL131}
N 1040 26240 1060 26240 {}
C {lab_pin.sym} 1060 26240 0 0 {name=l20989 lab=VDD}
N 1040 26160 1060 26160 {}
C {lab_pin.sym} 1060 26160 0 0 {name=l20990 lab=VSS}
C {bitcell_6t.sym} 1200 26200 0 0 {name=Xr131c6}
N 1160 26240 1140 26240 {}
C {lab_pin.sym} 1140 26240 0 0 {name=l20991 lab=BL6}
N 1160 26200 1140 26200 {}
C {lab_pin.sym} 1140 26200 0 0 {name=l20992 lab=BLB6}
N 1160 26160 1140 26160 {}
C {lab_pin.sym} 1140 26160 0 0 {name=l20993 lab=WL131}
N 1240 26240 1260 26240 {}
C {lab_pin.sym} 1260 26240 0 0 {name=l20994 lab=VDD}
N 1240 26160 1260 26160 {}
C {lab_pin.sym} 1260 26160 0 0 {name=l20995 lab=VSS}
C {bitcell_6t.sym} 1400 26200 0 0 {name=Xr131c7}
N 1360 26240 1340 26240 {}
C {lab_pin.sym} 1340 26240 0 0 {name=l20996 lab=BL7}
N 1360 26200 1340 26200 {}
C {lab_pin.sym} 1340 26200 0 0 {name=l20997 lab=BLB7}
N 1360 26160 1340 26160 {}
C {lab_pin.sym} 1340 26160 0 0 {name=l20998 lab=WL131}
N 1440 26240 1460 26240 {}
C {lab_pin.sym} 1460 26240 0 0 {name=l20999 lab=VDD}
N 1440 26160 1460 26160 {}
C {lab_pin.sym} 1460 26160 0 0 {name=l21000 lab=VSS}
C {bitcell_6t.sym} 1600 26200 0 0 {name=Xr131c8}
N 1560 26240 1540 26240 {}
C {lab_pin.sym} 1540 26240 0 0 {name=l21001 lab=BL8}
N 1560 26200 1540 26200 {}
C {lab_pin.sym} 1540 26200 0 0 {name=l21002 lab=BLB8}
N 1560 26160 1540 26160 {}
C {lab_pin.sym} 1540 26160 0 0 {name=l21003 lab=WL131}
N 1640 26240 1660 26240 {}
C {lab_pin.sym} 1660 26240 0 0 {name=l21004 lab=VDD}
N 1640 26160 1660 26160 {}
C {lab_pin.sym} 1660 26160 0 0 {name=l21005 lab=VSS}
C {bitcell_6t.sym} 1800 26200 0 0 {name=Xr131c9}
N 1760 26240 1740 26240 {}
C {lab_pin.sym} 1740 26240 0 0 {name=l21006 lab=BL9}
N 1760 26200 1740 26200 {}
C {lab_pin.sym} 1740 26200 0 0 {name=l21007 lab=BLB9}
N 1760 26160 1740 26160 {}
C {lab_pin.sym} 1740 26160 0 0 {name=l21008 lab=WL131}
N 1840 26240 1860 26240 {}
C {lab_pin.sym} 1860 26240 0 0 {name=l21009 lab=VDD}
N 1840 26160 1860 26160 {}
C {lab_pin.sym} 1860 26160 0 0 {name=l21010 lab=VSS}
C {bitcell_6t.sym} 2000 26200 0 0 {name=Xr131c10}
N 1960 26240 1940 26240 {}
C {lab_pin.sym} 1940 26240 0 0 {name=l21011 lab=BL10}
N 1960 26200 1940 26200 {}
C {lab_pin.sym} 1940 26200 0 0 {name=l21012 lab=BLB10}
N 1960 26160 1940 26160 {}
C {lab_pin.sym} 1940 26160 0 0 {name=l21013 lab=WL131}
N 2040 26240 2060 26240 {}
C {lab_pin.sym} 2060 26240 0 0 {name=l21014 lab=VDD}
N 2040 26160 2060 26160 {}
C {lab_pin.sym} 2060 26160 0 0 {name=l21015 lab=VSS}
C {bitcell_6t.sym} 2200 26200 0 0 {name=Xr131c11}
N 2160 26240 2140 26240 {}
C {lab_pin.sym} 2140 26240 0 0 {name=l21016 lab=BL11}
N 2160 26200 2140 26200 {}
C {lab_pin.sym} 2140 26200 0 0 {name=l21017 lab=BLB11}
N 2160 26160 2140 26160 {}
C {lab_pin.sym} 2140 26160 0 0 {name=l21018 lab=WL131}
N 2240 26240 2260 26240 {}
C {lab_pin.sym} 2260 26240 0 0 {name=l21019 lab=VDD}
N 2240 26160 2260 26160 {}
C {lab_pin.sym} 2260 26160 0 0 {name=l21020 lab=VSS}
C {bitcell_6t.sym} 2400 26200 0 0 {name=Xr131c12}
N 2360 26240 2340 26240 {}
C {lab_pin.sym} 2340 26240 0 0 {name=l21021 lab=BL12}
N 2360 26200 2340 26200 {}
C {lab_pin.sym} 2340 26200 0 0 {name=l21022 lab=BLB12}
N 2360 26160 2340 26160 {}
C {lab_pin.sym} 2340 26160 0 0 {name=l21023 lab=WL131}
N 2440 26240 2460 26240 {}
C {lab_pin.sym} 2460 26240 0 0 {name=l21024 lab=VDD}
N 2440 26160 2460 26160 {}
C {lab_pin.sym} 2460 26160 0 0 {name=l21025 lab=VSS}
C {bitcell_6t.sym} 2600 26200 0 0 {name=Xr131c13}
N 2560 26240 2540 26240 {}
C {lab_pin.sym} 2540 26240 0 0 {name=l21026 lab=BL13}
N 2560 26200 2540 26200 {}
C {lab_pin.sym} 2540 26200 0 0 {name=l21027 lab=BLB13}
N 2560 26160 2540 26160 {}
C {lab_pin.sym} 2540 26160 0 0 {name=l21028 lab=WL131}
N 2640 26240 2660 26240 {}
C {lab_pin.sym} 2660 26240 0 0 {name=l21029 lab=VDD}
N 2640 26160 2660 26160 {}
C {lab_pin.sym} 2660 26160 0 0 {name=l21030 lab=VSS}
C {bitcell_6t.sym} 2800 26200 0 0 {name=Xr131c14}
N 2760 26240 2740 26240 {}
C {lab_pin.sym} 2740 26240 0 0 {name=l21031 lab=BL14}
N 2760 26200 2740 26200 {}
C {lab_pin.sym} 2740 26200 0 0 {name=l21032 lab=BLB14}
N 2760 26160 2740 26160 {}
C {lab_pin.sym} 2740 26160 0 0 {name=l21033 lab=WL131}
N 2840 26240 2860 26240 {}
C {lab_pin.sym} 2860 26240 0 0 {name=l21034 lab=VDD}
N 2840 26160 2860 26160 {}
C {lab_pin.sym} 2860 26160 0 0 {name=l21035 lab=VSS}
C {bitcell_6t.sym} 3000 26200 0 0 {name=Xr131c15}
N 2960 26240 2940 26240 {}
C {lab_pin.sym} 2940 26240 0 0 {name=l21036 lab=BL15}
N 2960 26200 2940 26200 {}
C {lab_pin.sym} 2940 26200 0 0 {name=l21037 lab=BLB15}
N 2960 26160 2940 26160 {}
C {lab_pin.sym} 2940 26160 0 0 {name=l21038 lab=WL131}
N 3040 26240 3060 26240 {}
C {lab_pin.sym} 3060 26240 0 0 {name=l21039 lab=VDD}
N 3040 26160 3060 26160 {}
C {lab_pin.sym} 3060 26160 0 0 {name=l21040 lab=VSS}
C {bitcell_6t.sym} 3200 26200 0 0 {name=Xr131c16}
N 3160 26240 3140 26240 {}
C {lab_pin.sym} 3140 26240 0 0 {name=l21041 lab=BL16}
N 3160 26200 3140 26200 {}
C {lab_pin.sym} 3140 26200 0 0 {name=l21042 lab=BLB16}
N 3160 26160 3140 26160 {}
C {lab_pin.sym} 3140 26160 0 0 {name=l21043 lab=WL131}
N 3240 26240 3260 26240 {}
C {lab_pin.sym} 3260 26240 0 0 {name=l21044 lab=VDD}
N 3240 26160 3260 26160 {}
C {lab_pin.sym} 3260 26160 0 0 {name=l21045 lab=VSS}
C {bitcell_6t.sym} 3400 26200 0 0 {name=Xr131c17}
N 3360 26240 3340 26240 {}
C {lab_pin.sym} 3340 26240 0 0 {name=l21046 lab=BL17}
N 3360 26200 3340 26200 {}
C {lab_pin.sym} 3340 26200 0 0 {name=l21047 lab=BLB17}
N 3360 26160 3340 26160 {}
C {lab_pin.sym} 3340 26160 0 0 {name=l21048 lab=WL131}
N 3440 26240 3460 26240 {}
C {lab_pin.sym} 3460 26240 0 0 {name=l21049 lab=VDD}
N 3440 26160 3460 26160 {}
C {lab_pin.sym} 3460 26160 0 0 {name=l21050 lab=VSS}
C {bitcell_6t.sym} 3600 26200 0 0 {name=Xr131c18}
N 3560 26240 3540 26240 {}
C {lab_pin.sym} 3540 26240 0 0 {name=l21051 lab=BL18}
N 3560 26200 3540 26200 {}
C {lab_pin.sym} 3540 26200 0 0 {name=l21052 lab=BLB18}
N 3560 26160 3540 26160 {}
C {lab_pin.sym} 3540 26160 0 0 {name=l21053 lab=WL131}
N 3640 26240 3660 26240 {}
C {lab_pin.sym} 3660 26240 0 0 {name=l21054 lab=VDD}
N 3640 26160 3660 26160 {}
C {lab_pin.sym} 3660 26160 0 0 {name=l21055 lab=VSS}
C {bitcell_6t.sym} 3800 26200 0 0 {name=Xr131c19}
N 3760 26240 3740 26240 {}
C {lab_pin.sym} 3740 26240 0 0 {name=l21056 lab=BL19}
N 3760 26200 3740 26200 {}
C {lab_pin.sym} 3740 26200 0 0 {name=l21057 lab=BLB19}
N 3760 26160 3740 26160 {}
C {lab_pin.sym} 3740 26160 0 0 {name=l21058 lab=WL131}
N 3840 26240 3860 26240 {}
C {lab_pin.sym} 3860 26240 0 0 {name=l21059 lab=VDD}
N 3840 26160 3860 26160 {}
C {lab_pin.sym} 3860 26160 0 0 {name=l21060 lab=VSS}
C {bitcell_6t.sym} 4000 26200 0 0 {name=Xr131c20}
N 3960 26240 3940 26240 {}
C {lab_pin.sym} 3940 26240 0 0 {name=l21061 lab=BL20}
N 3960 26200 3940 26200 {}
C {lab_pin.sym} 3940 26200 0 0 {name=l21062 lab=BLB20}
N 3960 26160 3940 26160 {}
C {lab_pin.sym} 3940 26160 0 0 {name=l21063 lab=WL131}
N 4040 26240 4060 26240 {}
C {lab_pin.sym} 4060 26240 0 0 {name=l21064 lab=VDD}
N 4040 26160 4060 26160 {}
C {lab_pin.sym} 4060 26160 0 0 {name=l21065 lab=VSS}
C {bitcell_6t.sym} 4200 26200 0 0 {name=Xr131c21}
N 4160 26240 4140 26240 {}
C {lab_pin.sym} 4140 26240 0 0 {name=l21066 lab=BL21}
N 4160 26200 4140 26200 {}
C {lab_pin.sym} 4140 26200 0 0 {name=l21067 lab=BLB21}
N 4160 26160 4140 26160 {}
C {lab_pin.sym} 4140 26160 0 0 {name=l21068 lab=WL131}
N 4240 26240 4260 26240 {}
C {lab_pin.sym} 4260 26240 0 0 {name=l21069 lab=VDD}
N 4240 26160 4260 26160 {}
C {lab_pin.sym} 4260 26160 0 0 {name=l21070 lab=VSS}
C {bitcell_6t.sym} 4400 26200 0 0 {name=Xr131c22}
N 4360 26240 4340 26240 {}
C {lab_pin.sym} 4340 26240 0 0 {name=l21071 lab=BL22}
N 4360 26200 4340 26200 {}
C {lab_pin.sym} 4340 26200 0 0 {name=l21072 lab=BLB22}
N 4360 26160 4340 26160 {}
C {lab_pin.sym} 4340 26160 0 0 {name=l21073 lab=WL131}
N 4440 26240 4460 26240 {}
C {lab_pin.sym} 4460 26240 0 0 {name=l21074 lab=VDD}
N 4440 26160 4460 26160 {}
C {lab_pin.sym} 4460 26160 0 0 {name=l21075 lab=VSS}
C {bitcell_6t.sym} 4600 26200 0 0 {name=Xr131c23}
N 4560 26240 4540 26240 {}
C {lab_pin.sym} 4540 26240 0 0 {name=l21076 lab=BL23}
N 4560 26200 4540 26200 {}
C {lab_pin.sym} 4540 26200 0 0 {name=l21077 lab=BLB23}
N 4560 26160 4540 26160 {}
C {lab_pin.sym} 4540 26160 0 0 {name=l21078 lab=WL131}
N 4640 26240 4660 26240 {}
C {lab_pin.sym} 4660 26240 0 0 {name=l21079 lab=VDD}
N 4640 26160 4660 26160 {}
C {lab_pin.sym} 4660 26160 0 0 {name=l21080 lab=VSS}
C {bitcell_6t.sym} 4800 26200 0 0 {name=Xr131c24}
N 4760 26240 4740 26240 {}
C {lab_pin.sym} 4740 26240 0 0 {name=l21081 lab=BL24}
N 4760 26200 4740 26200 {}
C {lab_pin.sym} 4740 26200 0 0 {name=l21082 lab=BLB24}
N 4760 26160 4740 26160 {}
C {lab_pin.sym} 4740 26160 0 0 {name=l21083 lab=WL131}
N 4840 26240 4860 26240 {}
C {lab_pin.sym} 4860 26240 0 0 {name=l21084 lab=VDD}
N 4840 26160 4860 26160 {}
C {lab_pin.sym} 4860 26160 0 0 {name=l21085 lab=VSS}
C {bitcell_6t.sym} 5000 26200 0 0 {name=Xr131c25}
N 4960 26240 4940 26240 {}
C {lab_pin.sym} 4940 26240 0 0 {name=l21086 lab=BL25}
N 4960 26200 4940 26200 {}
C {lab_pin.sym} 4940 26200 0 0 {name=l21087 lab=BLB25}
N 4960 26160 4940 26160 {}
C {lab_pin.sym} 4940 26160 0 0 {name=l21088 lab=WL131}
N 5040 26240 5060 26240 {}
C {lab_pin.sym} 5060 26240 0 0 {name=l21089 lab=VDD}
N 5040 26160 5060 26160 {}
C {lab_pin.sym} 5060 26160 0 0 {name=l21090 lab=VSS}
C {bitcell_6t.sym} 5200 26200 0 0 {name=Xr131c26}
N 5160 26240 5140 26240 {}
C {lab_pin.sym} 5140 26240 0 0 {name=l21091 lab=BL26}
N 5160 26200 5140 26200 {}
C {lab_pin.sym} 5140 26200 0 0 {name=l21092 lab=BLB26}
N 5160 26160 5140 26160 {}
C {lab_pin.sym} 5140 26160 0 0 {name=l21093 lab=WL131}
N 5240 26240 5260 26240 {}
C {lab_pin.sym} 5260 26240 0 0 {name=l21094 lab=VDD}
N 5240 26160 5260 26160 {}
C {lab_pin.sym} 5260 26160 0 0 {name=l21095 lab=VSS}
C {bitcell_6t.sym} 5400 26200 0 0 {name=Xr131c27}
N 5360 26240 5340 26240 {}
C {lab_pin.sym} 5340 26240 0 0 {name=l21096 lab=BL27}
N 5360 26200 5340 26200 {}
C {lab_pin.sym} 5340 26200 0 0 {name=l21097 lab=BLB27}
N 5360 26160 5340 26160 {}
C {lab_pin.sym} 5340 26160 0 0 {name=l21098 lab=WL131}
N 5440 26240 5460 26240 {}
C {lab_pin.sym} 5460 26240 0 0 {name=l21099 lab=VDD}
N 5440 26160 5460 26160 {}
C {lab_pin.sym} 5460 26160 0 0 {name=l21100 lab=VSS}
C {bitcell_6t.sym} 5600 26200 0 0 {name=Xr131c28}
N 5560 26240 5540 26240 {}
C {lab_pin.sym} 5540 26240 0 0 {name=l21101 lab=BL28}
N 5560 26200 5540 26200 {}
C {lab_pin.sym} 5540 26200 0 0 {name=l21102 lab=BLB28}
N 5560 26160 5540 26160 {}
C {lab_pin.sym} 5540 26160 0 0 {name=l21103 lab=WL131}
N 5640 26240 5660 26240 {}
C {lab_pin.sym} 5660 26240 0 0 {name=l21104 lab=VDD}
N 5640 26160 5660 26160 {}
C {lab_pin.sym} 5660 26160 0 0 {name=l21105 lab=VSS}
C {bitcell_6t.sym} 5800 26200 0 0 {name=Xr131c29}
N 5760 26240 5740 26240 {}
C {lab_pin.sym} 5740 26240 0 0 {name=l21106 lab=BL29}
N 5760 26200 5740 26200 {}
C {lab_pin.sym} 5740 26200 0 0 {name=l21107 lab=BLB29}
N 5760 26160 5740 26160 {}
C {lab_pin.sym} 5740 26160 0 0 {name=l21108 lab=WL131}
N 5840 26240 5860 26240 {}
C {lab_pin.sym} 5860 26240 0 0 {name=l21109 lab=VDD}
N 5840 26160 5860 26160 {}
C {lab_pin.sym} 5860 26160 0 0 {name=l21110 lab=VSS}
C {bitcell_6t.sym} 6000 26200 0 0 {name=Xr131c30}
N 5960 26240 5940 26240 {}
C {lab_pin.sym} 5940 26240 0 0 {name=l21111 lab=BL30}
N 5960 26200 5940 26200 {}
C {lab_pin.sym} 5940 26200 0 0 {name=l21112 lab=BLB30}
N 5960 26160 5940 26160 {}
C {lab_pin.sym} 5940 26160 0 0 {name=l21113 lab=WL131}
N 6040 26240 6060 26240 {}
C {lab_pin.sym} 6060 26240 0 0 {name=l21114 lab=VDD}
N 6040 26160 6060 26160 {}
C {lab_pin.sym} 6060 26160 0 0 {name=l21115 lab=VSS}
C {bitcell_6t.sym} 6200 26200 0 0 {name=Xr131c31}
N 6160 26240 6140 26240 {}
C {lab_pin.sym} 6140 26240 0 0 {name=l21116 lab=BL31}
N 6160 26200 6140 26200 {}
C {lab_pin.sym} 6140 26200 0 0 {name=l21117 lab=BLB31}
N 6160 26160 6140 26160 {}
C {lab_pin.sym} 6140 26160 0 0 {name=l21118 lab=WL131}
N 6240 26240 6260 26240 {}
C {lab_pin.sym} 6260 26240 0 0 {name=l21119 lab=VDD}
N 6240 26160 6260 26160 {}
C {lab_pin.sym} 6260 26160 0 0 {name=l21120 lab=VSS}
C {bitcell_6t.sym} 0 26400 0 0 {name=Xr132c0}
N -40 26440 -60 26440 {}
C {lab_pin.sym} -60 26440 0 0 {name=l21121 lab=BL0}
N -40 26400 -60 26400 {}
C {lab_pin.sym} -60 26400 0 0 {name=l21122 lab=BLB0}
N -40 26360 -60 26360 {}
C {lab_pin.sym} -60 26360 0 0 {name=l21123 lab=WL132}
N 40 26440 60 26440 {}
C {lab_pin.sym} 60 26440 0 0 {name=l21124 lab=VDD}
N 40 26360 60 26360 {}
C {lab_pin.sym} 60 26360 0 0 {name=l21125 lab=VSS}
C {bitcell_6t.sym} 200 26400 0 0 {name=Xr132c1}
N 160 26440 140 26440 {}
C {lab_pin.sym} 140 26440 0 0 {name=l21126 lab=BL1}
N 160 26400 140 26400 {}
C {lab_pin.sym} 140 26400 0 0 {name=l21127 lab=BLB1}
N 160 26360 140 26360 {}
C {lab_pin.sym} 140 26360 0 0 {name=l21128 lab=WL132}
N 240 26440 260 26440 {}
C {lab_pin.sym} 260 26440 0 0 {name=l21129 lab=VDD}
N 240 26360 260 26360 {}
C {lab_pin.sym} 260 26360 0 0 {name=l21130 lab=VSS}
C {bitcell_6t.sym} 400 26400 0 0 {name=Xr132c2}
N 360 26440 340 26440 {}
C {lab_pin.sym} 340 26440 0 0 {name=l21131 lab=BL2}
N 360 26400 340 26400 {}
C {lab_pin.sym} 340 26400 0 0 {name=l21132 lab=BLB2}
N 360 26360 340 26360 {}
C {lab_pin.sym} 340 26360 0 0 {name=l21133 lab=WL132}
N 440 26440 460 26440 {}
C {lab_pin.sym} 460 26440 0 0 {name=l21134 lab=VDD}
N 440 26360 460 26360 {}
C {lab_pin.sym} 460 26360 0 0 {name=l21135 lab=VSS}
C {bitcell_6t.sym} 600 26400 0 0 {name=Xr132c3}
N 560 26440 540 26440 {}
C {lab_pin.sym} 540 26440 0 0 {name=l21136 lab=BL3}
N 560 26400 540 26400 {}
C {lab_pin.sym} 540 26400 0 0 {name=l21137 lab=BLB3}
N 560 26360 540 26360 {}
C {lab_pin.sym} 540 26360 0 0 {name=l21138 lab=WL132}
N 640 26440 660 26440 {}
C {lab_pin.sym} 660 26440 0 0 {name=l21139 lab=VDD}
N 640 26360 660 26360 {}
C {lab_pin.sym} 660 26360 0 0 {name=l21140 lab=VSS}
C {bitcell_6t.sym} 800 26400 0 0 {name=Xr132c4}
N 760 26440 740 26440 {}
C {lab_pin.sym} 740 26440 0 0 {name=l21141 lab=BL4}
N 760 26400 740 26400 {}
C {lab_pin.sym} 740 26400 0 0 {name=l21142 lab=BLB4}
N 760 26360 740 26360 {}
C {lab_pin.sym} 740 26360 0 0 {name=l21143 lab=WL132}
N 840 26440 860 26440 {}
C {lab_pin.sym} 860 26440 0 0 {name=l21144 lab=VDD}
N 840 26360 860 26360 {}
C {lab_pin.sym} 860 26360 0 0 {name=l21145 lab=VSS}
C {bitcell_6t.sym} 1000 26400 0 0 {name=Xr132c5}
N 960 26440 940 26440 {}
C {lab_pin.sym} 940 26440 0 0 {name=l21146 lab=BL5}
N 960 26400 940 26400 {}
C {lab_pin.sym} 940 26400 0 0 {name=l21147 lab=BLB5}
N 960 26360 940 26360 {}
C {lab_pin.sym} 940 26360 0 0 {name=l21148 lab=WL132}
N 1040 26440 1060 26440 {}
C {lab_pin.sym} 1060 26440 0 0 {name=l21149 lab=VDD}
N 1040 26360 1060 26360 {}
C {lab_pin.sym} 1060 26360 0 0 {name=l21150 lab=VSS}
C {bitcell_6t.sym} 1200 26400 0 0 {name=Xr132c6}
N 1160 26440 1140 26440 {}
C {lab_pin.sym} 1140 26440 0 0 {name=l21151 lab=BL6}
N 1160 26400 1140 26400 {}
C {lab_pin.sym} 1140 26400 0 0 {name=l21152 lab=BLB6}
N 1160 26360 1140 26360 {}
C {lab_pin.sym} 1140 26360 0 0 {name=l21153 lab=WL132}
N 1240 26440 1260 26440 {}
C {lab_pin.sym} 1260 26440 0 0 {name=l21154 lab=VDD}
N 1240 26360 1260 26360 {}
C {lab_pin.sym} 1260 26360 0 0 {name=l21155 lab=VSS}
C {bitcell_6t.sym} 1400 26400 0 0 {name=Xr132c7}
N 1360 26440 1340 26440 {}
C {lab_pin.sym} 1340 26440 0 0 {name=l21156 lab=BL7}
N 1360 26400 1340 26400 {}
C {lab_pin.sym} 1340 26400 0 0 {name=l21157 lab=BLB7}
N 1360 26360 1340 26360 {}
C {lab_pin.sym} 1340 26360 0 0 {name=l21158 lab=WL132}
N 1440 26440 1460 26440 {}
C {lab_pin.sym} 1460 26440 0 0 {name=l21159 lab=VDD}
N 1440 26360 1460 26360 {}
C {lab_pin.sym} 1460 26360 0 0 {name=l21160 lab=VSS}
C {bitcell_6t.sym} 1600 26400 0 0 {name=Xr132c8}
N 1560 26440 1540 26440 {}
C {lab_pin.sym} 1540 26440 0 0 {name=l21161 lab=BL8}
N 1560 26400 1540 26400 {}
C {lab_pin.sym} 1540 26400 0 0 {name=l21162 lab=BLB8}
N 1560 26360 1540 26360 {}
C {lab_pin.sym} 1540 26360 0 0 {name=l21163 lab=WL132}
N 1640 26440 1660 26440 {}
C {lab_pin.sym} 1660 26440 0 0 {name=l21164 lab=VDD}
N 1640 26360 1660 26360 {}
C {lab_pin.sym} 1660 26360 0 0 {name=l21165 lab=VSS}
C {bitcell_6t.sym} 1800 26400 0 0 {name=Xr132c9}
N 1760 26440 1740 26440 {}
C {lab_pin.sym} 1740 26440 0 0 {name=l21166 lab=BL9}
N 1760 26400 1740 26400 {}
C {lab_pin.sym} 1740 26400 0 0 {name=l21167 lab=BLB9}
N 1760 26360 1740 26360 {}
C {lab_pin.sym} 1740 26360 0 0 {name=l21168 lab=WL132}
N 1840 26440 1860 26440 {}
C {lab_pin.sym} 1860 26440 0 0 {name=l21169 lab=VDD}
N 1840 26360 1860 26360 {}
C {lab_pin.sym} 1860 26360 0 0 {name=l21170 lab=VSS}
C {bitcell_6t.sym} 2000 26400 0 0 {name=Xr132c10}
N 1960 26440 1940 26440 {}
C {lab_pin.sym} 1940 26440 0 0 {name=l21171 lab=BL10}
N 1960 26400 1940 26400 {}
C {lab_pin.sym} 1940 26400 0 0 {name=l21172 lab=BLB10}
N 1960 26360 1940 26360 {}
C {lab_pin.sym} 1940 26360 0 0 {name=l21173 lab=WL132}
N 2040 26440 2060 26440 {}
C {lab_pin.sym} 2060 26440 0 0 {name=l21174 lab=VDD}
N 2040 26360 2060 26360 {}
C {lab_pin.sym} 2060 26360 0 0 {name=l21175 lab=VSS}
C {bitcell_6t.sym} 2200 26400 0 0 {name=Xr132c11}
N 2160 26440 2140 26440 {}
C {lab_pin.sym} 2140 26440 0 0 {name=l21176 lab=BL11}
N 2160 26400 2140 26400 {}
C {lab_pin.sym} 2140 26400 0 0 {name=l21177 lab=BLB11}
N 2160 26360 2140 26360 {}
C {lab_pin.sym} 2140 26360 0 0 {name=l21178 lab=WL132}
N 2240 26440 2260 26440 {}
C {lab_pin.sym} 2260 26440 0 0 {name=l21179 lab=VDD}
N 2240 26360 2260 26360 {}
C {lab_pin.sym} 2260 26360 0 0 {name=l21180 lab=VSS}
C {bitcell_6t.sym} 2400 26400 0 0 {name=Xr132c12}
N 2360 26440 2340 26440 {}
C {lab_pin.sym} 2340 26440 0 0 {name=l21181 lab=BL12}
N 2360 26400 2340 26400 {}
C {lab_pin.sym} 2340 26400 0 0 {name=l21182 lab=BLB12}
N 2360 26360 2340 26360 {}
C {lab_pin.sym} 2340 26360 0 0 {name=l21183 lab=WL132}
N 2440 26440 2460 26440 {}
C {lab_pin.sym} 2460 26440 0 0 {name=l21184 lab=VDD}
N 2440 26360 2460 26360 {}
C {lab_pin.sym} 2460 26360 0 0 {name=l21185 lab=VSS}
C {bitcell_6t.sym} 2600 26400 0 0 {name=Xr132c13}
N 2560 26440 2540 26440 {}
C {lab_pin.sym} 2540 26440 0 0 {name=l21186 lab=BL13}
N 2560 26400 2540 26400 {}
C {lab_pin.sym} 2540 26400 0 0 {name=l21187 lab=BLB13}
N 2560 26360 2540 26360 {}
C {lab_pin.sym} 2540 26360 0 0 {name=l21188 lab=WL132}
N 2640 26440 2660 26440 {}
C {lab_pin.sym} 2660 26440 0 0 {name=l21189 lab=VDD}
N 2640 26360 2660 26360 {}
C {lab_pin.sym} 2660 26360 0 0 {name=l21190 lab=VSS}
C {bitcell_6t.sym} 2800 26400 0 0 {name=Xr132c14}
N 2760 26440 2740 26440 {}
C {lab_pin.sym} 2740 26440 0 0 {name=l21191 lab=BL14}
N 2760 26400 2740 26400 {}
C {lab_pin.sym} 2740 26400 0 0 {name=l21192 lab=BLB14}
N 2760 26360 2740 26360 {}
C {lab_pin.sym} 2740 26360 0 0 {name=l21193 lab=WL132}
N 2840 26440 2860 26440 {}
C {lab_pin.sym} 2860 26440 0 0 {name=l21194 lab=VDD}
N 2840 26360 2860 26360 {}
C {lab_pin.sym} 2860 26360 0 0 {name=l21195 lab=VSS}
C {bitcell_6t.sym} 3000 26400 0 0 {name=Xr132c15}
N 2960 26440 2940 26440 {}
C {lab_pin.sym} 2940 26440 0 0 {name=l21196 lab=BL15}
N 2960 26400 2940 26400 {}
C {lab_pin.sym} 2940 26400 0 0 {name=l21197 lab=BLB15}
N 2960 26360 2940 26360 {}
C {lab_pin.sym} 2940 26360 0 0 {name=l21198 lab=WL132}
N 3040 26440 3060 26440 {}
C {lab_pin.sym} 3060 26440 0 0 {name=l21199 lab=VDD}
N 3040 26360 3060 26360 {}
C {lab_pin.sym} 3060 26360 0 0 {name=l21200 lab=VSS}
C {bitcell_6t.sym} 3200 26400 0 0 {name=Xr132c16}
N 3160 26440 3140 26440 {}
C {lab_pin.sym} 3140 26440 0 0 {name=l21201 lab=BL16}
N 3160 26400 3140 26400 {}
C {lab_pin.sym} 3140 26400 0 0 {name=l21202 lab=BLB16}
N 3160 26360 3140 26360 {}
C {lab_pin.sym} 3140 26360 0 0 {name=l21203 lab=WL132}
N 3240 26440 3260 26440 {}
C {lab_pin.sym} 3260 26440 0 0 {name=l21204 lab=VDD}
N 3240 26360 3260 26360 {}
C {lab_pin.sym} 3260 26360 0 0 {name=l21205 lab=VSS}
C {bitcell_6t.sym} 3400 26400 0 0 {name=Xr132c17}
N 3360 26440 3340 26440 {}
C {lab_pin.sym} 3340 26440 0 0 {name=l21206 lab=BL17}
N 3360 26400 3340 26400 {}
C {lab_pin.sym} 3340 26400 0 0 {name=l21207 lab=BLB17}
N 3360 26360 3340 26360 {}
C {lab_pin.sym} 3340 26360 0 0 {name=l21208 lab=WL132}
N 3440 26440 3460 26440 {}
C {lab_pin.sym} 3460 26440 0 0 {name=l21209 lab=VDD}
N 3440 26360 3460 26360 {}
C {lab_pin.sym} 3460 26360 0 0 {name=l21210 lab=VSS}
C {bitcell_6t.sym} 3600 26400 0 0 {name=Xr132c18}
N 3560 26440 3540 26440 {}
C {lab_pin.sym} 3540 26440 0 0 {name=l21211 lab=BL18}
N 3560 26400 3540 26400 {}
C {lab_pin.sym} 3540 26400 0 0 {name=l21212 lab=BLB18}
N 3560 26360 3540 26360 {}
C {lab_pin.sym} 3540 26360 0 0 {name=l21213 lab=WL132}
N 3640 26440 3660 26440 {}
C {lab_pin.sym} 3660 26440 0 0 {name=l21214 lab=VDD}
N 3640 26360 3660 26360 {}
C {lab_pin.sym} 3660 26360 0 0 {name=l21215 lab=VSS}
C {bitcell_6t.sym} 3800 26400 0 0 {name=Xr132c19}
N 3760 26440 3740 26440 {}
C {lab_pin.sym} 3740 26440 0 0 {name=l21216 lab=BL19}
N 3760 26400 3740 26400 {}
C {lab_pin.sym} 3740 26400 0 0 {name=l21217 lab=BLB19}
N 3760 26360 3740 26360 {}
C {lab_pin.sym} 3740 26360 0 0 {name=l21218 lab=WL132}
N 3840 26440 3860 26440 {}
C {lab_pin.sym} 3860 26440 0 0 {name=l21219 lab=VDD}
N 3840 26360 3860 26360 {}
C {lab_pin.sym} 3860 26360 0 0 {name=l21220 lab=VSS}
C {bitcell_6t.sym} 4000 26400 0 0 {name=Xr132c20}
N 3960 26440 3940 26440 {}
C {lab_pin.sym} 3940 26440 0 0 {name=l21221 lab=BL20}
N 3960 26400 3940 26400 {}
C {lab_pin.sym} 3940 26400 0 0 {name=l21222 lab=BLB20}
N 3960 26360 3940 26360 {}
C {lab_pin.sym} 3940 26360 0 0 {name=l21223 lab=WL132}
N 4040 26440 4060 26440 {}
C {lab_pin.sym} 4060 26440 0 0 {name=l21224 lab=VDD}
N 4040 26360 4060 26360 {}
C {lab_pin.sym} 4060 26360 0 0 {name=l21225 lab=VSS}
C {bitcell_6t.sym} 4200 26400 0 0 {name=Xr132c21}
N 4160 26440 4140 26440 {}
C {lab_pin.sym} 4140 26440 0 0 {name=l21226 lab=BL21}
N 4160 26400 4140 26400 {}
C {lab_pin.sym} 4140 26400 0 0 {name=l21227 lab=BLB21}
N 4160 26360 4140 26360 {}
C {lab_pin.sym} 4140 26360 0 0 {name=l21228 lab=WL132}
N 4240 26440 4260 26440 {}
C {lab_pin.sym} 4260 26440 0 0 {name=l21229 lab=VDD}
N 4240 26360 4260 26360 {}
C {lab_pin.sym} 4260 26360 0 0 {name=l21230 lab=VSS}
C {bitcell_6t.sym} 4400 26400 0 0 {name=Xr132c22}
N 4360 26440 4340 26440 {}
C {lab_pin.sym} 4340 26440 0 0 {name=l21231 lab=BL22}
N 4360 26400 4340 26400 {}
C {lab_pin.sym} 4340 26400 0 0 {name=l21232 lab=BLB22}
N 4360 26360 4340 26360 {}
C {lab_pin.sym} 4340 26360 0 0 {name=l21233 lab=WL132}
N 4440 26440 4460 26440 {}
C {lab_pin.sym} 4460 26440 0 0 {name=l21234 lab=VDD}
N 4440 26360 4460 26360 {}
C {lab_pin.sym} 4460 26360 0 0 {name=l21235 lab=VSS}
C {bitcell_6t.sym} 4600 26400 0 0 {name=Xr132c23}
N 4560 26440 4540 26440 {}
C {lab_pin.sym} 4540 26440 0 0 {name=l21236 lab=BL23}
N 4560 26400 4540 26400 {}
C {lab_pin.sym} 4540 26400 0 0 {name=l21237 lab=BLB23}
N 4560 26360 4540 26360 {}
C {lab_pin.sym} 4540 26360 0 0 {name=l21238 lab=WL132}
N 4640 26440 4660 26440 {}
C {lab_pin.sym} 4660 26440 0 0 {name=l21239 lab=VDD}
N 4640 26360 4660 26360 {}
C {lab_pin.sym} 4660 26360 0 0 {name=l21240 lab=VSS}
C {bitcell_6t.sym} 4800 26400 0 0 {name=Xr132c24}
N 4760 26440 4740 26440 {}
C {lab_pin.sym} 4740 26440 0 0 {name=l21241 lab=BL24}
N 4760 26400 4740 26400 {}
C {lab_pin.sym} 4740 26400 0 0 {name=l21242 lab=BLB24}
N 4760 26360 4740 26360 {}
C {lab_pin.sym} 4740 26360 0 0 {name=l21243 lab=WL132}
N 4840 26440 4860 26440 {}
C {lab_pin.sym} 4860 26440 0 0 {name=l21244 lab=VDD}
N 4840 26360 4860 26360 {}
C {lab_pin.sym} 4860 26360 0 0 {name=l21245 lab=VSS}
C {bitcell_6t.sym} 5000 26400 0 0 {name=Xr132c25}
N 4960 26440 4940 26440 {}
C {lab_pin.sym} 4940 26440 0 0 {name=l21246 lab=BL25}
N 4960 26400 4940 26400 {}
C {lab_pin.sym} 4940 26400 0 0 {name=l21247 lab=BLB25}
N 4960 26360 4940 26360 {}
C {lab_pin.sym} 4940 26360 0 0 {name=l21248 lab=WL132}
N 5040 26440 5060 26440 {}
C {lab_pin.sym} 5060 26440 0 0 {name=l21249 lab=VDD}
N 5040 26360 5060 26360 {}
C {lab_pin.sym} 5060 26360 0 0 {name=l21250 lab=VSS}
C {bitcell_6t.sym} 5200 26400 0 0 {name=Xr132c26}
N 5160 26440 5140 26440 {}
C {lab_pin.sym} 5140 26440 0 0 {name=l21251 lab=BL26}
N 5160 26400 5140 26400 {}
C {lab_pin.sym} 5140 26400 0 0 {name=l21252 lab=BLB26}
N 5160 26360 5140 26360 {}
C {lab_pin.sym} 5140 26360 0 0 {name=l21253 lab=WL132}
N 5240 26440 5260 26440 {}
C {lab_pin.sym} 5260 26440 0 0 {name=l21254 lab=VDD}
N 5240 26360 5260 26360 {}
C {lab_pin.sym} 5260 26360 0 0 {name=l21255 lab=VSS}
C {bitcell_6t.sym} 5400 26400 0 0 {name=Xr132c27}
N 5360 26440 5340 26440 {}
C {lab_pin.sym} 5340 26440 0 0 {name=l21256 lab=BL27}
N 5360 26400 5340 26400 {}
C {lab_pin.sym} 5340 26400 0 0 {name=l21257 lab=BLB27}
N 5360 26360 5340 26360 {}
C {lab_pin.sym} 5340 26360 0 0 {name=l21258 lab=WL132}
N 5440 26440 5460 26440 {}
C {lab_pin.sym} 5460 26440 0 0 {name=l21259 lab=VDD}
N 5440 26360 5460 26360 {}
C {lab_pin.sym} 5460 26360 0 0 {name=l21260 lab=VSS}
C {bitcell_6t.sym} 5600 26400 0 0 {name=Xr132c28}
N 5560 26440 5540 26440 {}
C {lab_pin.sym} 5540 26440 0 0 {name=l21261 lab=BL28}
N 5560 26400 5540 26400 {}
C {lab_pin.sym} 5540 26400 0 0 {name=l21262 lab=BLB28}
N 5560 26360 5540 26360 {}
C {lab_pin.sym} 5540 26360 0 0 {name=l21263 lab=WL132}
N 5640 26440 5660 26440 {}
C {lab_pin.sym} 5660 26440 0 0 {name=l21264 lab=VDD}
N 5640 26360 5660 26360 {}
C {lab_pin.sym} 5660 26360 0 0 {name=l21265 lab=VSS}
C {bitcell_6t.sym} 5800 26400 0 0 {name=Xr132c29}
N 5760 26440 5740 26440 {}
C {lab_pin.sym} 5740 26440 0 0 {name=l21266 lab=BL29}
N 5760 26400 5740 26400 {}
C {lab_pin.sym} 5740 26400 0 0 {name=l21267 lab=BLB29}
N 5760 26360 5740 26360 {}
C {lab_pin.sym} 5740 26360 0 0 {name=l21268 lab=WL132}
N 5840 26440 5860 26440 {}
C {lab_pin.sym} 5860 26440 0 0 {name=l21269 lab=VDD}
N 5840 26360 5860 26360 {}
C {lab_pin.sym} 5860 26360 0 0 {name=l21270 lab=VSS}
C {bitcell_6t.sym} 6000 26400 0 0 {name=Xr132c30}
N 5960 26440 5940 26440 {}
C {lab_pin.sym} 5940 26440 0 0 {name=l21271 lab=BL30}
N 5960 26400 5940 26400 {}
C {lab_pin.sym} 5940 26400 0 0 {name=l21272 lab=BLB30}
N 5960 26360 5940 26360 {}
C {lab_pin.sym} 5940 26360 0 0 {name=l21273 lab=WL132}
N 6040 26440 6060 26440 {}
C {lab_pin.sym} 6060 26440 0 0 {name=l21274 lab=VDD}
N 6040 26360 6060 26360 {}
C {lab_pin.sym} 6060 26360 0 0 {name=l21275 lab=VSS}
C {bitcell_6t.sym} 6200 26400 0 0 {name=Xr132c31}
N 6160 26440 6140 26440 {}
C {lab_pin.sym} 6140 26440 0 0 {name=l21276 lab=BL31}
N 6160 26400 6140 26400 {}
C {lab_pin.sym} 6140 26400 0 0 {name=l21277 lab=BLB31}
N 6160 26360 6140 26360 {}
C {lab_pin.sym} 6140 26360 0 0 {name=l21278 lab=WL132}
N 6240 26440 6260 26440 {}
C {lab_pin.sym} 6260 26440 0 0 {name=l21279 lab=VDD}
N 6240 26360 6260 26360 {}
C {lab_pin.sym} 6260 26360 0 0 {name=l21280 lab=VSS}
C {bitcell_6t.sym} 0 26600 0 0 {name=Xr133c0}
N -40 26640 -60 26640 {}
C {lab_pin.sym} -60 26640 0 0 {name=l21281 lab=BL0}
N -40 26600 -60 26600 {}
C {lab_pin.sym} -60 26600 0 0 {name=l21282 lab=BLB0}
N -40 26560 -60 26560 {}
C {lab_pin.sym} -60 26560 0 0 {name=l21283 lab=WL133}
N 40 26640 60 26640 {}
C {lab_pin.sym} 60 26640 0 0 {name=l21284 lab=VDD}
N 40 26560 60 26560 {}
C {lab_pin.sym} 60 26560 0 0 {name=l21285 lab=VSS}
C {bitcell_6t.sym} 200 26600 0 0 {name=Xr133c1}
N 160 26640 140 26640 {}
C {lab_pin.sym} 140 26640 0 0 {name=l21286 lab=BL1}
N 160 26600 140 26600 {}
C {lab_pin.sym} 140 26600 0 0 {name=l21287 lab=BLB1}
N 160 26560 140 26560 {}
C {lab_pin.sym} 140 26560 0 0 {name=l21288 lab=WL133}
N 240 26640 260 26640 {}
C {lab_pin.sym} 260 26640 0 0 {name=l21289 lab=VDD}
N 240 26560 260 26560 {}
C {lab_pin.sym} 260 26560 0 0 {name=l21290 lab=VSS}
C {bitcell_6t.sym} 400 26600 0 0 {name=Xr133c2}
N 360 26640 340 26640 {}
C {lab_pin.sym} 340 26640 0 0 {name=l21291 lab=BL2}
N 360 26600 340 26600 {}
C {lab_pin.sym} 340 26600 0 0 {name=l21292 lab=BLB2}
N 360 26560 340 26560 {}
C {lab_pin.sym} 340 26560 0 0 {name=l21293 lab=WL133}
N 440 26640 460 26640 {}
C {lab_pin.sym} 460 26640 0 0 {name=l21294 lab=VDD}
N 440 26560 460 26560 {}
C {lab_pin.sym} 460 26560 0 0 {name=l21295 lab=VSS}
C {bitcell_6t.sym} 600 26600 0 0 {name=Xr133c3}
N 560 26640 540 26640 {}
C {lab_pin.sym} 540 26640 0 0 {name=l21296 lab=BL3}
N 560 26600 540 26600 {}
C {lab_pin.sym} 540 26600 0 0 {name=l21297 lab=BLB3}
N 560 26560 540 26560 {}
C {lab_pin.sym} 540 26560 0 0 {name=l21298 lab=WL133}
N 640 26640 660 26640 {}
C {lab_pin.sym} 660 26640 0 0 {name=l21299 lab=VDD}
N 640 26560 660 26560 {}
C {lab_pin.sym} 660 26560 0 0 {name=l21300 lab=VSS}
C {bitcell_6t.sym} 800 26600 0 0 {name=Xr133c4}
N 760 26640 740 26640 {}
C {lab_pin.sym} 740 26640 0 0 {name=l21301 lab=BL4}
N 760 26600 740 26600 {}
C {lab_pin.sym} 740 26600 0 0 {name=l21302 lab=BLB4}
N 760 26560 740 26560 {}
C {lab_pin.sym} 740 26560 0 0 {name=l21303 lab=WL133}
N 840 26640 860 26640 {}
C {lab_pin.sym} 860 26640 0 0 {name=l21304 lab=VDD}
N 840 26560 860 26560 {}
C {lab_pin.sym} 860 26560 0 0 {name=l21305 lab=VSS}
C {bitcell_6t.sym} 1000 26600 0 0 {name=Xr133c5}
N 960 26640 940 26640 {}
C {lab_pin.sym} 940 26640 0 0 {name=l21306 lab=BL5}
N 960 26600 940 26600 {}
C {lab_pin.sym} 940 26600 0 0 {name=l21307 lab=BLB5}
N 960 26560 940 26560 {}
C {lab_pin.sym} 940 26560 0 0 {name=l21308 lab=WL133}
N 1040 26640 1060 26640 {}
C {lab_pin.sym} 1060 26640 0 0 {name=l21309 lab=VDD}
N 1040 26560 1060 26560 {}
C {lab_pin.sym} 1060 26560 0 0 {name=l21310 lab=VSS}
C {bitcell_6t.sym} 1200 26600 0 0 {name=Xr133c6}
N 1160 26640 1140 26640 {}
C {lab_pin.sym} 1140 26640 0 0 {name=l21311 lab=BL6}
N 1160 26600 1140 26600 {}
C {lab_pin.sym} 1140 26600 0 0 {name=l21312 lab=BLB6}
N 1160 26560 1140 26560 {}
C {lab_pin.sym} 1140 26560 0 0 {name=l21313 lab=WL133}
N 1240 26640 1260 26640 {}
C {lab_pin.sym} 1260 26640 0 0 {name=l21314 lab=VDD}
N 1240 26560 1260 26560 {}
C {lab_pin.sym} 1260 26560 0 0 {name=l21315 lab=VSS}
C {bitcell_6t.sym} 1400 26600 0 0 {name=Xr133c7}
N 1360 26640 1340 26640 {}
C {lab_pin.sym} 1340 26640 0 0 {name=l21316 lab=BL7}
N 1360 26600 1340 26600 {}
C {lab_pin.sym} 1340 26600 0 0 {name=l21317 lab=BLB7}
N 1360 26560 1340 26560 {}
C {lab_pin.sym} 1340 26560 0 0 {name=l21318 lab=WL133}
N 1440 26640 1460 26640 {}
C {lab_pin.sym} 1460 26640 0 0 {name=l21319 lab=VDD}
N 1440 26560 1460 26560 {}
C {lab_pin.sym} 1460 26560 0 0 {name=l21320 lab=VSS}
C {bitcell_6t.sym} 1600 26600 0 0 {name=Xr133c8}
N 1560 26640 1540 26640 {}
C {lab_pin.sym} 1540 26640 0 0 {name=l21321 lab=BL8}
N 1560 26600 1540 26600 {}
C {lab_pin.sym} 1540 26600 0 0 {name=l21322 lab=BLB8}
N 1560 26560 1540 26560 {}
C {lab_pin.sym} 1540 26560 0 0 {name=l21323 lab=WL133}
N 1640 26640 1660 26640 {}
C {lab_pin.sym} 1660 26640 0 0 {name=l21324 lab=VDD}
N 1640 26560 1660 26560 {}
C {lab_pin.sym} 1660 26560 0 0 {name=l21325 lab=VSS}
C {bitcell_6t.sym} 1800 26600 0 0 {name=Xr133c9}
N 1760 26640 1740 26640 {}
C {lab_pin.sym} 1740 26640 0 0 {name=l21326 lab=BL9}
N 1760 26600 1740 26600 {}
C {lab_pin.sym} 1740 26600 0 0 {name=l21327 lab=BLB9}
N 1760 26560 1740 26560 {}
C {lab_pin.sym} 1740 26560 0 0 {name=l21328 lab=WL133}
N 1840 26640 1860 26640 {}
C {lab_pin.sym} 1860 26640 0 0 {name=l21329 lab=VDD}
N 1840 26560 1860 26560 {}
C {lab_pin.sym} 1860 26560 0 0 {name=l21330 lab=VSS}
C {bitcell_6t.sym} 2000 26600 0 0 {name=Xr133c10}
N 1960 26640 1940 26640 {}
C {lab_pin.sym} 1940 26640 0 0 {name=l21331 lab=BL10}
N 1960 26600 1940 26600 {}
C {lab_pin.sym} 1940 26600 0 0 {name=l21332 lab=BLB10}
N 1960 26560 1940 26560 {}
C {lab_pin.sym} 1940 26560 0 0 {name=l21333 lab=WL133}
N 2040 26640 2060 26640 {}
C {lab_pin.sym} 2060 26640 0 0 {name=l21334 lab=VDD}
N 2040 26560 2060 26560 {}
C {lab_pin.sym} 2060 26560 0 0 {name=l21335 lab=VSS}
C {bitcell_6t.sym} 2200 26600 0 0 {name=Xr133c11}
N 2160 26640 2140 26640 {}
C {lab_pin.sym} 2140 26640 0 0 {name=l21336 lab=BL11}
N 2160 26600 2140 26600 {}
C {lab_pin.sym} 2140 26600 0 0 {name=l21337 lab=BLB11}
N 2160 26560 2140 26560 {}
C {lab_pin.sym} 2140 26560 0 0 {name=l21338 lab=WL133}
N 2240 26640 2260 26640 {}
C {lab_pin.sym} 2260 26640 0 0 {name=l21339 lab=VDD}
N 2240 26560 2260 26560 {}
C {lab_pin.sym} 2260 26560 0 0 {name=l21340 lab=VSS}
C {bitcell_6t.sym} 2400 26600 0 0 {name=Xr133c12}
N 2360 26640 2340 26640 {}
C {lab_pin.sym} 2340 26640 0 0 {name=l21341 lab=BL12}
N 2360 26600 2340 26600 {}
C {lab_pin.sym} 2340 26600 0 0 {name=l21342 lab=BLB12}
N 2360 26560 2340 26560 {}
C {lab_pin.sym} 2340 26560 0 0 {name=l21343 lab=WL133}
N 2440 26640 2460 26640 {}
C {lab_pin.sym} 2460 26640 0 0 {name=l21344 lab=VDD}
N 2440 26560 2460 26560 {}
C {lab_pin.sym} 2460 26560 0 0 {name=l21345 lab=VSS}
C {bitcell_6t.sym} 2600 26600 0 0 {name=Xr133c13}
N 2560 26640 2540 26640 {}
C {lab_pin.sym} 2540 26640 0 0 {name=l21346 lab=BL13}
N 2560 26600 2540 26600 {}
C {lab_pin.sym} 2540 26600 0 0 {name=l21347 lab=BLB13}
N 2560 26560 2540 26560 {}
C {lab_pin.sym} 2540 26560 0 0 {name=l21348 lab=WL133}
N 2640 26640 2660 26640 {}
C {lab_pin.sym} 2660 26640 0 0 {name=l21349 lab=VDD}
N 2640 26560 2660 26560 {}
C {lab_pin.sym} 2660 26560 0 0 {name=l21350 lab=VSS}
C {bitcell_6t.sym} 2800 26600 0 0 {name=Xr133c14}
N 2760 26640 2740 26640 {}
C {lab_pin.sym} 2740 26640 0 0 {name=l21351 lab=BL14}
N 2760 26600 2740 26600 {}
C {lab_pin.sym} 2740 26600 0 0 {name=l21352 lab=BLB14}
N 2760 26560 2740 26560 {}
C {lab_pin.sym} 2740 26560 0 0 {name=l21353 lab=WL133}
N 2840 26640 2860 26640 {}
C {lab_pin.sym} 2860 26640 0 0 {name=l21354 lab=VDD}
N 2840 26560 2860 26560 {}
C {lab_pin.sym} 2860 26560 0 0 {name=l21355 lab=VSS}
C {bitcell_6t.sym} 3000 26600 0 0 {name=Xr133c15}
N 2960 26640 2940 26640 {}
C {lab_pin.sym} 2940 26640 0 0 {name=l21356 lab=BL15}
N 2960 26600 2940 26600 {}
C {lab_pin.sym} 2940 26600 0 0 {name=l21357 lab=BLB15}
N 2960 26560 2940 26560 {}
C {lab_pin.sym} 2940 26560 0 0 {name=l21358 lab=WL133}
N 3040 26640 3060 26640 {}
C {lab_pin.sym} 3060 26640 0 0 {name=l21359 lab=VDD}
N 3040 26560 3060 26560 {}
C {lab_pin.sym} 3060 26560 0 0 {name=l21360 lab=VSS}
C {bitcell_6t.sym} 3200 26600 0 0 {name=Xr133c16}
N 3160 26640 3140 26640 {}
C {lab_pin.sym} 3140 26640 0 0 {name=l21361 lab=BL16}
N 3160 26600 3140 26600 {}
C {lab_pin.sym} 3140 26600 0 0 {name=l21362 lab=BLB16}
N 3160 26560 3140 26560 {}
C {lab_pin.sym} 3140 26560 0 0 {name=l21363 lab=WL133}
N 3240 26640 3260 26640 {}
C {lab_pin.sym} 3260 26640 0 0 {name=l21364 lab=VDD}
N 3240 26560 3260 26560 {}
C {lab_pin.sym} 3260 26560 0 0 {name=l21365 lab=VSS}
C {bitcell_6t.sym} 3400 26600 0 0 {name=Xr133c17}
N 3360 26640 3340 26640 {}
C {lab_pin.sym} 3340 26640 0 0 {name=l21366 lab=BL17}
N 3360 26600 3340 26600 {}
C {lab_pin.sym} 3340 26600 0 0 {name=l21367 lab=BLB17}
N 3360 26560 3340 26560 {}
C {lab_pin.sym} 3340 26560 0 0 {name=l21368 lab=WL133}
N 3440 26640 3460 26640 {}
C {lab_pin.sym} 3460 26640 0 0 {name=l21369 lab=VDD}
N 3440 26560 3460 26560 {}
C {lab_pin.sym} 3460 26560 0 0 {name=l21370 lab=VSS}
C {bitcell_6t.sym} 3600 26600 0 0 {name=Xr133c18}
N 3560 26640 3540 26640 {}
C {lab_pin.sym} 3540 26640 0 0 {name=l21371 lab=BL18}
N 3560 26600 3540 26600 {}
C {lab_pin.sym} 3540 26600 0 0 {name=l21372 lab=BLB18}
N 3560 26560 3540 26560 {}
C {lab_pin.sym} 3540 26560 0 0 {name=l21373 lab=WL133}
N 3640 26640 3660 26640 {}
C {lab_pin.sym} 3660 26640 0 0 {name=l21374 lab=VDD}
N 3640 26560 3660 26560 {}
C {lab_pin.sym} 3660 26560 0 0 {name=l21375 lab=VSS}
C {bitcell_6t.sym} 3800 26600 0 0 {name=Xr133c19}
N 3760 26640 3740 26640 {}
C {lab_pin.sym} 3740 26640 0 0 {name=l21376 lab=BL19}
N 3760 26600 3740 26600 {}
C {lab_pin.sym} 3740 26600 0 0 {name=l21377 lab=BLB19}
N 3760 26560 3740 26560 {}
C {lab_pin.sym} 3740 26560 0 0 {name=l21378 lab=WL133}
N 3840 26640 3860 26640 {}
C {lab_pin.sym} 3860 26640 0 0 {name=l21379 lab=VDD}
N 3840 26560 3860 26560 {}
C {lab_pin.sym} 3860 26560 0 0 {name=l21380 lab=VSS}
C {bitcell_6t.sym} 4000 26600 0 0 {name=Xr133c20}
N 3960 26640 3940 26640 {}
C {lab_pin.sym} 3940 26640 0 0 {name=l21381 lab=BL20}
N 3960 26600 3940 26600 {}
C {lab_pin.sym} 3940 26600 0 0 {name=l21382 lab=BLB20}
N 3960 26560 3940 26560 {}
C {lab_pin.sym} 3940 26560 0 0 {name=l21383 lab=WL133}
N 4040 26640 4060 26640 {}
C {lab_pin.sym} 4060 26640 0 0 {name=l21384 lab=VDD}
N 4040 26560 4060 26560 {}
C {lab_pin.sym} 4060 26560 0 0 {name=l21385 lab=VSS}
C {bitcell_6t.sym} 4200 26600 0 0 {name=Xr133c21}
N 4160 26640 4140 26640 {}
C {lab_pin.sym} 4140 26640 0 0 {name=l21386 lab=BL21}
N 4160 26600 4140 26600 {}
C {lab_pin.sym} 4140 26600 0 0 {name=l21387 lab=BLB21}
N 4160 26560 4140 26560 {}
C {lab_pin.sym} 4140 26560 0 0 {name=l21388 lab=WL133}
N 4240 26640 4260 26640 {}
C {lab_pin.sym} 4260 26640 0 0 {name=l21389 lab=VDD}
N 4240 26560 4260 26560 {}
C {lab_pin.sym} 4260 26560 0 0 {name=l21390 lab=VSS}
C {bitcell_6t.sym} 4400 26600 0 0 {name=Xr133c22}
N 4360 26640 4340 26640 {}
C {lab_pin.sym} 4340 26640 0 0 {name=l21391 lab=BL22}
N 4360 26600 4340 26600 {}
C {lab_pin.sym} 4340 26600 0 0 {name=l21392 lab=BLB22}
N 4360 26560 4340 26560 {}
C {lab_pin.sym} 4340 26560 0 0 {name=l21393 lab=WL133}
N 4440 26640 4460 26640 {}
C {lab_pin.sym} 4460 26640 0 0 {name=l21394 lab=VDD}
N 4440 26560 4460 26560 {}
C {lab_pin.sym} 4460 26560 0 0 {name=l21395 lab=VSS}
C {bitcell_6t.sym} 4600 26600 0 0 {name=Xr133c23}
N 4560 26640 4540 26640 {}
C {lab_pin.sym} 4540 26640 0 0 {name=l21396 lab=BL23}
N 4560 26600 4540 26600 {}
C {lab_pin.sym} 4540 26600 0 0 {name=l21397 lab=BLB23}
N 4560 26560 4540 26560 {}
C {lab_pin.sym} 4540 26560 0 0 {name=l21398 lab=WL133}
N 4640 26640 4660 26640 {}
C {lab_pin.sym} 4660 26640 0 0 {name=l21399 lab=VDD}
N 4640 26560 4660 26560 {}
C {lab_pin.sym} 4660 26560 0 0 {name=l21400 lab=VSS}
C {bitcell_6t.sym} 4800 26600 0 0 {name=Xr133c24}
N 4760 26640 4740 26640 {}
C {lab_pin.sym} 4740 26640 0 0 {name=l21401 lab=BL24}
N 4760 26600 4740 26600 {}
C {lab_pin.sym} 4740 26600 0 0 {name=l21402 lab=BLB24}
N 4760 26560 4740 26560 {}
C {lab_pin.sym} 4740 26560 0 0 {name=l21403 lab=WL133}
N 4840 26640 4860 26640 {}
C {lab_pin.sym} 4860 26640 0 0 {name=l21404 lab=VDD}
N 4840 26560 4860 26560 {}
C {lab_pin.sym} 4860 26560 0 0 {name=l21405 lab=VSS}
C {bitcell_6t.sym} 5000 26600 0 0 {name=Xr133c25}
N 4960 26640 4940 26640 {}
C {lab_pin.sym} 4940 26640 0 0 {name=l21406 lab=BL25}
N 4960 26600 4940 26600 {}
C {lab_pin.sym} 4940 26600 0 0 {name=l21407 lab=BLB25}
N 4960 26560 4940 26560 {}
C {lab_pin.sym} 4940 26560 0 0 {name=l21408 lab=WL133}
N 5040 26640 5060 26640 {}
C {lab_pin.sym} 5060 26640 0 0 {name=l21409 lab=VDD}
N 5040 26560 5060 26560 {}
C {lab_pin.sym} 5060 26560 0 0 {name=l21410 lab=VSS}
C {bitcell_6t.sym} 5200 26600 0 0 {name=Xr133c26}
N 5160 26640 5140 26640 {}
C {lab_pin.sym} 5140 26640 0 0 {name=l21411 lab=BL26}
N 5160 26600 5140 26600 {}
C {lab_pin.sym} 5140 26600 0 0 {name=l21412 lab=BLB26}
N 5160 26560 5140 26560 {}
C {lab_pin.sym} 5140 26560 0 0 {name=l21413 lab=WL133}
N 5240 26640 5260 26640 {}
C {lab_pin.sym} 5260 26640 0 0 {name=l21414 lab=VDD}
N 5240 26560 5260 26560 {}
C {lab_pin.sym} 5260 26560 0 0 {name=l21415 lab=VSS}
C {bitcell_6t.sym} 5400 26600 0 0 {name=Xr133c27}
N 5360 26640 5340 26640 {}
C {lab_pin.sym} 5340 26640 0 0 {name=l21416 lab=BL27}
N 5360 26600 5340 26600 {}
C {lab_pin.sym} 5340 26600 0 0 {name=l21417 lab=BLB27}
N 5360 26560 5340 26560 {}
C {lab_pin.sym} 5340 26560 0 0 {name=l21418 lab=WL133}
N 5440 26640 5460 26640 {}
C {lab_pin.sym} 5460 26640 0 0 {name=l21419 lab=VDD}
N 5440 26560 5460 26560 {}
C {lab_pin.sym} 5460 26560 0 0 {name=l21420 lab=VSS}
C {bitcell_6t.sym} 5600 26600 0 0 {name=Xr133c28}
N 5560 26640 5540 26640 {}
C {lab_pin.sym} 5540 26640 0 0 {name=l21421 lab=BL28}
N 5560 26600 5540 26600 {}
C {lab_pin.sym} 5540 26600 0 0 {name=l21422 lab=BLB28}
N 5560 26560 5540 26560 {}
C {lab_pin.sym} 5540 26560 0 0 {name=l21423 lab=WL133}
N 5640 26640 5660 26640 {}
C {lab_pin.sym} 5660 26640 0 0 {name=l21424 lab=VDD}
N 5640 26560 5660 26560 {}
C {lab_pin.sym} 5660 26560 0 0 {name=l21425 lab=VSS}
C {bitcell_6t.sym} 5800 26600 0 0 {name=Xr133c29}
N 5760 26640 5740 26640 {}
C {lab_pin.sym} 5740 26640 0 0 {name=l21426 lab=BL29}
N 5760 26600 5740 26600 {}
C {lab_pin.sym} 5740 26600 0 0 {name=l21427 lab=BLB29}
N 5760 26560 5740 26560 {}
C {lab_pin.sym} 5740 26560 0 0 {name=l21428 lab=WL133}
N 5840 26640 5860 26640 {}
C {lab_pin.sym} 5860 26640 0 0 {name=l21429 lab=VDD}
N 5840 26560 5860 26560 {}
C {lab_pin.sym} 5860 26560 0 0 {name=l21430 lab=VSS}
C {bitcell_6t.sym} 6000 26600 0 0 {name=Xr133c30}
N 5960 26640 5940 26640 {}
C {lab_pin.sym} 5940 26640 0 0 {name=l21431 lab=BL30}
N 5960 26600 5940 26600 {}
C {lab_pin.sym} 5940 26600 0 0 {name=l21432 lab=BLB30}
N 5960 26560 5940 26560 {}
C {lab_pin.sym} 5940 26560 0 0 {name=l21433 lab=WL133}
N 6040 26640 6060 26640 {}
C {lab_pin.sym} 6060 26640 0 0 {name=l21434 lab=VDD}
N 6040 26560 6060 26560 {}
C {lab_pin.sym} 6060 26560 0 0 {name=l21435 lab=VSS}
C {bitcell_6t.sym} 6200 26600 0 0 {name=Xr133c31}
N 6160 26640 6140 26640 {}
C {lab_pin.sym} 6140 26640 0 0 {name=l21436 lab=BL31}
N 6160 26600 6140 26600 {}
C {lab_pin.sym} 6140 26600 0 0 {name=l21437 lab=BLB31}
N 6160 26560 6140 26560 {}
C {lab_pin.sym} 6140 26560 0 0 {name=l21438 lab=WL133}
N 6240 26640 6260 26640 {}
C {lab_pin.sym} 6260 26640 0 0 {name=l21439 lab=VDD}
N 6240 26560 6260 26560 {}
C {lab_pin.sym} 6260 26560 0 0 {name=l21440 lab=VSS}
C {bitcell_6t.sym} 0 26800 0 0 {name=Xr134c0}
N -40 26840 -60 26840 {}
C {lab_pin.sym} -60 26840 0 0 {name=l21441 lab=BL0}
N -40 26800 -60 26800 {}
C {lab_pin.sym} -60 26800 0 0 {name=l21442 lab=BLB0}
N -40 26760 -60 26760 {}
C {lab_pin.sym} -60 26760 0 0 {name=l21443 lab=WL134}
N 40 26840 60 26840 {}
C {lab_pin.sym} 60 26840 0 0 {name=l21444 lab=VDD}
N 40 26760 60 26760 {}
C {lab_pin.sym} 60 26760 0 0 {name=l21445 lab=VSS}
C {bitcell_6t.sym} 200 26800 0 0 {name=Xr134c1}
N 160 26840 140 26840 {}
C {lab_pin.sym} 140 26840 0 0 {name=l21446 lab=BL1}
N 160 26800 140 26800 {}
C {lab_pin.sym} 140 26800 0 0 {name=l21447 lab=BLB1}
N 160 26760 140 26760 {}
C {lab_pin.sym} 140 26760 0 0 {name=l21448 lab=WL134}
N 240 26840 260 26840 {}
C {lab_pin.sym} 260 26840 0 0 {name=l21449 lab=VDD}
N 240 26760 260 26760 {}
C {lab_pin.sym} 260 26760 0 0 {name=l21450 lab=VSS}
C {bitcell_6t.sym} 400 26800 0 0 {name=Xr134c2}
N 360 26840 340 26840 {}
C {lab_pin.sym} 340 26840 0 0 {name=l21451 lab=BL2}
N 360 26800 340 26800 {}
C {lab_pin.sym} 340 26800 0 0 {name=l21452 lab=BLB2}
N 360 26760 340 26760 {}
C {lab_pin.sym} 340 26760 0 0 {name=l21453 lab=WL134}
N 440 26840 460 26840 {}
C {lab_pin.sym} 460 26840 0 0 {name=l21454 lab=VDD}
N 440 26760 460 26760 {}
C {lab_pin.sym} 460 26760 0 0 {name=l21455 lab=VSS}
C {bitcell_6t.sym} 600 26800 0 0 {name=Xr134c3}
N 560 26840 540 26840 {}
C {lab_pin.sym} 540 26840 0 0 {name=l21456 lab=BL3}
N 560 26800 540 26800 {}
C {lab_pin.sym} 540 26800 0 0 {name=l21457 lab=BLB3}
N 560 26760 540 26760 {}
C {lab_pin.sym} 540 26760 0 0 {name=l21458 lab=WL134}
N 640 26840 660 26840 {}
C {lab_pin.sym} 660 26840 0 0 {name=l21459 lab=VDD}
N 640 26760 660 26760 {}
C {lab_pin.sym} 660 26760 0 0 {name=l21460 lab=VSS}
C {bitcell_6t.sym} 800 26800 0 0 {name=Xr134c4}
N 760 26840 740 26840 {}
C {lab_pin.sym} 740 26840 0 0 {name=l21461 lab=BL4}
N 760 26800 740 26800 {}
C {lab_pin.sym} 740 26800 0 0 {name=l21462 lab=BLB4}
N 760 26760 740 26760 {}
C {lab_pin.sym} 740 26760 0 0 {name=l21463 lab=WL134}
N 840 26840 860 26840 {}
C {lab_pin.sym} 860 26840 0 0 {name=l21464 lab=VDD}
N 840 26760 860 26760 {}
C {lab_pin.sym} 860 26760 0 0 {name=l21465 lab=VSS}
C {bitcell_6t.sym} 1000 26800 0 0 {name=Xr134c5}
N 960 26840 940 26840 {}
C {lab_pin.sym} 940 26840 0 0 {name=l21466 lab=BL5}
N 960 26800 940 26800 {}
C {lab_pin.sym} 940 26800 0 0 {name=l21467 lab=BLB5}
N 960 26760 940 26760 {}
C {lab_pin.sym} 940 26760 0 0 {name=l21468 lab=WL134}
N 1040 26840 1060 26840 {}
C {lab_pin.sym} 1060 26840 0 0 {name=l21469 lab=VDD}
N 1040 26760 1060 26760 {}
C {lab_pin.sym} 1060 26760 0 0 {name=l21470 lab=VSS}
C {bitcell_6t.sym} 1200 26800 0 0 {name=Xr134c6}
N 1160 26840 1140 26840 {}
C {lab_pin.sym} 1140 26840 0 0 {name=l21471 lab=BL6}
N 1160 26800 1140 26800 {}
C {lab_pin.sym} 1140 26800 0 0 {name=l21472 lab=BLB6}
N 1160 26760 1140 26760 {}
C {lab_pin.sym} 1140 26760 0 0 {name=l21473 lab=WL134}
N 1240 26840 1260 26840 {}
C {lab_pin.sym} 1260 26840 0 0 {name=l21474 lab=VDD}
N 1240 26760 1260 26760 {}
C {lab_pin.sym} 1260 26760 0 0 {name=l21475 lab=VSS}
C {bitcell_6t.sym} 1400 26800 0 0 {name=Xr134c7}
N 1360 26840 1340 26840 {}
C {lab_pin.sym} 1340 26840 0 0 {name=l21476 lab=BL7}
N 1360 26800 1340 26800 {}
C {lab_pin.sym} 1340 26800 0 0 {name=l21477 lab=BLB7}
N 1360 26760 1340 26760 {}
C {lab_pin.sym} 1340 26760 0 0 {name=l21478 lab=WL134}
N 1440 26840 1460 26840 {}
C {lab_pin.sym} 1460 26840 0 0 {name=l21479 lab=VDD}
N 1440 26760 1460 26760 {}
C {lab_pin.sym} 1460 26760 0 0 {name=l21480 lab=VSS}
C {bitcell_6t.sym} 1600 26800 0 0 {name=Xr134c8}
N 1560 26840 1540 26840 {}
C {lab_pin.sym} 1540 26840 0 0 {name=l21481 lab=BL8}
N 1560 26800 1540 26800 {}
C {lab_pin.sym} 1540 26800 0 0 {name=l21482 lab=BLB8}
N 1560 26760 1540 26760 {}
C {lab_pin.sym} 1540 26760 0 0 {name=l21483 lab=WL134}
N 1640 26840 1660 26840 {}
C {lab_pin.sym} 1660 26840 0 0 {name=l21484 lab=VDD}
N 1640 26760 1660 26760 {}
C {lab_pin.sym} 1660 26760 0 0 {name=l21485 lab=VSS}
C {bitcell_6t.sym} 1800 26800 0 0 {name=Xr134c9}
N 1760 26840 1740 26840 {}
C {lab_pin.sym} 1740 26840 0 0 {name=l21486 lab=BL9}
N 1760 26800 1740 26800 {}
C {lab_pin.sym} 1740 26800 0 0 {name=l21487 lab=BLB9}
N 1760 26760 1740 26760 {}
C {lab_pin.sym} 1740 26760 0 0 {name=l21488 lab=WL134}
N 1840 26840 1860 26840 {}
C {lab_pin.sym} 1860 26840 0 0 {name=l21489 lab=VDD}
N 1840 26760 1860 26760 {}
C {lab_pin.sym} 1860 26760 0 0 {name=l21490 lab=VSS}
C {bitcell_6t.sym} 2000 26800 0 0 {name=Xr134c10}
N 1960 26840 1940 26840 {}
C {lab_pin.sym} 1940 26840 0 0 {name=l21491 lab=BL10}
N 1960 26800 1940 26800 {}
C {lab_pin.sym} 1940 26800 0 0 {name=l21492 lab=BLB10}
N 1960 26760 1940 26760 {}
C {lab_pin.sym} 1940 26760 0 0 {name=l21493 lab=WL134}
N 2040 26840 2060 26840 {}
C {lab_pin.sym} 2060 26840 0 0 {name=l21494 lab=VDD}
N 2040 26760 2060 26760 {}
C {lab_pin.sym} 2060 26760 0 0 {name=l21495 lab=VSS}
C {bitcell_6t.sym} 2200 26800 0 0 {name=Xr134c11}
N 2160 26840 2140 26840 {}
C {lab_pin.sym} 2140 26840 0 0 {name=l21496 lab=BL11}
N 2160 26800 2140 26800 {}
C {lab_pin.sym} 2140 26800 0 0 {name=l21497 lab=BLB11}
N 2160 26760 2140 26760 {}
C {lab_pin.sym} 2140 26760 0 0 {name=l21498 lab=WL134}
N 2240 26840 2260 26840 {}
C {lab_pin.sym} 2260 26840 0 0 {name=l21499 lab=VDD}
N 2240 26760 2260 26760 {}
C {lab_pin.sym} 2260 26760 0 0 {name=l21500 lab=VSS}
C {bitcell_6t.sym} 2400 26800 0 0 {name=Xr134c12}
N 2360 26840 2340 26840 {}
C {lab_pin.sym} 2340 26840 0 0 {name=l21501 lab=BL12}
N 2360 26800 2340 26800 {}
C {lab_pin.sym} 2340 26800 0 0 {name=l21502 lab=BLB12}
N 2360 26760 2340 26760 {}
C {lab_pin.sym} 2340 26760 0 0 {name=l21503 lab=WL134}
N 2440 26840 2460 26840 {}
C {lab_pin.sym} 2460 26840 0 0 {name=l21504 lab=VDD}
N 2440 26760 2460 26760 {}
C {lab_pin.sym} 2460 26760 0 0 {name=l21505 lab=VSS}
C {bitcell_6t.sym} 2600 26800 0 0 {name=Xr134c13}
N 2560 26840 2540 26840 {}
C {lab_pin.sym} 2540 26840 0 0 {name=l21506 lab=BL13}
N 2560 26800 2540 26800 {}
C {lab_pin.sym} 2540 26800 0 0 {name=l21507 lab=BLB13}
N 2560 26760 2540 26760 {}
C {lab_pin.sym} 2540 26760 0 0 {name=l21508 lab=WL134}
N 2640 26840 2660 26840 {}
C {lab_pin.sym} 2660 26840 0 0 {name=l21509 lab=VDD}
N 2640 26760 2660 26760 {}
C {lab_pin.sym} 2660 26760 0 0 {name=l21510 lab=VSS}
C {bitcell_6t.sym} 2800 26800 0 0 {name=Xr134c14}
N 2760 26840 2740 26840 {}
C {lab_pin.sym} 2740 26840 0 0 {name=l21511 lab=BL14}
N 2760 26800 2740 26800 {}
C {lab_pin.sym} 2740 26800 0 0 {name=l21512 lab=BLB14}
N 2760 26760 2740 26760 {}
C {lab_pin.sym} 2740 26760 0 0 {name=l21513 lab=WL134}
N 2840 26840 2860 26840 {}
C {lab_pin.sym} 2860 26840 0 0 {name=l21514 lab=VDD}
N 2840 26760 2860 26760 {}
C {lab_pin.sym} 2860 26760 0 0 {name=l21515 lab=VSS}
C {bitcell_6t.sym} 3000 26800 0 0 {name=Xr134c15}
N 2960 26840 2940 26840 {}
C {lab_pin.sym} 2940 26840 0 0 {name=l21516 lab=BL15}
N 2960 26800 2940 26800 {}
C {lab_pin.sym} 2940 26800 0 0 {name=l21517 lab=BLB15}
N 2960 26760 2940 26760 {}
C {lab_pin.sym} 2940 26760 0 0 {name=l21518 lab=WL134}
N 3040 26840 3060 26840 {}
C {lab_pin.sym} 3060 26840 0 0 {name=l21519 lab=VDD}
N 3040 26760 3060 26760 {}
C {lab_pin.sym} 3060 26760 0 0 {name=l21520 lab=VSS}
C {bitcell_6t.sym} 3200 26800 0 0 {name=Xr134c16}
N 3160 26840 3140 26840 {}
C {lab_pin.sym} 3140 26840 0 0 {name=l21521 lab=BL16}
N 3160 26800 3140 26800 {}
C {lab_pin.sym} 3140 26800 0 0 {name=l21522 lab=BLB16}
N 3160 26760 3140 26760 {}
C {lab_pin.sym} 3140 26760 0 0 {name=l21523 lab=WL134}
N 3240 26840 3260 26840 {}
C {lab_pin.sym} 3260 26840 0 0 {name=l21524 lab=VDD}
N 3240 26760 3260 26760 {}
C {lab_pin.sym} 3260 26760 0 0 {name=l21525 lab=VSS}
C {bitcell_6t.sym} 3400 26800 0 0 {name=Xr134c17}
N 3360 26840 3340 26840 {}
C {lab_pin.sym} 3340 26840 0 0 {name=l21526 lab=BL17}
N 3360 26800 3340 26800 {}
C {lab_pin.sym} 3340 26800 0 0 {name=l21527 lab=BLB17}
N 3360 26760 3340 26760 {}
C {lab_pin.sym} 3340 26760 0 0 {name=l21528 lab=WL134}
N 3440 26840 3460 26840 {}
C {lab_pin.sym} 3460 26840 0 0 {name=l21529 lab=VDD}
N 3440 26760 3460 26760 {}
C {lab_pin.sym} 3460 26760 0 0 {name=l21530 lab=VSS}
C {bitcell_6t.sym} 3600 26800 0 0 {name=Xr134c18}
N 3560 26840 3540 26840 {}
C {lab_pin.sym} 3540 26840 0 0 {name=l21531 lab=BL18}
N 3560 26800 3540 26800 {}
C {lab_pin.sym} 3540 26800 0 0 {name=l21532 lab=BLB18}
N 3560 26760 3540 26760 {}
C {lab_pin.sym} 3540 26760 0 0 {name=l21533 lab=WL134}
N 3640 26840 3660 26840 {}
C {lab_pin.sym} 3660 26840 0 0 {name=l21534 lab=VDD}
N 3640 26760 3660 26760 {}
C {lab_pin.sym} 3660 26760 0 0 {name=l21535 lab=VSS}
C {bitcell_6t.sym} 3800 26800 0 0 {name=Xr134c19}
N 3760 26840 3740 26840 {}
C {lab_pin.sym} 3740 26840 0 0 {name=l21536 lab=BL19}
N 3760 26800 3740 26800 {}
C {lab_pin.sym} 3740 26800 0 0 {name=l21537 lab=BLB19}
N 3760 26760 3740 26760 {}
C {lab_pin.sym} 3740 26760 0 0 {name=l21538 lab=WL134}
N 3840 26840 3860 26840 {}
C {lab_pin.sym} 3860 26840 0 0 {name=l21539 lab=VDD}
N 3840 26760 3860 26760 {}
C {lab_pin.sym} 3860 26760 0 0 {name=l21540 lab=VSS}
C {bitcell_6t.sym} 4000 26800 0 0 {name=Xr134c20}
N 3960 26840 3940 26840 {}
C {lab_pin.sym} 3940 26840 0 0 {name=l21541 lab=BL20}
N 3960 26800 3940 26800 {}
C {lab_pin.sym} 3940 26800 0 0 {name=l21542 lab=BLB20}
N 3960 26760 3940 26760 {}
C {lab_pin.sym} 3940 26760 0 0 {name=l21543 lab=WL134}
N 4040 26840 4060 26840 {}
C {lab_pin.sym} 4060 26840 0 0 {name=l21544 lab=VDD}
N 4040 26760 4060 26760 {}
C {lab_pin.sym} 4060 26760 0 0 {name=l21545 lab=VSS}
C {bitcell_6t.sym} 4200 26800 0 0 {name=Xr134c21}
N 4160 26840 4140 26840 {}
C {lab_pin.sym} 4140 26840 0 0 {name=l21546 lab=BL21}
N 4160 26800 4140 26800 {}
C {lab_pin.sym} 4140 26800 0 0 {name=l21547 lab=BLB21}
N 4160 26760 4140 26760 {}
C {lab_pin.sym} 4140 26760 0 0 {name=l21548 lab=WL134}
N 4240 26840 4260 26840 {}
C {lab_pin.sym} 4260 26840 0 0 {name=l21549 lab=VDD}
N 4240 26760 4260 26760 {}
C {lab_pin.sym} 4260 26760 0 0 {name=l21550 lab=VSS}
C {bitcell_6t.sym} 4400 26800 0 0 {name=Xr134c22}
N 4360 26840 4340 26840 {}
C {lab_pin.sym} 4340 26840 0 0 {name=l21551 lab=BL22}
N 4360 26800 4340 26800 {}
C {lab_pin.sym} 4340 26800 0 0 {name=l21552 lab=BLB22}
N 4360 26760 4340 26760 {}
C {lab_pin.sym} 4340 26760 0 0 {name=l21553 lab=WL134}
N 4440 26840 4460 26840 {}
C {lab_pin.sym} 4460 26840 0 0 {name=l21554 lab=VDD}
N 4440 26760 4460 26760 {}
C {lab_pin.sym} 4460 26760 0 0 {name=l21555 lab=VSS}
C {bitcell_6t.sym} 4600 26800 0 0 {name=Xr134c23}
N 4560 26840 4540 26840 {}
C {lab_pin.sym} 4540 26840 0 0 {name=l21556 lab=BL23}
N 4560 26800 4540 26800 {}
C {lab_pin.sym} 4540 26800 0 0 {name=l21557 lab=BLB23}
N 4560 26760 4540 26760 {}
C {lab_pin.sym} 4540 26760 0 0 {name=l21558 lab=WL134}
N 4640 26840 4660 26840 {}
C {lab_pin.sym} 4660 26840 0 0 {name=l21559 lab=VDD}
N 4640 26760 4660 26760 {}
C {lab_pin.sym} 4660 26760 0 0 {name=l21560 lab=VSS}
C {bitcell_6t.sym} 4800 26800 0 0 {name=Xr134c24}
N 4760 26840 4740 26840 {}
C {lab_pin.sym} 4740 26840 0 0 {name=l21561 lab=BL24}
N 4760 26800 4740 26800 {}
C {lab_pin.sym} 4740 26800 0 0 {name=l21562 lab=BLB24}
N 4760 26760 4740 26760 {}
C {lab_pin.sym} 4740 26760 0 0 {name=l21563 lab=WL134}
N 4840 26840 4860 26840 {}
C {lab_pin.sym} 4860 26840 0 0 {name=l21564 lab=VDD}
N 4840 26760 4860 26760 {}
C {lab_pin.sym} 4860 26760 0 0 {name=l21565 lab=VSS}
C {bitcell_6t.sym} 5000 26800 0 0 {name=Xr134c25}
N 4960 26840 4940 26840 {}
C {lab_pin.sym} 4940 26840 0 0 {name=l21566 lab=BL25}
N 4960 26800 4940 26800 {}
C {lab_pin.sym} 4940 26800 0 0 {name=l21567 lab=BLB25}
N 4960 26760 4940 26760 {}
C {lab_pin.sym} 4940 26760 0 0 {name=l21568 lab=WL134}
N 5040 26840 5060 26840 {}
C {lab_pin.sym} 5060 26840 0 0 {name=l21569 lab=VDD}
N 5040 26760 5060 26760 {}
C {lab_pin.sym} 5060 26760 0 0 {name=l21570 lab=VSS}
C {bitcell_6t.sym} 5200 26800 0 0 {name=Xr134c26}
N 5160 26840 5140 26840 {}
C {lab_pin.sym} 5140 26840 0 0 {name=l21571 lab=BL26}
N 5160 26800 5140 26800 {}
C {lab_pin.sym} 5140 26800 0 0 {name=l21572 lab=BLB26}
N 5160 26760 5140 26760 {}
C {lab_pin.sym} 5140 26760 0 0 {name=l21573 lab=WL134}
N 5240 26840 5260 26840 {}
C {lab_pin.sym} 5260 26840 0 0 {name=l21574 lab=VDD}
N 5240 26760 5260 26760 {}
C {lab_pin.sym} 5260 26760 0 0 {name=l21575 lab=VSS}
C {bitcell_6t.sym} 5400 26800 0 0 {name=Xr134c27}
N 5360 26840 5340 26840 {}
C {lab_pin.sym} 5340 26840 0 0 {name=l21576 lab=BL27}
N 5360 26800 5340 26800 {}
C {lab_pin.sym} 5340 26800 0 0 {name=l21577 lab=BLB27}
N 5360 26760 5340 26760 {}
C {lab_pin.sym} 5340 26760 0 0 {name=l21578 lab=WL134}
N 5440 26840 5460 26840 {}
C {lab_pin.sym} 5460 26840 0 0 {name=l21579 lab=VDD}
N 5440 26760 5460 26760 {}
C {lab_pin.sym} 5460 26760 0 0 {name=l21580 lab=VSS}
C {bitcell_6t.sym} 5600 26800 0 0 {name=Xr134c28}
N 5560 26840 5540 26840 {}
C {lab_pin.sym} 5540 26840 0 0 {name=l21581 lab=BL28}
N 5560 26800 5540 26800 {}
C {lab_pin.sym} 5540 26800 0 0 {name=l21582 lab=BLB28}
N 5560 26760 5540 26760 {}
C {lab_pin.sym} 5540 26760 0 0 {name=l21583 lab=WL134}
N 5640 26840 5660 26840 {}
C {lab_pin.sym} 5660 26840 0 0 {name=l21584 lab=VDD}
N 5640 26760 5660 26760 {}
C {lab_pin.sym} 5660 26760 0 0 {name=l21585 lab=VSS}
C {bitcell_6t.sym} 5800 26800 0 0 {name=Xr134c29}
N 5760 26840 5740 26840 {}
C {lab_pin.sym} 5740 26840 0 0 {name=l21586 lab=BL29}
N 5760 26800 5740 26800 {}
C {lab_pin.sym} 5740 26800 0 0 {name=l21587 lab=BLB29}
N 5760 26760 5740 26760 {}
C {lab_pin.sym} 5740 26760 0 0 {name=l21588 lab=WL134}
N 5840 26840 5860 26840 {}
C {lab_pin.sym} 5860 26840 0 0 {name=l21589 lab=VDD}
N 5840 26760 5860 26760 {}
C {lab_pin.sym} 5860 26760 0 0 {name=l21590 lab=VSS}
C {bitcell_6t.sym} 6000 26800 0 0 {name=Xr134c30}
N 5960 26840 5940 26840 {}
C {lab_pin.sym} 5940 26840 0 0 {name=l21591 lab=BL30}
N 5960 26800 5940 26800 {}
C {lab_pin.sym} 5940 26800 0 0 {name=l21592 lab=BLB30}
N 5960 26760 5940 26760 {}
C {lab_pin.sym} 5940 26760 0 0 {name=l21593 lab=WL134}
N 6040 26840 6060 26840 {}
C {lab_pin.sym} 6060 26840 0 0 {name=l21594 lab=VDD}
N 6040 26760 6060 26760 {}
C {lab_pin.sym} 6060 26760 0 0 {name=l21595 lab=VSS}
C {bitcell_6t.sym} 6200 26800 0 0 {name=Xr134c31}
N 6160 26840 6140 26840 {}
C {lab_pin.sym} 6140 26840 0 0 {name=l21596 lab=BL31}
N 6160 26800 6140 26800 {}
C {lab_pin.sym} 6140 26800 0 0 {name=l21597 lab=BLB31}
N 6160 26760 6140 26760 {}
C {lab_pin.sym} 6140 26760 0 0 {name=l21598 lab=WL134}
N 6240 26840 6260 26840 {}
C {lab_pin.sym} 6260 26840 0 0 {name=l21599 lab=VDD}
N 6240 26760 6260 26760 {}
C {lab_pin.sym} 6260 26760 0 0 {name=l21600 lab=VSS}
C {bitcell_6t.sym} 0 27000 0 0 {name=Xr135c0}
N -40 27040 -60 27040 {}
C {lab_pin.sym} -60 27040 0 0 {name=l21601 lab=BL0}
N -40 27000 -60 27000 {}
C {lab_pin.sym} -60 27000 0 0 {name=l21602 lab=BLB0}
N -40 26960 -60 26960 {}
C {lab_pin.sym} -60 26960 0 0 {name=l21603 lab=WL135}
N 40 27040 60 27040 {}
C {lab_pin.sym} 60 27040 0 0 {name=l21604 lab=VDD}
N 40 26960 60 26960 {}
C {lab_pin.sym} 60 26960 0 0 {name=l21605 lab=VSS}
C {bitcell_6t.sym} 200 27000 0 0 {name=Xr135c1}
N 160 27040 140 27040 {}
C {lab_pin.sym} 140 27040 0 0 {name=l21606 lab=BL1}
N 160 27000 140 27000 {}
C {lab_pin.sym} 140 27000 0 0 {name=l21607 lab=BLB1}
N 160 26960 140 26960 {}
C {lab_pin.sym} 140 26960 0 0 {name=l21608 lab=WL135}
N 240 27040 260 27040 {}
C {lab_pin.sym} 260 27040 0 0 {name=l21609 lab=VDD}
N 240 26960 260 26960 {}
C {lab_pin.sym} 260 26960 0 0 {name=l21610 lab=VSS}
C {bitcell_6t.sym} 400 27000 0 0 {name=Xr135c2}
N 360 27040 340 27040 {}
C {lab_pin.sym} 340 27040 0 0 {name=l21611 lab=BL2}
N 360 27000 340 27000 {}
C {lab_pin.sym} 340 27000 0 0 {name=l21612 lab=BLB2}
N 360 26960 340 26960 {}
C {lab_pin.sym} 340 26960 0 0 {name=l21613 lab=WL135}
N 440 27040 460 27040 {}
C {lab_pin.sym} 460 27040 0 0 {name=l21614 lab=VDD}
N 440 26960 460 26960 {}
C {lab_pin.sym} 460 26960 0 0 {name=l21615 lab=VSS}
C {bitcell_6t.sym} 600 27000 0 0 {name=Xr135c3}
N 560 27040 540 27040 {}
C {lab_pin.sym} 540 27040 0 0 {name=l21616 lab=BL3}
N 560 27000 540 27000 {}
C {lab_pin.sym} 540 27000 0 0 {name=l21617 lab=BLB3}
N 560 26960 540 26960 {}
C {lab_pin.sym} 540 26960 0 0 {name=l21618 lab=WL135}
N 640 27040 660 27040 {}
C {lab_pin.sym} 660 27040 0 0 {name=l21619 lab=VDD}
N 640 26960 660 26960 {}
C {lab_pin.sym} 660 26960 0 0 {name=l21620 lab=VSS}
C {bitcell_6t.sym} 800 27000 0 0 {name=Xr135c4}
N 760 27040 740 27040 {}
C {lab_pin.sym} 740 27040 0 0 {name=l21621 lab=BL4}
N 760 27000 740 27000 {}
C {lab_pin.sym} 740 27000 0 0 {name=l21622 lab=BLB4}
N 760 26960 740 26960 {}
C {lab_pin.sym} 740 26960 0 0 {name=l21623 lab=WL135}
N 840 27040 860 27040 {}
C {lab_pin.sym} 860 27040 0 0 {name=l21624 lab=VDD}
N 840 26960 860 26960 {}
C {lab_pin.sym} 860 26960 0 0 {name=l21625 lab=VSS}
C {bitcell_6t.sym} 1000 27000 0 0 {name=Xr135c5}
N 960 27040 940 27040 {}
C {lab_pin.sym} 940 27040 0 0 {name=l21626 lab=BL5}
N 960 27000 940 27000 {}
C {lab_pin.sym} 940 27000 0 0 {name=l21627 lab=BLB5}
N 960 26960 940 26960 {}
C {lab_pin.sym} 940 26960 0 0 {name=l21628 lab=WL135}
N 1040 27040 1060 27040 {}
C {lab_pin.sym} 1060 27040 0 0 {name=l21629 lab=VDD}
N 1040 26960 1060 26960 {}
C {lab_pin.sym} 1060 26960 0 0 {name=l21630 lab=VSS}
C {bitcell_6t.sym} 1200 27000 0 0 {name=Xr135c6}
N 1160 27040 1140 27040 {}
C {lab_pin.sym} 1140 27040 0 0 {name=l21631 lab=BL6}
N 1160 27000 1140 27000 {}
C {lab_pin.sym} 1140 27000 0 0 {name=l21632 lab=BLB6}
N 1160 26960 1140 26960 {}
C {lab_pin.sym} 1140 26960 0 0 {name=l21633 lab=WL135}
N 1240 27040 1260 27040 {}
C {lab_pin.sym} 1260 27040 0 0 {name=l21634 lab=VDD}
N 1240 26960 1260 26960 {}
C {lab_pin.sym} 1260 26960 0 0 {name=l21635 lab=VSS}
C {bitcell_6t.sym} 1400 27000 0 0 {name=Xr135c7}
N 1360 27040 1340 27040 {}
C {lab_pin.sym} 1340 27040 0 0 {name=l21636 lab=BL7}
N 1360 27000 1340 27000 {}
C {lab_pin.sym} 1340 27000 0 0 {name=l21637 lab=BLB7}
N 1360 26960 1340 26960 {}
C {lab_pin.sym} 1340 26960 0 0 {name=l21638 lab=WL135}
N 1440 27040 1460 27040 {}
C {lab_pin.sym} 1460 27040 0 0 {name=l21639 lab=VDD}
N 1440 26960 1460 26960 {}
C {lab_pin.sym} 1460 26960 0 0 {name=l21640 lab=VSS}
C {bitcell_6t.sym} 1600 27000 0 0 {name=Xr135c8}
N 1560 27040 1540 27040 {}
C {lab_pin.sym} 1540 27040 0 0 {name=l21641 lab=BL8}
N 1560 27000 1540 27000 {}
C {lab_pin.sym} 1540 27000 0 0 {name=l21642 lab=BLB8}
N 1560 26960 1540 26960 {}
C {lab_pin.sym} 1540 26960 0 0 {name=l21643 lab=WL135}
N 1640 27040 1660 27040 {}
C {lab_pin.sym} 1660 27040 0 0 {name=l21644 lab=VDD}
N 1640 26960 1660 26960 {}
C {lab_pin.sym} 1660 26960 0 0 {name=l21645 lab=VSS}
C {bitcell_6t.sym} 1800 27000 0 0 {name=Xr135c9}
N 1760 27040 1740 27040 {}
C {lab_pin.sym} 1740 27040 0 0 {name=l21646 lab=BL9}
N 1760 27000 1740 27000 {}
C {lab_pin.sym} 1740 27000 0 0 {name=l21647 lab=BLB9}
N 1760 26960 1740 26960 {}
C {lab_pin.sym} 1740 26960 0 0 {name=l21648 lab=WL135}
N 1840 27040 1860 27040 {}
C {lab_pin.sym} 1860 27040 0 0 {name=l21649 lab=VDD}
N 1840 26960 1860 26960 {}
C {lab_pin.sym} 1860 26960 0 0 {name=l21650 lab=VSS}
C {bitcell_6t.sym} 2000 27000 0 0 {name=Xr135c10}
N 1960 27040 1940 27040 {}
C {lab_pin.sym} 1940 27040 0 0 {name=l21651 lab=BL10}
N 1960 27000 1940 27000 {}
C {lab_pin.sym} 1940 27000 0 0 {name=l21652 lab=BLB10}
N 1960 26960 1940 26960 {}
C {lab_pin.sym} 1940 26960 0 0 {name=l21653 lab=WL135}
N 2040 27040 2060 27040 {}
C {lab_pin.sym} 2060 27040 0 0 {name=l21654 lab=VDD}
N 2040 26960 2060 26960 {}
C {lab_pin.sym} 2060 26960 0 0 {name=l21655 lab=VSS}
C {bitcell_6t.sym} 2200 27000 0 0 {name=Xr135c11}
N 2160 27040 2140 27040 {}
C {lab_pin.sym} 2140 27040 0 0 {name=l21656 lab=BL11}
N 2160 27000 2140 27000 {}
C {lab_pin.sym} 2140 27000 0 0 {name=l21657 lab=BLB11}
N 2160 26960 2140 26960 {}
C {lab_pin.sym} 2140 26960 0 0 {name=l21658 lab=WL135}
N 2240 27040 2260 27040 {}
C {lab_pin.sym} 2260 27040 0 0 {name=l21659 lab=VDD}
N 2240 26960 2260 26960 {}
C {lab_pin.sym} 2260 26960 0 0 {name=l21660 lab=VSS}
C {bitcell_6t.sym} 2400 27000 0 0 {name=Xr135c12}
N 2360 27040 2340 27040 {}
C {lab_pin.sym} 2340 27040 0 0 {name=l21661 lab=BL12}
N 2360 27000 2340 27000 {}
C {lab_pin.sym} 2340 27000 0 0 {name=l21662 lab=BLB12}
N 2360 26960 2340 26960 {}
C {lab_pin.sym} 2340 26960 0 0 {name=l21663 lab=WL135}
N 2440 27040 2460 27040 {}
C {lab_pin.sym} 2460 27040 0 0 {name=l21664 lab=VDD}
N 2440 26960 2460 26960 {}
C {lab_pin.sym} 2460 26960 0 0 {name=l21665 lab=VSS}
C {bitcell_6t.sym} 2600 27000 0 0 {name=Xr135c13}
N 2560 27040 2540 27040 {}
C {lab_pin.sym} 2540 27040 0 0 {name=l21666 lab=BL13}
N 2560 27000 2540 27000 {}
C {lab_pin.sym} 2540 27000 0 0 {name=l21667 lab=BLB13}
N 2560 26960 2540 26960 {}
C {lab_pin.sym} 2540 26960 0 0 {name=l21668 lab=WL135}
N 2640 27040 2660 27040 {}
C {lab_pin.sym} 2660 27040 0 0 {name=l21669 lab=VDD}
N 2640 26960 2660 26960 {}
C {lab_pin.sym} 2660 26960 0 0 {name=l21670 lab=VSS}
C {bitcell_6t.sym} 2800 27000 0 0 {name=Xr135c14}
N 2760 27040 2740 27040 {}
C {lab_pin.sym} 2740 27040 0 0 {name=l21671 lab=BL14}
N 2760 27000 2740 27000 {}
C {lab_pin.sym} 2740 27000 0 0 {name=l21672 lab=BLB14}
N 2760 26960 2740 26960 {}
C {lab_pin.sym} 2740 26960 0 0 {name=l21673 lab=WL135}
N 2840 27040 2860 27040 {}
C {lab_pin.sym} 2860 27040 0 0 {name=l21674 lab=VDD}
N 2840 26960 2860 26960 {}
C {lab_pin.sym} 2860 26960 0 0 {name=l21675 lab=VSS}
C {bitcell_6t.sym} 3000 27000 0 0 {name=Xr135c15}
N 2960 27040 2940 27040 {}
C {lab_pin.sym} 2940 27040 0 0 {name=l21676 lab=BL15}
N 2960 27000 2940 27000 {}
C {lab_pin.sym} 2940 27000 0 0 {name=l21677 lab=BLB15}
N 2960 26960 2940 26960 {}
C {lab_pin.sym} 2940 26960 0 0 {name=l21678 lab=WL135}
N 3040 27040 3060 27040 {}
C {lab_pin.sym} 3060 27040 0 0 {name=l21679 lab=VDD}
N 3040 26960 3060 26960 {}
C {lab_pin.sym} 3060 26960 0 0 {name=l21680 lab=VSS}
C {bitcell_6t.sym} 3200 27000 0 0 {name=Xr135c16}
N 3160 27040 3140 27040 {}
C {lab_pin.sym} 3140 27040 0 0 {name=l21681 lab=BL16}
N 3160 27000 3140 27000 {}
C {lab_pin.sym} 3140 27000 0 0 {name=l21682 lab=BLB16}
N 3160 26960 3140 26960 {}
C {lab_pin.sym} 3140 26960 0 0 {name=l21683 lab=WL135}
N 3240 27040 3260 27040 {}
C {lab_pin.sym} 3260 27040 0 0 {name=l21684 lab=VDD}
N 3240 26960 3260 26960 {}
C {lab_pin.sym} 3260 26960 0 0 {name=l21685 lab=VSS}
C {bitcell_6t.sym} 3400 27000 0 0 {name=Xr135c17}
N 3360 27040 3340 27040 {}
C {lab_pin.sym} 3340 27040 0 0 {name=l21686 lab=BL17}
N 3360 27000 3340 27000 {}
C {lab_pin.sym} 3340 27000 0 0 {name=l21687 lab=BLB17}
N 3360 26960 3340 26960 {}
C {lab_pin.sym} 3340 26960 0 0 {name=l21688 lab=WL135}
N 3440 27040 3460 27040 {}
C {lab_pin.sym} 3460 27040 0 0 {name=l21689 lab=VDD}
N 3440 26960 3460 26960 {}
C {lab_pin.sym} 3460 26960 0 0 {name=l21690 lab=VSS}
C {bitcell_6t.sym} 3600 27000 0 0 {name=Xr135c18}
N 3560 27040 3540 27040 {}
C {lab_pin.sym} 3540 27040 0 0 {name=l21691 lab=BL18}
N 3560 27000 3540 27000 {}
C {lab_pin.sym} 3540 27000 0 0 {name=l21692 lab=BLB18}
N 3560 26960 3540 26960 {}
C {lab_pin.sym} 3540 26960 0 0 {name=l21693 lab=WL135}
N 3640 27040 3660 27040 {}
C {lab_pin.sym} 3660 27040 0 0 {name=l21694 lab=VDD}
N 3640 26960 3660 26960 {}
C {lab_pin.sym} 3660 26960 0 0 {name=l21695 lab=VSS}
C {bitcell_6t.sym} 3800 27000 0 0 {name=Xr135c19}
N 3760 27040 3740 27040 {}
C {lab_pin.sym} 3740 27040 0 0 {name=l21696 lab=BL19}
N 3760 27000 3740 27000 {}
C {lab_pin.sym} 3740 27000 0 0 {name=l21697 lab=BLB19}
N 3760 26960 3740 26960 {}
C {lab_pin.sym} 3740 26960 0 0 {name=l21698 lab=WL135}
N 3840 27040 3860 27040 {}
C {lab_pin.sym} 3860 27040 0 0 {name=l21699 lab=VDD}
N 3840 26960 3860 26960 {}
C {lab_pin.sym} 3860 26960 0 0 {name=l21700 lab=VSS}
C {bitcell_6t.sym} 4000 27000 0 0 {name=Xr135c20}
N 3960 27040 3940 27040 {}
C {lab_pin.sym} 3940 27040 0 0 {name=l21701 lab=BL20}
N 3960 27000 3940 27000 {}
C {lab_pin.sym} 3940 27000 0 0 {name=l21702 lab=BLB20}
N 3960 26960 3940 26960 {}
C {lab_pin.sym} 3940 26960 0 0 {name=l21703 lab=WL135}
N 4040 27040 4060 27040 {}
C {lab_pin.sym} 4060 27040 0 0 {name=l21704 lab=VDD}
N 4040 26960 4060 26960 {}
C {lab_pin.sym} 4060 26960 0 0 {name=l21705 lab=VSS}
C {bitcell_6t.sym} 4200 27000 0 0 {name=Xr135c21}
N 4160 27040 4140 27040 {}
C {lab_pin.sym} 4140 27040 0 0 {name=l21706 lab=BL21}
N 4160 27000 4140 27000 {}
C {lab_pin.sym} 4140 27000 0 0 {name=l21707 lab=BLB21}
N 4160 26960 4140 26960 {}
C {lab_pin.sym} 4140 26960 0 0 {name=l21708 lab=WL135}
N 4240 27040 4260 27040 {}
C {lab_pin.sym} 4260 27040 0 0 {name=l21709 lab=VDD}
N 4240 26960 4260 26960 {}
C {lab_pin.sym} 4260 26960 0 0 {name=l21710 lab=VSS}
C {bitcell_6t.sym} 4400 27000 0 0 {name=Xr135c22}
N 4360 27040 4340 27040 {}
C {lab_pin.sym} 4340 27040 0 0 {name=l21711 lab=BL22}
N 4360 27000 4340 27000 {}
C {lab_pin.sym} 4340 27000 0 0 {name=l21712 lab=BLB22}
N 4360 26960 4340 26960 {}
C {lab_pin.sym} 4340 26960 0 0 {name=l21713 lab=WL135}
N 4440 27040 4460 27040 {}
C {lab_pin.sym} 4460 27040 0 0 {name=l21714 lab=VDD}
N 4440 26960 4460 26960 {}
C {lab_pin.sym} 4460 26960 0 0 {name=l21715 lab=VSS}
C {bitcell_6t.sym} 4600 27000 0 0 {name=Xr135c23}
N 4560 27040 4540 27040 {}
C {lab_pin.sym} 4540 27040 0 0 {name=l21716 lab=BL23}
N 4560 27000 4540 27000 {}
C {lab_pin.sym} 4540 27000 0 0 {name=l21717 lab=BLB23}
N 4560 26960 4540 26960 {}
C {lab_pin.sym} 4540 26960 0 0 {name=l21718 lab=WL135}
N 4640 27040 4660 27040 {}
C {lab_pin.sym} 4660 27040 0 0 {name=l21719 lab=VDD}
N 4640 26960 4660 26960 {}
C {lab_pin.sym} 4660 26960 0 0 {name=l21720 lab=VSS}
C {bitcell_6t.sym} 4800 27000 0 0 {name=Xr135c24}
N 4760 27040 4740 27040 {}
C {lab_pin.sym} 4740 27040 0 0 {name=l21721 lab=BL24}
N 4760 27000 4740 27000 {}
C {lab_pin.sym} 4740 27000 0 0 {name=l21722 lab=BLB24}
N 4760 26960 4740 26960 {}
C {lab_pin.sym} 4740 26960 0 0 {name=l21723 lab=WL135}
N 4840 27040 4860 27040 {}
C {lab_pin.sym} 4860 27040 0 0 {name=l21724 lab=VDD}
N 4840 26960 4860 26960 {}
C {lab_pin.sym} 4860 26960 0 0 {name=l21725 lab=VSS}
C {bitcell_6t.sym} 5000 27000 0 0 {name=Xr135c25}
N 4960 27040 4940 27040 {}
C {lab_pin.sym} 4940 27040 0 0 {name=l21726 lab=BL25}
N 4960 27000 4940 27000 {}
C {lab_pin.sym} 4940 27000 0 0 {name=l21727 lab=BLB25}
N 4960 26960 4940 26960 {}
C {lab_pin.sym} 4940 26960 0 0 {name=l21728 lab=WL135}
N 5040 27040 5060 27040 {}
C {lab_pin.sym} 5060 27040 0 0 {name=l21729 lab=VDD}
N 5040 26960 5060 26960 {}
C {lab_pin.sym} 5060 26960 0 0 {name=l21730 lab=VSS}
C {bitcell_6t.sym} 5200 27000 0 0 {name=Xr135c26}
N 5160 27040 5140 27040 {}
C {lab_pin.sym} 5140 27040 0 0 {name=l21731 lab=BL26}
N 5160 27000 5140 27000 {}
C {lab_pin.sym} 5140 27000 0 0 {name=l21732 lab=BLB26}
N 5160 26960 5140 26960 {}
C {lab_pin.sym} 5140 26960 0 0 {name=l21733 lab=WL135}
N 5240 27040 5260 27040 {}
C {lab_pin.sym} 5260 27040 0 0 {name=l21734 lab=VDD}
N 5240 26960 5260 26960 {}
C {lab_pin.sym} 5260 26960 0 0 {name=l21735 lab=VSS}
C {bitcell_6t.sym} 5400 27000 0 0 {name=Xr135c27}
N 5360 27040 5340 27040 {}
C {lab_pin.sym} 5340 27040 0 0 {name=l21736 lab=BL27}
N 5360 27000 5340 27000 {}
C {lab_pin.sym} 5340 27000 0 0 {name=l21737 lab=BLB27}
N 5360 26960 5340 26960 {}
C {lab_pin.sym} 5340 26960 0 0 {name=l21738 lab=WL135}
N 5440 27040 5460 27040 {}
C {lab_pin.sym} 5460 27040 0 0 {name=l21739 lab=VDD}
N 5440 26960 5460 26960 {}
C {lab_pin.sym} 5460 26960 0 0 {name=l21740 lab=VSS}
C {bitcell_6t.sym} 5600 27000 0 0 {name=Xr135c28}
N 5560 27040 5540 27040 {}
C {lab_pin.sym} 5540 27040 0 0 {name=l21741 lab=BL28}
N 5560 27000 5540 27000 {}
C {lab_pin.sym} 5540 27000 0 0 {name=l21742 lab=BLB28}
N 5560 26960 5540 26960 {}
C {lab_pin.sym} 5540 26960 0 0 {name=l21743 lab=WL135}
N 5640 27040 5660 27040 {}
C {lab_pin.sym} 5660 27040 0 0 {name=l21744 lab=VDD}
N 5640 26960 5660 26960 {}
C {lab_pin.sym} 5660 26960 0 0 {name=l21745 lab=VSS}
C {bitcell_6t.sym} 5800 27000 0 0 {name=Xr135c29}
N 5760 27040 5740 27040 {}
C {lab_pin.sym} 5740 27040 0 0 {name=l21746 lab=BL29}
N 5760 27000 5740 27000 {}
C {lab_pin.sym} 5740 27000 0 0 {name=l21747 lab=BLB29}
N 5760 26960 5740 26960 {}
C {lab_pin.sym} 5740 26960 0 0 {name=l21748 lab=WL135}
N 5840 27040 5860 27040 {}
C {lab_pin.sym} 5860 27040 0 0 {name=l21749 lab=VDD}
N 5840 26960 5860 26960 {}
C {lab_pin.sym} 5860 26960 0 0 {name=l21750 lab=VSS}
C {bitcell_6t.sym} 6000 27000 0 0 {name=Xr135c30}
N 5960 27040 5940 27040 {}
C {lab_pin.sym} 5940 27040 0 0 {name=l21751 lab=BL30}
N 5960 27000 5940 27000 {}
C {lab_pin.sym} 5940 27000 0 0 {name=l21752 lab=BLB30}
N 5960 26960 5940 26960 {}
C {lab_pin.sym} 5940 26960 0 0 {name=l21753 lab=WL135}
N 6040 27040 6060 27040 {}
C {lab_pin.sym} 6060 27040 0 0 {name=l21754 lab=VDD}
N 6040 26960 6060 26960 {}
C {lab_pin.sym} 6060 26960 0 0 {name=l21755 lab=VSS}
C {bitcell_6t.sym} 6200 27000 0 0 {name=Xr135c31}
N 6160 27040 6140 27040 {}
C {lab_pin.sym} 6140 27040 0 0 {name=l21756 lab=BL31}
N 6160 27000 6140 27000 {}
C {lab_pin.sym} 6140 27000 0 0 {name=l21757 lab=BLB31}
N 6160 26960 6140 26960 {}
C {lab_pin.sym} 6140 26960 0 0 {name=l21758 lab=WL135}
N 6240 27040 6260 27040 {}
C {lab_pin.sym} 6260 27040 0 0 {name=l21759 lab=VDD}
N 6240 26960 6260 26960 {}
C {lab_pin.sym} 6260 26960 0 0 {name=l21760 lab=VSS}
C {bitcell_6t.sym} 0 27200 0 0 {name=Xr136c0}
N -40 27240 -60 27240 {}
C {lab_pin.sym} -60 27240 0 0 {name=l21761 lab=BL0}
N -40 27200 -60 27200 {}
C {lab_pin.sym} -60 27200 0 0 {name=l21762 lab=BLB0}
N -40 27160 -60 27160 {}
C {lab_pin.sym} -60 27160 0 0 {name=l21763 lab=WL136}
N 40 27240 60 27240 {}
C {lab_pin.sym} 60 27240 0 0 {name=l21764 lab=VDD}
N 40 27160 60 27160 {}
C {lab_pin.sym} 60 27160 0 0 {name=l21765 lab=VSS}
C {bitcell_6t.sym} 200 27200 0 0 {name=Xr136c1}
N 160 27240 140 27240 {}
C {lab_pin.sym} 140 27240 0 0 {name=l21766 lab=BL1}
N 160 27200 140 27200 {}
C {lab_pin.sym} 140 27200 0 0 {name=l21767 lab=BLB1}
N 160 27160 140 27160 {}
C {lab_pin.sym} 140 27160 0 0 {name=l21768 lab=WL136}
N 240 27240 260 27240 {}
C {lab_pin.sym} 260 27240 0 0 {name=l21769 lab=VDD}
N 240 27160 260 27160 {}
C {lab_pin.sym} 260 27160 0 0 {name=l21770 lab=VSS}
C {bitcell_6t.sym} 400 27200 0 0 {name=Xr136c2}
N 360 27240 340 27240 {}
C {lab_pin.sym} 340 27240 0 0 {name=l21771 lab=BL2}
N 360 27200 340 27200 {}
C {lab_pin.sym} 340 27200 0 0 {name=l21772 lab=BLB2}
N 360 27160 340 27160 {}
C {lab_pin.sym} 340 27160 0 0 {name=l21773 lab=WL136}
N 440 27240 460 27240 {}
C {lab_pin.sym} 460 27240 0 0 {name=l21774 lab=VDD}
N 440 27160 460 27160 {}
C {lab_pin.sym} 460 27160 0 0 {name=l21775 lab=VSS}
C {bitcell_6t.sym} 600 27200 0 0 {name=Xr136c3}
N 560 27240 540 27240 {}
C {lab_pin.sym} 540 27240 0 0 {name=l21776 lab=BL3}
N 560 27200 540 27200 {}
C {lab_pin.sym} 540 27200 0 0 {name=l21777 lab=BLB3}
N 560 27160 540 27160 {}
C {lab_pin.sym} 540 27160 0 0 {name=l21778 lab=WL136}
N 640 27240 660 27240 {}
C {lab_pin.sym} 660 27240 0 0 {name=l21779 lab=VDD}
N 640 27160 660 27160 {}
C {lab_pin.sym} 660 27160 0 0 {name=l21780 lab=VSS}
C {bitcell_6t.sym} 800 27200 0 0 {name=Xr136c4}
N 760 27240 740 27240 {}
C {lab_pin.sym} 740 27240 0 0 {name=l21781 lab=BL4}
N 760 27200 740 27200 {}
C {lab_pin.sym} 740 27200 0 0 {name=l21782 lab=BLB4}
N 760 27160 740 27160 {}
C {lab_pin.sym} 740 27160 0 0 {name=l21783 lab=WL136}
N 840 27240 860 27240 {}
C {lab_pin.sym} 860 27240 0 0 {name=l21784 lab=VDD}
N 840 27160 860 27160 {}
C {lab_pin.sym} 860 27160 0 0 {name=l21785 lab=VSS}
C {bitcell_6t.sym} 1000 27200 0 0 {name=Xr136c5}
N 960 27240 940 27240 {}
C {lab_pin.sym} 940 27240 0 0 {name=l21786 lab=BL5}
N 960 27200 940 27200 {}
C {lab_pin.sym} 940 27200 0 0 {name=l21787 lab=BLB5}
N 960 27160 940 27160 {}
C {lab_pin.sym} 940 27160 0 0 {name=l21788 lab=WL136}
N 1040 27240 1060 27240 {}
C {lab_pin.sym} 1060 27240 0 0 {name=l21789 lab=VDD}
N 1040 27160 1060 27160 {}
C {lab_pin.sym} 1060 27160 0 0 {name=l21790 lab=VSS}
C {bitcell_6t.sym} 1200 27200 0 0 {name=Xr136c6}
N 1160 27240 1140 27240 {}
C {lab_pin.sym} 1140 27240 0 0 {name=l21791 lab=BL6}
N 1160 27200 1140 27200 {}
C {lab_pin.sym} 1140 27200 0 0 {name=l21792 lab=BLB6}
N 1160 27160 1140 27160 {}
C {lab_pin.sym} 1140 27160 0 0 {name=l21793 lab=WL136}
N 1240 27240 1260 27240 {}
C {lab_pin.sym} 1260 27240 0 0 {name=l21794 lab=VDD}
N 1240 27160 1260 27160 {}
C {lab_pin.sym} 1260 27160 0 0 {name=l21795 lab=VSS}
C {bitcell_6t.sym} 1400 27200 0 0 {name=Xr136c7}
N 1360 27240 1340 27240 {}
C {lab_pin.sym} 1340 27240 0 0 {name=l21796 lab=BL7}
N 1360 27200 1340 27200 {}
C {lab_pin.sym} 1340 27200 0 0 {name=l21797 lab=BLB7}
N 1360 27160 1340 27160 {}
C {lab_pin.sym} 1340 27160 0 0 {name=l21798 lab=WL136}
N 1440 27240 1460 27240 {}
C {lab_pin.sym} 1460 27240 0 0 {name=l21799 lab=VDD}
N 1440 27160 1460 27160 {}
C {lab_pin.sym} 1460 27160 0 0 {name=l21800 lab=VSS}
C {bitcell_6t.sym} 1600 27200 0 0 {name=Xr136c8}
N 1560 27240 1540 27240 {}
C {lab_pin.sym} 1540 27240 0 0 {name=l21801 lab=BL8}
N 1560 27200 1540 27200 {}
C {lab_pin.sym} 1540 27200 0 0 {name=l21802 lab=BLB8}
N 1560 27160 1540 27160 {}
C {lab_pin.sym} 1540 27160 0 0 {name=l21803 lab=WL136}
N 1640 27240 1660 27240 {}
C {lab_pin.sym} 1660 27240 0 0 {name=l21804 lab=VDD}
N 1640 27160 1660 27160 {}
C {lab_pin.sym} 1660 27160 0 0 {name=l21805 lab=VSS}
C {bitcell_6t.sym} 1800 27200 0 0 {name=Xr136c9}
N 1760 27240 1740 27240 {}
C {lab_pin.sym} 1740 27240 0 0 {name=l21806 lab=BL9}
N 1760 27200 1740 27200 {}
C {lab_pin.sym} 1740 27200 0 0 {name=l21807 lab=BLB9}
N 1760 27160 1740 27160 {}
C {lab_pin.sym} 1740 27160 0 0 {name=l21808 lab=WL136}
N 1840 27240 1860 27240 {}
C {lab_pin.sym} 1860 27240 0 0 {name=l21809 lab=VDD}
N 1840 27160 1860 27160 {}
C {lab_pin.sym} 1860 27160 0 0 {name=l21810 lab=VSS}
C {bitcell_6t.sym} 2000 27200 0 0 {name=Xr136c10}
N 1960 27240 1940 27240 {}
C {lab_pin.sym} 1940 27240 0 0 {name=l21811 lab=BL10}
N 1960 27200 1940 27200 {}
C {lab_pin.sym} 1940 27200 0 0 {name=l21812 lab=BLB10}
N 1960 27160 1940 27160 {}
C {lab_pin.sym} 1940 27160 0 0 {name=l21813 lab=WL136}
N 2040 27240 2060 27240 {}
C {lab_pin.sym} 2060 27240 0 0 {name=l21814 lab=VDD}
N 2040 27160 2060 27160 {}
C {lab_pin.sym} 2060 27160 0 0 {name=l21815 lab=VSS}
C {bitcell_6t.sym} 2200 27200 0 0 {name=Xr136c11}
N 2160 27240 2140 27240 {}
C {lab_pin.sym} 2140 27240 0 0 {name=l21816 lab=BL11}
N 2160 27200 2140 27200 {}
C {lab_pin.sym} 2140 27200 0 0 {name=l21817 lab=BLB11}
N 2160 27160 2140 27160 {}
C {lab_pin.sym} 2140 27160 0 0 {name=l21818 lab=WL136}
N 2240 27240 2260 27240 {}
C {lab_pin.sym} 2260 27240 0 0 {name=l21819 lab=VDD}
N 2240 27160 2260 27160 {}
C {lab_pin.sym} 2260 27160 0 0 {name=l21820 lab=VSS}
C {bitcell_6t.sym} 2400 27200 0 0 {name=Xr136c12}
N 2360 27240 2340 27240 {}
C {lab_pin.sym} 2340 27240 0 0 {name=l21821 lab=BL12}
N 2360 27200 2340 27200 {}
C {lab_pin.sym} 2340 27200 0 0 {name=l21822 lab=BLB12}
N 2360 27160 2340 27160 {}
C {lab_pin.sym} 2340 27160 0 0 {name=l21823 lab=WL136}
N 2440 27240 2460 27240 {}
C {lab_pin.sym} 2460 27240 0 0 {name=l21824 lab=VDD}
N 2440 27160 2460 27160 {}
C {lab_pin.sym} 2460 27160 0 0 {name=l21825 lab=VSS}
C {bitcell_6t.sym} 2600 27200 0 0 {name=Xr136c13}
N 2560 27240 2540 27240 {}
C {lab_pin.sym} 2540 27240 0 0 {name=l21826 lab=BL13}
N 2560 27200 2540 27200 {}
C {lab_pin.sym} 2540 27200 0 0 {name=l21827 lab=BLB13}
N 2560 27160 2540 27160 {}
C {lab_pin.sym} 2540 27160 0 0 {name=l21828 lab=WL136}
N 2640 27240 2660 27240 {}
C {lab_pin.sym} 2660 27240 0 0 {name=l21829 lab=VDD}
N 2640 27160 2660 27160 {}
C {lab_pin.sym} 2660 27160 0 0 {name=l21830 lab=VSS}
C {bitcell_6t.sym} 2800 27200 0 0 {name=Xr136c14}
N 2760 27240 2740 27240 {}
C {lab_pin.sym} 2740 27240 0 0 {name=l21831 lab=BL14}
N 2760 27200 2740 27200 {}
C {lab_pin.sym} 2740 27200 0 0 {name=l21832 lab=BLB14}
N 2760 27160 2740 27160 {}
C {lab_pin.sym} 2740 27160 0 0 {name=l21833 lab=WL136}
N 2840 27240 2860 27240 {}
C {lab_pin.sym} 2860 27240 0 0 {name=l21834 lab=VDD}
N 2840 27160 2860 27160 {}
C {lab_pin.sym} 2860 27160 0 0 {name=l21835 lab=VSS}
C {bitcell_6t.sym} 3000 27200 0 0 {name=Xr136c15}
N 2960 27240 2940 27240 {}
C {lab_pin.sym} 2940 27240 0 0 {name=l21836 lab=BL15}
N 2960 27200 2940 27200 {}
C {lab_pin.sym} 2940 27200 0 0 {name=l21837 lab=BLB15}
N 2960 27160 2940 27160 {}
C {lab_pin.sym} 2940 27160 0 0 {name=l21838 lab=WL136}
N 3040 27240 3060 27240 {}
C {lab_pin.sym} 3060 27240 0 0 {name=l21839 lab=VDD}
N 3040 27160 3060 27160 {}
C {lab_pin.sym} 3060 27160 0 0 {name=l21840 lab=VSS}
C {bitcell_6t.sym} 3200 27200 0 0 {name=Xr136c16}
N 3160 27240 3140 27240 {}
C {lab_pin.sym} 3140 27240 0 0 {name=l21841 lab=BL16}
N 3160 27200 3140 27200 {}
C {lab_pin.sym} 3140 27200 0 0 {name=l21842 lab=BLB16}
N 3160 27160 3140 27160 {}
C {lab_pin.sym} 3140 27160 0 0 {name=l21843 lab=WL136}
N 3240 27240 3260 27240 {}
C {lab_pin.sym} 3260 27240 0 0 {name=l21844 lab=VDD}
N 3240 27160 3260 27160 {}
C {lab_pin.sym} 3260 27160 0 0 {name=l21845 lab=VSS}
C {bitcell_6t.sym} 3400 27200 0 0 {name=Xr136c17}
N 3360 27240 3340 27240 {}
C {lab_pin.sym} 3340 27240 0 0 {name=l21846 lab=BL17}
N 3360 27200 3340 27200 {}
C {lab_pin.sym} 3340 27200 0 0 {name=l21847 lab=BLB17}
N 3360 27160 3340 27160 {}
C {lab_pin.sym} 3340 27160 0 0 {name=l21848 lab=WL136}
N 3440 27240 3460 27240 {}
C {lab_pin.sym} 3460 27240 0 0 {name=l21849 lab=VDD}
N 3440 27160 3460 27160 {}
C {lab_pin.sym} 3460 27160 0 0 {name=l21850 lab=VSS}
C {bitcell_6t.sym} 3600 27200 0 0 {name=Xr136c18}
N 3560 27240 3540 27240 {}
C {lab_pin.sym} 3540 27240 0 0 {name=l21851 lab=BL18}
N 3560 27200 3540 27200 {}
C {lab_pin.sym} 3540 27200 0 0 {name=l21852 lab=BLB18}
N 3560 27160 3540 27160 {}
C {lab_pin.sym} 3540 27160 0 0 {name=l21853 lab=WL136}
N 3640 27240 3660 27240 {}
C {lab_pin.sym} 3660 27240 0 0 {name=l21854 lab=VDD}
N 3640 27160 3660 27160 {}
C {lab_pin.sym} 3660 27160 0 0 {name=l21855 lab=VSS}
C {bitcell_6t.sym} 3800 27200 0 0 {name=Xr136c19}
N 3760 27240 3740 27240 {}
C {lab_pin.sym} 3740 27240 0 0 {name=l21856 lab=BL19}
N 3760 27200 3740 27200 {}
C {lab_pin.sym} 3740 27200 0 0 {name=l21857 lab=BLB19}
N 3760 27160 3740 27160 {}
C {lab_pin.sym} 3740 27160 0 0 {name=l21858 lab=WL136}
N 3840 27240 3860 27240 {}
C {lab_pin.sym} 3860 27240 0 0 {name=l21859 lab=VDD}
N 3840 27160 3860 27160 {}
C {lab_pin.sym} 3860 27160 0 0 {name=l21860 lab=VSS}
C {bitcell_6t.sym} 4000 27200 0 0 {name=Xr136c20}
N 3960 27240 3940 27240 {}
C {lab_pin.sym} 3940 27240 0 0 {name=l21861 lab=BL20}
N 3960 27200 3940 27200 {}
C {lab_pin.sym} 3940 27200 0 0 {name=l21862 lab=BLB20}
N 3960 27160 3940 27160 {}
C {lab_pin.sym} 3940 27160 0 0 {name=l21863 lab=WL136}
N 4040 27240 4060 27240 {}
C {lab_pin.sym} 4060 27240 0 0 {name=l21864 lab=VDD}
N 4040 27160 4060 27160 {}
C {lab_pin.sym} 4060 27160 0 0 {name=l21865 lab=VSS}
C {bitcell_6t.sym} 4200 27200 0 0 {name=Xr136c21}
N 4160 27240 4140 27240 {}
C {lab_pin.sym} 4140 27240 0 0 {name=l21866 lab=BL21}
N 4160 27200 4140 27200 {}
C {lab_pin.sym} 4140 27200 0 0 {name=l21867 lab=BLB21}
N 4160 27160 4140 27160 {}
C {lab_pin.sym} 4140 27160 0 0 {name=l21868 lab=WL136}
N 4240 27240 4260 27240 {}
C {lab_pin.sym} 4260 27240 0 0 {name=l21869 lab=VDD}
N 4240 27160 4260 27160 {}
C {lab_pin.sym} 4260 27160 0 0 {name=l21870 lab=VSS}
C {bitcell_6t.sym} 4400 27200 0 0 {name=Xr136c22}
N 4360 27240 4340 27240 {}
C {lab_pin.sym} 4340 27240 0 0 {name=l21871 lab=BL22}
N 4360 27200 4340 27200 {}
C {lab_pin.sym} 4340 27200 0 0 {name=l21872 lab=BLB22}
N 4360 27160 4340 27160 {}
C {lab_pin.sym} 4340 27160 0 0 {name=l21873 lab=WL136}
N 4440 27240 4460 27240 {}
C {lab_pin.sym} 4460 27240 0 0 {name=l21874 lab=VDD}
N 4440 27160 4460 27160 {}
C {lab_pin.sym} 4460 27160 0 0 {name=l21875 lab=VSS}
C {bitcell_6t.sym} 4600 27200 0 0 {name=Xr136c23}
N 4560 27240 4540 27240 {}
C {lab_pin.sym} 4540 27240 0 0 {name=l21876 lab=BL23}
N 4560 27200 4540 27200 {}
C {lab_pin.sym} 4540 27200 0 0 {name=l21877 lab=BLB23}
N 4560 27160 4540 27160 {}
C {lab_pin.sym} 4540 27160 0 0 {name=l21878 lab=WL136}
N 4640 27240 4660 27240 {}
C {lab_pin.sym} 4660 27240 0 0 {name=l21879 lab=VDD}
N 4640 27160 4660 27160 {}
C {lab_pin.sym} 4660 27160 0 0 {name=l21880 lab=VSS}
C {bitcell_6t.sym} 4800 27200 0 0 {name=Xr136c24}
N 4760 27240 4740 27240 {}
C {lab_pin.sym} 4740 27240 0 0 {name=l21881 lab=BL24}
N 4760 27200 4740 27200 {}
C {lab_pin.sym} 4740 27200 0 0 {name=l21882 lab=BLB24}
N 4760 27160 4740 27160 {}
C {lab_pin.sym} 4740 27160 0 0 {name=l21883 lab=WL136}
N 4840 27240 4860 27240 {}
C {lab_pin.sym} 4860 27240 0 0 {name=l21884 lab=VDD}
N 4840 27160 4860 27160 {}
C {lab_pin.sym} 4860 27160 0 0 {name=l21885 lab=VSS}
C {bitcell_6t.sym} 5000 27200 0 0 {name=Xr136c25}
N 4960 27240 4940 27240 {}
C {lab_pin.sym} 4940 27240 0 0 {name=l21886 lab=BL25}
N 4960 27200 4940 27200 {}
C {lab_pin.sym} 4940 27200 0 0 {name=l21887 lab=BLB25}
N 4960 27160 4940 27160 {}
C {lab_pin.sym} 4940 27160 0 0 {name=l21888 lab=WL136}
N 5040 27240 5060 27240 {}
C {lab_pin.sym} 5060 27240 0 0 {name=l21889 lab=VDD}
N 5040 27160 5060 27160 {}
C {lab_pin.sym} 5060 27160 0 0 {name=l21890 lab=VSS}
C {bitcell_6t.sym} 5200 27200 0 0 {name=Xr136c26}
N 5160 27240 5140 27240 {}
C {lab_pin.sym} 5140 27240 0 0 {name=l21891 lab=BL26}
N 5160 27200 5140 27200 {}
C {lab_pin.sym} 5140 27200 0 0 {name=l21892 lab=BLB26}
N 5160 27160 5140 27160 {}
C {lab_pin.sym} 5140 27160 0 0 {name=l21893 lab=WL136}
N 5240 27240 5260 27240 {}
C {lab_pin.sym} 5260 27240 0 0 {name=l21894 lab=VDD}
N 5240 27160 5260 27160 {}
C {lab_pin.sym} 5260 27160 0 0 {name=l21895 lab=VSS}
C {bitcell_6t.sym} 5400 27200 0 0 {name=Xr136c27}
N 5360 27240 5340 27240 {}
C {lab_pin.sym} 5340 27240 0 0 {name=l21896 lab=BL27}
N 5360 27200 5340 27200 {}
C {lab_pin.sym} 5340 27200 0 0 {name=l21897 lab=BLB27}
N 5360 27160 5340 27160 {}
C {lab_pin.sym} 5340 27160 0 0 {name=l21898 lab=WL136}
N 5440 27240 5460 27240 {}
C {lab_pin.sym} 5460 27240 0 0 {name=l21899 lab=VDD}
N 5440 27160 5460 27160 {}
C {lab_pin.sym} 5460 27160 0 0 {name=l21900 lab=VSS}
C {bitcell_6t.sym} 5600 27200 0 0 {name=Xr136c28}
N 5560 27240 5540 27240 {}
C {lab_pin.sym} 5540 27240 0 0 {name=l21901 lab=BL28}
N 5560 27200 5540 27200 {}
C {lab_pin.sym} 5540 27200 0 0 {name=l21902 lab=BLB28}
N 5560 27160 5540 27160 {}
C {lab_pin.sym} 5540 27160 0 0 {name=l21903 lab=WL136}
N 5640 27240 5660 27240 {}
C {lab_pin.sym} 5660 27240 0 0 {name=l21904 lab=VDD}
N 5640 27160 5660 27160 {}
C {lab_pin.sym} 5660 27160 0 0 {name=l21905 lab=VSS}
C {bitcell_6t.sym} 5800 27200 0 0 {name=Xr136c29}
N 5760 27240 5740 27240 {}
C {lab_pin.sym} 5740 27240 0 0 {name=l21906 lab=BL29}
N 5760 27200 5740 27200 {}
C {lab_pin.sym} 5740 27200 0 0 {name=l21907 lab=BLB29}
N 5760 27160 5740 27160 {}
C {lab_pin.sym} 5740 27160 0 0 {name=l21908 lab=WL136}
N 5840 27240 5860 27240 {}
C {lab_pin.sym} 5860 27240 0 0 {name=l21909 lab=VDD}
N 5840 27160 5860 27160 {}
C {lab_pin.sym} 5860 27160 0 0 {name=l21910 lab=VSS}
C {bitcell_6t.sym} 6000 27200 0 0 {name=Xr136c30}
N 5960 27240 5940 27240 {}
C {lab_pin.sym} 5940 27240 0 0 {name=l21911 lab=BL30}
N 5960 27200 5940 27200 {}
C {lab_pin.sym} 5940 27200 0 0 {name=l21912 lab=BLB30}
N 5960 27160 5940 27160 {}
C {lab_pin.sym} 5940 27160 0 0 {name=l21913 lab=WL136}
N 6040 27240 6060 27240 {}
C {lab_pin.sym} 6060 27240 0 0 {name=l21914 lab=VDD}
N 6040 27160 6060 27160 {}
C {lab_pin.sym} 6060 27160 0 0 {name=l21915 lab=VSS}
C {bitcell_6t.sym} 6200 27200 0 0 {name=Xr136c31}
N 6160 27240 6140 27240 {}
C {lab_pin.sym} 6140 27240 0 0 {name=l21916 lab=BL31}
N 6160 27200 6140 27200 {}
C {lab_pin.sym} 6140 27200 0 0 {name=l21917 lab=BLB31}
N 6160 27160 6140 27160 {}
C {lab_pin.sym} 6140 27160 0 0 {name=l21918 lab=WL136}
N 6240 27240 6260 27240 {}
C {lab_pin.sym} 6260 27240 0 0 {name=l21919 lab=VDD}
N 6240 27160 6260 27160 {}
C {lab_pin.sym} 6260 27160 0 0 {name=l21920 lab=VSS}
C {bitcell_6t.sym} 0 27400 0 0 {name=Xr137c0}
N -40 27440 -60 27440 {}
C {lab_pin.sym} -60 27440 0 0 {name=l21921 lab=BL0}
N -40 27400 -60 27400 {}
C {lab_pin.sym} -60 27400 0 0 {name=l21922 lab=BLB0}
N -40 27360 -60 27360 {}
C {lab_pin.sym} -60 27360 0 0 {name=l21923 lab=WL137}
N 40 27440 60 27440 {}
C {lab_pin.sym} 60 27440 0 0 {name=l21924 lab=VDD}
N 40 27360 60 27360 {}
C {lab_pin.sym} 60 27360 0 0 {name=l21925 lab=VSS}
C {bitcell_6t.sym} 200 27400 0 0 {name=Xr137c1}
N 160 27440 140 27440 {}
C {lab_pin.sym} 140 27440 0 0 {name=l21926 lab=BL1}
N 160 27400 140 27400 {}
C {lab_pin.sym} 140 27400 0 0 {name=l21927 lab=BLB1}
N 160 27360 140 27360 {}
C {lab_pin.sym} 140 27360 0 0 {name=l21928 lab=WL137}
N 240 27440 260 27440 {}
C {lab_pin.sym} 260 27440 0 0 {name=l21929 lab=VDD}
N 240 27360 260 27360 {}
C {lab_pin.sym} 260 27360 0 0 {name=l21930 lab=VSS}
C {bitcell_6t.sym} 400 27400 0 0 {name=Xr137c2}
N 360 27440 340 27440 {}
C {lab_pin.sym} 340 27440 0 0 {name=l21931 lab=BL2}
N 360 27400 340 27400 {}
C {lab_pin.sym} 340 27400 0 0 {name=l21932 lab=BLB2}
N 360 27360 340 27360 {}
C {lab_pin.sym} 340 27360 0 0 {name=l21933 lab=WL137}
N 440 27440 460 27440 {}
C {lab_pin.sym} 460 27440 0 0 {name=l21934 lab=VDD}
N 440 27360 460 27360 {}
C {lab_pin.sym} 460 27360 0 0 {name=l21935 lab=VSS}
C {bitcell_6t.sym} 600 27400 0 0 {name=Xr137c3}
N 560 27440 540 27440 {}
C {lab_pin.sym} 540 27440 0 0 {name=l21936 lab=BL3}
N 560 27400 540 27400 {}
C {lab_pin.sym} 540 27400 0 0 {name=l21937 lab=BLB3}
N 560 27360 540 27360 {}
C {lab_pin.sym} 540 27360 0 0 {name=l21938 lab=WL137}
N 640 27440 660 27440 {}
C {lab_pin.sym} 660 27440 0 0 {name=l21939 lab=VDD}
N 640 27360 660 27360 {}
C {lab_pin.sym} 660 27360 0 0 {name=l21940 lab=VSS}
C {bitcell_6t.sym} 800 27400 0 0 {name=Xr137c4}
N 760 27440 740 27440 {}
C {lab_pin.sym} 740 27440 0 0 {name=l21941 lab=BL4}
N 760 27400 740 27400 {}
C {lab_pin.sym} 740 27400 0 0 {name=l21942 lab=BLB4}
N 760 27360 740 27360 {}
C {lab_pin.sym} 740 27360 0 0 {name=l21943 lab=WL137}
N 840 27440 860 27440 {}
C {lab_pin.sym} 860 27440 0 0 {name=l21944 lab=VDD}
N 840 27360 860 27360 {}
C {lab_pin.sym} 860 27360 0 0 {name=l21945 lab=VSS}
C {bitcell_6t.sym} 1000 27400 0 0 {name=Xr137c5}
N 960 27440 940 27440 {}
C {lab_pin.sym} 940 27440 0 0 {name=l21946 lab=BL5}
N 960 27400 940 27400 {}
C {lab_pin.sym} 940 27400 0 0 {name=l21947 lab=BLB5}
N 960 27360 940 27360 {}
C {lab_pin.sym} 940 27360 0 0 {name=l21948 lab=WL137}
N 1040 27440 1060 27440 {}
C {lab_pin.sym} 1060 27440 0 0 {name=l21949 lab=VDD}
N 1040 27360 1060 27360 {}
C {lab_pin.sym} 1060 27360 0 0 {name=l21950 lab=VSS}
C {bitcell_6t.sym} 1200 27400 0 0 {name=Xr137c6}
N 1160 27440 1140 27440 {}
C {lab_pin.sym} 1140 27440 0 0 {name=l21951 lab=BL6}
N 1160 27400 1140 27400 {}
C {lab_pin.sym} 1140 27400 0 0 {name=l21952 lab=BLB6}
N 1160 27360 1140 27360 {}
C {lab_pin.sym} 1140 27360 0 0 {name=l21953 lab=WL137}
N 1240 27440 1260 27440 {}
C {lab_pin.sym} 1260 27440 0 0 {name=l21954 lab=VDD}
N 1240 27360 1260 27360 {}
C {lab_pin.sym} 1260 27360 0 0 {name=l21955 lab=VSS}
C {bitcell_6t.sym} 1400 27400 0 0 {name=Xr137c7}
N 1360 27440 1340 27440 {}
C {lab_pin.sym} 1340 27440 0 0 {name=l21956 lab=BL7}
N 1360 27400 1340 27400 {}
C {lab_pin.sym} 1340 27400 0 0 {name=l21957 lab=BLB7}
N 1360 27360 1340 27360 {}
C {lab_pin.sym} 1340 27360 0 0 {name=l21958 lab=WL137}
N 1440 27440 1460 27440 {}
C {lab_pin.sym} 1460 27440 0 0 {name=l21959 lab=VDD}
N 1440 27360 1460 27360 {}
C {lab_pin.sym} 1460 27360 0 0 {name=l21960 lab=VSS}
C {bitcell_6t.sym} 1600 27400 0 0 {name=Xr137c8}
N 1560 27440 1540 27440 {}
C {lab_pin.sym} 1540 27440 0 0 {name=l21961 lab=BL8}
N 1560 27400 1540 27400 {}
C {lab_pin.sym} 1540 27400 0 0 {name=l21962 lab=BLB8}
N 1560 27360 1540 27360 {}
C {lab_pin.sym} 1540 27360 0 0 {name=l21963 lab=WL137}
N 1640 27440 1660 27440 {}
C {lab_pin.sym} 1660 27440 0 0 {name=l21964 lab=VDD}
N 1640 27360 1660 27360 {}
C {lab_pin.sym} 1660 27360 0 0 {name=l21965 lab=VSS}
C {bitcell_6t.sym} 1800 27400 0 0 {name=Xr137c9}
N 1760 27440 1740 27440 {}
C {lab_pin.sym} 1740 27440 0 0 {name=l21966 lab=BL9}
N 1760 27400 1740 27400 {}
C {lab_pin.sym} 1740 27400 0 0 {name=l21967 lab=BLB9}
N 1760 27360 1740 27360 {}
C {lab_pin.sym} 1740 27360 0 0 {name=l21968 lab=WL137}
N 1840 27440 1860 27440 {}
C {lab_pin.sym} 1860 27440 0 0 {name=l21969 lab=VDD}
N 1840 27360 1860 27360 {}
C {lab_pin.sym} 1860 27360 0 0 {name=l21970 lab=VSS}
C {bitcell_6t.sym} 2000 27400 0 0 {name=Xr137c10}
N 1960 27440 1940 27440 {}
C {lab_pin.sym} 1940 27440 0 0 {name=l21971 lab=BL10}
N 1960 27400 1940 27400 {}
C {lab_pin.sym} 1940 27400 0 0 {name=l21972 lab=BLB10}
N 1960 27360 1940 27360 {}
C {lab_pin.sym} 1940 27360 0 0 {name=l21973 lab=WL137}
N 2040 27440 2060 27440 {}
C {lab_pin.sym} 2060 27440 0 0 {name=l21974 lab=VDD}
N 2040 27360 2060 27360 {}
C {lab_pin.sym} 2060 27360 0 0 {name=l21975 lab=VSS}
C {bitcell_6t.sym} 2200 27400 0 0 {name=Xr137c11}
N 2160 27440 2140 27440 {}
C {lab_pin.sym} 2140 27440 0 0 {name=l21976 lab=BL11}
N 2160 27400 2140 27400 {}
C {lab_pin.sym} 2140 27400 0 0 {name=l21977 lab=BLB11}
N 2160 27360 2140 27360 {}
C {lab_pin.sym} 2140 27360 0 0 {name=l21978 lab=WL137}
N 2240 27440 2260 27440 {}
C {lab_pin.sym} 2260 27440 0 0 {name=l21979 lab=VDD}
N 2240 27360 2260 27360 {}
C {lab_pin.sym} 2260 27360 0 0 {name=l21980 lab=VSS}
C {bitcell_6t.sym} 2400 27400 0 0 {name=Xr137c12}
N 2360 27440 2340 27440 {}
C {lab_pin.sym} 2340 27440 0 0 {name=l21981 lab=BL12}
N 2360 27400 2340 27400 {}
C {lab_pin.sym} 2340 27400 0 0 {name=l21982 lab=BLB12}
N 2360 27360 2340 27360 {}
C {lab_pin.sym} 2340 27360 0 0 {name=l21983 lab=WL137}
N 2440 27440 2460 27440 {}
C {lab_pin.sym} 2460 27440 0 0 {name=l21984 lab=VDD}
N 2440 27360 2460 27360 {}
C {lab_pin.sym} 2460 27360 0 0 {name=l21985 lab=VSS}
C {bitcell_6t.sym} 2600 27400 0 0 {name=Xr137c13}
N 2560 27440 2540 27440 {}
C {lab_pin.sym} 2540 27440 0 0 {name=l21986 lab=BL13}
N 2560 27400 2540 27400 {}
C {lab_pin.sym} 2540 27400 0 0 {name=l21987 lab=BLB13}
N 2560 27360 2540 27360 {}
C {lab_pin.sym} 2540 27360 0 0 {name=l21988 lab=WL137}
N 2640 27440 2660 27440 {}
C {lab_pin.sym} 2660 27440 0 0 {name=l21989 lab=VDD}
N 2640 27360 2660 27360 {}
C {lab_pin.sym} 2660 27360 0 0 {name=l21990 lab=VSS}
C {bitcell_6t.sym} 2800 27400 0 0 {name=Xr137c14}
N 2760 27440 2740 27440 {}
C {lab_pin.sym} 2740 27440 0 0 {name=l21991 lab=BL14}
N 2760 27400 2740 27400 {}
C {lab_pin.sym} 2740 27400 0 0 {name=l21992 lab=BLB14}
N 2760 27360 2740 27360 {}
C {lab_pin.sym} 2740 27360 0 0 {name=l21993 lab=WL137}
N 2840 27440 2860 27440 {}
C {lab_pin.sym} 2860 27440 0 0 {name=l21994 lab=VDD}
N 2840 27360 2860 27360 {}
C {lab_pin.sym} 2860 27360 0 0 {name=l21995 lab=VSS}
C {bitcell_6t.sym} 3000 27400 0 0 {name=Xr137c15}
N 2960 27440 2940 27440 {}
C {lab_pin.sym} 2940 27440 0 0 {name=l21996 lab=BL15}
N 2960 27400 2940 27400 {}
C {lab_pin.sym} 2940 27400 0 0 {name=l21997 lab=BLB15}
N 2960 27360 2940 27360 {}
C {lab_pin.sym} 2940 27360 0 0 {name=l21998 lab=WL137}
N 3040 27440 3060 27440 {}
C {lab_pin.sym} 3060 27440 0 0 {name=l21999 lab=VDD}
N 3040 27360 3060 27360 {}
C {lab_pin.sym} 3060 27360 0 0 {name=l22000 lab=VSS}
C {bitcell_6t.sym} 3200 27400 0 0 {name=Xr137c16}
N 3160 27440 3140 27440 {}
C {lab_pin.sym} 3140 27440 0 0 {name=l22001 lab=BL16}
N 3160 27400 3140 27400 {}
C {lab_pin.sym} 3140 27400 0 0 {name=l22002 lab=BLB16}
N 3160 27360 3140 27360 {}
C {lab_pin.sym} 3140 27360 0 0 {name=l22003 lab=WL137}
N 3240 27440 3260 27440 {}
C {lab_pin.sym} 3260 27440 0 0 {name=l22004 lab=VDD}
N 3240 27360 3260 27360 {}
C {lab_pin.sym} 3260 27360 0 0 {name=l22005 lab=VSS}
C {bitcell_6t.sym} 3400 27400 0 0 {name=Xr137c17}
N 3360 27440 3340 27440 {}
C {lab_pin.sym} 3340 27440 0 0 {name=l22006 lab=BL17}
N 3360 27400 3340 27400 {}
C {lab_pin.sym} 3340 27400 0 0 {name=l22007 lab=BLB17}
N 3360 27360 3340 27360 {}
C {lab_pin.sym} 3340 27360 0 0 {name=l22008 lab=WL137}
N 3440 27440 3460 27440 {}
C {lab_pin.sym} 3460 27440 0 0 {name=l22009 lab=VDD}
N 3440 27360 3460 27360 {}
C {lab_pin.sym} 3460 27360 0 0 {name=l22010 lab=VSS}
C {bitcell_6t.sym} 3600 27400 0 0 {name=Xr137c18}
N 3560 27440 3540 27440 {}
C {lab_pin.sym} 3540 27440 0 0 {name=l22011 lab=BL18}
N 3560 27400 3540 27400 {}
C {lab_pin.sym} 3540 27400 0 0 {name=l22012 lab=BLB18}
N 3560 27360 3540 27360 {}
C {lab_pin.sym} 3540 27360 0 0 {name=l22013 lab=WL137}
N 3640 27440 3660 27440 {}
C {lab_pin.sym} 3660 27440 0 0 {name=l22014 lab=VDD}
N 3640 27360 3660 27360 {}
C {lab_pin.sym} 3660 27360 0 0 {name=l22015 lab=VSS}
C {bitcell_6t.sym} 3800 27400 0 0 {name=Xr137c19}
N 3760 27440 3740 27440 {}
C {lab_pin.sym} 3740 27440 0 0 {name=l22016 lab=BL19}
N 3760 27400 3740 27400 {}
C {lab_pin.sym} 3740 27400 0 0 {name=l22017 lab=BLB19}
N 3760 27360 3740 27360 {}
C {lab_pin.sym} 3740 27360 0 0 {name=l22018 lab=WL137}
N 3840 27440 3860 27440 {}
C {lab_pin.sym} 3860 27440 0 0 {name=l22019 lab=VDD}
N 3840 27360 3860 27360 {}
C {lab_pin.sym} 3860 27360 0 0 {name=l22020 lab=VSS}
C {bitcell_6t.sym} 4000 27400 0 0 {name=Xr137c20}
N 3960 27440 3940 27440 {}
C {lab_pin.sym} 3940 27440 0 0 {name=l22021 lab=BL20}
N 3960 27400 3940 27400 {}
C {lab_pin.sym} 3940 27400 0 0 {name=l22022 lab=BLB20}
N 3960 27360 3940 27360 {}
C {lab_pin.sym} 3940 27360 0 0 {name=l22023 lab=WL137}
N 4040 27440 4060 27440 {}
C {lab_pin.sym} 4060 27440 0 0 {name=l22024 lab=VDD}
N 4040 27360 4060 27360 {}
C {lab_pin.sym} 4060 27360 0 0 {name=l22025 lab=VSS}
C {bitcell_6t.sym} 4200 27400 0 0 {name=Xr137c21}
N 4160 27440 4140 27440 {}
C {lab_pin.sym} 4140 27440 0 0 {name=l22026 lab=BL21}
N 4160 27400 4140 27400 {}
C {lab_pin.sym} 4140 27400 0 0 {name=l22027 lab=BLB21}
N 4160 27360 4140 27360 {}
C {lab_pin.sym} 4140 27360 0 0 {name=l22028 lab=WL137}
N 4240 27440 4260 27440 {}
C {lab_pin.sym} 4260 27440 0 0 {name=l22029 lab=VDD}
N 4240 27360 4260 27360 {}
C {lab_pin.sym} 4260 27360 0 0 {name=l22030 lab=VSS}
C {bitcell_6t.sym} 4400 27400 0 0 {name=Xr137c22}
N 4360 27440 4340 27440 {}
C {lab_pin.sym} 4340 27440 0 0 {name=l22031 lab=BL22}
N 4360 27400 4340 27400 {}
C {lab_pin.sym} 4340 27400 0 0 {name=l22032 lab=BLB22}
N 4360 27360 4340 27360 {}
C {lab_pin.sym} 4340 27360 0 0 {name=l22033 lab=WL137}
N 4440 27440 4460 27440 {}
C {lab_pin.sym} 4460 27440 0 0 {name=l22034 lab=VDD}
N 4440 27360 4460 27360 {}
C {lab_pin.sym} 4460 27360 0 0 {name=l22035 lab=VSS}
C {bitcell_6t.sym} 4600 27400 0 0 {name=Xr137c23}
N 4560 27440 4540 27440 {}
C {lab_pin.sym} 4540 27440 0 0 {name=l22036 lab=BL23}
N 4560 27400 4540 27400 {}
C {lab_pin.sym} 4540 27400 0 0 {name=l22037 lab=BLB23}
N 4560 27360 4540 27360 {}
C {lab_pin.sym} 4540 27360 0 0 {name=l22038 lab=WL137}
N 4640 27440 4660 27440 {}
C {lab_pin.sym} 4660 27440 0 0 {name=l22039 lab=VDD}
N 4640 27360 4660 27360 {}
C {lab_pin.sym} 4660 27360 0 0 {name=l22040 lab=VSS}
C {bitcell_6t.sym} 4800 27400 0 0 {name=Xr137c24}
N 4760 27440 4740 27440 {}
C {lab_pin.sym} 4740 27440 0 0 {name=l22041 lab=BL24}
N 4760 27400 4740 27400 {}
C {lab_pin.sym} 4740 27400 0 0 {name=l22042 lab=BLB24}
N 4760 27360 4740 27360 {}
C {lab_pin.sym} 4740 27360 0 0 {name=l22043 lab=WL137}
N 4840 27440 4860 27440 {}
C {lab_pin.sym} 4860 27440 0 0 {name=l22044 lab=VDD}
N 4840 27360 4860 27360 {}
C {lab_pin.sym} 4860 27360 0 0 {name=l22045 lab=VSS}
C {bitcell_6t.sym} 5000 27400 0 0 {name=Xr137c25}
N 4960 27440 4940 27440 {}
C {lab_pin.sym} 4940 27440 0 0 {name=l22046 lab=BL25}
N 4960 27400 4940 27400 {}
C {lab_pin.sym} 4940 27400 0 0 {name=l22047 lab=BLB25}
N 4960 27360 4940 27360 {}
C {lab_pin.sym} 4940 27360 0 0 {name=l22048 lab=WL137}
N 5040 27440 5060 27440 {}
C {lab_pin.sym} 5060 27440 0 0 {name=l22049 lab=VDD}
N 5040 27360 5060 27360 {}
C {lab_pin.sym} 5060 27360 0 0 {name=l22050 lab=VSS}
C {bitcell_6t.sym} 5200 27400 0 0 {name=Xr137c26}
N 5160 27440 5140 27440 {}
C {lab_pin.sym} 5140 27440 0 0 {name=l22051 lab=BL26}
N 5160 27400 5140 27400 {}
C {lab_pin.sym} 5140 27400 0 0 {name=l22052 lab=BLB26}
N 5160 27360 5140 27360 {}
C {lab_pin.sym} 5140 27360 0 0 {name=l22053 lab=WL137}
N 5240 27440 5260 27440 {}
C {lab_pin.sym} 5260 27440 0 0 {name=l22054 lab=VDD}
N 5240 27360 5260 27360 {}
C {lab_pin.sym} 5260 27360 0 0 {name=l22055 lab=VSS}
C {bitcell_6t.sym} 5400 27400 0 0 {name=Xr137c27}
N 5360 27440 5340 27440 {}
C {lab_pin.sym} 5340 27440 0 0 {name=l22056 lab=BL27}
N 5360 27400 5340 27400 {}
C {lab_pin.sym} 5340 27400 0 0 {name=l22057 lab=BLB27}
N 5360 27360 5340 27360 {}
C {lab_pin.sym} 5340 27360 0 0 {name=l22058 lab=WL137}
N 5440 27440 5460 27440 {}
C {lab_pin.sym} 5460 27440 0 0 {name=l22059 lab=VDD}
N 5440 27360 5460 27360 {}
C {lab_pin.sym} 5460 27360 0 0 {name=l22060 lab=VSS}
C {bitcell_6t.sym} 5600 27400 0 0 {name=Xr137c28}
N 5560 27440 5540 27440 {}
C {lab_pin.sym} 5540 27440 0 0 {name=l22061 lab=BL28}
N 5560 27400 5540 27400 {}
C {lab_pin.sym} 5540 27400 0 0 {name=l22062 lab=BLB28}
N 5560 27360 5540 27360 {}
C {lab_pin.sym} 5540 27360 0 0 {name=l22063 lab=WL137}
N 5640 27440 5660 27440 {}
C {lab_pin.sym} 5660 27440 0 0 {name=l22064 lab=VDD}
N 5640 27360 5660 27360 {}
C {lab_pin.sym} 5660 27360 0 0 {name=l22065 lab=VSS}
C {bitcell_6t.sym} 5800 27400 0 0 {name=Xr137c29}
N 5760 27440 5740 27440 {}
C {lab_pin.sym} 5740 27440 0 0 {name=l22066 lab=BL29}
N 5760 27400 5740 27400 {}
C {lab_pin.sym} 5740 27400 0 0 {name=l22067 lab=BLB29}
N 5760 27360 5740 27360 {}
C {lab_pin.sym} 5740 27360 0 0 {name=l22068 lab=WL137}
N 5840 27440 5860 27440 {}
C {lab_pin.sym} 5860 27440 0 0 {name=l22069 lab=VDD}
N 5840 27360 5860 27360 {}
C {lab_pin.sym} 5860 27360 0 0 {name=l22070 lab=VSS}
C {bitcell_6t.sym} 6000 27400 0 0 {name=Xr137c30}
N 5960 27440 5940 27440 {}
C {lab_pin.sym} 5940 27440 0 0 {name=l22071 lab=BL30}
N 5960 27400 5940 27400 {}
C {lab_pin.sym} 5940 27400 0 0 {name=l22072 lab=BLB30}
N 5960 27360 5940 27360 {}
C {lab_pin.sym} 5940 27360 0 0 {name=l22073 lab=WL137}
N 6040 27440 6060 27440 {}
C {lab_pin.sym} 6060 27440 0 0 {name=l22074 lab=VDD}
N 6040 27360 6060 27360 {}
C {lab_pin.sym} 6060 27360 0 0 {name=l22075 lab=VSS}
C {bitcell_6t.sym} 6200 27400 0 0 {name=Xr137c31}
N 6160 27440 6140 27440 {}
C {lab_pin.sym} 6140 27440 0 0 {name=l22076 lab=BL31}
N 6160 27400 6140 27400 {}
C {lab_pin.sym} 6140 27400 0 0 {name=l22077 lab=BLB31}
N 6160 27360 6140 27360 {}
C {lab_pin.sym} 6140 27360 0 0 {name=l22078 lab=WL137}
N 6240 27440 6260 27440 {}
C {lab_pin.sym} 6260 27440 0 0 {name=l22079 lab=VDD}
N 6240 27360 6260 27360 {}
C {lab_pin.sym} 6260 27360 0 0 {name=l22080 lab=VSS}
C {bitcell_6t.sym} 0 27600 0 0 {name=Xr138c0}
N -40 27640 -60 27640 {}
C {lab_pin.sym} -60 27640 0 0 {name=l22081 lab=BL0}
N -40 27600 -60 27600 {}
C {lab_pin.sym} -60 27600 0 0 {name=l22082 lab=BLB0}
N -40 27560 -60 27560 {}
C {lab_pin.sym} -60 27560 0 0 {name=l22083 lab=WL138}
N 40 27640 60 27640 {}
C {lab_pin.sym} 60 27640 0 0 {name=l22084 lab=VDD}
N 40 27560 60 27560 {}
C {lab_pin.sym} 60 27560 0 0 {name=l22085 lab=VSS}
C {bitcell_6t.sym} 200 27600 0 0 {name=Xr138c1}
N 160 27640 140 27640 {}
C {lab_pin.sym} 140 27640 0 0 {name=l22086 lab=BL1}
N 160 27600 140 27600 {}
C {lab_pin.sym} 140 27600 0 0 {name=l22087 lab=BLB1}
N 160 27560 140 27560 {}
C {lab_pin.sym} 140 27560 0 0 {name=l22088 lab=WL138}
N 240 27640 260 27640 {}
C {lab_pin.sym} 260 27640 0 0 {name=l22089 lab=VDD}
N 240 27560 260 27560 {}
C {lab_pin.sym} 260 27560 0 0 {name=l22090 lab=VSS}
C {bitcell_6t.sym} 400 27600 0 0 {name=Xr138c2}
N 360 27640 340 27640 {}
C {lab_pin.sym} 340 27640 0 0 {name=l22091 lab=BL2}
N 360 27600 340 27600 {}
C {lab_pin.sym} 340 27600 0 0 {name=l22092 lab=BLB2}
N 360 27560 340 27560 {}
C {lab_pin.sym} 340 27560 0 0 {name=l22093 lab=WL138}
N 440 27640 460 27640 {}
C {lab_pin.sym} 460 27640 0 0 {name=l22094 lab=VDD}
N 440 27560 460 27560 {}
C {lab_pin.sym} 460 27560 0 0 {name=l22095 lab=VSS}
C {bitcell_6t.sym} 600 27600 0 0 {name=Xr138c3}
N 560 27640 540 27640 {}
C {lab_pin.sym} 540 27640 0 0 {name=l22096 lab=BL3}
N 560 27600 540 27600 {}
C {lab_pin.sym} 540 27600 0 0 {name=l22097 lab=BLB3}
N 560 27560 540 27560 {}
C {lab_pin.sym} 540 27560 0 0 {name=l22098 lab=WL138}
N 640 27640 660 27640 {}
C {lab_pin.sym} 660 27640 0 0 {name=l22099 lab=VDD}
N 640 27560 660 27560 {}
C {lab_pin.sym} 660 27560 0 0 {name=l22100 lab=VSS}
C {bitcell_6t.sym} 800 27600 0 0 {name=Xr138c4}
N 760 27640 740 27640 {}
C {lab_pin.sym} 740 27640 0 0 {name=l22101 lab=BL4}
N 760 27600 740 27600 {}
C {lab_pin.sym} 740 27600 0 0 {name=l22102 lab=BLB4}
N 760 27560 740 27560 {}
C {lab_pin.sym} 740 27560 0 0 {name=l22103 lab=WL138}
N 840 27640 860 27640 {}
C {lab_pin.sym} 860 27640 0 0 {name=l22104 lab=VDD}
N 840 27560 860 27560 {}
C {lab_pin.sym} 860 27560 0 0 {name=l22105 lab=VSS}
C {bitcell_6t.sym} 1000 27600 0 0 {name=Xr138c5}
N 960 27640 940 27640 {}
C {lab_pin.sym} 940 27640 0 0 {name=l22106 lab=BL5}
N 960 27600 940 27600 {}
C {lab_pin.sym} 940 27600 0 0 {name=l22107 lab=BLB5}
N 960 27560 940 27560 {}
C {lab_pin.sym} 940 27560 0 0 {name=l22108 lab=WL138}
N 1040 27640 1060 27640 {}
C {lab_pin.sym} 1060 27640 0 0 {name=l22109 lab=VDD}
N 1040 27560 1060 27560 {}
C {lab_pin.sym} 1060 27560 0 0 {name=l22110 lab=VSS}
C {bitcell_6t.sym} 1200 27600 0 0 {name=Xr138c6}
N 1160 27640 1140 27640 {}
C {lab_pin.sym} 1140 27640 0 0 {name=l22111 lab=BL6}
N 1160 27600 1140 27600 {}
C {lab_pin.sym} 1140 27600 0 0 {name=l22112 lab=BLB6}
N 1160 27560 1140 27560 {}
C {lab_pin.sym} 1140 27560 0 0 {name=l22113 lab=WL138}
N 1240 27640 1260 27640 {}
C {lab_pin.sym} 1260 27640 0 0 {name=l22114 lab=VDD}
N 1240 27560 1260 27560 {}
C {lab_pin.sym} 1260 27560 0 0 {name=l22115 lab=VSS}
C {bitcell_6t.sym} 1400 27600 0 0 {name=Xr138c7}
N 1360 27640 1340 27640 {}
C {lab_pin.sym} 1340 27640 0 0 {name=l22116 lab=BL7}
N 1360 27600 1340 27600 {}
C {lab_pin.sym} 1340 27600 0 0 {name=l22117 lab=BLB7}
N 1360 27560 1340 27560 {}
C {lab_pin.sym} 1340 27560 0 0 {name=l22118 lab=WL138}
N 1440 27640 1460 27640 {}
C {lab_pin.sym} 1460 27640 0 0 {name=l22119 lab=VDD}
N 1440 27560 1460 27560 {}
C {lab_pin.sym} 1460 27560 0 0 {name=l22120 lab=VSS}
C {bitcell_6t.sym} 1600 27600 0 0 {name=Xr138c8}
N 1560 27640 1540 27640 {}
C {lab_pin.sym} 1540 27640 0 0 {name=l22121 lab=BL8}
N 1560 27600 1540 27600 {}
C {lab_pin.sym} 1540 27600 0 0 {name=l22122 lab=BLB8}
N 1560 27560 1540 27560 {}
C {lab_pin.sym} 1540 27560 0 0 {name=l22123 lab=WL138}
N 1640 27640 1660 27640 {}
C {lab_pin.sym} 1660 27640 0 0 {name=l22124 lab=VDD}
N 1640 27560 1660 27560 {}
C {lab_pin.sym} 1660 27560 0 0 {name=l22125 lab=VSS}
C {bitcell_6t.sym} 1800 27600 0 0 {name=Xr138c9}
N 1760 27640 1740 27640 {}
C {lab_pin.sym} 1740 27640 0 0 {name=l22126 lab=BL9}
N 1760 27600 1740 27600 {}
C {lab_pin.sym} 1740 27600 0 0 {name=l22127 lab=BLB9}
N 1760 27560 1740 27560 {}
C {lab_pin.sym} 1740 27560 0 0 {name=l22128 lab=WL138}
N 1840 27640 1860 27640 {}
C {lab_pin.sym} 1860 27640 0 0 {name=l22129 lab=VDD}
N 1840 27560 1860 27560 {}
C {lab_pin.sym} 1860 27560 0 0 {name=l22130 lab=VSS}
C {bitcell_6t.sym} 2000 27600 0 0 {name=Xr138c10}
N 1960 27640 1940 27640 {}
C {lab_pin.sym} 1940 27640 0 0 {name=l22131 lab=BL10}
N 1960 27600 1940 27600 {}
C {lab_pin.sym} 1940 27600 0 0 {name=l22132 lab=BLB10}
N 1960 27560 1940 27560 {}
C {lab_pin.sym} 1940 27560 0 0 {name=l22133 lab=WL138}
N 2040 27640 2060 27640 {}
C {lab_pin.sym} 2060 27640 0 0 {name=l22134 lab=VDD}
N 2040 27560 2060 27560 {}
C {lab_pin.sym} 2060 27560 0 0 {name=l22135 lab=VSS}
C {bitcell_6t.sym} 2200 27600 0 0 {name=Xr138c11}
N 2160 27640 2140 27640 {}
C {lab_pin.sym} 2140 27640 0 0 {name=l22136 lab=BL11}
N 2160 27600 2140 27600 {}
C {lab_pin.sym} 2140 27600 0 0 {name=l22137 lab=BLB11}
N 2160 27560 2140 27560 {}
C {lab_pin.sym} 2140 27560 0 0 {name=l22138 lab=WL138}
N 2240 27640 2260 27640 {}
C {lab_pin.sym} 2260 27640 0 0 {name=l22139 lab=VDD}
N 2240 27560 2260 27560 {}
C {lab_pin.sym} 2260 27560 0 0 {name=l22140 lab=VSS}
C {bitcell_6t.sym} 2400 27600 0 0 {name=Xr138c12}
N 2360 27640 2340 27640 {}
C {lab_pin.sym} 2340 27640 0 0 {name=l22141 lab=BL12}
N 2360 27600 2340 27600 {}
C {lab_pin.sym} 2340 27600 0 0 {name=l22142 lab=BLB12}
N 2360 27560 2340 27560 {}
C {lab_pin.sym} 2340 27560 0 0 {name=l22143 lab=WL138}
N 2440 27640 2460 27640 {}
C {lab_pin.sym} 2460 27640 0 0 {name=l22144 lab=VDD}
N 2440 27560 2460 27560 {}
C {lab_pin.sym} 2460 27560 0 0 {name=l22145 lab=VSS}
C {bitcell_6t.sym} 2600 27600 0 0 {name=Xr138c13}
N 2560 27640 2540 27640 {}
C {lab_pin.sym} 2540 27640 0 0 {name=l22146 lab=BL13}
N 2560 27600 2540 27600 {}
C {lab_pin.sym} 2540 27600 0 0 {name=l22147 lab=BLB13}
N 2560 27560 2540 27560 {}
C {lab_pin.sym} 2540 27560 0 0 {name=l22148 lab=WL138}
N 2640 27640 2660 27640 {}
C {lab_pin.sym} 2660 27640 0 0 {name=l22149 lab=VDD}
N 2640 27560 2660 27560 {}
C {lab_pin.sym} 2660 27560 0 0 {name=l22150 lab=VSS}
C {bitcell_6t.sym} 2800 27600 0 0 {name=Xr138c14}
N 2760 27640 2740 27640 {}
C {lab_pin.sym} 2740 27640 0 0 {name=l22151 lab=BL14}
N 2760 27600 2740 27600 {}
C {lab_pin.sym} 2740 27600 0 0 {name=l22152 lab=BLB14}
N 2760 27560 2740 27560 {}
C {lab_pin.sym} 2740 27560 0 0 {name=l22153 lab=WL138}
N 2840 27640 2860 27640 {}
C {lab_pin.sym} 2860 27640 0 0 {name=l22154 lab=VDD}
N 2840 27560 2860 27560 {}
C {lab_pin.sym} 2860 27560 0 0 {name=l22155 lab=VSS}
C {bitcell_6t.sym} 3000 27600 0 0 {name=Xr138c15}
N 2960 27640 2940 27640 {}
C {lab_pin.sym} 2940 27640 0 0 {name=l22156 lab=BL15}
N 2960 27600 2940 27600 {}
C {lab_pin.sym} 2940 27600 0 0 {name=l22157 lab=BLB15}
N 2960 27560 2940 27560 {}
C {lab_pin.sym} 2940 27560 0 0 {name=l22158 lab=WL138}
N 3040 27640 3060 27640 {}
C {lab_pin.sym} 3060 27640 0 0 {name=l22159 lab=VDD}
N 3040 27560 3060 27560 {}
C {lab_pin.sym} 3060 27560 0 0 {name=l22160 lab=VSS}
C {bitcell_6t.sym} 3200 27600 0 0 {name=Xr138c16}
N 3160 27640 3140 27640 {}
C {lab_pin.sym} 3140 27640 0 0 {name=l22161 lab=BL16}
N 3160 27600 3140 27600 {}
C {lab_pin.sym} 3140 27600 0 0 {name=l22162 lab=BLB16}
N 3160 27560 3140 27560 {}
C {lab_pin.sym} 3140 27560 0 0 {name=l22163 lab=WL138}
N 3240 27640 3260 27640 {}
C {lab_pin.sym} 3260 27640 0 0 {name=l22164 lab=VDD}
N 3240 27560 3260 27560 {}
C {lab_pin.sym} 3260 27560 0 0 {name=l22165 lab=VSS}
C {bitcell_6t.sym} 3400 27600 0 0 {name=Xr138c17}
N 3360 27640 3340 27640 {}
C {lab_pin.sym} 3340 27640 0 0 {name=l22166 lab=BL17}
N 3360 27600 3340 27600 {}
C {lab_pin.sym} 3340 27600 0 0 {name=l22167 lab=BLB17}
N 3360 27560 3340 27560 {}
C {lab_pin.sym} 3340 27560 0 0 {name=l22168 lab=WL138}
N 3440 27640 3460 27640 {}
C {lab_pin.sym} 3460 27640 0 0 {name=l22169 lab=VDD}
N 3440 27560 3460 27560 {}
C {lab_pin.sym} 3460 27560 0 0 {name=l22170 lab=VSS}
C {bitcell_6t.sym} 3600 27600 0 0 {name=Xr138c18}
N 3560 27640 3540 27640 {}
C {lab_pin.sym} 3540 27640 0 0 {name=l22171 lab=BL18}
N 3560 27600 3540 27600 {}
C {lab_pin.sym} 3540 27600 0 0 {name=l22172 lab=BLB18}
N 3560 27560 3540 27560 {}
C {lab_pin.sym} 3540 27560 0 0 {name=l22173 lab=WL138}
N 3640 27640 3660 27640 {}
C {lab_pin.sym} 3660 27640 0 0 {name=l22174 lab=VDD}
N 3640 27560 3660 27560 {}
C {lab_pin.sym} 3660 27560 0 0 {name=l22175 lab=VSS}
C {bitcell_6t.sym} 3800 27600 0 0 {name=Xr138c19}
N 3760 27640 3740 27640 {}
C {lab_pin.sym} 3740 27640 0 0 {name=l22176 lab=BL19}
N 3760 27600 3740 27600 {}
C {lab_pin.sym} 3740 27600 0 0 {name=l22177 lab=BLB19}
N 3760 27560 3740 27560 {}
C {lab_pin.sym} 3740 27560 0 0 {name=l22178 lab=WL138}
N 3840 27640 3860 27640 {}
C {lab_pin.sym} 3860 27640 0 0 {name=l22179 lab=VDD}
N 3840 27560 3860 27560 {}
C {lab_pin.sym} 3860 27560 0 0 {name=l22180 lab=VSS}
C {bitcell_6t.sym} 4000 27600 0 0 {name=Xr138c20}
N 3960 27640 3940 27640 {}
C {lab_pin.sym} 3940 27640 0 0 {name=l22181 lab=BL20}
N 3960 27600 3940 27600 {}
C {lab_pin.sym} 3940 27600 0 0 {name=l22182 lab=BLB20}
N 3960 27560 3940 27560 {}
C {lab_pin.sym} 3940 27560 0 0 {name=l22183 lab=WL138}
N 4040 27640 4060 27640 {}
C {lab_pin.sym} 4060 27640 0 0 {name=l22184 lab=VDD}
N 4040 27560 4060 27560 {}
C {lab_pin.sym} 4060 27560 0 0 {name=l22185 lab=VSS}
C {bitcell_6t.sym} 4200 27600 0 0 {name=Xr138c21}
N 4160 27640 4140 27640 {}
C {lab_pin.sym} 4140 27640 0 0 {name=l22186 lab=BL21}
N 4160 27600 4140 27600 {}
C {lab_pin.sym} 4140 27600 0 0 {name=l22187 lab=BLB21}
N 4160 27560 4140 27560 {}
C {lab_pin.sym} 4140 27560 0 0 {name=l22188 lab=WL138}
N 4240 27640 4260 27640 {}
C {lab_pin.sym} 4260 27640 0 0 {name=l22189 lab=VDD}
N 4240 27560 4260 27560 {}
C {lab_pin.sym} 4260 27560 0 0 {name=l22190 lab=VSS}
C {bitcell_6t.sym} 4400 27600 0 0 {name=Xr138c22}
N 4360 27640 4340 27640 {}
C {lab_pin.sym} 4340 27640 0 0 {name=l22191 lab=BL22}
N 4360 27600 4340 27600 {}
C {lab_pin.sym} 4340 27600 0 0 {name=l22192 lab=BLB22}
N 4360 27560 4340 27560 {}
C {lab_pin.sym} 4340 27560 0 0 {name=l22193 lab=WL138}
N 4440 27640 4460 27640 {}
C {lab_pin.sym} 4460 27640 0 0 {name=l22194 lab=VDD}
N 4440 27560 4460 27560 {}
C {lab_pin.sym} 4460 27560 0 0 {name=l22195 lab=VSS}
C {bitcell_6t.sym} 4600 27600 0 0 {name=Xr138c23}
N 4560 27640 4540 27640 {}
C {lab_pin.sym} 4540 27640 0 0 {name=l22196 lab=BL23}
N 4560 27600 4540 27600 {}
C {lab_pin.sym} 4540 27600 0 0 {name=l22197 lab=BLB23}
N 4560 27560 4540 27560 {}
C {lab_pin.sym} 4540 27560 0 0 {name=l22198 lab=WL138}
N 4640 27640 4660 27640 {}
C {lab_pin.sym} 4660 27640 0 0 {name=l22199 lab=VDD}
N 4640 27560 4660 27560 {}
C {lab_pin.sym} 4660 27560 0 0 {name=l22200 lab=VSS}
C {bitcell_6t.sym} 4800 27600 0 0 {name=Xr138c24}
N 4760 27640 4740 27640 {}
C {lab_pin.sym} 4740 27640 0 0 {name=l22201 lab=BL24}
N 4760 27600 4740 27600 {}
C {lab_pin.sym} 4740 27600 0 0 {name=l22202 lab=BLB24}
N 4760 27560 4740 27560 {}
C {lab_pin.sym} 4740 27560 0 0 {name=l22203 lab=WL138}
N 4840 27640 4860 27640 {}
C {lab_pin.sym} 4860 27640 0 0 {name=l22204 lab=VDD}
N 4840 27560 4860 27560 {}
C {lab_pin.sym} 4860 27560 0 0 {name=l22205 lab=VSS}
C {bitcell_6t.sym} 5000 27600 0 0 {name=Xr138c25}
N 4960 27640 4940 27640 {}
C {lab_pin.sym} 4940 27640 0 0 {name=l22206 lab=BL25}
N 4960 27600 4940 27600 {}
C {lab_pin.sym} 4940 27600 0 0 {name=l22207 lab=BLB25}
N 4960 27560 4940 27560 {}
C {lab_pin.sym} 4940 27560 0 0 {name=l22208 lab=WL138}
N 5040 27640 5060 27640 {}
C {lab_pin.sym} 5060 27640 0 0 {name=l22209 lab=VDD}
N 5040 27560 5060 27560 {}
C {lab_pin.sym} 5060 27560 0 0 {name=l22210 lab=VSS}
C {bitcell_6t.sym} 5200 27600 0 0 {name=Xr138c26}
N 5160 27640 5140 27640 {}
C {lab_pin.sym} 5140 27640 0 0 {name=l22211 lab=BL26}
N 5160 27600 5140 27600 {}
C {lab_pin.sym} 5140 27600 0 0 {name=l22212 lab=BLB26}
N 5160 27560 5140 27560 {}
C {lab_pin.sym} 5140 27560 0 0 {name=l22213 lab=WL138}
N 5240 27640 5260 27640 {}
C {lab_pin.sym} 5260 27640 0 0 {name=l22214 lab=VDD}
N 5240 27560 5260 27560 {}
C {lab_pin.sym} 5260 27560 0 0 {name=l22215 lab=VSS}
C {bitcell_6t.sym} 5400 27600 0 0 {name=Xr138c27}
N 5360 27640 5340 27640 {}
C {lab_pin.sym} 5340 27640 0 0 {name=l22216 lab=BL27}
N 5360 27600 5340 27600 {}
C {lab_pin.sym} 5340 27600 0 0 {name=l22217 lab=BLB27}
N 5360 27560 5340 27560 {}
C {lab_pin.sym} 5340 27560 0 0 {name=l22218 lab=WL138}
N 5440 27640 5460 27640 {}
C {lab_pin.sym} 5460 27640 0 0 {name=l22219 lab=VDD}
N 5440 27560 5460 27560 {}
C {lab_pin.sym} 5460 27560 0 0 {name=l22220 lab=VSS}
C {bitcell_6t.sym} 5600 27600 0 0 {name=Xr138c28}
N 5560 27640 5540 27640 {}
C {lab_pin.sym} 5540 27640 0 0 {name=l22221 lab=BL28}
N 5560 27600 5540 27600 {}
C {lab_pin.sym} 5540 27600 0 0 {name=l22222 lab=BLB28}
N 5560 27560 5540 27560 {}
C {lab_pin.sym} 5540 27560 0 0 {name=l22223 lab=WL138}
N 5640 27640 5660 27640 {}
C {lab_pin.sym} 5660 27640 0 0 {name=l22224 lab=VDD}
N 5640 27560 5660 27560 {}
C {lab_pin.sym} 5660 27560 0 0 {name=l22225 lab=VSS}
C {bitcell_6t.sym} 5800 27600 0 0 {name=Xr138c29}
N 5760 27640 5740 27640 {}
C {lab_pin.sym} 5740 27640 0 0 {name=l22226 lab=BL29}
N 5760 27600 5740 27600 {}
C {lab_pin.sym} 5740 27600 0 0 {name=l22227 lab=BLB29}
N 5760 27560 5740 27560 {}
C {lab_pin.sym} 5740 27560 0 0 {name=l22228 lab=WL138}
N 5840 27640 5860 27640 {}
C {lab_pin.sym} 5860 27640 0 0 {name=l22229 lab=VDD}
N 5840 27560 5860 27560 {}
C {lab_pin.sym} 5860 27560 0 0 {name=l22230 lab=VSS}
C {bitcell_6t.sym} 6000 27600 0 0 {name=Xr138c30}
N 5960 27640 5940 27640 {}
C {lab_pin.sym} 5940 27640 0 0 {name=l22231 lab=BL30}
N 5960 27600 5940 27600 {}
C {lab_pin.sym} 5940 27600 0 0 {name=l22232 lab=BLB30}
N 5960 27560 5940 27560 {}
C {lab_pin.sym} 5940 27560 0 0 {name=l22233 lab=WL138}
N 6040 27640 6060 27640 {}
C {lab_pin.sym} 6060 27640 0 0 {name=l22234 lab=VDD}
N 6040 27560 6060 27560 {}
C {lab_pin.sym} 6060 27560 0 0 {name=l22235 lab=VSS}
C {bitcell_6t.sym} 6200 27600 0 0 {name=Xr138c31}
N 6160 27640 6140 27640 {}
C {lab_pin.sym} 6140 27640 0 0 {name=l22236 lab=BL31}
N 6160 27600 6140 27600 {}
C {lab_pin.sym} 6140 27600 0 0 {name=l22237 lab=BLB31}
N 6160 27560 6140 27560 {}
C {lab_pin.sym} 6140 27560 0 0 {name=l22238 lab=WL138}
N 6240 27640 6260 27640 {}
C {lab_pin.sym} 6260 27640 0 0 {name=l22239 lab=VDD}
N 6240 27560 6260 27560 {}
C {lab_pin.sym} 6260 27560 0 0 {name=l22240 lab=VSS}
C {bitcell_6t.sym} 0 27800 0 0 {name=Xr139c0}
N -40 27840 -60 27840 {}
C {lab_pin.sym} -60 27840 0 0 {name=l22241 lab=BL0}
N -40 27800 -60 27800 {}
C {lab_pin.sym} -60 27800 0 0 {name=l22242 lab=BLB0}
N -40 27760 -60 27760 {}
C {lab_pin.sym} -60 27760 0 0 {name=l22243 lab=WL139}
N 40 27840 60 27840 {}
C {lab_pin.sym} 60 27840 0 0 {name=l22244 lab=VDD}
N 40 27760 60 27760 {}
C {lab_pin.sym} 60 27760 0 0 {name=l22245 lab=VSS}
C {bitcell_6t.sym} 200 27800 0 0 {name=Xr139c1}
N 160 27840 140 27840 {}
C {lab_pin.sym} 140 27840 0 0 {name=l22246 lab=BL1}
N 160 27800 140 27800 {}
C {lab_pin.sym} 140 27800 0 0 {name=l22247 lab=BLB1}
N 160 27760 140 27760 {}
C {lab_pin.sym} 140 27760 0 0 {name=l22248 lab=WL139}
N 240 27840 260 27840 {}
C {lab_pin.sym} 260 27840 0 0 {name=l22249 lab=VDD}
N 240 27760 260 27760 {}
C {lab_pin.sym} 260 27760 0 0 {name=l22250 lab=VSS}
C {bitcell_6t.sym} 400 27800 0 0 {name=Xr139c2}
N 360 27840 340 27840 {}
C {lab_pin.sym} 340 27840 0 0 {name=l22251 lab=BL2}
N 360 27800 340 27800 {}
C {lab_pin.sym} 340 27800 0 0 {name=l22252 lab=BLB2}
N 360 27760 340 27760 {}
C {lab_pin.sym} 340 27760 0 0 {name=l22253 lab=WL139}
N 440 27840 460 27840 {}
C {lab_pin.sym} 460 27840 0 0 {name=l22254 lab=VDD}
N 440 27760 460 27760 {}
C {lab_pin.sym} 460 27760 0 0 {name=l22255 lab=VSS}
C {bitcell_6t.sym} 600 27800 0 0 {name=Xr139c3}
N 560 27840 540 27840 {}
C {lab_pin.sym} 540 27840 0 0 {name=l22256 lab=BL3}
N 560 27800 540 27800 {}
C {lab_pin.sym} 540 27800 0 0 {name=l22257 lab=BLB3}
N 560 27760 540 27760 {}
C {lab_pin.sym} 540 27760 0 0 {name=l22258 lab=WL139}
N 640 27840 660 27840 {}
C {lab_pin.sym} 660 27840 0 0 {name=l22259 lab=VDD}
N 640 27760 660 27760 {}
C {lab_pin.sym} 660 27760 0 0 {name=l22260 lab=VSS}
C {bitcell_6t.sym} 800 27800 0 0 {name=Xr139c4}
N 760 27840 740 27840 {}
C {lab_pin.sym} 740 27840 0 0 {name=l22261 lab=BL4}
N 760 27800 740 27800 {}
C {lab_pin.sym} 740 27800 0 0 {name=l22262 lab=BLB4}
N 760 27760 740 27760 {}
C {lab_pin.sym} 740 27760 0 0 {name=l22263 lab=WL139}
N 840 27840 860 27840 {}
C {lab_pin.sym} 860 27840 0 0 {name=l22264 lab=VDD}
N 840 27760 860 27760 {}
C {lab_pin.sym} 860 27760 0 0 {name=l22265 lab=VSS}
C {bitcell_6t.sym} 1000 27800 0 0 {name=Xr139c5}
N 960 27840 940 27840 {}
C {lab_pin.sym} 940 27840 0 0 {name=l22266 lab=BL5}
N 960 27800 940 27800 {}
C {lab_pin.sym} 940 27800 0 0 {name=l22267 lab=BLB5}
N 960 27760 940 27760 {}
C {lab_pin.sym} 940 27760 0 0 {name=l22268 lab=WL139}
N 1040 27840 1060 27840 {}
C {lab_pin.sym} 1060 27840 0 0 {name=l22269 lab=VDD}
N 1040 27760 1060 27760 {}
C {lab_pin.sym} 1060 27760 0 0 {name=l22270 lab=VSS}
C {bitcell_6t.sym} 1200 27800 0 0 {name=Xr139c6}
N 1160 27840 1140 27840 {}
C {lab_pin.sym} 1140 27840 0 0 {name=l22271 lab=BL6}
N 1160 27800 1140 27800 {}
C {lab_pin.sym} 1140 27800 0 0 {name=l22272 lab=BLB6}
N 1160 27760 1140 27760 {}
C {lab_pin.sym} 1140 27760 0 0 {name=l22273 lab=WL139}
N 1240 27840 1260 27840 {}
C {lab_pin.sym} 1260 27840 0 0 {name=l22274 lab=VDD}
N 1240 27760 1260 27760 {}
C {lab_pin.sym} 1260 27760 0 0 {name=l22275 lab=VSS}
C {bitcell_6t.sym} 1400 27800 0 0 {name=Xr139c7}
N 1360 27840 1340 27840 {}
C {lab_pin.sym} 1340 27840 0 0 {name=l22276 lab=BL7}
N 1360 27800 1340 27800 {}
C {lab_pin.sym} 1340 27800 0 0 {name=l22277 lab=BLB7}
N 1360 27760 1340 27760 {}
C {lab_pin.sym} 1340 27760 0 0 {name=l22278 lab=WL139}
N 1440 27840 1460 27840 {}
C {lab_pin.sym} 1460 27840 0 0 {name=l22279 lab=VDD}
N 1440 27760 1460 27760 {}
C {lab_pin.sym} 1460 27760 0 0 {name=l22280 lab=VSS}
C {bitcell_6t.sym} 1600 27800 0 0 {name=Xr139c8}
N 1560 27840 1540 27840 {}
C {lab_pin.sym} 1540 27840 0 0 {name=l22281 lab=BL8}
N 1560 27800 1540 27800 {}
C {lab_pin.sym} 1540 27800 0 0 {name=l22282 lab=BLB8}
N 1560 27760 1540 27760 {}
C {lab_pin.sym} 1540 27760 0 0 {name=l22283 lab=WL139}
N 1640 27840 1660 27840 {}
C {lab_pin.sym} 1660 27840 0 0 {name=l22284 lab=VDD}
N 1640 27760 1660 27760 {}
C {lab_pin.sym} 1660 27760 0 0 {name=l22285 lab=VSS}
C {bitcell_6t.sym} 1800 27800 0 0 {name=Xr139c9}
N 1760 27840 1740 27840 {}
C {lab_pin.sym} 1740 27840 0 0 {name=l22286 lab=BL9}
N 1760 27800 1740 27800 {}
C {lab_pin.sym} 1740 27800 0 0 {name=l22287 lab=BLB9}
N 1760 27760 1740 27760 {}
C {lab_pin.sym} 1740 27760 0 0 {name=l22288 lab=WL139}
N 1840 27840 1860 27840 {}
C {lab_pin.sym} 1860 27840 0 0 {name=l22289 lab=VDD}
N 1840 27760 1860 27760 {}
C {lab_pin.sym} 1860 27760 0 0 {name=l22290 lab=VSS}
C {bitcell_6t.sym} 2000 27800 0 0 {name=Xr139c10}
N 1960 27840 1940 27840 {}
C {lab_pin.sym} 1940 27840 0 0 {name=l22291 lab=BL10}
N 1960 27800 1940 27800 {}
C {lab_pin.sym} 1940 27800 0 0 {name=l22292 lab=BLB10}
N 1960 27760 1940 27760 {}
C {lab_pin.sym} 1940 27760 0 0 {name=l22293 lab=WL139}
N 2040 27840 2060 27840 {}
C {lab_pin.sym} 2060 27840 0 0 {name=l22294 lab=VDD}
N 2040 27760 2060 27760 {}
C {lab_pin.sym} 2060 27760 0 0 {name=l22295 lab=VSS}
C {bitcell_6t.sym} 2200 27800 0 0 {name=Xr139c11}
N 2160 27840 2140 27840 {}
C {lab_pin.sym} 2140 27840 0 0 {name=l22296 lab=BL11}
N 2160 27800 2140 27800 {}
C {lab_pin.sym} 2140 27800 0 0 {name=l22297 lab=BLB11}
N 2160 27760 2140 27760 {}
C {lab_pin.sym} 2140 27760 0 0 {name=l22298 lab=WL139}
N 2240 27840 2260 27840 {}
C {lab_pin.sym} 2260 27840 0 0 {name=l22299 lab=VDD}
N 2240 27760 2260 27760 {}
C {lab_pin.sym} 2260 27760 0 0 {name=l22300 lab=VSS}
C {bitcell_6t.sym} 2400 27800 0 0 {name=Xr139c12}
N 2360 27840 2340 27840 {}
C {lab_pin.sym} 2340 27840 0 0 {name=l22301 lab=BL12}
N 2360 27800 2340 27800 {}
C {lab_pin.sym} 2340 27800 0 0 {name=l22302 lab=BLB12}
N 2360 27760 2340 27760 {}
C {lab_pin.sym} 2340 27760 0 0 {name=l22303 lab=WL139}
N 2440 27840 2460 27840 {}
C {lab_pin.sym} 2460 27840 0 0 {name=l22304 lab=VDD}
N 2440 27760 2460 27760 {}
C {lab_pin.sym} 2460 27760 0 0 {name=l22305 lab=VSS}
C {bitcell_6t.sym} 2600 27800 0 0 {name=Xr139c13}
N 2560 27840 2540 27840 {}
C {lab_pin.sym} 2540 27840 0 0 {name=l22306 lab=BL13}
N 2560 27800 2540 27800 {}
C {lab_pin.sym} 2540 27800 0 0 {name=l22307 lab=BLB13}
N 2560 27760 2540 27760 {}
C {lab_pin.sym} 2540 27760 0 0 {name=l22308 lab=WL139}
N 2640 27840 2660 27840 {}
C {lab_pin.sym} 2660 27840 0 0 {name=l22309 lab=VDD}
N 2640 27760 2660 27760 {}
C {lab_pin.sym} 2660 27760 0 0 {name=l22310 lab=VSS}
C {bitcell_6t.sym} 2800 27800 0 0 {name=Xr139c14}
N 2760 27840 2740 27840 {}
C {lab_pin.sym} 2740 27840 0 0 {name=l22311 lab=BL14}
N 2760 27800 2740 27800 {}
C {lab_pin.sym} 2740 27800 0 0 {name=l22312 lab=BLB14}
N 2760 27760 2740 27760 {}
C {lab_pin.sym} 2740 27760 0 0 {name=l22313 lab=WL139}
N 2840 27840 2860 27840 {}
C {lab_pin.sym} 2860 27840 0 0 {name=l22314 lab=VDD}
N 2840 27760 2860 27760 {}
C {lab_pin.sym} 2860 27760 0 0 {name=l22315 lab=VSS}
C {bitcell_6t.sym} 3000 27800 0 0 {name=Xr139c15}
N 2960 27840 2940 27840 {}
C {lab_pin.sym} 2940 27840 0 0 {name=l22316 lab=BL15}
N 2960 27800 2940 27800 {}
C {lab_pin.sym} 2940 27800 0 0 {name=l22317 lab=BLB15}
N 2960 27760 2940 27760 {}
C {lab_pin.sym} 2940 27760 0 0 {name=l22318 lab=WL139}
N 3040 27840 3060 27840 {}
C {lab_pin.sym} 3060 27840 0 0 {name=l22319 lab=VDD}
N 3040 27760 3060 27760 {}
C {lab_pin.sym} 3060 27760 0 0 {name=l22320 lab=VSS}
C {bitcell_6t.sym} 3200 27800 0 0 {name=Xr139c16}
N 3160 27840 3140 27840 {}
C {lab_pin.sym} 3140 27840 0 0 {name=l22321 lab=BL16}
N 3160 27800 3140 27800 {}
C {lab_pin.sym} 3140 27800 0 0 {name=l22322 lab=BLB16}
N 3160 27760 3140 27760 {}
C {lab_pin.sym} 3140 27760 0 0 {name=l22323 lab=WL139}
N 3240 27840 3260 27840 {}
C {lab_pin.sym} 3260 27840 0 0 {name=l22324 lab=VDD}
N 3240 27760 3260 27760 {}
C {lab_pin.sym} 3260 27760 0 0 {name=l22325 lab=VSS}
C {bitcell_6t.sym} 3400 27800 0 0 {name=Xr139c17}
N 3360 27840 3340 27840 {}
C {lab_pin.sym} 3340 27840 0 0 {name=l22326 lab=BL17}
N 3360 27800 3340 27800 {}
C {lab_pin.sym} 3340 27800 0 0 {name=l22327 lab=BLB17}
N 3360 27760 3340 27760 {}
C {lab_pin.sym} 3340 27760 0 0 {name=l22328 lab=WL139}
N 3440 27840 3460 27840 {}
C {lab_pin.sym} 3460 27840 0 0 {name=l22329 lab=VDD}
N 3440 27760 3460 27760 {}
C {lab_pin.sym} 3460 27760 0 0 {name=l22330 lab=VSS}
C {bitcell_6t.sym} 3600 27800 0 0 {name=Xr139c18}
N 3560 27840 3540 27840 {}
C {lab_pin.sym} 3540 27840 0 0 {name=l22331 lab=BL18}
N 3560 27800 3540 27800 {}
C {lab_pin.sym} 3540 27800 0 0 {name=l22332 lab=BLB18}
N 3560 27760 3540 27760 {}
C {lab_pin.sym} 3540 27760 0 0 {name=l22333 lab=WL139}
N 3640 27840 3660 27840 {}
C {lab_pin.sym} 3660 27840 0 0 {name=l22334 lab=VDD}
N 3640 27760 3660 27760 {}
C {lab_pin.sym} 3660 27760 0 0 {name=l22335 lab=VSS}
C {bitcell_6t.sym} 3800 27800 0 0 {name=Xr139c19}
N 3760 27840 3740 27840 {}
C {lab_pin.sym} 3740 27840 0 0 {name=l22336 lab=BL19}
N 3760 27800 3740 27800 {}
C {lab_pin.sym} 3740 27800 0 0 {name=l22337 lab=BLB19}
N 3760 27760 3740 27760 {}
C {lab_pin.sym} 3740 27760 0 0 {name=l22338 lab=WL139}
N 3840 27840 3860 27840 {}
C {lab_pin.sym} 3860 27840 0 0 {name=l22339 lab=VDD}
N 3840 27760 3860 27760 {}
C {lab_pin.sym} 3860 27760 0 0 {name=l22340 lab=VSS}
C {bitcell_6t.sym} 4000 27800 0 0 {name=Xr139c20}
N 3960 27840 3940 27840 {}
C {lab_pin.sym} 3940 27840 0 0 {name=l22341 lab=BL20}
N 3960 27800 3940 27800 {}
C {lab_pin.sym} 3940 27800 0 0 {name=l22342 lab=BLB20}
N 3960 27760 3940 27760 {}
C {lab_pin.sym} 3940 27760 0 0 {name=l22343 lab=WL139}
N 4040 27840 4060 27840 {}
C {lab_pin.sym} 4060 27840 0 0 {name=l22344 lab=VDD}
N 4040 27760 4060 27760 {}
C {lab_pin.sym} 4060 27760 0 0 {name=l22345 lab=VSS}
C {bitcell_6t.sym} 4200 27800 0 0 {name=Xr139c21}
N 4160 27840 4140 27840 {}
C {lab_pin.sym} 4140 27840 0 0 {name=l22346 lab=BL21}
N 4160 27800 4140 27800 {}
C {lab_pin.sym} 4140 27800 0 0 {name=l22347 lab=BLB21}
N 4160 27760 4140 27760 {}
C {lab_pin.sym} 4140 27760 0 0 {name=l22348 lab=WL139}
N 4240 27840 4260 27840 {}
C {lab_pin.sym} 4260 27840 0 0 {name=l22349 lab=VDD}
N 4240 27760 4260 27760 {}
C {lab_pin.sym} 4260 27760 0 0 {name=l22350 lab=VSS}
C {bitcell_6t.sym} 4400 27800 0 0 {name=Xr139c22}
N 4360 27840 4340 27840 {}
C {lab_pin.sym} 4340 27840 0 0 {name=l22351 lab=BL22}
N 4360 27800 4340 27800 {}
C {lab_pin.sym} 4340 27800 0 0 {name=l22352 lab=BLB22}
N 4360 27760 4340 27760 {}
C {lab_pin.sym} 4340 27760 0 0 {name=l22353 lab=WL139}
N 4440 27840 4460 27840 {}
C {lab_pin.sym} 4460 27840 0 0 {name=l22354 lab=VDD}
N 4440 27760 4460 27760 {}
C {lab_pin.sym} 4460 27760 0 0 {name=l22355 lab=VSS}
C {bitcell_6t.sym} 4600 27800 0 0 {name=Xr139c23}
N 4560 27840 4540 27840 {}
C {lab_pin.sym} 4540 27840 0 0 {name=l22356 lab=BL23}
N 4560 27800 4540 27800 {}
C {lab_pin.sym} 4540 27800 0 0 {name=l22357 lab=BLB23}
N 4560 27760 4540 27760 {}
C {lab_pin.sym} 4540 27760 0 0 {name=l22358 lab=WL139}
N 4640 27840 4660 27840 {}
C {lab_pin.sym} 4660 27840 0 0 {name=l22359 lab=VDD}
N 4640 27760 4660 27760 {}
C {lab_pin.sym} 4660 27760 0 0 {name=l22360 lab=VSS}
C {bitcell_6t.sym} 4800 27800 0 0 {name=Xr139c24}
N 4760 27840 4740 27840 {}
C {lab_pin.sym} 4740 27840 0 0 {name=l22361 lab=BL24}
N 4760 27800 4740 27800 {}
C {lab_pin.sym} 4740 27800 0 0 {name=l22362 lab=BLB24}
N 4760 27760 4740 27760 {}
C {lab_pin.sym} 4740 27760 0 0 {name=l22363 lab=WL139}
N 4840 27840 4860 27840 {}
C {lab_pin.sym} 4860 27840 0 0 {name=l22364 lab=VDD}
N 4840 27760 4860 27760 {}
C {lab_pin.sym} 4860 27760 0 0 {name=l22365 lab=VSS}
C {bitcell_6t.sym} 5000 27800 0 0 {name=Xr139c25}
N 4960 27840 4940 27840 {}
C {lab_pin.sym} 4940 27840 0 0 {name=l22366 lab=BL25}
N 4960 27800 4940 27800 {}
C {lab_pin.sym} 4940 27800 0 0 {name=l22367 lab=BLB25}
N 4960 27760 4940 27760 {}
C {lab_pin.sym} 4940 27760 0 0 {name=l22368 lab=WL139}
N 5040 27840 5060 27840 {}
C {lab_pin.sym} 5060 27840 0 0 {name=l22369 lab=VDD}
N 5040 27760 5060 27760 {}
C {lab_pin.sym} 5060 27760 0 0 {name=l22370 lab=VSS}
C {bitcell_6t.sym} 5200 27800 0 0 {name=Xr139c26}
N 5160 27840 5140 27840 {}
C {lab_pin.sym} 5140 27840 0 0 {name=l22371 lab=BL26}
N 5160 27800 5140 27800 {}
C {lab_pin.sym} 5140 27800 0 0 {name=l22372 lab=BLB26}
N 5160 27760 5140 27760 {}
C {lab_pin.sym} 5140 27760 0 0 {name=l22373 lab=WL139}
N 5240 27840 5260 27840 {}
C {lab_pin.sym} 5260 27840 0 0 {name=l22374 lab=VDD}
N 5240 27760 5260 27760 {}
C {lab_pin.sym} 5260 27760 0 0 {name=l22375 lab=VSS}
C {bitcell_6t.sym} 5400 27800 0 0 {name=Xr139c27}
N 5360 27840 5340 27840 {}
C {lab_pin.sym} 5340 27840 0 0 {name=l22376 lab=BL27}
N 5360 27800 5340 27800 {}
C {lab_pin.sym} 5340 27800 0 0 {name=l22377 lab=BLB27}
N 5360 27760 5340 27760 {}
C {lab_pin.sym} 5340 27760 0 0 {name=l22378 lab=WL139}
N 5440 27840 5460 27840 {}
C {lab_pin.sym} 5460 27840 0 0 {name=l22379 lab=VDD}
N 5440 27760 5460 27760 {}
C {lab_pin.sym} 5460 27760 0 0 {name=l22380 lab=VSS}
C {bitcell_6t.sym} 5600 27800 0 0 {name=Xr139c28}
N 5560 27840 5540 27840 {}
C {lab_pin.sym} 5540 27840 0 0 {name=l22381 lab=BL28}
N 5560 27800 5540 27800 {}
C {lab_pin.sym} 5540 27800 0 0 {name=l22382 lab=BLB28}
N 5560 27760 5540 27760 {}
C {lab_pin.sym} 5540 27760 0 0 {name=l22383 lab=WL139}
N 5640 27840 5660 27840 {}
C {lab_pin.sym} 5660 27840 0 0 {name=l22384 lab=VDD}
N 5640 27760 5660 27760 {}
C {lab_pin.sym} 5660 27760 0 0 {name=l22385 lab=VSS}
C {bitcell_6t.sym} 5800 27800 0 0 {name=Xr139c29}
N 5760 27840 5740 27840 {}
C {lab_pin.sym} 5740 27840 0 0 {name=l22386 lab=BL29}
N 5760 27800 5740 27800 {}
C {lab_pin.sym} 5740 27800 0 0 {name=l22387 lab=BLB29}
N 5760 27760 5740 27760 {}
C {lab_pin.sym} 5740 27760 0 0 {name=l22388 lab=WL139}
N 5840 27840 5860 27840 {}
C {lab_pin.sym} 5860 27840 0 0 {name=l22389 lab=VDD}
N 5840 27760 5860 27760 {}
C {lab_pin.sym} 5860 27760 0 0 {name=l22390 lab=VSS}
C {bitcell_6t.sym} 6000 27800 0 0 {name=Xr139c30}
N 5960 27840 5940 27840 {}
C {lab_pin.sym} 5940 27840 0 0 {name=l22391 lab=BL30}
N 5960 27800 5940 27800 {}
C {lab_pin.sym} 5940 27800 0 0 {name=l22392 lab=BLB30}
N 5960 27760 5940 27760 {}
C {lab_pin.sym} 5940 27760 0 0 {name=l22393 lab=WL139}
N 6040 27840 6060 27840 {}
C {lab_pin.sym} 6060 27840 0 0 {name=l22394 lab=VDD}
N 6040 27760 6060 27760 {}
C {lab_pin.sym} 6060 27760 0 0 {name=l22395 lab=VSS}
C {bitcell_6t.sym} 6200 27800 0 0 {name=Xr139c31}
N 6160 27840 6140 27840 {}
C {lab_pin.sym} 6140 27840 0 0 {name=l22396 lab=BL31}
N 6160 27800 6140 27800 {}
C {lab_pin.sym} 6140 27800 0 0 {name=l22397 lab=BLB31}
N 6160 27760 6140 27760 {}
C {lab_pin.sym} 6140 27760 0 0 {name=l22398 lab=WL139}
N 6240 27840 6260 27840 {}
C {lab_pin.sym} 6260 27840 0 0 {name=l22399 lab=VDD}
N 6240 27760 6260 27760 {}
C {lab_pin.sym} 6260 27760 0 0 {name=l22400 lab=VSS}
C {bitcell_6t.sym} 0 28000 0 0 {name=Xr140c0}
N -40 28040 -60 28040 {}
C {lab_pin.sym} -60 28040 0 0 {name=l22401 lab=BL0}
N -40 28000 -60 28000 {}
C {lab_pin.sym} -60 28000 0 0 {name=l22402 lab=BLB0}
N -40 27960 -60 27960 {}
C {lab_pin.sym} -60 27960 0 0 {name=l22403 lab=WL140}
N 40 28040 60 28040 {}
C {lab_pin.sym} 60 28040 0 0 {name=l22404 lab=VDD}
N 40 27960 60 27960 {}
C {lab_pin.sym} 60 27960 0 0 {name=l22405 lab=VSS}
C {bitcell_6t.sym} 200 28000 0 0 {name=Xr140c1}
N 160 28040 140 28040 {}
C {lab_pin.sym} 140 28040 0 0 {name=l22406 lab=BL1}
N 160 28000 140 28000 {}
C {lab_pin.sym} 140 28000 0 0 {name=l22407 lab=BLB1}
N 160 27960 140 27960 {}
C {lab_pin.sym} 140 27960 0 0 {name=l22408 lab=WL140}
N 240 28040 260 28040 {}
C {lab_pin.sym} 260 28040 0 0 {name=l22409 lab=VDD}
N 240 27960 260 27960 {}
C {lab_pin.sym} 260 27960 0 0 {name=l22410 lab=VSS}
C {bitcell_6t.sym} 400 28000 0 0 {name=Xr140c2}
N 360 28040 340 28040 {}
C {lab_pin.sym} 340 28040 0 0 {name=l22411 lab=BL2}
N 360 28000 340 28000 {}
C {lab_pin.sym} 340 28000 0 0 {name=l22412 lab=BLB2}
N 360 27960 340 27960 {}
C {lab_pin.sym} 340 27960 0 0 {name=l22413 lab=WL140}
N 440 28040 460 28040 {}
C {lab_pin.sym} 460 28040 0 0 {name=l22414 lab=VDD}
N 440 27960 460 27960 {}
C {lab_pin.sym} 460 27960 0 0 {name=l22415 lab=VSS}
C {bitcell_6t.sym} 600 28000 0 0 {name=Xr140c3}
N 560 28040 540 28040 {}
C {lab_pin.sym} 540 28040 0 0 {name=l22416 lab=BL3}
N 560 28000 540 28000 {}
C {lab_pin.sym} 540 28000 0 0 {name=l22417 lab=BLB3}
N 560 27960 540 27960 {}
C {lab_pin.sym} 540 27960 0 0 {name=l22418 lab=WL140}
N 640 28040 660 28040 {}
C {lab_pin.sym} 660 28040 0 0 {name=l22419 lab=VDD}
N 640 27960 660 27960 {}
C {lab_pin.sym} 660 27960 0 0 {name=l22420 lab=VSS}
C {bitcell_6t.sym} 800 28000 0 0 {name=Xr140c4}
N 760 28040 740 28040 {}
C {lab_pin.sym} 740 28040 0 0 {name=l22421 lab=BL4}
N 760 28000 740 28000 {}
C {lab_pin.sym} 740 28000 0 0 {name=l22422 lab=BLB4}
N 760 27960 740 27960 {}
C {lab_pin.sym} 740 27960 0 0 {name=l22423 lab=WL140}
N 840 28040 860 28040 {}
C {lab_pin.sym} 860 28040 0 0 {name=l22424 lab=VDD}
N 840 27960 860 27960 {}
C {lab_pin.sym} 860 27960 0 0 {name=l22425 lab=VSS}
C {bitcell_6t.sym} 1000 28000 0 0 {name=Xr140c5}
N 960 28040 940 28040 {}
C {lab_pin.sym} 940 28040 0 0 {name=l22426 lab=BL5}
N 960 28000 940 28000 {}
C {lab_pin.sym} 940 28000 0 0 {name=l22427 lab=BLB5}
N 960 27960 940 27960 {}
C {lab_pin.sym} 940 27960 0 0 {name=l22428 lab=WL140}
N 1040 28040 1060 28040 {}
C {lab_pin.sym} 1060 28040 0 0 {name=l22429 lab=VDD}
N 1040 27960 1060 27960 {}
C {lab_pin.sym} 1060 27960 0 0 {name=l22430 lab=VSS}
C {bitcell_6t.sym} 1200 28000 0 0 {name=Xr140c6}
N 1160 28040 1140 28040 {}
C {lab_pin.sym} 1140 28040 0 0 {name=l22431 lab=BL6}
N 1160 28000 1140 28000 {}
C {lab_pin.sym} 1140 28000 0 0 {name=l22432 lab=BLB6}
N 1160 27960 1140 27960 {}
C {lab_pin.sym} 1140 27960 0 0 {name=l22433 lab=WL140}
N 1240 28040 1260 28040 {}
C {lab_pin.sym} 1260 28040 0 0 {name=l22434 lab=VDD}
N 1240 27960 1260 27960 {}
C {lab_pin.sym} 1260 27960 0 0 {name=l22435 lab=VSS}
C {bitcell_6t.sym} 1400 28000 0 0 {name=Xr140c7}
N 1360 28040 1340 28040 {}
C {lab_pin.sym} 1340 28040 0 0 {name=l22436 lab=BL7}
N 1360 28000 1340 28000 {}
C {lab_pin.sym} 1340 28000 0 0 {name=l22437 lab=BLB7}
N 1360 27960 1340 27960 {}
C {lab_pin.sym} 1340 27960 0 0 {name=l22438 lab=WL140}
N 1440 28040 1460 28040 {}
C {lab_pin.sym} 1460 28040 0 0 {name=l22439 lab=VDD}
N 1440 27960 1460 27960 {}
C {lab_pin.sym} 1460 27960 0 0 {name=l22440 lab=VSS}
C {bitcell_6t.sym} 1600 28000 0 0 {name=Xr140c8}
N 1560 28040 1540 28040 {}
C {lab_pin.sym} 1540 28040 0 0 {name=l22441 lab=BL8}
N 1560 28000 1540 28000 {}
C {lab_pin.sym} 1540 28000 0 0 {name=l22442 lab=BLB8}
N 1560 27960 1540 27960 {}
C {lab_pin.sym} 1540 27960 0 0 {name=l22443 lab=WL140}
N 1640 28040 1660 28040 {}
C {lab_pin.sym} 1660 28040 0 0 {name=l22444 lab=VDD}
N 1640 27960 1660 27960 {}
C {lab_pin.sym} 1660 27960 0 0 {name=l22445 lab=VSS}
C {bitcell_6t.sym} 1800 28000 0 0 {name=Xr140c9}
N 1760 28040 1740 28040 {}
C {lab_pin.sym} 1740 28040 0 0 {name=l22446 lab=BL9}
N 1760 28000 1740 28000 {}
C {lab_pin.sym} 1740 28000 0 0 {name=l22447 lab=BLB9}
N 1760 27960 1740 27960 {}
C {lab_pin.sym} 1740 27960 0 0 {name=l22448 lab=WL140}
N 1840 28040 1860 28040 {}
C {lab_pin.sym} 1860 28040 0 0 {name=l22449 lab=VDD}
N 1840 27960 1860 27960 {}
C {lab_pin.sym} 1860 27960 0 0 {name=l22450 lab=VSS}
C {bitcell_6t.sym} 2000 28000 0 0 {name=Xr140c10}
N 1960 28040 1940 28040 {}
C {lab_pin.sym} 1940 28040 0 0 {name=l22451 lab=BL10}
N 1960 28000 1940 28000 {}
C {lab_pin.sym} 1940 28000 0 0 {name=l22452 lab=BLB10}
N 1960 27960 1940 27960 {}
C {lab_pin.sym} 1940 27960 0 0 {name=l22453 lab=WL140}
N 2040 28040 2060 28040 {}
C {lab_pin.sym} 2060 28040 0 0 {name=l22454 lab=VDD}
N 2040 27960 2060 27960 {}
C {lab_pin.sym} 2060 27960 0 0 {name=l22455 lab=VSS}
C {bitcell_6t.sym} 2200 28000 0 0 {name=Xr140c11}
N 2160 28040 2140 28040 {}
C {lab_pin.sym} 2140 28040 0 0 {name=l22456 lab=BL11}
N 2160 28000 2140 28000 {}
C {lab_pin.sym} 2140 28000 0 0 {name=l22457 lab=BLB11}
N 2160 27960 2140 27960 {}
C {lab_pin.sym} 2140 27960 0 0 {name=l22458 lab=WL140}
N 2240 28040 2260 28040 {}
C {lab_pin.sym} 2260 28040 0 0 {name=l22459 lab=VDD}
N 2240 27960 2260 27960 {}
C {lab_pin.sym} 2260 27960 0 0 {name=l22460 lab=VSS}
C {bitcell_6t.sym} 2400 28000 0 0 {name=Xr140c12}
N 2360 28040 2340 28040 {}
C {lab_pin.sym} 2340 28040 0 0 {name=l22461 lab=BL12}
N 2360 28000 2340 28000 {}
C {lab_pin.sym} 2340 28000 0 0 {name=l22462 lab=BLB12}
N 2360 27960 2340 27960 {}
C {lab_pin.sym} 2340 27960 0 0 {name=l22463 lab=WL140}
N 2440 28040 2460 28040 {}
C {lab_pin.sym} 2460 28040 0 0 {name=l22464 lab=VDD}
N 2440 27960 2460 27960 {}
C {lab_pin.sym} 2460 27960 0 0 {name=l22465 lab=VSS}
C {bitcell_6t.sym} 2600 28000 0 0 {name=Xr140c13}
N 2560 28040 2540 28040 {}
C {lab_pin.sym} 2540 28040 0 0 {name=l22466 lab=BL13}
N 2560 28000 2540 28000 {}
C {lab_pin.sym} 2540 28000 0 0 {name=l22467 lab=BLB13}
N 2560 27960 2540 27960 {}
C {lab_pin.sym} 2540 27960 0 0 {name=l22468 lab=WL140}
N 2640 28040 2660 28040 {}
C {lab_pin.sym} 2660 28040 0 0 {name=l22469 lab=VDD}
N 2640 27960 2660 27960 {}
C {lab_pin.sym} 2660 27960 0 0 {name=l22470 lab=VSS}
C {bitcell_6t.sym} 2800 28000 0 0 {name=Xr140c14}
N 2760 28040 2740 28040 {}
C {lab_pin.sym} 2740 28040 0 0 {name=l22471 lab=BL14}
N 2760 28000 2740 28000 {}
C {lab_pin.sym} 2740 28000 0 0 {name=l22472 lab=BLB14}
N 2760 27960 2740 27960 {}
C {lab_pin.sym} 2740 27960 0 0 {name=l22473 lab=WL140}
N 2840 28040 2860 28040 {}
C {lab_pin.sym} 2860 28040 0 0 {name=l22474 lab=VDD}
N 2840 27960 2860 27960 {}
C {lab_pin.sym} 2860 27960 0 0 {name=l22475 lab=VSS}
C {bitcell_6t.sym} 3000 28000 0 0 {name=Xr140c15}
N 2960 28040 2940 28040 {}
C {lab_pin.sym} 2940 28040 0 0 {name=l22476 lab=BL15}
N 2960 28000 2940 28000 {}
C {lab_pin.sym} 2940 28000 0 0 {name=l22477 lab=BLB15}
N 2960 27960 2940 27960 {}
C {lab_pin.sym} 2940 27960 0 0 {name=l22478 lab=WL140}
N 3040 28040 3060 28040 {}
C {lab_pin.sym} 3060 28040 0 0 {name=l22479 lab=VDD}
N 3040 27960 3060 27960 {}
C {lab_pin.sym} 3060 27960 0 0 {name=l22480 lab=VSS}
C {bitcell_6t.sym} 3200 28000 0 0 {name=Xr140c16}
N 3160 28040 3140 28040 {}
C {lab_pin.sym} 3140 28040 0 0 {name=l22481 lab=BL16}
N 3160 28000 3140 28000 {}
C {lab_pin.sym} 3140 28000 0 0 {name=l22482 lab=BLB16}
N 3160 27960 3140 27960 {}
C {lab_pin.sym} 3140 27960 0 0 {name=l22483 lab=WL140}
N 3240 28040 3260 28040 {}
C {lab_pin.sym} 3260 28040 0 0 {name=l22484 lab=VDD}
N 3240 27960 3260 27960 {}
C {lab_pin.sym} 3260 27960 0 0 {name=l22485 lab=VSS}
C {bitcell_6t.sym} 3400 28000 0 0 {name=Xr140c17}
N 3360 28040 3340 28040 {}
C {lab_pin.sym} 3340 28040 0 0 {name=l22486 lab=BL17}
N 3360 28000 3340 28000 {}
C {lab_pin.sym} 3340 28000 0 0 {name=l22487 lab=BLB17}
N 3360 27960 3340 27960 {}
C {lab_pin.sym} 3340 27960 0 0 {name=l22488 lab=WL140}
N 3440 28040 3460 28040 {}
C {lab_pin.sym} 3460 28040 0 0 {name=l22489 lab=VDD}
N 3440 27960 3460 27960 {}
C {lab_pin.sym} 3460 27960 0 0 {name=l22490 lab=VSS}
C {bitcell_6t.sym} 3600 28000 0 0 {name=Xr140c18}
N 3560 28040 3540 28040 {}
C {lab_pin.sym} 3540 28040 0 0 {name=l22491 lab=BL18}
N 3560 28000 3540 28000 {}
C {lab_pin.sym} 3540 28000 0 0 {name=l22492 lab=BLB18}
N 3560 27960 3540 27960 {}
C {lab_pin.sym} 3540 27960 0 0 {name=l22493 lab=WL140}
N 3640 28040 3660 28040 {}
C {lab_pin.sym} 3660 28040 0 0 {name=l22494 lab=VDD}
N 3640 27960 3660 27960 {}
C {lab_pin.sym} 3660 27960 0 0 {name=l22495 lab=VSS}
C {bitcell_6t.sym} 3800 28000 0 0 {name=Xr140c19}
N 3760 28040 3740 28040 {}
C {lab_pin.sym} 3740 28040 0 0 {name=l22496 lab=BL19}
N 3760 28000 3740 28000 {}
C {lab_pin.sym} 3740 28000 0 0 {name=l22497 lab=BLB19}
N 3760 27960 3740 27960 {}
C {lab_pin.sym} 3740 27960 0 0 {name=l22498 lab=WL140}
N 3840 28040 3860 28040 {}
C {lab_pin.sym} 3860 28040 0 0 {name=l22499 lab=VDD}
N 3840 27960 3860 27960 {}
C {lab_pin.sym} 3860 27960 0 0 {name=l22500 lab=VSS}
C {bitcell_6t.sym} 4000 28000 0 0 {name=Xr140c20}
N 3960 28040 3940 28040 {}
C {lab_pin.sym} 3940 28040 0 0 {name=l22501 lab=BL20}
N 3960 28000 3940 28000 {}
C {lab_pin.sym} 3940 28000 0 0 {name=l22502 lab=BLB20}
N 3960 27960 3940 27960 {}
C {lab_pin.sym} 3940 27960 0 0 {name=l22503 lab=WL140}
N 4040 28040 4060 28040 {}
C {lab_pin.sym} 4060 28040 0 0 {name=l22504 lab=VDD}
N 4040 27960 4060 27960 {}
C {lab_pin.sym} 4060 27960 0 0 {name=l22505 lab=VSS}
C {bitcell_6t.sym} 4200 28000 0 0 {name=Xr140c21}
N 4160 28040 4140 28040 {}
C {lab_pin.sym} 4140 28040 0 0 {name=l22506 lab=BL21}
N 4160 28000 4140 28000 {}
C {lab_pin.sym} 4140 28000 0 0 {name=l22507 lab=BLB21}
N 4160 27960 4140 27960 {}
C {lab_pin.sym} 4140 27960 0 0 {name=l22508 lab=WL140}
N 4240 28040 4260 28040 {}
C {lab_pin.sym} 4260 28040 0 0 {name=l22509 lab=VDD}
N 4240 27960 4260 27960 {}
C {lab_pin.sym} 4260 27960 0 0 {name=l22510 lab=VSS}
C {bitcell_6t.sym} 4400 28000 0 0 {name=Xr140c22}
N 4360 28040 4340 28040 {}
C {lab_pin.sym} 4340 28040 0 0 {name=l22511 lab=BL22}
N 4360 28000 4340 28000 {}
C {lab_pin.sym} 4340 28000 0 0 {name=l22512 lab=BLB22}
N 4360 27960 4340 27960 {}
C {lab_pin.sym} 4340 27960 0 0 {name=l22513 lab=WL140}
N 4440 28040 4460 28040 {}
C {lab_pin.sym} 4460 28040 0 0 {name=l22514 lab=VDD}
N 4440 27960 4460 27960 {}
C {lab_pin.sym} 4460 27960 0 0 {name=l22515 lab=VSS}
C {bitcell_6t.sym} 4600 28000 0 0 {name=Xr140c23}
N 4560 28040 4540 28040 {}
C {lab_pin.sym} 4540 28040 0 0 {name=l22516 lab=BL23}
N 4560 28000 4540 28000 {}
C {lab_pin.sym} 4540 28000 0 0 {name=l22517 lab=BLB23}
N 4560 27960 4540 27960 {}
C {lab_pin.sym} 4540 27960 0 0 {name=l22518 lab=WL140}
N 4640 28040 4660 28040 {}
C {lab_pin.sym} 4660 28040 0 0 {name=l22519 lab=VDD}
N 4640 27960 4660 27960 {}
C {lab_pin.sym} 4660 27960 0 0 {name=l22520 lab=VSS}
C {bitcell_6t.sym} 4800 28000 0 0 {name=Xr140c24}
N 4760 28040 4740 28040 {}
C {lab_pin.sym} 4740 28040 0 0 {name=l22521 lab=BL24}
N 4760 28000 4740 28000 {}
C {lab_pin.sym} 4740 28000 0 0 {name=l22522 lab=BLB24}
N 4760 27960 4740 27960 {}
C {lab_pin.sym} 4740 27960 0 0 {name=l22523 lab=WL140}
N 4840 28040 4860 28040 {}
C {lab_pin.sym} 4860 28040 0 0 {name=l22524 lab=VDD}
N 4840 27960 4860 27960 {}
C {lab_pin.sym} 4860 27960 0 0 {name=l22525 lab=VSS}
C {bitcell_6t.sym} 5000 28000 0 0 {name=Xr140c25}
N 4960 28040 4940 28040 {}
C {lab_pin.sym} 4940 28040 0 0 {name=l22526 lab=BL25}
N 4960 28000 4940 28000 {}
C {lab_pin.sym} 4940 28000 0 0 {name=l22527 lab=BLB25}
N 4960 27960 4940 27960 {}
C {lab_pin.sym} 4940 27960 0 0 {name=l22528 lab=WL140}
N 5040 28040 5060 28040 {}
C {lab_pin.sym} 5060 28040 0 0 {name=l22529 lab=VDD}
N 5040 27960 5060 27960 {}
C {lab_pin.sym} 5060 27960 0 0 {name=l22530 lab=VSS}
C {bitcell_6t.sym} 5200 28000 0 0 {name=Xr140c26}
N 5160 28040 5140 28040 {}
C {lab_pin.sym} 5140 28040 0 0 {name=l22531 lab=BL26}
N 5160 28000 5140 28000 {}
C {lab_pin.sym} 5140 28000 0 0 {name=l22532 lab=BLB26}
N 5160 27960 5140 27960 {}
C {lab_pin.sym} 5140 27960 0 0 {name=l22533 lab=WL140}
N 5240 28040 5260 28040 {}
C {lab_pin.sym} 5260 28040 0 0 {name=l22534 lab=VDD}
N 5240 27960 5260 27960 {}
C {lab_pin.sym} 5260 27960 0 0 {name=l22535 lab=VSS}
C {bitcell_6t.sym} 5400 28000 0 0 {name=Xr140c27}
N 5360 28040 5340 28040 {}
C {lab_pin.sym} 5340 28040 0 0 {name=l22536 lab=BL27}
N 5360 28000 5340 28000 {}
C {lab_pin.sym} 5340 28000 0 0 {name=l22537 lab=BLB27}
N 5360 27960 5340 27960 {}
C {lab_pin.sym} 5340 27960 0 0 {name=l22538 lab=WL140}
N 5440 28040 5460 28040 {}
C {lab_pin.sym} 5460 28040 0 0 {name=l22539 lab=VDD}
N 5440 27960 5460 27960 {}
C {lab_pin.sym} 5460 27960 0 0 {name=l22540 lab=VSS}
C {bitcell_6t.sym} 5600 28000 0 0 {name=Xr140c28}
N 5560 28040 5540 28040 {}
C {lab_pin.sym} 5540 28040 0 0 {name=l22541 lab=BL28}
N 5560 28000 5540 28000 {}
C {lab_pin.sym} 5540 28000 0 0 {name=l22542 lab=BLB28}
N 5560 27960 5540 27960 {}
C {lab_pin.sym} 5540 27960 0 0 {name=l22543 lab=WL140}
N 5640 28040 5660 28040 {}
C {lab_pin.sym} 5660 28040 0 0 {name=l22544 lab=VDD}
N 5640 27960 5660 27960 {}
C {lab_pin.sym} 5660 27960 0 0 {name=l22545 lab=VSS}
C {bitcell_6t.sym} 5800 28000 0 0 {name=Xr140c29}
N 5760 28040 5740 28040 {}
C {lab_pin.sym} 5740 28040 0 0 {name=l22546 lab=BL29}
N 5760 28000 5740 28000 {}
C {lab_pin.sym} 5740 28000 0 0 {name=l22547 lab=BLB29}
N 5760 27960 5740 27960 {}
C {lab_pin.sym} 5740 27960 0 0 {name=l22548 lab=WL140}
N 5840 28040 5860 28040 {}
C {lab_pin.sym} 5860 28040 0 0 {name=l22549 lab=VDD}
N 5840 27960 5860 27960 {}
C {lab_pin.sym} 5860 27960 0 0 {name=l22550 lab=VSS}
C {bitcell_6t.sym} 6000 28000 0 0 {name=Xr140c30}
N 5960 28040 5940 28040 {}
C {lab_pin.sym} 5940 28040 0 0 {name=l22551 lab=BL30}
N 5960 28000 5940 28000 {}
C {lab_pin.sym} 5940 28000 0 0 {name=l22552 lab=BLB30}
N 5960 27960 5940 27960 {}
C {lab_pin.sym} 5940 27960 0 0 {name=l22553 lab=WL140}
N 6040 28040 6060 28040 {}
C {lab_pin.sym} 6060 28040 0 0 {name=l22554 lab=VDD}
N 6040 27960 6060 27960 {}
C {lab_pin.sym} 6060 27960 0 0 {name=l22555 lab=VSS}
C {bitcell_6t.sym} 6200 28000 0 0 {name=Xr140c31}
N 6160 28040 6140 28040 {}
C {lab_pin.sym} 6140 28040 0 0 {name=l22556 lab=BL31}
N 6160 28000 6140 28000 {}
C {lab_pin.sym} 6140 28000 0 0 {name=l22557 lab=BLB31}
N 6160 27960 6140 27960 {}
C {lab_pin.sym} 6140 27960 0 0 {name=l22558 lab=WL140}
N 6240 28040 6260 28040 {}
C {lab_pin.sym} 6260 28040 0 0 {name=l22559 lab=VDD}
N 6240 27960 6260 27960 {}
C {lab_pin.sym} 6260 27960 0 0 {name=l22560 lab=VSS}
C {bitcell_6t.sym} 0 28200 0 0 {name=Xr141c0}
N -40 28240 -60 28240 {}
C {lab_pin.sym} -60 28240 0 0 {name=l22561 lab=BL0}
N -40 28200 -60 28200 {}
C {lab_pin.sym} -60 28200 0 0 {name=l22562 lab=BLB0}
N -40 28160 -60 28160 {}
C {lab_pin.sym} -60 28160 0 0 {name=l22563 lab=WL141}
N 40 28240 60 28240 {}
C {lab_pin.sym} 60 28240 0 0 {name=l22564 lab=VDD}
N 40 28160 60 28160 {}
C {lab_pin.sym} 60 28160 0 0 {name=l22565 lab=VSS}
C {bitcell_6t.sym} 200 28200 0 0 {name=Xr141c1}
N 160 28240 140 28240 {}
C {lab_pin.sym} 140 28240 0 0 {name=l22566 lab=BL1}
N 160 28200 140 28200 {}
C {lab_pin.sym} 140 28200 0 0 {name=l22567 lab=BLB1}
N 160 28160 140 28160 {}
C {lab_pin.sym} 140 28160 0 0 {name=l22568 lab=WL141}
N 240 28240 260 28240 {}
C {lab_pin.sym} 260 28240 0 0 {name=l22569 lab=VDD}
N 240 28160 260 28160 {}
C {lab_pin.sym} 260 28160 0 0 {name=l22570 lab=VSS}
C {bitcell_6t.sym} 400 28200 0 0 {name=Xr141c2}
N 360 28240 340 28240 {}
C {lab_pin.sym} 340 28240 0 0 {name=l22571 lab=BL2}
N 360 28200 340 28200 {}
C {lab_pin.sym} 340 28200 0 0 {name=l22572 lab=BLB2}
N 360 28160 340 28160 {}
C {lab_pin.sym} 340 28160 0 0 {name=l22573 lab=WL141}
N 440 28240 460 28240 {}
C {lab_pin.sym} 460 28240 0 0 {name=l22574 lab=VDD}
N 440 28160 460 28160 {}
C {lab_pin.sym} 460 28160 0 0 {name=l22575 lab=VSS}
C {bitcell_6t.sym} 600 28200 0 0 {name=Xr141c3}
N 560 28240 540 28240 {}
C {lab_pin.sym} 540 28240 0 0 {name=l22576 lab=BL3}
N 560 28200 540 28200 {}
C {lab_pin.sym} 540 28200 0 0 {name=l22577 lab=BLB3}
N 560 28160 540 28160 {}
C {lab_pin.sym} 540 28160 0 0 {name=l22578 lab=WL141}
N 640 28240 660 28240 {}
C {lab_pin.sym} 660 28240 0 0 {name=l22579 lab=VDD}
N 640 28160 660 28160 {}
C {lab_pin.sym} 660 28160 0 0 {name=l22580 lab=VSS}
C {bitcell_6t.sym} 800 28200 0 0 {name=Xr141c4}
N 760 28240 740 28240 {}
C {lab_pin.sym} 740 28240 0 0 {name=l22581 lab=BL4}
N 760 28200 740 28200 {}
C {lab_pin.sym} 740 28200 0 0 {name=l22582 lab=BLB4}
N 760 28160 740 28160 {}
C {lab_pin.sym} 740 28160 0 0 {name=l22583 lab=WL141}
N 840 28240 860 28240 {}
C {lab_pin.sym} 860 28240 0 0 {name=l22584 lab=VDD}
N 840 28160 860 28160 {}
C {lab_pin.sym} 860 28160 0 0 {name=l22585 lab=VSS}
C {bitcell_6t.sym} 1000 28200 0 0 {name=Xr141c5}
N 960 28240 940 28240 {}
C {lab_pin.sym} 940 28240 0 0 {name=l22586 lab=BL5}
N 960 28200 940 28200 {}
C {lab_pin.sym} 940 28200 0 0 {name=l22587 lab=BLB5}
N 960 28160 940 28160 {}
C {lab_pin.sym} 940 28160 0 0 {name=l22588 lab=WL141}
N 1040 28240 1060 28240 {}
C {lab_pin.sym} 1060 28240 0 0 {name=l22589 lab=VDD}
N 1040 28160 1060 28160 {}
C {lab_pin.sym} 1060 28160 0 0 {name=l22590 lab=VSS}
C {bitcell_6t.sym} 1200 28200 0 0 {name=Xr141c6}
N 1160 28240 1140 28240 {}
C {lab_pin.sym} 1140 28240 0 0 {name=l22591 lab=BL6}
N 1160 28200 1140 28200 {}
C {lab_pin.sym} 1140 28200 0 0 {name=l22592 lab=BLB6}
N 1160 28160 1140 28160 {}
C {lab_pin.sym} 1140 28160 0 0 {name=l22593 lab=WL141}
N 1240 28240 1260 28240 {}
C {lab_pin.sym} 1260 28240 0 0 {name=l22594 lab=VDD}
N 1240 28160 1260 28160 {}
C {lab_pin.sym} 1260 28160 0 0 {name=l22595 lab=VSS}
C {bitcell_6t.sym} 1400 28200 0 0 {name=Xr141c7}
N 1360 28240 1340 28240 {}
C {lab_pin.sym} 1340 28240 0 0 {name=l22596 lab=BL7}
N 1360 28200 1340 28200 {}
C {lab_pin.sym} 1340 28200 0 0 {name=l22597 lab=BLB7}
N 1360 28160 1340 28160 {}
C {lab_pin.sym} 1340 28160 0 0 {name=l22598 lab=WL141}
N 1440 28240 1460 28240 {}
C {lab_pin.sym} 1460 28240 0 0 {name=l22599 lab=VDD}
N 1440 28160 1460 28160 {}
C {lab_pin.sym} 1460 28160 0 0 {name=l22600 lab=VSS}
C {bitcell_6t.sym} 1600 28200 0 0 {name=Xr141c8}
N 1560 28240 1540 28240 {}
C {lab_pin.sym} 1540 28240 0 0 {name=l22601 lab=BL8}
N 1560 28200 1540 28200 {}
C {lab_pin.sym} 1540 28200 0 0 {name=l22602 lab=BLB8}
N 1560 28160 1540 28160 {}
C {lab_pin.sym} 1540 28160 0 0 {name=l22603 lab=WL141}
N 1640 28240 1660 28240 {}
C {lab_pin.sym} 1660 28240 0 0 {name=l22604 lab=VDD}
N 1640 28160 1660 28160 {}
C {lab_pin.sym} 1660 28160 0 0 {name=l22605 lab=VSS}
C {bitcell_6t.sym} 1800 28200 0 0 {name=Xr141c9}
N 1760 28240 1740 28240 {}
C {lab_pin.sym} 1740 28240 0 0 {name=l22606 lab=BL9}
N 1760 28200 1740 28200 {}
C {lab_pin.sym} 1740 28200 0 0 {name=l22607 lab=BLB9}
N 1760 28160 1740 28160 {}
C {lab_pin.sym} 1740 28160 0 0 {name=l22608 lab=WL141}
N 1840 28240 1860 28240 {}
C {lab_pin.sym} 1860 28240 0 0 {name=l22609 lab=VDD}
N 1840 28160 1860 28160 {}
C {lab_pin.sym} 1860 28160 0 0 {name=l22610 lab=VSS}
C {bitcell_6t.sym} 2000 28200 0 0 {name=Xr141c10}
N 1960 28240 1940 28240 {}
C {lab_pin.sym} 1940 28240 0 0 {name=l22611 lab=BL10}
N 1960 28200 1940 28200 {}
C {lab_pin.sym} 1940 28200 0 0 {name=l22612 lab=BLB10}
N 1960 28160 1940 28160 {}
C {lab_pin.sym} 1940 28160 0 0 {name=l22613 lab=WL141}
N 2040 28240 2060 28240 {}
C {lab_pin.sym} 2060 28240 0 0 {name=l22614 lab=VDD}
N 2040 28160 2060 28160 {}
C {lab_pin.sym} 2060 28160 0 0 {name=l22615 lab=VSS}
C {bitcell_6t.sym} 2200 28200 0 0 {name=Xr141c11}
N 2160 28240 2140 28240 {}
C {lab_pin.sym} 2140 28240 0 0 {name=l22616 lab=BL11}
N 2160 28200 2140 28200 {}
C {lab_pin.sym} 2140 28200 0 0 {name=l22617 lab=BLB11}
N 2160 28160 2140 28160 {}
C {lab_pin.sym} 2140 28160 0 0 {name=l22618 lab=WL141}
N 2240 28240 2260 28240 {}
C {lab_pin.sym} 2260 28240 0 0 {name=l22619 lab=VDD}
N 2240 28160 2260 28160 {}
C {lab_pin.sym} 2260 28160 0 0 {name=l22620 lab=VSS}
C {bitcell_6t.sym} 2400 28200 0 0 {name=Xr141c12}
N 2360 28240 2340 28240 {}
C {lab_pin.sym} 2340 28240 0 0 {name=l22621 lab=BL12}
N 2360 28200 2340 28200 {}
C {lab_pin.sym} 2340 28200 0 0 {name=l22622 lab=BLB12}
N 2360 28160 2340 28160 {}
C {lab_pin.sym} 2340 28160 0 0 {name=l22623 lab=WL141}
N 2440 28240 2460 28240 {}
C {lab_pin.sym} 2460 28240 0 0 {name=l22624 lab=VDD}
N 2440 28160 2460 28160 {}
C {lab_pin.sym} 2460 28160 0 0 {name=l22625 lab=VSS}
C {bitcell_6t.sym} 2600 28200 0 0 {name=Xr141c13}
N 2560 28240 2540 28240 {}
C {lab_pin.sym} 2540 28240 0 0 {name=l22626 lab=BL13}
N 2560 28200 2540 28200 {}
C {lab_pin.sym} 2540 28200 0 0 {name=l22627 lab=BLB13}
N 2560 28160 2540 28160 {}
C {lab_pin.sym} 2540 28160 0 0 {name=l22628 lab=WL141}
N 2640 28240 2660 28240 {}
C {lab_pin.sym} 2660 28240 0 0 {name=l22629 lab=VDD}
N 2640 28160 2660 28160 {}
C {lab_pin.sym} 2660 28160 0 0 {name=l22630 lab=VSS}
C {bitcell_6t.sym} 2800 28200 0 0 {name=Xr141c14}
N 2760 28240 2740 28240 {}
C {lab_pin.sym} 2740 28240 0 0 {name=l22631 lab=BL14}
N 2760 28200 2740 28200 {}
C {lab_pin.sym} 2740 28200 0 0 {name=l22632 lab=BLB14}
N 2760 28160 2740 28160 {}
C {lab_pin.sym} 2740 28160 0 0 {name=l22633 lab=WL141}
N 2840 28240 2860 28240 {}
C {lab_pin.sym} 2860 28240 0 0 {name=l22634 lab=VDD}
N 2840 28160 2860 28160 {}
C {lab_pin.sym} 2860 28160 0 0 {name=l22635 lab=VSS}
C {bitcell_6t.sym} 3000 28200 0 0 {name=Xr141c15}
N 2960 28240 2940 28240 {}
C {lab_pin.sym} 2940 28240 0 0 {name=l22636 lab=BL15}
N 2960 28200 2940 28200 {}
C {lab_pin.sym} 2940 28200 0 0 {name=l22637 lab=BLB15}
N 2960 28160 2940 28160 {}
C {lab_pin.sym} 2940 28160 0 0 {name=l22638 lab=WL141}
N 3040 28240 3060 28240 {}
C {lab_pin.sym} 3060 28240 0 0 {name=l22639 lab=VDD}
N 3040 28160 3060 28160 {}
C {lab_pin.sym} 3060 28160 0 0 {name=l22640 lab=VSS}
C {bitcell_6t.sym} 3200 28200 0 0 {name=Xr141c16}
N 3160 28240 3140 28240 {}
C {lab_pin.sym} 3140 28240 0 0 {name=l22641 lab=BL16}
N 3160 28200 3140 28200 {}
C {lab_pin.sym} 3140 28200 0 0 {name=l22642 lab=BLB16}
N 3160 28160 3140 28160 {}
C {lab_pin.sym} 3140 28160 0 0 {name=l22643 lab=WL141}
N 3240 28240 3260 28240 {}
C {lab_pin.sym} 3260 28240 0 0 {name=l22644 lab=VDD}
N 3240 28160 3260 28160 {}
C {lab_pin.sym} 3260 28160 0 0 {name=l22645 lab=VSS}
C {bitcell_6t.sym} 3400 28200 0 0 {name=Xr141c17}
N 3360 28240 3340 28240 {}
C {lab_pin.sym} 3340 28240 0 0 {name=l22646 lab=BL17}
N 3360 28200 3340 28200 {}
C {lab_pin.sym} 3340 28200 0 0 {name=l22647 lab=BLB17}
N 3360 28160 3340 28160 {}
C {lab_pin.sym} 3340 28160 0 0 {name=l22648 lab=WL141}
N 3440 28240 3460 28240 {}
C {lab_pin.sym} 3460 28240 0 0 {name=l22649 lab=VDD}
N 3440 28160 3460 28160 {}
C {lab_pin.sym} 3460 28160 0 0 {name=l22650 lab=VSS}
C {bitcell_6t.sym} 3600 28200 0 0 {name=Xr141c18}
N 3560 28240 3540 28240 {}
C {lab_pin.sym} 3540 28240 0 0 {name=l22651 lab=BL18}
N 3560 28200 3540 28200 {}
C {lab_pin.sym} 3540 28200 0 0 {name=l22652 lab=BLB18}
N 3560 28160 3540 28160 {}
C {lab_pin.sym} 3540 28160 0 0 {name=l22653 lab=WL141}
N 3640 28240 3660 28240 {}
C {lab_pin.sym} 3660 28240 0 0 {name=l22654 lab=VDD}
N 3640 28160 3660 28160 {}
C {lab_pin.sym} 3660 28160 0 0 {name=l22655 lab=VSS}
C {bitcell_6t.sym} 3800 28200 0 0 {name=Xr141c19}
N 3760 28240 3740 28240 {}
C {lab_pin.sym} 3740 28240 0 0 {name=l22656 lab=BL19}
N 3760 28200 3740 28200 {}
C {lab_pin.sym} 3740 28200 0 0 {name=l22657 lab=BLB19}
N 3760 28160 3740 28160 {}
C {lab_pin.sym} 3740 28160 0 0 {name=l22658 lab=WL141}
N 3840 28240 3860 28240 {}
C {lab_pin.sym} 3860 28240 0 0 {name=l22659 lab=VDD}
N 3840 28160 3860 28160 {}
C {lab_pin.sym} 3860 28160 0 0 {name=l22660 lab=VSS}
C {bitcell_6t.sym} 4000 28200 0 0 {name=Xr141c20}
N 3960 28240 3940 28240 {}
C {lab_pin.sym} 3940 28240 0 0 {name=l22661 lab=BL20}
N 3960 28200 3940 28200 {}
C {lab_pin.sym} 3940 28200 0 0 {name=l22662 lab=BLB20}
N 3960 28160 3940 28160 {}
C {lab_pin.sym} 3940 28160 0 0 {name=l22663 lab=WL141}
N 4040 28240 4060 28240 {}
C {lab_pin.sym} 4060 28240 0 0 {name=l22664 lab=VDD}
N 4040 28160 4060 28160 {}
C {lab_pin.sym} 4060 28160 0 0 {name=l22665 lab=VSS}
C {bitcell_6t.sym} 4200 28200 0 0 {name=Xr141c21}
N 4160 28240 4140 28240 {}
C {lab_pin.sym} 4140 28240 0 0 {name=l22666 lab=BL21}
N 4160 28200 4140 28200 {}
C {lab_pin.sym} 4140 28200 0 0 {name=l22667 lab=BLB21}
N 4160 28160 4140 28160 {}
C {lab_pin.sym} 4140 28160 0 0 {name=l22668 lab=WL141}
N 4240 28240 4260 28240 {}
C {lab_pin.sym} 4260 28240 0 0 {name=l22669 lab=VDD}
N 4240 28160 4260 28160 {}
C {lab_pin.sym} 4260 28160 0 0 {name=l22670 lab=VSS}
C {bitcell_6t.sym} 4400 28200 0 0 {name=Xr141c22}
N 4360 28240 4340 28240 {}
C {lab_pin.sym} 4340 28240 0 0 {name=l22671 lab=BL22}
N 4360 28200 4340 28200 {}
C {lab_pin.sym} 4340 28200 0 0 {name=l22672 lab=BLB22}
N 4360 28160 4340 28160 {}
C {lab_pin.sym} 4340 28160 0 0 {name=l22673 lab=WL141}
N 4440 28240 4460 28240 {}
C {lab_pin.sym} 4460 28240 0 0 {name=l22674 lab=VDD}
N 4440 28160 4460 28160 {}
C {lab_pin.sym} 4460 28160 0 0 {name=l22675 lab=VSS}
C {bitcell_6t.sym} 4600 28200 0 0 {name=Xr141c23}
N 4560 28240 4540 28240 {}
C {lab_pin.sym} 4540 28240 0 0 {name=l22676 lab=BL23}
N 4560 28200 4540 28200 {}
