C {lab_pin.sym} 2740 33840 0 0 {name=l27111 lab=BL14}
N 2760 33800 2740 33800 {}
C {lab_pin.sym} 2740 33800 0 0 {name=l27112 lab=BLB14}
N 2760 33760 2740 33760 {}
C {lab_pin.sym} 2740 33760 0 0 {name=l27113 lab=WL169}
N 2840 33840 2860 33840 {}
C {lab_pin.sym} 2860 33840 0 0 {name=l27114 lab=VDD}
N 2840 33760 2860 33760 {}
C {lab_pin.sym} 2860 33760 0 0 {name=l27115 lab=VSS}
C {bitcell_6t.sym} 3000 33800 0 0 {name=Xr169c15}
N 2960 33840 2940 33840 {}
C {lab_pin.sym} 2940 33840 0 0 {name=l27116 lab=BL15}
N 2960 33800 2940 33800 {}
C {lab_pin.sym} 2940 33800 0 0 {name=l27117 lab=BLB15}
N 2960 33760 2940 33760 {}
C {lab_pin.sym} 2940 33760 0 0 {name=l27118 lab=WL169}
N 3040 33840 3060 33840 {}
C {lab_pin.sym} 3060 33840 0 0 {name=l27119 lab=VDD}
N 3040 33760 3060 33760 {}
C {lab_pin.sym} 3060 33760 0 0 {name=l27120 lab=VSS}
C {bitcell_6t.sym} 3200 33800 0 0 {name=Xr169c16}
N 3160 33840 3140 33840 {}
C {lab_pin.sym} 3140 33840 0 0 {name=l27121 lab=BL16}
N 3160 33800 3140 33800 {}
C {lab_pin.sym} 3140 33800 0 0 {name=l27122 lab=BLB16}
N 3160 33760 3140 33760 {}
C {lab_pin.sym} 3140 33760 0 0 {name=l27123 lab=WL169}
N 3240 33840 3260 33840 {}
C {lab_pin.sym} 3260 33840 0 0 {name=l27124 lab=VDD}
N 3240 33760 3260 33760 {}
C {lab_pin.sym} 3260 33760 0 0 {name=l27125 lab=VSS}
C {bitcell_6t.sym} 3400 33800 0 0 {name=Xr169c17}
N 3360 33840 3340 33840 {}
C {lab_pin.sym} 3340 33840 0 0 {name=l27126 lab=BL17}
N 3360 33800 3340 33800 {}
C {lab_pin.sym} 3340 33800 0 0 {name=l27127 lab=BLB17}
N 3360 33760 3340 33760 {}
C {lab_pin.sym} 3340 33760 0 0 {name=l27128 lab=WL169}
N 3440 33840 3460 33840 {}
C {lab_pin.sym} 3460 33840 0 0 {name=l27129 lab=VDD}
N 3440 33760 3460 33760 {}
C {lab_pin.sym} 3460 33760 0 0 {name=l27130 lab=VSS}
C {bitcell_6t.sym} 3600 33800 0 0 {name=Xr169c18}
N 3560 33840 3540 33840 {}
C {lab_pin.sym} 3540 33840 0 0 {name=l27131 lab=BL18}
N 3560 33800 3540 33800 {}
C {lab_pin.sym} 3540 33800 0 0 {name=l27132 lab=BLB18}
N 3560 33760 3540 33760 {}
C {lab_pin.sym} 3540 33760 0 0 {name=l27133 lab=WL169}
N 3640 33840 3660 33840 {}
C {lab_pin.sym} 3660 33840 0 0 {name=l27134 lab=VDD}
N 3640 33760 3660 33760 {}
C {lab_pin.sym} 3660 33760 0 0 {name=l27135 lab=VSS}
C {bitcell_6t.sym} 3800 33800 0 0 {name=Xr169c19}
N 3760 33840 3740 33840 {}
C {lab_pin.sym} 3740 33840 0 0 {name=l27136 lab=BL19}
N 3760 33800 3740 33800 {}
C {lab_pin.sym} 3740 33800 0 0 {name=l27137 lab=BLB19}
N 3760 33760 3740 33760 {}
C {lab_pin.sym} 3740 33760 0 0 {name=l27138 lab=WL169}
N 3840 33840 3860 33840 {}
C {lab_pin.sym} 3860 33840 0 0 {name=l27139 lab=VDD}
N 3840 33760 3860 33760 {}
C {lab_pin.sym} 3860 33760 0 0 {name=l27140 lab=VSS}
C {bitcell_6t.sym} 4000 33800 0 0 {name=Xr169c20}
N 3960 33840 3940 33840 {}
C {lab_pin.sym} 3940 33840 0 0 {name=l27141 lab=BL20}
N 3960 33800 3940 33800 {}
C {lab_pin.sym} 3940 33800 0 0 {name=l27142 lab=BLB20}
N 3960 33760 3940 33760 {}
C {lab_pin.sym} 3940 33760 0 0 {name=l27143 lab=WL169}
N 4040 33840 4060 33840 {}
C {lab_pin.sym} 4060 33840 0 0 {name=l27144 lab=VDD}
N 4040 33760 4060 33760 {}
C {lab_pin.sym} 4060 33760 0 0 {name=l27145 lab=VSS}
C {bitcell_6t.sym} 4200 33800 0 0 {name=Xr169c21}
N 4160 33840 4140 33840 {}
C {lab_pin.sym} 4140 33840 0 0 {name=l27146 lab=BL21}
N 4160 33800 4140 33800 {}
C {lab_pin.sym} 4140 33800 0 0 {name=l27147 lab=BLB21}
N 4160 33760 4140 33760 {}
C {lab_pin.sym} 4140 33760 0 0 {name=l27148 lab=WL169}
N 4240 33840 4260 33840 {}
C {lab_pin.sym} 4260 33840 0 0 {name=l27149 lab=VDD}
N 4240 33760 4260 33760 {}
C {lab_pin.sym} 4260 33760 0 0 {name=l27150 lab=VSS}
C {bitcell_6t.sym} 4400 33800 0 0 {name=Xr169c22}
N 4360 33840 4340 33840 {}
C {lab_pin.sym} 4340 33840 0 0 {name=l27151 lab=BL22}
N 4360 33800 4340 33800 {}
C {lab_pin.sym} 4340 33800 0 0 {name=l27152 lab=BLB22}
N 4360 33760 4340 33760 {}
C {lab_pin.sym} 4340 33760 0 0 {name=l27153 lab=WL169}
N 4440 33840 4460 33840 {}
C {lab_pin.sym} 4460 33840 0 0 {name=l27154 lab=VDD}
N 4440 33760 4460 33760 {}
C {lab_pin.sym} 4460 33760 0 0 {name=l27155 lab=VSS}
C {bitcell_6t.sym} 4600 33800 0 0 {name=Xr169c23}
N 4560 33840 4540 33840 {}
C {lab_pin.sym} 4540 33840 0 0 {name=l27156 lab=BL23}
N 4560 33800 4540 33800 {}
C {lab_pin.sym} 4540 33800 0 0 {name=l27157 lab=BLB23}
N 4560 33760 4540 33760 {}
C {lab_pin.sym} 4540 33760 0 0 {name=l27158 lab=WL169}
N 4640 33840 4660 33840 {}
C {lab_pin.sym} 4660 33840 0 0 {name=l27159 lab=VDD}
N 4640 33760 4660 33760 {}
C {lab_pin.sym} 4660 33760 0 0 {name=l27160 lab=VSS}
C {bitcell_6t.sym} 4800 33800 0 0 {name=Xr169c24}
N 4760 33840 4740 33840 {}
C {lab_pin.sym} 4740 33840 0 0 {name=l27161 lab=BL24}
N 4760 33800 4740 33800 {}
C {lab_pin.sym} 4740 33800 0 0 {name=l27162 lab=BLB24}
N 4760 33760 4740 33760 {}
C {lab_pin.sym} 4740 33760 0 0 {name=l27163 lab=WL169}
N 4840 33840 4860 33840 {}
C {lab_pin.sym} 4860 33840 0 0 {name=l27164 lab=VDD}
N 4840 33760 4860 33760 {}
C {lab_pin.sym} 4860 33760 0 0 {name=l27165 lab=VSS}
C {bitcell_6t.sym} 5000 33800 0 0 {name=Xr169c25}
N 4960 33840 4940 33840 {}
C {lab_pin.sym} 4940 33840 0 0 {name=l27166 lab=BL25}
N 4960 33800 4940 33800 {}
C {lab_pin.sym} 4940 33800 0 0 {name=l27167 lab=BLB25}
N 4960 33760 4940 33760 {}
C {lab_pin.sym} 4940 33760 0 0 {name=l27168 lab=WL169}
N 5040 33840 5060 33840 {}
C {lab_pin.sym} 5060 33840 0 0 {name=l27169 lab=VDD}
N 5040 33760 5060 33760 {}
C {lab_pin.sym} 5060 33760 0 0 {name=l27170 lab=VSS}
C {bitcell_6t.sym} 5200 33800 0 0 {name=Xr169c26}
N 5160 33840 5140 33840 {}
C {lab_pin.sym} 5140 33840 0 0 {name=l27171 lab=BL26}
N 5160 33800 5140 33800 {}
C {lab_pin.sym} 5140 33800 0 0 {name=l27172 lab=BLB26}
N 5160 33760 5140 33760 {}
C {lab_pin.sym} 5140 33760 0 0 {name=l27173 lab=WL169}
N 5240 33840 5260 33840 {}
C {lab_pin.sym} 5260 33840 0 0 {name=l27174 lab=VDD}
N 5240 33760 5260 33760 {}
C {lab_pin.sym} 5260 33760 0 0 {name=l27175 lab=VSS}
C {bitcell_6t.sym} 5400 33800 0 0 {name=Xr169c27}
N 5360 33840 5340 33840 {}
C {lab_pin.sym} 5340 33840 0 0 {name=l27176 lab=BL27}
N 5360 33800 5340 33800 {}
C {lab_pin.sym} 5340 33800 0 0 {name=l27177 lab=BLB27}
N 5360 33760 5340 33760 {}
C {lab_pin.sym} 5340 33760 0 0 {name=l27178 lab=WL169}
N 5440 33840 5460 33840 {}
C {lab_pin.sym} 5460 33840 0 0 {name=l27179 lab=VDD}
N 5440 33760 5460 33760 {}
C {lab_pin.sym} 5460 33760 0 0 {name=l27180 lab=VSS}
C {bitcell_6t.sym} 5600 33800 0 0 {name=Xr169c28}
N 5560 33840 5540 33840 {}
C {lab_pin.sym} 5540 33840 0 0 {name=l27181 lab=BL28}
N 5560 33800 5540 33800 {}
C {lab_pin.sym} 5540 33800 0 0 {name=l27182 lab=BLB28}
N 5560 33760 5540 33760 {}
C {lab_pin.sym} 5540 33760 0 0 {name=l27183 lab=WL169}
N 5640 33840 5660 33840 {}
C {lab_pin.sym} 5660 33840 0 0 {name=l27184 lab=VDD}
N 5640 33760 5660 33760 {}
C {lab_pin.sym} 5660 33760 0 0 {name=l27185 lab=VSS}
C {bitcell_6t.sym} 5800 33800 0 0 {name=Xr169c29}
N 5760 33840 5740 33840 {}
C {lab_pin.sym} 5740 33840 0 0 {name=l27186 lab=BL29}
N 5760 33800 5740 33800 {}
C {lab_pin.sym} 5740 33800 0 0 {name=l27187 lab=BLB29}
N 5760 33760 5740 33760 {}
C {lab_pin.sym} 5740 33760 0 0 {name=l27188 lab=WL169}
N 5840 33840 5860 33840 {}
C {lab_pin.sym} 5860 33840 0 0 {name=l27189 lab=VDD}
N 5840 33760 5860 33760 {}
C {lab_pin.sym} 5860 33760 0 0 {name=l27190 lab=VSS}
C {bitcell_6t.sym} 6000 33800 0 0 {name=Xr169c30}
N 5960 33840 5940 33840 {}
C {lab_pin.sym} 5940 33840 0 0 {name=l27191 lab=BL30}
N 5960 33800 5940 33800 {}
C {lab_pin.sym} 5940 33800 0 0 {name=l27192 lab=BLB30}
N 5960 33760 5940 33760 {}
C {lab_pin.sym} 5940 33760 0 0 {name=l27193 lab=WL169}
N 6040 33840 6060 33840 {}
C {lab_pin.sym} 6060 33840 0 0 {name=l27194 lab=VDD}
N 6040 33760 6060 33760 {}
C {lab_pin.sym} 6060 33760 0 0 {name=l27195 lab=VSS}
C {bitcell_6t.sym} 6200 33800 0 0 {name=Xr169c31}
N 6160 33840 6140 33840 {}
C {lab_pin.sym} 6140 33840 0 0 {name=l27196 lab=BL31}
N 6160 33800 6140 33800 {}
C {lab_pin.sym} 6140 33800 0 0 {name=l27197 lab=BLB31}
N 6160 33760 6140 33760 {}
C {lab_pin.sym} 6140 33760 0 0 {name=l27198 lab=WL169}
N 6240 33840 6260 33840 {}
C {lab_pin.sym} 6260 33840 0 0 {name=l27199 lab=VDD}
N 6240 33760 6260 33760 {}
C {lab_pin.sym} 6260 33760 0 0 {name=l27200 lab=VSS}
C {bitcell_6t.sym} 0 34000 0 0 {name=Xr170c0}
N -40 34040 -60 34040 {}
C {lab_pin.sym} -60 34040 0 0 {name=l27201 lab=BL0}
N -40 34000 -60 34000 {}
C {lab_pin.sym} -60 34000 0 0 {name=l27202 lab=BLB0}
N -40 33960 -60 33960 {}
C {lab_pin.sym} -60 33960 0 0 {name=l27203 lab=WL170}
N 40 34040 60 34040 {}
C {lab_pin.sym} 60 34040 0 0 {name=l27204 lab=VDD}
N 40 33960 60 33960 {}
C {lab_pin.sym} 60 33960 0 0 {name=l27205 lab=VSS}
C {bitcell_6t.sym} 200 34000 0 0 {name=Xr170c1}
N 160 34040 140 34040 {}
C {lab_pin.sym} 140 34040 0 0 {name=l27206 lab=BL1}
N 160 34000 140 34000 {}
C {lab_pin.sym} 140 34000 0 0 {name=l27207 lab=BLB1}
N 160 33960 140 33960 {}
C {lab_pin.sym} 140 33960 0 0 {name=l27208 lab=WL170}
N 240 34040 260 34040 {}
C {lab_pin.sym} 260 34040 0 0 {name=l27209 lab=VDD}
N 240 33960 260 33960 {}
C {lab_pin.sym} 260 33960 0 0 {name=l27210 lab=VSS}
C {bitcell_6t.sym} 400 34000 0 0 {name=Xr170c2}
N 360 34040 340 34040 {}
C {lab_pin.sym} 340 34040 0 0 {name=l27211 lab=BL2}
N 360 34000 340 34000 {}
C {lab_pin.sym} 340 34000 0 0 {name=l27212 lab=BLB2}
N 360 33960 340 33960 {}
C {lab_pin.sym} 340 33960 0 0 {name=l27213 lab=WL170}
N 440 34040 460 34040 {}
C {lab_pin.sym} 460 34040 0 0 {name=l27214 lab=VDD}
N 440 33960 460 33960 {}
C {lab_pin.sym} 460 33960 0 0 {name=l27215 lab=VSS}
C {bitcell_6t.sym} 600 34000 0 0 {name=Xr170c3}
N 560 34040 540 34040 {}
C {lab_pin.sym} 540 34040 0 0 {name=l27216 lab=BL3}
N 560 34000 540 34000 {}
C {lab_pin.sym} 540 34000 0 0 {name=l27217 lab=BLB3}
N 560 33960 540 33960 {}
C {lab_pin.sym} 540 33960 0 0 {name=l27218 lab=WL170}
N 640 34040 660 34040 {}
C {lab_pin.sym} 660 34040 0 0 {name=l27219 lab=VDD}
N 640 33960 660 33960 {}
C {lab_pin.sym} 660 33960 0 0 {name=l27220 lab=VSS}
C {bitcell_6t.sym} 800 34000 0 0 {name=Xr170c4}
N 760 34040 740 34040 {}
C {lab_pin.sym} 740 34040 0 0 {name=l27221 lab=BL4}
N 760 34000 740 34000 {}
C {lab_pin.sym} 740 34000 0 0 {name=l27222 lab=BLB4}
N 760 33960 740 33960 {}
C {lab_pin.sym} 740 33960 0 0 {name=l27223 lab=WL170}
N 840 34040 860 34040 {}
C {lab_pin.sym} 860 34040 0 0 {name=l27224 lab=VDD}
N 840 33960 860 33960 {}
C {lab_pin.sym} 860 33960 0 0 {name=l27225 lab=VSS}
C {bitcell_6t.sym} 1000 34000 0 0 {name=Xr170c5}
N 960 34040 940 34040 {}
C {lab_pin.sym} 940 34040 0 0 {name=l27226 lab=BL5}
N 960 34000 940 34000 {}
C {lab_pin.sym} 940 34000 0 0 {name=l27227 lab=BLB5}
N 960 33960 940 33960 {}
C {lab_pin.sym} 940 33960 0 0 {name=l27228 lab=WL170}
N 1040 34040 1060 34040 {}
C {lab_pin.sym} 1060 34040 0 0 {name=l27229 lab=VDD}
N 1040 33960 1060 33960 {}
C {lab_pin.sym} 1060 33960 0 0 {name=l27230 lab=VSS}
C {bitcell_6t.sym} 1200 34000 0 0 {name=Xr170c6}
N 1160 34040 1140 34040 {}
C {lab_pin.sym} 1140 34040 0 0 {name=l27231 lab=BL6}
N 1160 34000 1140 34000 {}
C {lab_pin.sym} 1140 34000 0 0 {name=l27232 lab=BLB6}
N 1160 33960 1140 33960 {}
C {lab_pin.sym} 1140 33960 0 0 {name=l27233 lab=WL170}
N 1240 34040 1260 34040 {}
C {lab_pin.sym} 1260 34040 0 0 {name=l27234 lab=VDD}
N 1240 33960 1260 33960 {}
C {lab_pin.sym} 1260 33960 0 0 {name=l27235 lab=VSS}
C {bitcell_6t.sym} 1400 34000 0 0 {name=Xr170c7}
N 1360 34040 1340 34040 {}
C {lab_pin.sym} 1340 34040 0 0 {name=l27236 lab=BL7}
N 1360 34000 1340 34000 {}
C {lab_pin.sym} 1340 34000 0 0 {name=l27237 lab=BLB7}
N 1360 33960 1340 33960 {}
C {lab_pin.sym} 1340 33960 0 0 {name=l27238 lab=WL170}
N 1440 34040 1460 34040 {}
C {lab_pin.sym} 1460 34040 0 0 {name=l27239 lab=VDD}
N 1440 33960 1460 33960 {}
C {lab_pin.sym} 1460 33960 0 0 {name=l27240 lab=VSS}
C {bitcell_6t.sym} 1600 34000 0 0 {name=Xr170c8}
N 1560 34040 1540 34040 {}
C {lab_pin.sym} 1540 34040 0 0 {name=l27241 lab=BL8}
N 1560 34000 1540 34000 {}
C {lab_pin.sym} 1540 34000 0 0 {name=l27242 lab=BLB8}
N 1560 33960 1540 33960 {}
C {lab_pin.sym} 1540 33960 0 0 {name=l27243 lab=WL170}
N 1640 34040 1660 34040 {}
C {lab_pin.sym} 1660 34040 0 0 {name=l27244 lab=VDD}
N 1640 33960 1660 33960 {}
C {lab_pin.sym} 1660 33960 0 0 {name=l27245 lab=VSS}
C {bitcell_6t.sym} 1800 34000 0 0 {name=Xr170c9}
N 1760 34040 1740 34040 {}
C {lab_pin.sym} 1740 34040 0 0 {name=l27246 lab=BL9}
N 1760 34000 1740 34000 {}
C {lab_pin.sym} 1740 34000 0 0 {name=l27247 lab=BLB9}
N 1760 33960 1740 33960 {}
C {lab_pin.sym} 1740 33960 0 0 {name=l27248 lab=WL170}
N 1840 34040 1860 34040 {}
C {lab_pin.sym} 1860 34040 0 0 {name=l27249 lab=VDD}
N 1840 33960 1860 33960 {}
C {lab_pin.sym} 1860 33960 0 0 {name=l27250 lab=VSS}
C {bitcell_6t.sym} 2000 34000 0 0 {name=Xr170c10}
N 1960 34040 1940 34040 {}
C {lab_pin.sym} 1940 34040 0 0 {name=l27251 lab=BL10}
N 1960 34000 1940 34000 {}
C {lab_pin.sym} 1940 34000 0 0 {name=l27252 lab=BLB10}
N 1960 33960 1940 33960 {}
C {lab_pin.sym} 1940 33960 0 0 {name=l27253 lab=WL170}
N 2040 34040 2060 34040 {}
C {lab_pin.sym} 2060 34040 0 0 {name=l27254 lab=VDD}
N 2040 33960 2060 33960 {}
C {lab_pin.sym} 2060 33960 0 0 {name=l27255 lab=VSS}
C {bitcell_6t.sym} 2200 34000 0 0 {name=Xr170c11}
N 2160 34040 2140 34040 {}
C {lab_pin.sym} 2140 34040 0 0 {name=l27256 lab=BL11}
N 2160 34000 2140 34000 {}
C {lab_pin.sym} 2140 34000 0 0 {name=l27257 lab=BLB11}
N 2160 33960 2140 33960 {}
C {lab_pin.sym} 2140 33960 0 0 {name=l27258 lab=WL170}
N 2240 34040 2260 34040 {}
C {lab_pin.sym} 2260 34040 0 0 {name=l27259 lab=VDD}
N 2240 33960 2260 33960 {}
C {lab_pin.sym} 2260 33960 0 0 {name=l27260 lab=VSS}
C {bitcell_6t.sym} 2400 34000 0 0 {name=Xr170c12}
N 2360 34040 2340 34040 {}
C {lab_pin.sym} 2340 34040 0 0 {name=l27261 lab=BL12}
N 2360 34000 2340 34000 {}
C {lab_pin.sym} 2340 34000 0 0 {name=l27262 lab=BLB12}
N 2360 33960 2340 33960 {}
C {lab_pin.sym} 2340 33960 0 0 {name=l27263 lab=WL170}
N 2440 34040 2460 34040 {}
C {lab_pin.sym} 2460 34040 0 0 {name=l27264 lab=VDD}
N 2440 33960 2460 33960 {}
C {lab_pin.sym} 2460 33960 0 0 {name=l27265 lab=VSS}
C {bitcell_6t.sym} 2600 34000 0 0 {name=Xr170c13}
N 2560 34040 2540 34040 {}
C {lab_pin.sym} 2540 34040 0 0 {name=l27266 lab=BL13}
N 2560 34000 2540 34000 {}
C {lab_pin.sym} 2540 34000 0 0 {name=l27267 lab=BLB13}
N 2560 33960 2540 33960 {}
C {lab_pin.sym} 2540 33960 0 0 {name=l27268 lab=WL170}
N 2640 34040 2660 34040 {}
C {lab_pin.sym} 2660 34040 0 0 {name=l27269 lab=VDD}
N 2640 33960 2660 33960 {}
C {lab_pin.sym} 2660 33960 0 0 {name=l27270 lab=VSS}
C {bitcell_6t.sym} 2800 34000 0 0 {name=Xr170c14}
N 2760 34040 2740 34040 {}
C {lab_pin.sym} 2740 34040 0 0 {name=l27271 lab=BL14}
N 2760 34000 2740 34000 {}
C {lab_pin.sym} 2740 34000 0 0 {name=l27272 lab=BLB14}
N 2760 33960 2740 33960 {}
C {lab_pin.sym} 2740 33960 0 0 {name=l27273 lab=WL170}
N 2840 34040 2860 34040 {}
C {lab_pin.sym} 2860 34040 0 0 {name=l27274 lab=VDD}
N 2840 33960 2860 33960 {}
C {lab_pin.sym} 2860 33960 0 0 {name=l27275 lab=VSS}
C {bitcell_6t.sym} 3000 34000 0 0 {name=Xr170c15}
N 2960 34040 2940 34040 {}
C {lab_pin.sym} 2940 34040 0 0 {name=l27276 lab=BL15}
N 2960 34000 2940 34000 {}
C {lab_pin.sym} 2940 34000 0 0 {name=l27277 lab=BLB15}
N 2960 33960 2940 33960 {}
C {lab_pin.sym} 2940 33960 0 0 {name=l27278 lab=WL170}
N 3040 34040 3060 34040 {}
C {lab_pin.sym} 3060 34040 0 0 {name=l27279 lab=VDD}
N 3040 33960 3060 33960 {}
C {lab_pin.sym} 3060 33960 0 0 {name=l27280 lab=VSS}
C {bitcell_6t.sym} 3200 34000 0 0 {name=Xr170c16}
N 3160 34040 3140 34040 {}
C {lab_pin.sym} 3140 34040 0 0 {name=l27281 lab=BL16}
N 3160 34000 3140 34000 {}
C {lab_pin.sym} 3140 34000 0 0 {name=l27282 lab=BLB16}
N 3160 33960 3140 33960 {}
C {lab_pin.sym} 3140 33960 0 0 {name=l27283 lab=WL170}
N 3240 34040 3260 34040 {}
C {lab_pin.sym} 3260 34040 0 0 {name=l27284 lab=VDD}
N 3240 33960 3260 33960 {}
C {lab_pin.sym} 3260 33960 0 0 {name=l27285 lab=VSS}
C {bitcell_6t.sym} 3400 34000 0 0 {name=Xr170c17}
N 3360 34040 3340 34040 {}
C {lab_pin.sym} 3340 34040 0 0 {name=l27286 lab=BL17}
N 3360 34000 3340 34000 {}
C {lab_pin.sym} 3340 34000 0 0 {name=l27287 lab=BLB17}
N 3360 33960 3340 33960 {}
C {lab_pin.sym} 3340 33960 0 0 {name=l27288 lab=WL170}
N 3440 34040 3460 34040 {}
C {lab_pin.sym} 3460 34040 0 0 {name=l27289 lab=VDD}
N 3440 33960 3460 33960 {}
C {lab_pin.sym} 3460 33960 0 0 {name=l27290 lab=VSS}
C {bitcell_6t.sym} 3600 34000 0 0 {name=Xr170c18}
N 3560 34040 3540 34040 {}
C {lab_pin.sym} 3540 34040 0 0 {name=l27291 lab=BL18}
N 3560 34000 3540 34000 {}
C {lab_pin.sym} 3540 34000 0 0 {name=l27292 lab=BLB18}
N 3560 33960 3540 33960 {}
C {lab_pin.sym} 3540 33960 0 0 {name=l27293 lab=WL170}
N 3640 34040 3660 34040 {}
C {lab_pin.sym} 3660 34040 0 0 {name=l27294 lab=VDD}
N 3640 33960 3660 33960 {}
C {lab_pin.sym} 3660 33960 0 0 {name=l27295 lab=VSS}
C {bitcell_6t.sym} 3800 34000 0 0 {name=Xr170c19}
N 3760 34040 3740 34040 {}
C {lab_pin.sym} 3740 34040 0 0 {name=l27296 lab=BL19}
N 3760 34000 3740 34000 {}
C {lab_pin.sym} 3740 34000 0 0 {name=l27297 lab=BLB19}
N 3760 33960 3740 33960 {}
C {lab_pin.sym} 3740 33960 0 0 {name=l27298 lab=WL170}
N 3840 34040 3860 34040 {}
C {lab_pin.sym} 3860 34040 0 0 {name=l27299 lab=VDD}
N 3840 33960 3860 33960 {}
C {lab_pin.sym} 3860 33960 0 0 {name=l27300 lab=VSS}
C {bitcell_6t.sym} 4000 34000 0 0 {name=Xr170c20}
N 3960 34040 3940 34040 {}
C {lab_pin.sym} 3940 34040 0 0 {name=l27301 lab=BL20}
N 3960 34000 3940 34000 {}
C {lab_pin.sym} 3940 34000 0 0 {name=l27302 lab=BLB20}
N 3960 33960 3940 33960 {}
C {lab_pin.sym} 3940 33960 0 0 {name=l27303 lab=WL170}
N 4040 34040 4060 34040 {}
C {lab_pin.sym} 4060 34040 0 0 {name=l27304 lab=VDD}
N 4040 33960 4060 33960 {}
C {lab_pin.sym} 4060 33960 0 0 {name=l27305 lab=VSS}
C {bitcell_6t.sym} 4200 34000 0 0 {name=Xr170c21}
N 4160 34040 4140 34040 {}
C {lab_pin.sym} 4140 34040 0 0 {name=l27306 lab=BL21}
N 4160 34000 4140 34000 {}
C {lab_pin.sym} 4140 34000 0 0 {name=l27307 lab=BLB21}
N 4160 33960 4140 33960 {}
C {lab_pin.sym} 4140 33960 0 0 {name=l27308 lab=WL170}
N 4240 34040 4260 34040 {}
C {lab_pin.sym} 4260 34040 0 0 {name=l27309 lab=VDD}
N 4240 33960 4260 33960 {}
C {lab_pin.sym} 4260 33960 0 0 {name=l27310 lab=VSS}
C {bitcell_6t.sym} 4400 34000 0 0 {name=Xr170c22}
N 4360 34040 4340 34040 {}
C {lab_pin.sym} 4340 34040 0 0 {name=l27311 lab=BL22}
N 4360 34000 4340 34000 {}
C {lab_pin.sym} 4340 34000 0 0 {name=l27312 lab=BLB22}
N 4360 33960 4340 33960 {}
C {lab_pin.sym} 4340 33960 0 0 {name=l27313 lab=WL170}
N 4440 34040 4460 34040 {}
C {lab_pin.sym} 4460 34040 0 0 {name=l27314 lab=VDD}
N 4440 33960 4460 33960 {}
C {lab_pin.sym} 4460 33960 0 0 {name=l27315 lab=VSS}
C {bitcell_6t.sym} 4600 34000 0 0 {name=Xr170c23}
N 4560 34040 4540 34040 {}
C {lab_pin.sym} 4540 34040 0 0 {name=l27316 lab=BL23}
N 4560 34000 4540 34000 {}
C {lab_pin.sym} 4540 34000 0 0 {name=l27317 lab=BLB23}
N 4560 33960 4540 33960 {}
C {lab_pin.sym} 4540 33960 0 0 {name=l27318 lab=WL170}
N 4640 34040 4660 34040 {}
C {lab_pin.sym} 4660 34040 0 0 {name=l27319 lab=VDD}
N 4640 33960 4660 33960 {}
C {lab_pin.sym} 4660 33960 0 0 {name=l27320 lab=VSS}
C {bitcell_6t.sym} 4800 34000 0 0 {name=Xr170c24}
N 4760 34040 4740 34040 {}
C {lab_pin.sym} 4740 34040 0 0 {name=l27321 lab=BL24}
N 4760 34000 4740 34000 {}
C {lab_pin.sym} 4740 34000 0 0 {name=l27322 lab=BLB24}
N 4760 33960 4740 33960 {}
C {lab_pin.sym} 4740 33960 0 0 {name=l27323 lab=WL170}
N 4840 34040 4860 34040 {}
C {lab_pin.sym} 4860 34040 0 0 {name=l27324 lab=VDD}
N 4840 33960 4860 33960 {}
C {lab_pin.sym} 4860 33960 0 0 {name=l27325 lab=VSS}
C {bitcell_6t.sym} 5000 34000 0 0 {name=Xr170c25}
N 4960 34040 4940 34040 {}
C {lab_pin.sym} 4940 34040 0 0 {name=l27326 lab=BL25}
N 4960 34000 4940 34000 {}
C {lab_pin.sym} 4940 34000 0 0 {name=l27327 lab=BLB25}
N 4960 33960 4940 33960 {}
C {lab_pin.sym} 4940 33960 0 0 {name=l27328 lab=WL170}
N 5040 34040 5060 34040 {}
C {lab_pin.sym} 5060 34040 0 0 {name=l27329 lab=VDD}
N 5040 33960 5060 33960 {}
C {lab_pin.sym} 5060 33960 0 0 {name=l27330 lab=VSS}
C {bitcell_6t.sym} 5200 34000 0 0 {name=Xr170c26}
N 5160 34040 5140 34040 {}
C {lab_pin.sym} 5140 34040 0 0 {name=l27331 lab=BL26}
N 5160 34000 5140 34000 {}
C {lab_pin.sym} 5140 34000 0 0 {name=l27332 lab=BLB26}
N 5160 33960 5140 33960 {}
C {lab_pin.sym} 5140 33960 0 0 {name=l27333 lab=WL170}
N 5240 34040 5260 34040 {}
C {lab_pin.sym} 5260 34040 0 0 {name=l27334 lab=VDD}
N 5240 33960 5260 33960 {}
C {lab_pin.sym} 5260 33960 0 0 {name=l27335 lab=VSS}
C {bitcell_6t.sym} 5400 34000 0 0 {name=Xr170c27}
N 5360 34040 5340 34040 {}
C {lab_pin.sym} 5340 34040 0 0 {name=l27336 lab=BL27}
N 5360 34000 5340 34000 {}
C {lab_pin.sym} 5340 34000 0 0 {name=l27337 lab=BLB27}
N 5360 33960 5340 33960 {}
C {lab_pin.sym} 5340 33960 0 0 {name=l27338 lab=WL170}
N 5440 34040 5460 34040 {}
C {lab_pin.sym} 5460 34040 0 0 {name=l27339 lab=VDD}
N 5440 33960 5460 33960 {}
C {lab_pin.sym} 5460 33960 0 0 {name=l27340 lab=VSS}
C {bitcell_6t.sym} 5600 34000 0 0 {name=Xr170c28}
N 5560 34040 5540 34040 {}
C {lab_pin.sym} 5540 34040 0 0 {name=l27341 lab=BL28}
N 5560 34000 5540 34000 {}
C {lab_pin.sym} 5540 34000 0 0 {name=l27342 lab=BLB28}
N 5560 33960 5540 33960 {}
C {lab_pin.sym} 5540 33960 0 0 {name=l27343 lab=WL170}
N 5640 34040 5660 34040 {}
C {lab_pin.sym} 5660 34040 0 0 {name=l27344 lab=VDD}
N 5640 33960 5660 33960 {}
C {lab_pin.sym} 5660 33960 0 0 {name=l27345 lab=VSS}
C {bitcell_6t.sym} 5800 34000 0 0 {name=Xr170c29}
N 5760 34040 5740 34040 {}
C {lab_pin.sym} 5740 34040 0 0 {name=l27346 lab=BL29}
N 5760 34000 5740 34000 {}
C {lab_pin.sym} 5740 34000 0 0 {name=l27347 lab=BLB29}
N 5760 33960 5740 33960 {}
C {lab_pin.sym} 5740 33960 0 0 {name=l27348 lab=WL170}
N 5840 34040 5860 34040 {}
C {lab_pin.sym} 5860 34040 0 0 {name=l27349 lab=VDD}
N 5840 33960 5860 33960 {}
C {lab_pin.sym} 5860 33960 0 0 {name=l27350 lab=VSS}
C {bitcell_6t.sym} 6000 34000 0 0 {name=Xr170c30}
N 5960 34040 5940 34040 {}
C {lab_pin.sym} 5940 34040 0 0 {name=l27351 lab=BL30}
N 5960 34000 5940 34000 {}
C {lab_pin.sym} 5940 34000 0 0 {name=l27352 lab=BLB30}
N 5960 33960 5940 33960 {}
C {lab_pin.sym} 5940 33960 0 0 {name=l27353 lab=WL170}
N 6040 34040 6060 34040 {}
C {lab_pin.sym} 6060 34040 0 0 {name=l27354 lab=VDD}
N 6040 33960 6060 33960 {}
C {lab_pin.sym} 6060 33960 0 0 {name=l27355 lab=VSS}
C {bitcell_6t.sym} 6200 34000 0 0 {name=Xr170c31}
N 6160 34040 6140 34040 {}
C {lab_pin.sym} 6140 34040 0 0 {name=l27356 lab=BL31}
N 6160 34000 6140 34000 {}
C {lab_pin.sym} 6140 34000 0 0 {name=l27357 lab=BLB31}
N 6160 33960 6140 33960 {}
C {lab_pin.sym} 6140 33960 0 0 {name=l27358 lab=WL170}
N 6240 34040 6260 34040 {}
C {lab_pin.sym} 6260 34040 0 0 {name=l27359 lab=VDD}
N 6240 33960 6260 33960 {}
C {lab_pin.sym} 6260 33960 0 0 {name=l27360 lab=VSS}
C {bitcell_6t.sym} 0 34200 0 0 {name=Xr171c0}
N -40 34240 -60 34240 {}
C {lab_pin.sym} -60 34240 0 0 {name=l27361 lab=BL0}
N -40 34200 -60 34200 {}
C {lab_pin.sym} -60 34200 0 0 {name=l27362 lab=BLB0}
N -40 34160 -60 34160 {}
C {lab_pin.sym} -60 34160 0 0 {name=l27363 lab=WL171}
N 40 34240 60 34240 {}
C {lab_pin.sym} 60 34240 0 0 {name=l27364 lab=VDD}
N 40 34160 60 34160 {}
C {lab_pin.sym} 60 34160 0 0 {name=l27365 lab=VSS}
C {bitcell_6t.sym} 200 34200 0 0 {name=Xr171c1}
N 160 34240 140 34240 {}
C {lab_pin.sym} 140 34240 0 0 {name=l27366 lab=BL1}
N 160 34200 140 34200 {}
C {lab_pin.sym} 140 34200 0 0 {name=l27367 lab=BLB1}
N 160 34160 140 34160 {}
C {lab_pin.sym} 140 34160 0 0 {name=l27368 lab=WL171}
N 240 34240 260 34240 {}
C {lab_pin.sym} 260 34240 0 0 {name=l27369 lab=VDD}
N 240 34160 260 34160 {}
C {lab_pin.sym} 260 34160 0 0 {name=l27370 lab=VSS}
C {bitcell_6t.sym} 400 34200 0 0 {name=Xr171c2}
N 360 34240 340 34240 {}
C {lab_pin.sym} 340 34240 0 0 {name=l27371 lab=BL2}
N 360 34200 340 34200 {}
C {lab_pin.sym} 340 34200 0 0 {name=l27372 lab=BLB2}
N 360 34160 340 34160 {}
C {lab_pin.sym} 340 34160 0 0 {name=l27373 lab=WL171}
N 440 34240 460 34240 {}
C {lab_pin.sym} 460 34240 0 0 {name=l27374 lab=VDD}
N 440 34160 460 34160 {}
C {lab_pin.sym} 460 34160 0 0 {name=l27375 lab=VSS}
C {bitcell_6t.sym} 600 34200 0 0 {name=Xr171c3}
N 560 34240 540 34240 {}
C {lab_pin.sym} 540 34240 0 0 {name=l27376 lab=BL3}
N 560 34200 540 34200 {}
C {lab_pin.sym} 540 34200 0 0 {name=l27377 lab=BLB3}
N 560 34160 540 34160 {}
C {lab_pin.sym} 540 34160 0 0 {name=l27378 lab=WL171}
N 640 34240 660 34240 {}
C {lab_pin.sym} 660 34240 0 0 {name=l27379 lab=VDD}
N 640 34160 660 34160 {}
C {lab_pin.sym} 660 34160 0 0 {name=l27380 lab=VSS}
C {bitcell_6t.sym} 800 34200 0 0 {name=Xr171c4}
N 760 34240 740 34240 {}
C {lab_pin.sym} 740 34240 0 0 {name=l27381 lab=BL4}
N 760 34200 740 34200 {}
C {lab_pin.sym} 740 34200 0 0 {name=l27382 lab=BLB4}
N 760 34160 740 34160 {}
C {lab_pin.sym} 740 34160 0 0 {name=l27383 lab=WL171}
N 840 34240 860 34240 {}
C {lab_pin.sym} 860 34240 0 0 {name=l27384 lab=VDD}
N 840 34160 860 34160 {}
C {lab_pin.sym} 860 34160 0 0 {name=l27385 lab=VSS}
C {bitcell_6t.sym} 1000 34200 0 0 {name=Xr171c5}
N 960 34240 940 34240 {}
C {lab_pin.sym} 940 34240 0 0 {name=l27386 lab=BL5}
N 960 34200 940 34200 {}
C {lab_pin.sym} 940 34200 0 0 {name=l27387 lab=BLB5}
N 960 34160 940 34160 {}
C {lab_pin.sym} 940 34160 0 0 {name=l27388 lab=WL171}
N 1040 34240 1060 34240 {}
C {lab_pin.sym} 1060 34240 0 0 {name=l27389 lab=VDD}
N 1040 34160 1060 34160 {}
C {lab_pin.sym} 1060 34160 0 0 {name=l27390 lab=VSS}
C {bitcell_6t.sym} 1200 34200 0 0 {name=Xr171c6}
N 1160 34240 1140 34240 {}
C {lab_pin.sym} 1140 34240 0 0 {name=l27391 lab=BL6}
N 1160 34200 1140 34200 {}
C {lab_pin.sym} 1140 34200 0 0 {name=l27392 lab=BLB6}
N 1160 34160 1140 34160 {}
C {lab_pin.sym} 1140 34160 0 0 {name=l27393 lab=WL171}
N 1240 34240 1260 34240 {}
C {lab_pin.sym} 1260 34240 0 0 {name=l27394 lab=VDD}
N 1240 34160 1260 34160 {}
C {lab_pin.sym} 1260 34160 0 0 {name=l27395 lab=VSS}
C {bitcell_6t.sym} 1400 34200 0 0 {name=Xr171c7}
N 1360 34240 1340 34240 {}
C {lab_pin.sym} 1340 34240 0 0 {name=l27396 lab=BL7}
N 1360 34200 1340 34200 {}
C {lab_pin.sym} 1340 34200 0 0 {name=l27397 lab=BLB7}
N 1360 34160 1340 34160 {}
C {lab_pin.sym} 1340 34160 0 0 {name=l27398 lab=WL171}
N 1440 34240 1460 34240 {}
C {lab_pin.sym} 1460 34240 0 0 {name=l27399 lab=VDD}
N 1440 34160 1460 34160 {}
C {lab_pin.sym} 1460 34160 0 0 {name=l27400 lab=VSS}
C {bitcell_6t.sym} 1600 34200 0 0 {name=Xr171c8}
N 1560 34240 1540 34240 {}
C {lab_pin.sym} 1540 34240 0 0 {name=l27401 lab=BL8}
N 1560 34200 1540 34200 {}
C {lab_pin.sym} 1540 34200 0 0 {name=l27402 lab=BLB8}
N 1560 34160 1540 34160 {}
C {lab_pin.sym} 1540 34160 0 0 {name=l27403 lab=WL171}
N 1640 34240 1660 34240 {}
C {lab_pin.sym} 1660 34240 0 0 {name=l27404 lab=VDD}
N 1640 34160 1660 34160 {}
C {lab_pin.sym} 1660 34160 0 0 {name=l27405 lab=VSS}
C {bitcell_6t.sym} 1800 34200 0 0 {name=Xr171c9}
N 1760 34240 1740 34240 {}
C {lab_pin.sym} 1740 34240 0 0 {name=l27406 lab=BL9}
N 1760 34200 1740 34200 {}
C {lab_pin.sym} 1740 34200 0 0 {name=l27407 lab=BLB9}
N 1760 34160 1740 34160 {}
C {lab_pin.sym} 1740 34160 0 0 {name=l27408 lab=WL171}
N 1840 34240 1860 34240 {}
C {lab_pin.sym} 1860 34240 0 0 {name=l27409 lab=VDD}
N 1840 34160 1860 34160 {}
C {lab_pin.sym} 1860 34160 0 0 {name=l27410 lab=VSS}
C {bitcell_6t.sym} 2000 34200 0 0 {name=Xr171c10}
N 1960 34240 1940 34240 {}
C {lab_pin.sym} 1940 34240 0 0 {name=l27411 lab=BL10}
N 1960 34200 1940 34200 {}
C {lab_pin.sym} 1940 34200 0 0 {name=l27412 lab=BLB10}
N 1960 34160 1940 34160 {}
C {lab_pin.sym} 1940 34160 0 0 {name=l27413 lab=WL171}
N 2040 34240 2060 34240 {}
C {lab_pin.sym} 2060 34240 0 0 {name=l27414 lab=VDD}
N 2040 34160 2060 34160 {}
C {lab_pin.sym} 2060 34160 0 0 {name=l27415 lab=VSS}
C {bitcell_6t.sym} 2200 34200 0 0 {name=Xr171c11}
N 2160 34240 2140 34240 {}
C {lab_pin.sym} 2140 34240 0 0 {name=l27416 lab=BL11}
N 2160 34200 2140 34200 {}
C {lab_pin.sym} 2140 34200 0 0 {name=l27417 lab=BLB11}
N 2160 34160 2140 34160 {}
C {lab_pin.sym} 2140 34160 0 0 {name=l27418 lab=WL171}
N 2240 34240 2260 34240 {}
C {lab_pin.sym} 2260 34240 0 0 {name=l27419 lab=VDD}
N 2240 34160 2260 34160 {}
C {lab_pin.sym} 2260 34160 0 0 {name=l27420 lab=VSS}
C {bitcell_6t.sym} 2400 34200 0 0 {name=Xr171c12}
N 2360 34240 2340 34240 {}
C {lab_pin.sym} 2340 34240 0 0 {name=l27421 lab=BL12}
N 2360 34200 2340 34200 {}
C {lab_pin.sym} 2340 34200 0 0 {name=l27422 lab=BLB12}
N 2360 34160 2340 34160 {}
C {lab_pin.sym} 2340 34160 0 0 {name=l27423 lab=WL171}
N 2440 34240 2460 34240 {}
C {lab_pin.sym} 2460 34240 0 0 {name=l27424 lab=VDD}
N 2440 34160 2460 34160 {}
C {lab_pin.sym} 2460 34160 0 0 {name=l27425 lab=VSS}
C {bitcell_6t.sym} 2600 34200 0 0 {name=Xr171c13}
N 2560 34240 2540 34240 {}
C {lab_pin.sym} 2540 34240 0 0 {name=l27426 lab=BL13}
N 2560 34200 2540 34200 {}
C {lab_pin.sym} 2540 34200 0 0 {name=l27427 lab=BLB13}
N 2560 34160 2540 34160 {}
C {lab_pin.sym} 2540 34160 0 0 {name=l27428 lab=WL171}
N 2640 34240 2660 34240 {}
C {lab_pin.sym} 2660 34240 0 0 {name=l27429 lab=VDD}
N 2640 34160 2660 34160 {}
C {lab_pin.sym} 2660 34160 0 0 {name=l27430 lab=VSS}
C {bitcell_6t.sym} 2800 34200 0 0 {name=Xr171c14}
N 2760 34240 2740 34240 {}
C {lab_pin.sym} 2740 34240 0 0 {name=l27431 lab=BL14}
N 2760 34200 2740 34200 {}
C {lab_pin.sym} 2740 34200 0 0 {name=l27432 lab=BLB14}
N 2760 34160 2740 34160 {}
C {lab_pin.sym} 2740 34160 0 0 {name=l27433 lab=WL171}
N 2840 34240 2860 34240 {}
C {lab_pin.sym} 2860 34240 0 0 {name=l27434 lab=VDD}
N 2840 34160 2860 34160 {}
C {lab_pin.sym} 2860 34160 0 0 {name=l27435 lab=VSS}
C {bitcell_6t.sym} 3000 34200 0 0 {name=Xr171c15}
N 2960 34240 2940 34240 {}
C {lab_pin.sym} 2940 34240 0 0 {name=l27436 lab=BL15}
N 2960 34200 2940 34200 {}
C {lab_pin.sym} 2940 34200 0 0 {name=l27437 lab=BLB15}
N 2960 34160 2940 34160 {}
C {lab_pin.sym} 2940 34160 0 0 {name=l27438 lab=WL171}
N 3040 34240 3060 34240 {}
C {lab_pin.sym} 3060 34240 0 0 {name=l27439 lab=VDD}
N 3040 34160 3060 34160 {}
C {lab_pin.sym} 3060 34160 0 0 {name=l27440 lab=VSS}
C {bitcell_6t.sym} 3200 34200 0 0 {name=Xr171c16}
N 3160 34240 3140 34240 {}
C {lab_pin.sym} 3140 34240 0 0 {name=l27441 lab=BL16}
N 3160 34200 3140 34200 {}
C {lab_pin.sym} 3140 34200 0 0 {name=l27442 lab=BLB16}
N 3160 34160 3140 34160 {}
C {lab_pin.sym} 3140 34160 0 0 {name=l27443 lab=WL171}
N 3240 34240 3260 34240 {}
C {lab_pin.sym} 3260 34240 0 0 {name=l27444 lab=VDD}
N 3240 34160 3260 34160 {}
C {lab_pin.sym} 3260 34160 0 0 {name=l27445 lab=VSS}
C {bitcell_6t.sym} 3400 34200 0 0 {name=Xr171c17}
N 3360 34240 3340 34240 {}
C {lab_pin.sym} 3340 34240 0 0 {name=l27446 lab=BL17}
N 3360 34200 3340 34200 {}
C {lab_pin.sym} 3340 34200 0 0 {name=l27447 lab=BLB17}
N 3360 34160 3340 34160 {}
C {lab_pin.sym} 3340 34160 0 0 {name=l27448 lab=WL171}
N 3440 34240 3460 34240 {}
C {lab_pin.sym} 3460 34240 0 0 {name=l27449 lab=VDD}
N 3440 34160 3460 34160 {}
C {lab_pin.sym} 3460 34160 0 0 {name=l27450 lab=VSS}
C {bitcell_6t.sym} 3600 34200 0 0 {name=Xr171c18}
N 3560 34240 3540 34240 {}
C {lab_pin.sym} 3540 34240 0 0 {name=l27451 lab=BL18}
N 3560 34200 3540 34200 {}
C {lab_pin.sym} 3540 34200 0 0 {name=l27452 lab=BLB18}
N 3560 34160 3540 34160 {}
C {lab_pin.sym} 3540 34160 0 0 {name=l27453 lab=WL171}
N 3640 34240 3660 34240 {}
C {lab_pin.sym} 3660 34240 0 0 {name=l27454 lab=VDD}
N 3640 34160 3660 34160 {}
C {lab_pin.sym} 3660 34160 0 0 {name=l27455 lab=VSS}
C {bitcell_6t.sym} 3800 34200 0 0 {name=Xr171c19}
N 3760 34240 3740 34240 {}
C {lab_pin.sym} 3740 34240 0 0 {name=l27456 lab=BL19}
N 3760 34200 3740 34200 {}
C {lab_pin.sym} 3740 34200 0 0 {name=l27457 lab=BLB19}
N 3760 34160 3740 34160 {}
C {lab_pin.sym} 3740 34160 0 0 {name=l27458 lab=WL171}
N 3840 34240 3860 34240 {}
C {lab_pin.sym} 3860 34240 0 0 {name=l27459 lab=VDD}
N 3840 34160 3860 34160 {}
C {lab_pin.sym} 3860 34160 0 0 {name=l27460 lab=VSS}
C {bitcell_6t.sym} 4000 34200 0 0 {name=Xr171c20}
N 3960 34240 3940 34240 {}
C {lab_pin.sym} 3940 34240 0 0 {name=l27461 lab=BL20}
N 3960 34200 3940 34200 {}
C {lab_pin.sym} 3940 34200 0 0 {name=l27462 lab=BLB20}
N 3960 34160 3940 34160 {}
C {lab_pin.sym} 3940 34160 0 0 {name=l27463 lab=WL171}
N 4040 34240 4060 34240 {}
C {lab_pin.sym} 4060 34240 0 0 {name=l27464 lab=VDD}
N 4040 34160 4060 34160 {}
C {lab_pin.sym} 4060 34160 0 0 {name=l27465 lab=VSS}
C {bitcell_6t.sym} 4200 34200 0 0 {name=Xr171c21}
N 4160 34240 4140 34240 {}
C {lab_pin.sym} 4140 34240 0 0 {name=l27466 lab=BL21}
N 4160 34200 4140 34200 {}
C {lab_pin.sym} 4140 34200 0 0 {name=l27467 lab=BLB21}
N 4160 34160 4140 34160 {}
C {lab_pin.sym} 4140 34160 0 0 {name=l27468 lab=WL171}
N 4240 34240 4260 34240 {}
C {lab_pin.sym} 4260 34240 0 0 {name=l27469 lab=VDD}
N 4240 34160 4260 34160 {}
C {lab_pin.sym} 4260 34160 0 0 {name=l27470 lab=VSS}
C {bitcell_6t.sym} 4400 34200 0 0 {name=Xr171c22}
N 4360 34240 4340 34240 {}
C {lab_pin.sym} 4340 34240 0 0 {name=l27471 lab=BL22}
N 4360 34200 4340 34200 {}
C {lab_pin.sym} 4340 34200 0 0 {name=l27472 lab=BLB22}
N 4360 34160 4340 34160 {}
C {lab_pin.sym} 4340 34160 0 0 {name=l27473 lab=WL171}
N 4440 34240 4460 34240 {}
C {lab_pin.sym} 4460 34240 0 0 {name=l27474 lab=VDD}
N 4440 34160 4460 34160 {}
C {lab_pin.sym} 4460 34160 0 0 {name=l27475 lab=VSS}
C {bitcell_6t.sym} 4600 34200 0 0 {name=Xr171c23}
N 4560 34240 4540 34240 {}
C {lab_pin.sym} 4540 34240 0 0 {name=l27476 lab=BL23}
N 4560 34200 4540 34200 {}
C {lab_pin.sym} 4540 34200 0 0 {name=l27477 lab=BLB23}
N 4560 34160 4540 34160 {}
C {lab_pin.sym} 4540 34160 0 0 {name=l27478 lab=WL171}
N 4640 34240 4660 34240 {}
C {lab_pin.sym} 4660 34240 0 0 {name=l27479 lab=VDD}
N 4640 34160 4660 34160 {}
C {lab_pin.sym} 4660 34160 0 0 {name=l27480 lab=VSS}
C {bitcell_6t.sym} 4800 34200 0 0 {name=Xr171c24}
N 4760 34240 4740 34240 {}
C {lab_pin.sym} 4740 34240 0 0 {name=l27481 lab=BL24}
N 4760 34200 4740 34200 {}
C {lab_pin.sym} 4740 34200 0 0 {name=l27482 lab=BLB24}
N 4760 34160 4740 34160 {}
C {lab_pin.sym} 4740 34160 0 0 {name=l27483 lab=WL171}
N 4840 34240 4860 34240 {}
C {lab_pin.sym} 4860 34240 0 0 {name=l27484 lab=VDD}
N 4840 34160 4860 34160 {}
C {lab_pin.sym} 4860 34160 0 0 {name=l27485 lab=VSS}
C {bitcell_6t.sym} 5000 34200 0 0 {name=Xr171c25}
N 4960 34240 4940 34240 {}
C {lab_pin.sym} 4940 34240 0 0 {name=l27486 lab=BL25}
N 4960 34200 4940 34200 {}
C {lab_pin.sym} 4940 34200 0 0 {name=l27487 lab=BLB25}
N 4960 34160 4940 34160 {}
C {lab_pin.sym} 4940 34160 0 0 {name=l27488 lab=WL171}
N 5040 34240 5060 34240 {}
C {lab_pin.sym} 5060 34240 0 0 {name=l27489 lab=VDD}
N 5040 34160 5060 34160 {}
C {lab_pin.sym} 5060 34160 0 0 {name=l27490 lab=VSS}
C {bitcell_6t.sym} 5200 34200 0 0 {name=Xr171c26}
N 5160 34240 5140 34240 {}
C {lab_pin.sym} 5140 34240 0 0 {name=l27491 lab=BL26}
N 5160 34200 5140 34200 {}
C {lab_pin.sym} 5140 34200 0 0 {name=l27492 lab=BLB26}
N 5160 34160 5140 34160 {}
C {lab_pin.sym} 5140 34160 0 0 {name=l27493 lab=WL171}
N 5240 34240 5260 34240 {}
C {lab_pin.sym} 5260 34240 0 0 {name=l27494 lab=VDD}
N 5240 34160 5260 34160 {}
C {lab_pin.sym} 5260 34160 0 0 {name=l27495 lab=VSS}
C {bitcell_6t.sym} 5400 34200 0 0 {name=Xr171c27}
N 5360 34240 5340 34240 {}
C {lab_pin.sym} 5340 34240 0 0 {name=l27496 lab=BL27}
N 5360 34200 5340 34200 {}
C {lab_pin.sym} 5340 34200 0 0 {name=l27497 lab=BLB27}
N 5360 34160 5340 34160 {}
C {lab_pin.sym} 5340 34160 0 0 {name=l27498 lab=WL171}
N 5440 34240 5460 34240 {}
C {lab_pin.sym} 5460 34240 0 0 {name=l27499 lab=VDD}
N 5440 34160 5460 34160 {}
C {lab_pin.sym} 5460 34160 0 0 {name=l27500 lab=VSS}
C {bitcell_6t.sym} 5600 34200 0 0 {name=Xr171c28}
N 5560 34240 5540 34240 {}
C {lab_pin.sym} 5540 34240 0 0 {name=l27501 lab=BL28}
N 5560 34200 5540 34200 {}
C {lab_pin.sym} 5540 34200 0 0 {name=l27502 lab=BLB28}
N 5560 34160 5540 34160 {}
C {lab_pin.sym} 5540 34160 0 0 {name=l27503 lab=WL171}
N 5640 34240 5660 34240 {}
C {lab_pin.sym} 5660 34240 0 0 {name=l27504 lab=VDD}
N 5640 34160 5660 34160 {}
C {lab_pin.sym} 5660 34160 0 0 {name=l27505 lab=VSS}
C {bitcell_6t.sym} 5800 34200 0 0 {name=Xr171c29}
N 5760 34240 5740 34240 {}
C {lab_pin.sym} 5740 34240 0 0 {name=l27506 lab=BL29}
N 5760 34200 5740 34200 {}
C {lab_pin.sym} 5740 34200 0 0 {name=l27507 lab=BLB29}
N 5760 34160 5740 34160 {}
C {lab_pin.sym} 5740 34160 0 0 {name=l27508 lab=WL171}
N 5840 34240 5860 34240 {}
C {lab_pin.sym} 5860 34240 0 0 {name=l27509 lab=VDD}
N 5840 34160 5860 34160 {}
C {lab_pin.sym} 5860 34160 0 0 {name=l27510 lab=VSS}
C {bitcell_6t.sym} 6000 34200 0 0 {name=Xr171c30}
N 5960 34240 5940 34240 {}
C {lab_pin.sym} 5940 34240 0 0 {name=l27511 lab=BL30}
N 5960 34200 5940 34200 {}
C {lab_pin.sym} 5940 34200 0 0 {name=l27512 lab=BLB30}
N 5960 34160 5940 34160 {}
C {lab_pin.sym} 5940 34160 0 0 {name=l27513 lab=WL171}
N 6040 34240 6060 34240 {}
C {lab_pin.sym} 6060 34240 0 0 {name=l27514 lab=VDD}
N 6040 34160 6060 34160 {}
C {lab_pin.sym} 6060 34160 0 0 {name=l27515 lab=VSS}
C {bitcell_6t.sym} 6200 34200 0 0 {name=Xr171c31}
N 6160 34240 6140 34240 {}
C {lab_pin.sym} 6140 34240 0 0 {name=l27516 lab=BL31}
N 6160 34200 6140 34200 {}
C {lab_pin.sym} 6140 34200 0 0 {name=l27517 lab=BLB31}
N 6160 34160 6140 34160 {}
C {lab_pin.sym} 6140 34160 0 0 {name=l27518 lab=WL171}
N 6240 34240 6260 34240 {}
C {lab_pin.sym} 6260 34240 0 0 {name=l27519 lab=VDD}
N 6240 34160 6260 34160 {}
C {lab_pin.sym} 6260 34160 0 0 {name=l27520 lab=VSS}
C {bitcell_6t.sym} 0 34400 0 0 {name=Xr172c0}
N -40 34440 -60 34440 {}
C {lab_pin.sym} -60 34440 0 0 {name=l27521 lab=BL0}
N -40 34400 -60 34400 {}
C {lab_pin.sym} -60 34400 0 0 {name=l27522 lab=BLB0}
N -40 34360 -60 34360 {}
C {lab_pin.sym} -60 34360 0 0 {name=l27523 lab=WL172}
N 40 34440 60 34440 {}
C {lab_pin.sym} 60 34440 0 0 {name=l27524 lab=VDD}
N 40 34360 60 34360 {}
C {lab_pin.sym} 60 34360 0 0 {name=l27525 lab=VSS}
C {bitcell_6t.sym} 200 34400 0 0 {name=Xr172c1}
N 160 34440 140 34440 {}
C {lab_pin.sym} 140 34440 0 0 {name=l27526 lab=BL1}
N 160 34400 140 34400 {}
C {lab_pin.sym} 140 34400 0 0 {name=l27527 lab=BLB1}
N 160 34360 140 34360 {}
C {lab_pin.sym} 140 34360 0 0 {name=l27528 lab=WL172}
N 240 34440 260 34440 {}
C {lab_pin.sym} 260 34440 0 0 {name=l27529 lab=VDD}
N 240 34360 260 34360 {}
C {lab_pin.sym} 260 34360 0 0 {name=l27530 lab=VSS}
C {bitcell_6t.sym} 400 34400 0 0 {name=Xr172c2}
N 360 34440 340 34440 {}
C {lab_pin.sym} 340 34440 0 0 {name=l27531 lab=BL2}
N 360 34400 340 34400 {}
C {lab_pin.sym} 340 34400 0 0 {name=l27532 lab=BLB2}
N 360 34360 340 34360 {}
C {lab_pin.sym} 340 34360 0 0 {name=l27533 lab=WL172}
N 440 34440 460 34440 {}
C {lab_pin.sym} 460 34440 0 0 {name=l27534 lab=VDD}
N 440 34360 460 34360 {}
C {lab_pin.sym} 460 34360 0 0 {name=l27535 lab=VSS}
C {bitcell_6t.sym} 600 34400 0 0 {name=Xr172c3}
N 560 34440 540 34440 {}
C {lab_pin.sym} 540 34440 0 0 {name=l27536 lab=BL3}
N 560 34400 540 34400 {}
C {lab_pin.sym} 540 34400 0 0 {name=l27537 lab=BLB3}
N 560 34360 540 34360 {}
C {lab_pin.sym} 540 34360 0 0 {name=l27538 lab=WL172}
N 640 34440 660 34440 {}
C {lab_pin.sym} 660 34440 0 0 {name=l27539 lab=VDD}
N 640 34360 660 34360 {}
C {lab_pin.sym} 660 34360 0 0 {name=l27540 lab=VSS}
C {bitcell_6t.sym} 800 34400 0 0 {name=Xr172c4}
N 760 34440 740 34440 {}
C {lab_pin.sym} 740 34440 0 0 {name=l27541 lab=BL4}
N 760 34400 740 34400 {}
C {lab_pin.sym} 740 34400 0 0 {name=l27542 lab=BLB4}
N 760 34360 740 34360 {}
C {lab_pin.sym} 740 34360 0 0 {name=l27543 lab=WL172}
N 840 34440 860 34440 {}
C {lab_pin.sym} 860 34440 0 0 {name=l27544 lab=VDD}
N 840 34360 860 34360 {}
C {lab_pin.sym} 860 34360 0 0 {name=l27545 lab=VSS}
C {bitcell_6t.sym} 1000 34400 0 0 {name=Xr172c5}
N 960 34440 940 34440 {}
C {lab_pin.sym} 940 34440 0 0 {name=l27546 lab=BL5}
N 960 34400 940 34400 {}
C {lab_pin.sym} 940 34400 0 0 {name=l27547 lab=BLB5}
N 960 34360 940 34360 {}
C {lab_pin.sym} 940 34360 0 0 {name=l27548 lab=WL172}
N 1040 34440 1060 34440 {}
C {lab_pin.sym} 1060 34440 0 0 {name=l27549 lab=VDD}
N 1040 34360 1060 34360 {}
C {lab_pin.sym} 1060 34360 0 0 {name=l27550 lab=VSS}
C {bitcell_6t.sym} 1200 34400 0 0 {name=Xr172c6}
N 1160 34440 1140 34440 {}
C {lab_pin.sym} 1140 34440 0 0 {name=l27551 lab=BL6}
N 1160 34400 1140 34400 {}
C {lab_pin.sym} 1140 34400 0 0 {name=l27552 lab=BLB6}
N 1160 34360 1140 34360 {}
C {lab_pin.sym} 1140 34360 0 0 {name=l27553 lab=WL172}
N 1240 34440 1260 34440 {}
C {lab_pin.sym} 1260 34440 0 0 {name=l27554 lab=VDD}
N 1240 34360 1260 34360 {}
C {lab_pin.sym} 1260 34360 0 0 {name=l27555 lab=VSS}
C {bitcell_6t.sym} 1400 34400 0 0 {name=Xr172c7}
N 1360 34440 1340 34440 {}
C {lab_pin.sym} 1340 34440 0 0 {name=l27556 lab=BL7}
N 1360 34400 1340 34400 {}
C {lab_pin.sym} 1340 34400 0 0 {name=l27557 lab=BLB7}
N 1360 34360 1340 34360 {}
C {lab_pin.sym} 1340 34360 0 0 {name=l27558 lab=WL172}
N 1440 34440 1460 34440 {}
C {lab_pin.sym} 1460 34440 0 0 {name=l27559 lab=VDD}
N 1440 34360 1460 34360 {}
C {lab_pin.sym} 1460 34360 0 0 {name=l27560 lab=VSS}
C {bitcell_6t.sym} 1600 34400 0 0 {name=Xr172c8}
N 1560 34440 1540 34440 {}
C {lab_pin.sym} 1540 34440 0 0 {name=l27561 lab=BL8}
N 1560 34400 1540 34400 {}
C {lab_pin.sym} 1540 34400 0 0 {name=l27562 lab=BLB8}
N 1560 34360 1540 34360 {}
C {lab_pin.sym} 1540 34360 0 0 {name=l27563 lab=WL172}
N 1640 34440 1660 34440 {}
C {lab_pin.sym} 1660 34440 0 0 {name=l27564 lab=VDD}
N 1640 34360 1660 34360 {}
C {lab_pin.sym} 1660 34360 0 0 {name=l27565 lab=VSS}
C {bitcell_6t.sym} 1800 34400 0 0 {name=Xr172c9}
N 1760 34440 1740 34440 {}
C {lab_pin.sym} 1740 34440 0 0 {name=l27566 lab=BL9}
N 1760 34400 1740 34400 {}
C {lab_pin.sym} 1740 34400 0 0 {name=l27567 lab=BLB9}
N 1760 34360 1740 34360 {}
C {lab_pin.sym} 1740 34360 0 0 {name=l27568 lab=WL172}
N 1840 34440 1860 34440 {}
C {lab_pin.sym} 1860 34440 0 0 {name=l27569 lab=VDD}
N 1840 34360 1860 34360 {}
C {lab_pin.sym} 1860 34360 0 0 {name=l27570 lab=VSS}
C {bitcell_6t.sym} 2000 34400 0 0 {name=Xr172c10}
N 1960 34440 1940 34440 {}
C {lab_pin.sym} 1940 34440 0 0 {name=l27571 lab=BL10}
N 1960 34400 1940 34400 {}
C {lab_pin.sym} 1940 34400 0 0 {name=l27572 lab=BLB10}
N 1960 34360 1940 34360 {}
C {lab_pin.sym} 1940 34360 0 0 {name=l27573 lab=WL172}
N 2040 34440 2060 34440 {}
C {lab_pin.sym} 2060 34440 0 0 {name=l27574 lab=VDD}
N 2040 34360 2060 34360 {}
C {lab_pin.sym} 2060 34360 0 0 {name=l27575 lab=VSS}
C {bitcell_6t.sym} 2200 34400 0 0 {name=Xr172c11}
N 2160 34440 2140 34440 {}
C {lab_pin.sym} 2140 34440 0 0 {name=l27576 lab=BL11}
N 2160 34400 2140 34400 {}
C {lab_pin.sym} 2140 34400 0 0 {name=l27577 lab=BLB11}
N 2160 34360 2140 34360 {}
C {lab_pin.sym} 2140 34360 0 0 {name=l27578 lab=WL172}
N 2240 34440 2260 34440 {}
C {lab_pin.sym} 2260 34440 0 0 {name=l27579 lab=VDD}
N 2240 34360 2260 34360 {}
C {lab_pin.sym} 2260 34360 0 0 {name=l27580 lab=VSS}
C {bitcell_6t.sym} 2400 34400 0 0 {name=Xr172c12}
N 2360 34440 2340 34440 {}
C {lab_pin.sym} 2340 34440 0 0 {name=l27581 lab=BL12}
N 2360 34400 2340 34400 {}
C {lab_pin.sym} 2340 34400 0 0 {name=l27582 lab=BLB12}
N 2360 34360 2340 34360 {}
C {lab_pin.sym} 2340 34360 0 0 {name=l27583 lab=WL172}
N 2440 34440 2460 34440 {}
C {lab_pin.sym} 2460 34440 0 0 {name=l27584 lab=VDD}
N 2440 34360 2460 34360 {}
C {lab_pin.sym} 2460 34360 0 0 {name=l27585 lab=VSS}
C {bitcell_6t.sym} 2600 34400 0 0 {name=Xr172c13}
N 2560 34440 2540 34440 {}
C {lab_pin.sym} 2540 34440 0 0 {name=l27586 lab=BL13}
N 2560 34400 2540 34400 {}
C {lab_pin.sym} 2540 34400 0 0 {name=l27587 lab=BLB13}
N 2560 34360 2540 34360 {}
C {lab_pin.sym} 2540 34360 0 0 {name=l27588 lab=WL172}
N 2640 34440 2660 34440 {}
C {lab_pin.sym} 2660 34440 0 0 {name=l27589 lab=VDD}
N 2640 34360 2660 34360 {}
C {lab_pin.sym} 2660 34360 0 0 {name=l27590 lab=VSS}
C {bitcell_6t.sym} 2800 34400 0 0 {name=Xr172c14}
N 2760 34440 2740 34440 {}
C {lab_pin.sym} 2740 34440 0 0 {name=l27591 lab=BL14}
N 2760 34400 2740 34400 {}
C {lab_pin.sym} 2740 34400 0 0 {name=l27592 lab=BLB14}
N 2760 34360 2740 34360 {}
C {lab_pin.sym} 2740 34360 0 0 {name=l27593 lab=WL172}
N 2840 34440 2860 34440 {}
C {lab_pin.sym} 2860 34440 0 0 {name=l27594 lab=VDD}
N 2840 34360 2860 34360 {}
C {lab_pin.sym} 2860 34360 0 0 {name=l27595 lab=VSS}
C {bitcell_6t.sym} 3000 34400 0 0 {name=Xr172c15}
N 2960 34440 2940 34440 {}
C {lab_pin.sym} 2940 34440 0 0 {name=l27596 lab=BL15}
N 2960 34400 2940 34400 {}
C {lab_pin.sym} 2940 34400 0 0 {name=l27597 lab=BLB15}
N 2960 34360 2940 34360 {}
C {lab_pin.sym} 2940 34360 0 0 {name=l27598 lab=WL172}
N 3040 34440 3060 34440 {}
C {lab_pin.sym} 3060 34440 0 0 {name=l27599 lab=VDD}
N 3040 34360 3060 34360 {}
C {lab_pin.sym} 3060 34360 0 0 {name=l27600 lab=VSS}
C {bitcell_6t.sym} 3200 34400 0 0 {name=Xr172c16}
N 3160 34440 3140 34440 {}
C {lab_pin.sym} 3140 34440 0 0 {name=l27601 lab=BL16}
N 3160 34400 3140 34400 {}
C {lab_pin.sym} 3140 34400 0 0 {name=l27602 lab=BLB16}
N 3160 34360 3140 34360 {}
C {lab_pin.sym} 3140 34360 0 0 {name=l27603 lab=WL172}
N 3240 34440 3260 34440 {}
C {lab_pin.sym} 3260 34440 0 0 {name=l27604 lab=VDD}
N 3240 34360 3260 34360 {}
C {lab_pin.sym} 3260 34360 0 0 {name=l27605 lab=VSS}
C {bitcell_6t.sym} 3400 34400 0 0 {name=Xr172c17}
N 3360 34440 3340 34440 {}
C {lab_pin.sym} 3340 34440 0 0 {name=l27606 lab=BL17}
N 3360 34400 3340 34400 {}
C {lab_pin.sym} 3340 34400 0 0 {name=l27607 lab=BLB17}
N 3360 34360 3340 34360 {}
C {lab_pin.sym} 3340 34360 0 0 {name=l27608 lab=WL172}
N 3440 34440 3460 34440 {}
C {lab_pin.sym} 3460 34440 0 0 {name=l27609 lab=VDD}
N 3440 34360 3460 34360 {}
C {lab_pin.sym} 3460 34360 0 0 {name=l27610 lab=VSS}
C {bitcell_6t.sym} 3600 34400 0 0 {name=Xr172c18}
N 3560 34440 3540 34440 {}
C {lab_pin.sym} 3540 34440 0 0 {name=l27611 lab=BL18}
N 3560 34400 3540 34400 {}
C {lab_pin.sym} 3540 34400 0 0 {name=l27612 lab=BLB18}
N 3560 34360 3540 34360 {}
C {lab_pin.sym} 3540 34360 0 0 {name=l27613 lab=WL172}
N 3640 34440 3660 34440 {}
C {lab_pin.sym} 3660 34440 0 0 {name=l27614 lab=VDD}
N 3640 34360 3660 34360 {}
C {lab_pin.sym} 3660 34360 0 0 {name=l27615 lab=VSS}
C {bitcell_6t.sym} 3800 34400 0 0 {name=Xr172c19}
N 3760 34440 3740 34440 {}
C {lab_pin.sym} 3740 34440 0 0 {name=l27616 lab=BL19}
N 3760 34400 3740 34400 {}
C {lab_pin.sym} 3740 34400 0 0 {name=l27617 lab=BLB19}
N 3760 34360 3740 34360 {}
C {lab_pin.sym} 3740 34360 0 0 {name=l27618 lab=WL172}
N 3840 34440 3860 34440 {}
C {lab_pin.sym} 3860 34440 0 0 {name=l27619 lab=VDD}
N 3840 34360 3860 34360 {}
C {lab_pin.sym} 3860 34360 0 0 {name=l27620 lab=VSS}
C {bitcell_6t.sym} 4000 34400 0 0 {name=Xr172c20}
N 3960 34440 3940 34440 {}
C {lab_pin.sym} 3940 34440 0 0 {name=l27621 lab=BL20}
N 3960 34400 3940 34400 {}
C {lab_pin.sym} 3940 34400 0 0 {name=l27622 lab=BLB20}
N 3960 34360 3940 34360 {}
C {lab_pin.sym} 3940 34360 0 0 {name=l27623 lab=WL172}
N 4040 34440 4060 34440 {}
C {lab_pin.sym} 4060 34440 0 0 {name=l27624 lab=VDD}
N 4040 34360 4060 34360 {}
C {lab_pin.sym} 4060 34360 0 0 {name=l27625 lab=VSS}
C {bitcell_6t.sym} 4200 34400 0 0 {name=Xr172c21}
N 4160 34440 4140 34440 {}
C {lab_pin.sym} 4140 34440 0 0 {name=l27626 lab=BL21}
N 4160 34400 4140 34400 {}
C {lab_pin.sym} 4140 34400 0 0 {name=l27627 lab=BLB21}
N 4160 34360 4140 34360 {}
C {lab_pin.sym} 4140 34360 0 0 {name=l27628 lab=WL172}
N 4240 34440 4260 34440 {}
C {lab_pin.sym} 4260 34440 0 0 {name=l27629 lab=VDD}
N 4240 34360 4260 34360 {}
C {lab_pin.sym} 4260 34360 0 0 {name=l27630 lab=VSS}
C {bitcell_6t.sym} 4400 34400 0 0 {name=Xr172c22}
N 4360 34440 4340 34440 {}
C {lab_pin.sym} 4340 34440 0 0 {name=l27631 lab=BL22}
N 4360 34400 4340 34400 {}
C {lab_pin.sym} 4340 34400 0 0 {name=l27632 lab=BLB22}
N 4360 34360 4340 34360 {}
C {lab_pin.sym} 4340 34360 0 0 {name=l27633 lab=WL172}
N 4440 34440 4460 34440 {}
C {lab_pin.sym} 4460 34440 0 0 {name=l27634 lab=VDD}
N 4440 34360 4460 34360 {}
C {lab_pin.sym} 4460 34360 0 0 {name=l27635 lab=VSS}
C {bitcell_6t.sym} 4600 34400 0 0 {name=Xr172c23}
N 4560 34440 4540 34440 {}
C {lab_pin.sym} 4540 34440 0 0 {name=l27636 lab=BL23}
N 4560 34400 4540 34400 {}
C {lab_pin.sym} 4540 34400 0 0 {name=l27637 lab=BLB23}
N 4560 34360 4540 34360 {}
C {lab_pin.sym} 4540 34360 0 0 {name=l27638 lab=WL172}
N 4640 34440 4660 34440 {}
C {lab_pin.sym} 4660 34440 0 0 {name=l27639 lab=VDD}
N 4640 34360 4660 34360 {}
C {lab_pin.sym} 4660 34360 0 0 {name=l27640 lab=VSS}
C {bitcell_6t.sym} 4800 34400 0 0 {name=Xr172c24}
N 4760 34440 4740 34440 {}
C {lab_pin.sym} 4740 34440 0 0 {name=l27641 lab=BL24}
N 4760 34400 4740 34400 {}
C {lab_pin.sym} 4740 34400 0 0 {name=l27642 lab=BLB24}
N 4760 34360 4740 34360 {}
C {lab_pin.sym} 4740 34360 0 0 {name=l27643 lab=WL172}
N 4840 34440 4860 34440 {}
C {lab_pin.sym} 4860 34440 0 0 {name=l27644 lab=VDD}
N 4840 34360 4860 34360 {}
C {lab_pin.sym} 4860 34360 0 0 {name=l27645 lab=VSS}
C {bitcell_6t.sym} 5000 34400 0 0 {name=Xr172c25}
N 4960 34440 4940 34440 {}
C {lab_pin.sym} 4940 34440 0 0 {name=l27646 lab=BL25}
N 4960 34400 4940 34400 {}
C {lab_pin.sym} 4940 34400 0 0 {name=l27647 lab=BLB25}
N 4960 34360 4940 34360 {}
C {lab_pin.sym} 4940 34360 0 0 {name=l27648 lab=WL172}
N 5040 34440 5060 34440 {}
C {lab_pin.sym} 5060 34440 0 0 {name=l27649 lab=VDD}
N 5040 34360 5060 34360 {}
C {lab_pin.sym} 5060 34360 0 0 {name=l27650 lab=VSS}
C {bitcell_6t.sym} 5200 34400 0 0 {name=Xr172c26}
N 5160 34440 5140 34440 {}
C {lab_pin.sym} 5140 34440 0 0 {name=l27651 lab=BL26}
N 5160 34400 5140 34400 {}
C {lab_pin.sym} 5140 34400 0 0 {name=l27652 lab=BLB26}
N 5160 34360 5140 34360 {}
C {lab_pin.sym} 5140 34360 0 0 {name=l27653 lab=WL172}
N 5240 34440 5260 34440 {}
C {lab_pin.sym} 5260 34440 0 0 {name=l27654 lab=VDD}
N 5240 34360 5260 34360 {}
C {lab_pin.sym} 5260 34360 0 0 {name=l27655 lab=VSS}
C {bitcell_6t.sym} 5400 34400 0 0 {name=Xr172c27}
N 5360 34440 5340 34440 {}
C {lab_pin.sym} 5340 34440 0 0 {name=l27656 lab=BL27}
N 5360 34400 5340 34400 {}
C {lab_pin.sym} 5340 34400 0 0 {name=l27657 lab=BLB27}
N 5360 34360 5340 34360 {}
C {lab_pin.sym} 5340 34360 0 0 {name=l27658 lab=WL172}
N 5440 34440 5460 34440 {}
C {lab_pin.sym} 5460 34440 0 0 {name=l27659 lab=VDD}
N 5440 34360 5460 34360 {}
C {lab_pin.sym} 5460 34360 0 0 {name=l27660 lab=VSS}
C {bitcell_6t.sym} 5600 34400 0 0 {name=Xr172c28}
N 5560 34440 5540 34440 {}
C {lab_pin.sym} 5540 34440 0 0 {name=l27661 lab=BL28}
N 5560 34400 5540 34400 {}
C {lab_pin.sym} 5540 34400 0 0 {name=l27662 lab=BLB28}
N 5560 34360 5540 34360 {}
C {lab_pin.sym} 5540 34360 0 0 {name=l27663 lab=WL172}
N 5640 34440 5660 34440 {}
C {lab_pin.sym} 5660 34440 0 0 {name=l27664 lab=VDD}
N 5640 34360 5660 34360 {}
C {lab_pin.sym} 5660 34360 0 0 {name=l27665 lab=VSS}
C {bitcell_6t.sym} 5800 34400 0 0 {name=Xr172c29}
N 5760 34440 5740 34440 {}
C {lab_pin.sym} 5740 34440 0 0 {name=l27666 lab=BL29}
N 5760 34400 5740 34400 {}
C {lab_pin.sym} 5740 34400 0 0 {name=l27667 lab=BLB29}
N 5760 34360 5740 34360 {}
C {lab_pin.sym} 5740 34360 0 0 {name=l27668 lab=WL172}
N 5840 34440 5860 34440 {}
C {lab_pin.sym} 5860 34440 0 0 {name=l27669 lab=VDD}
N 5840 34360 5860 34360 {}
C {lab_pin.sym} 5860 34360 0 0 {name=l27670 lab=VSS}
C {bitcell_6t.sym} 6000 34400 0 0 {name=Xr172c30}
N 5960 34440 5940 34440 {}
C {lab_pin.sym} 5940 34440 0 0 {name=l27671 lab=BL30}
N 5960 34400 5940 34400 {}
C {lab_pin.sym} 5940 34400 0 0 {name=l27672 lab=BLB30}
N 5960 34360 5940 34360 {}
C {lab_pin.sym} 5940 34360 0 0 {name=l27673 lab=WL172}
N 6040 34440 6060 34440 {}
C {lab_pin.sym} 6060 34440 0 0 {name=l27674 lab=VDD}
N 6040 34360 6060 34360 {}
C {lab_pin.sym} 6060 34360 0 0 {name=l27675 lab=VSS}
C {bitcell_6t.sym} 6200 34400 0 0 {name=Xr172c31}
N 6160 34440 6140 34440 {}
C {lab_pin.sym} 6140 34440 0 0 {name=l27676 lab=BL31}
N 6160 34400 6140 34400 {}
C {lab_pin.sym} 6140 34400 0 0 {name=l27677 lab=BLB31}
N 6160 34360 6140 34360 {}
C {lab_pin.sym} 6140 34360 0 0 {name=l27678 lab=WL172}
N 6240 34440 6260 34440 {}
C {lab_pin.sym} 6260 34440 0 0 {name=l27679 lab=VDD}
N 6240 34360 6260 34360 {}
C {lab_pin.sym} 6260 34360 0 0 {name=l27680 lab=VSS}
C {bitcell_6t.sym} 0 34600 0 0 {name=Xr173c0}
N -40 34640 -60 34640 {}
C {lab_pin.sym} -60 34640 0 0 {name=l27681 lab=BL0}
N -40 34600 -60 34600 {}
C {lab_pin.sym} -60 34600 0 0 {name=l27682 lab=BLB0}
N -40 34560 -60 34560 {}
C {lab_pin.sym} -60 34560 0 0 {name=l27683 lab=WL173}
N 40 34640 60 34640 {}
C {lab_pin.sym} 60 34640 0 0 {name=l27684 lab=VDD}
N 40 34560 60 34560 {}
C {lab_pin.sym} 60 34560 0 0 {name=l27685 lab=VSS}
C {bitcell_6t.sym} 200 34600 0 0 {name=Xr173c1}
N 160 34640 140 34640 {}
C {lab_pin.sym} 140 34640 0 0 {name=l27686 lab=BL1}
N 160 34600 140 34600 {}
C {lab_pin.sym} 140 34600 0 0 {name=l27687 lab=BLB1}
N 160 34560 140 34560 {}
C {lab_pin.sym} 140 34560 0 0 {name=l27688 lab=WL173}
N 240 34640 260 34640 {}
C {lab_pin.sym} 260 34640 0 0 {name=l27689 lab=VDD}
N 240 34560 260 34560 {}
C {lab_pin.sym} 260 34560 0 0 {name=l27690 lab=VSS}
C {bitcell_6t.sym} 400 34600 0 0 {name=Xr173c2}
N 360 34640 340 34640 {}
C {lab_pin.sym} 340 34640 0 0 {name=l27691 lab=BL2}
N 360 34600 340 34600 {}
C {lab_pin.sym} 340 34600 0 0 {name=l27692 lab=BLB2}
N 360 34560 340 34560 {}
C {lab_pin.sym} 340 34560 0 0 {name=l27693 lab=WL173}
N 440 34640 460 34640 {}
C {lab_pin.sym} 460 34640 0 0 {name=l27694 lab=VDD}
N 440 34560 460 34560 {}
C {lab_pin.sym} 460 34560 0 0 {name=l27695 lab=VSS}
C {bitcell_6t.sym} 600 34600 0 0 {name=Xr173c3}
N 560 34640 540 34640 {}
C {lab_pin.sym} 540 34640 0 0 {name=l27696 lab=BL3}
N 560 34600 540 34600 {}
C {lab_pin.sym} 540 34600 0 0 {name=l27697 lab=BLB3}
N 560 34560 540 34560 {}
C {lab_pin.sym} 540 34560 0 0 {name=l27698 lab=WL173}
N 640 34640 660 34640 {}
C {lab_pin.sym} 660 34640 0 0 {name=l27699 lab=VDD}
N 640 34560 660 34560 {}
C {lab_pin.sym} 660 34560 0 0 {name=l27700 lab=VSS}
C {bitcell_6t.sym} 800 34600 0 0 {name=Xr173c4}
N 760 34640 740 34640 {}
C {lab_pin.sym} 740 34640 0 0 {name=l27701 lab=BL4}
N 760 34600 740 34600 {}
C {lab_pin.sym} 740 34600 0 0 {name=l27702 lab=BLB4}
N 760 34560 740 34560 {}
C {lab_pin.sym} 740 34560 0 0 {name=l27703 lab=WL173}
N 840 34640 860 34640 {}
C {lab_pin.sym} 860 34640 0 0 {name=l27704 lab=VDD}
N 840 34560 860 34560 {}
C {lab_pin.sym} 860 34560 0 0 {name=l27705 lab=VSS}
C {bitcell_6t.sym} 1000 34600 0 0 {name=Xr173c5}
N 960 34640 940 34640 {}
C {lab_pin.sym} 940 34640 0 0 {name=l27706 lab=BL5}
N 960 34600 940 34600 {}
C {lab_pin.sym} 940 34600 0 0 {name=l27707 lab=BLB5}
N 960 34560 940 34560 {}
C {lab_pin.sym} 940 34560 0 0 {name=l27708 lab=WL173}
N 1040 34640 1060 34640 {}
C {lab_pin.sym} 1060 34640 0 0 {name=l27709 lab=VDD}
N 1040 34560 1060 34560 {}
C {lab_pin.sym} 1060 34560 0 0 {name=l27710 lab=VSS}
C {bitcell_6t.sym} 1200 34600 0 0 {name=Xr173c6}
N 1160 34640 1140 34640 {}
C {lab_pin.sym} 1140 34640 0 0 {name=l27711 lab=BL6}
N 1160 34600 1140 34600 {}
C {lab_pin.sym} 1140 34600 0 0 {name=l27712 lab=BLB6}
N 1160 34560 1140 34560 {}
C {lab_pin.sym} 1140 34560 0 0 {name=l27713 lab=WL173}
N 1240 34640 1260 34640 {}
C {lab_pin.sym} 1260 34640 0 0 {name=l27714 lab=VDD}
N 1240 34560 1260 34560 {}
C {lab_pin.sym} 1260 34560 0 0 {name=l27715 lab=VSS}
C {bitcell_6t.sym} 1400 34600 0 0 {name=Xr173c7}
N 1360 34640 1340 34640 {}
C {lab_pin.sym} 1340 34640 0 0 {name=l27716 lab=BL7}
N 1360 34600 1340 34600 {}
C {lab_pin.sym} 1340 34600 0 0 {name=l27717 lab=BLB7}
N 1360 34560 1340 34560 {}
C {lab_pin.sym} 1340 34560 0 0 {name=l27718 lab=WL173}
N 1440 34640 1460 34640 {}
C {lab_pin.sym} 1460 34640 0 0 {name=l27719 lab=VDD}
N 1440 34560 1460 34560 {}
C {lab_pin.sym} 1460 34560 0 0 {name=l27720 lab=VSS}
C {bitcell_6t.sym} 1600 34600 0 0 {name=Xr173c8}
N 1560 34640 1540 34640 {}
C {lab_pin.sym} 1540 34640 0 0 {name=l27721 lab=BL8}
N 1560 34600 1540 34600 {}
C {lab_pin.sym} 1540 34600 0 0 {name=l27722 lab=BLB8}
N 1560 34560 1540 34560 {}
C {lab_pin.sym} 1540 34560 0 0 {name=l27723 lab=WL173}
N 1640 34640 1660 34640 {}
C {lab_pin.sym} 1660 34640 0 0 {name=l27724 lab=VDD}
N 1640 34560 1660 34560 {}
C {lab_pin.sym} 1660 34560 0 0 {name=l27725 lab=VSS}
C {bitcell_6t.sym} 1800 34600 0 0 {name=Xr173c9}
N 1760 34640 1740 34640 {}
C {lab_pin.sym} 1740 34640 0 0 {name=l27726 lab=BL9}
N 1760 34600 1740 34600 {}
C {lab_pin.sym} 1740 34600 0 0 {name=l27727 lab=BLB9}
N 1760 34560 1740 34560 {}
C {lab_pin.sym} 1740 34560 0 0 {name=l27728 lab=WL173}
N 1840 34640 1860 34640 {}
C {lab_pin.sym} 1860 34640 0 0 {name=l27729 lab=VDD}
N 1840 34560 1860 34560 {}
C {lab_pin.sym} 1860 34560 0 0 {name=l27730 lab=VSS}
C {bitcell_6t.sym} 2000 34600 0 0 {name=Xr173c10}
N 1960 34640 1940 34640 {}
C {lab_pin.sym} 1940 34640 0 0 {name=l27731 lab=BL10}
N 1960 34600 1940 34600 {}
C {lab_pin.sym} 1940 34600 0 0 {name=l27732 lab=BLB10}
N 1960 34560 1940 34560 {}
C {lab_pin.sym} 1940 34560 0 0 {name=l27733 lab=WL173}
N 2040 34640 2060 34640 {}
C {lab_pin.sym} 2060 34640 0 0 {name=l27734 lab=VDD}
N 2040 34560 2060 34560 {}
C {lab_pin.sym} 2060 34560 0 0 {name=l27735 lab=VSS}
C {bitcell_6t.sym} 2200 34600 0 0 {name=Xr173c11}
N 2160 34640 2140 34640 {}
C {lab_pin.sym} 2140 34640 0 0 {name=l27736 lab=BL11}
N 2160 34600 2140 34600 {}
C {lab_pin.sym} 2140 34600 0 0 {name=l27737 lab=BLB11}
N 2160 34560 2140 34560 {}
C {lab_pin.sym} 2140 34560 0 0 {name=l27738 lab=WL173}
N 2240 34640 2260 34640 {}
C {lab_pin.sym} 2260 34640 0 0 {name=l27739 lab=VDD}
N 2240 34560 2260 34560 {}
C {lab_pin.sym} 2260 34560 0 0 {name=l27740 lab=VSS}
C {bitcell_6t.sym} 2400 34600 0 0 {name=Xr173c12}
N 2360 34640 2340 34640 {}
C {lab_pin.sym} 2340 34640 0 0 {name=l27741 lab=BL12}
N 2360 34600 2340 34600 {}
C {lab_pin.sym} 2340 34600 0 0 {name=l27742 lab=BLB12}
N 2360 34560 2340 34560 {}
C {lab_pin.sym} 2340 34560 0 0 {name=l27743 lab=WL173}
N 2440 34640 2460 34640 {}
C {lab_pin.sym} 2460 34640 0 0 {name=l27744 lab=VDD}
N 2440 34560 2460 34560 {}
C {lab_pin.sym} 2460 34560 0 0 {name=l27745 lab=VSS}
C {bitcell_6t.sym} 2600 34600 0 0 {name=Xr173c13}
N 2560 34640 2540 34640 {}
C {lab_pin.sym} 2540 34640 0 0 {name=l27746 lab=BL13}
N 2560 34600 2540 34600 {}
C {lab_pin.sym} 2540 34600 0 0 {name=l27747 lab=BLB13}
N 2560 34560 2540 34560 {}
C {lab_pin.sym} 2540 34560 0 0 {name=l27748 lab=WL173}
N 2640 34640 2660 34640 {}
C {lab_pin.sym} 2660 34640 0 0 {name=l27749 lab=VDD}
N 2640 34560 2660 34560 {}
C {lab_pin.sym} 2660 34560 0 0 {name=l27750 lab=VSS}
C {bitcell_6t.sym} 2800 34600 0 0 {name=Xr173c14}
N 2760 34640 2740 34640 {}
C {lab_pin.sym} 2740 34640 0 0 {name=l27751 lab=BL14}
N 2760 34600 2740 34600 {}
C {lab_pin.sym} 2740 34600 0 0 {name=l27752 lab=BLB14}
N 2760 34560 2740 34560 {}
C {lab_pin.sym} 2740 34560 0 0 {name=l27753 lab=WL173}
N 2840 34640 2860 34640 {}
C {lab_pin.sym} 2860 34640 0 0 {name=l27754 lab=VDD}
N 2840 34560 2860 34560 {}
C {lab_pin.sym} 2860 34560 0 0 {name=l27755 lab=VSS}
C {bitcell_6t.sym} 3000 34600 0 0 {name=Xr173c15}
N 2960 34640 2940 34640 {}
C {lab_pin.sym} 2940 34640 0 0 {name=l27756 lab=BL15}
N 2960 34600 2940 34600 {}
C {lab_pin.sym} 2940 34600 0 0 {name=l27757 lab=BLB15}
N 2960 34560 2940 34560 {}
C {lab_pin.sym} 2940 34560 0 0 {name=l27758 lab=WL173}
N 3040 34640 3060 34640 {}
C {lab_pin.sym} 3060 34640 0 0 {name=l27759 lab=VDD}
N 3040 34560 3060 34560 {}
C {lab_pin.sym} 3060 34560 0 0 {name=l27760 lab=VSS}
C {bitcell_6t.sym} 3200 34600 0 0 {name=Xr173c16}
N 3160 34640 3140 34640 {}
C {lab_pin.sym} 3140 34640 0 0 {name=l27761 lab=BL16}
N 3160 34600 3140 34600 {}
C {lab_pin.sym} 3140 34600 0 0 {name=l27762 lab=BLB16}
N 3160 34560 3140 34560 {}
C {lab_pin.sym} 3140 34560 0 0 {name=l27763 lab=WL173}
N 3240 34640 3260 34640 {}
C {lab_pin.sym} 3260 34640 0 0 {name=l27764 lab=VDD}
N 3240 34560 3260 34560 {}
C {lab_pin.sym} 3260 34560 0 0 {name=l27765 lab=VSS}
C {bitcell_6t.sym} 3400 34600 0 0 {name=Xr173c17}
N 3360 34640 3340 34640 {}
C {lab_pin.sym} 3340 34640 0 0 {name=l27766 lab=BL17}
N 3360 34600 3340 34600 {}
C {lab_pin.sym} 3340 34600 0 0 {name=l27767 lab=BLB17}
N 3360 34560 3340 34560 {}
C {lab_pin.sym} 3340 34560 0 0 {name=l27768 lab=WL173}
N 3440 34640 3460 34640 {}
C {lab_pin.sym} 3460 34640 0 0 {name=l27769 lab=VDD}
N 3440 34560 3460 34560 {}
C {lab_pin.sym} 3460 34560 0 0 {name=l27770 lab=VSS}
C {bitcell_6t.sym} 3600 34600 0 0 {name=Xr173c18}
N 3560 34640 3540 34640 {}
C {lab_pin.sym} 3540 34640 0 0 {name=l27771 lab=BL18}
N 3560 34600 3540 34600 {}
C {lab_pin.sym} 3540 34600 0 0 {name=l27772 lab=BLB18}
N 3560 34560 3540 34560 {}
C {lab_pin.sym} 3540 34560 0 0 {name=l27773 lab=WL173}
N 3640 34640 3660 34640 {}
C {lab_pin.sym} 3660 34640 0 0 {name=l27774 lab=VDD}
N 3640 34560 3660 34560 {}
C {lab_pin.sym} 3660 34560 0 0 {name=l27775 lab=VSS}
C {bitcell_6t.sym} 3800 34600 0 0 {name=Xr173c19}
N 3760 34640 3740 34640 {}
C {lab_pin.sym} 3740 34640 0 0 {name=l27776 lab=BL19}
N 3760 34600 3740 34600 {}
C {lab_pin.sym} 3740 34600 0 0 {name=l27777 lab=BLB19}
N 3760 34560 3740 34560 {}
C {lab_pin.sym} 3740 34560 0 0 {name=l27778 lab=WL173}
N 3840 34640 3860 34640 {}
C {lab_pin.sym} 3860 34640 0 0 {name=l27779 lab=VDD}
N 3840 34560 3860 34560 {}
C {lab_pin.sym} 3860 34560 0 0 {name=l27780 lab=VSS}
C {bitcell_6t.sym} 4000 34600 0 0 {name=Xr173c20}
N 3960 34640 3940 34640 {}
C {lab_pin.sym} 3940 34640 0 0 {name=l27781 lab=BL20}
N 3960 34600 3940 34600 {}
C {lab_pin.sym} 3940 34600 0 0 {name=l27782 lab=BLB20}
N 3960 34560 3940 34560 {}
C {lab_pin.sym} 3940 34560 0 0 {name=l27783 lab=WL173}
N 4040 34640 4060 34640 {}
C {lab_pin.sym} 4060 34640 0 0 {name=l27784 lab=VDD}
N 4040 34560 4060 34560 {}
C {lab_pin.sym} 4060 34560 0 0 {name=l27785 lab=VSS}
C {bitcell_6t.sym} 4200 34600 0 0 {name=Xr173c21}
N 4160 34640 4140 34640 {}
C {lab_pin.sym} 4140 34640 0 0 {name=l27786 lab=BL21}
N 4160 34600 4140 34600 {}
C {lab_pin.sym} 4140 34600 0 0 {name=l27787 lab=BLB21}
N 4160 34560 4140 34560 {}
C {lab_pin.sym} 4140 34560 0 0 {name=l27788 lab=WL173}
N 4240 34640 4260 34640 {}
C {lab_pin.sym} 4260 34640 0 0 {name=l27789 lab=VDD}
N 4240 34560 4260 34560 {}
C {lab_pin.sym} 4260 34560 0 0 {name=l27790 lab=VSS}
C {bitcell_6t.sym} 4400 34600 0 0 {name=Xr173c22}
N 4360 34640 4340 34640 {}
C {lab_pin.sym} 4340 34640 0 0 {name=l27791 lab=BL22}
N 4360 34600 4340 34600 {}
C {lab_pin.sym} 4340 34600 0 0 {name=l27792 lab=BLB22}
N 4360 34560 4340 34560 {}
C {lab_pin.sym} 4340 34560 0 0 {name=l27793 lab=WL173}
N 4440 34640 4460 34640 {}
C {lab_pin.sym} 4460 34640 0 0 {name=l27794 lab=VDD}
N 4440 34560 4460 34560 {}
C {lab_pin.sym} 4460 34560 0 0 {name=l27795 lab=VSS}
C {bitcell_6t.sym} 4600 34600 0 0 {name=Xr173c23}
N 4560 34640 4540 34640 {}
C {lab_pin.sym} 4540 34640 0 0 {name=l27796 lab=BL23}
N 4560 34600 4540 34600 {}
C {lab_pin.sym} 4540 34600 0 0 {name=l27797 lab=BLB23}
N 4560 34560 4540 34560 {}
C {lab_pin.sym} 4540 34560 0 0 {name=l27798 lab=WL173}
N 4640 34640 4660 34640 {}
C {lab_pin.sym} 4660 34640 0 0 {name=l27799 lab=VDD}
N 4640 34560 4660 34560 {}
C {lab_pin.sym} 4660 34560 0 0 {name=l27800 lab=VSS}
C {bitcell_6t.sym} 4800 34600 0 0 {name=Xr173c24}
N 4760 34640 4740 34640 {}
C {lab_pin.sym} 4740 34640 0 0 {name=l27801 lab=BL24}
N 4760 34600 4740 34600 {}
C {lab_pin.sym} 4740 34600 0 0 {name=l27802 lab=BLB24}
N 4760 34560 4740 34560 {}
C {lab_pin.sym} 4740 34560 0 0 {name=l27803 lab=WL173}
N 4840 34640 4860 34640 {}
C {lab_pin.sym} 4860 34640 0 0 {name=l27804 lab=VDD}
N 4840 34560 4860 34560 {}
C {lab_pin.sym} 4860 34560 0 0 {name=l27805 lab=VSS}
C {bitcell_6t.sym} 5000 34600 0 0 {name=Xr173c25}
N 4960 34640 4940 34640 {}
C {lab_pin.sym} 4940 34640 0 0 {name=l27806 lab=BL25}
N 4960 34600 4940 34600 {}
C {lab_pin.sym} 4940 34600 0 0 {name=l27807 lab=BLB25}
N 4960 34560 4940 34560 {}
C {lab_pin.sym} 4940 34560 0 0 {name=l27808 lab=WL173}
N 5040 34640 5060 34640 {}
C {lab_pin.sym} 5060 34640 0 0 {name=l27809 lab=VDD}
N 5040 34560 5060 34560 {}
C {lab_pin.sym} 5060 34560 0 0 {name=l27810 lab=VSS}
C {bitcell_6t.sym} 5200 34600 0 0 {name=Xr173c26}
N 5160 34640 5140 34640 {}
C {lab_pin.sym} 5140 34640 0 0 {name=l27811 lab=BL26}
N 5160 34600 5140 34600 {}
C {lab_pin.sym} 5140 34600 0 0 {name=l27812 lab=BLB26}
N 5160 34560 5140 34560 {}
C {lab_pin.sym} 5140 34560 0 0 {name=l27813 lab=WL173}
N 5240 34640 5260 34640 {}
C {lab_pin.sym} 5260 34640 0 0 {name=l27814 lab=VDD}
N 5240 34560 5260 34560 {}
C {lab_pin.sym} 5260 34560 0 0 {name=l27815 lab=VSS}
C {bitcell_6t.sym} 5400 34600 0 0 {name=Xr173c27}
N 5360 34640 5340 34640 {}
C {lab_pin.sym} 5340 34640 0 0 {name=l27816 lab=BL27}
N 5360 34600 5340 34600 {}
C {lab_pin.sym} 5340 34600 0 0 {name=l27817 lab=BLB27}
N 5360 34560 5340 34560 {}
C {lab_pin.sym} 5340 34560 0 0 {name=l27818 lab=WL173}
N 5440 34640 5460 34640 {}
C {lab_pin.sym} 5460 34640 0 0 {name=l27819 lab=VDD}
N 5440 34560 5460 34560 {}
C {lab_pin.sym} 5460 34560 0 0 {name=l27820 lab=VSS}
C {bitcell_6t.sym} 5600 34600 0 0 {name=Xr173c28}
N 5560 34640 5540 34640 {}
C {lab_pin.sym} 5540 34640 0 0 {name=l27821 lab=BL28}
N 5560 34600 5540 34600 {}
C {lab_pin.sym} 5540 34600 0 0 {name=l27822 lab=BLB28}
N 5560 34560 5540 34560 {}
C {lab_pin.sym} 5540 34560 0 0 {name=l27823 lab=WL173}
N 5640 34640 5660 34640 {}
C {lab_pin.sym} 5660 34640 0 0 {name=l27824 lab=VDD}
N 5640 34560 5660 34560 {}
C {lab_pin.sym} 5660 34560 0 0 {name=l27825 lab=VSS}
C {bitcell_6t.sym} 5800 34600 0 0 {name=Xr173c29}
N 5760 34640 5740 34640 {}
C {lab_pin.sym} 5740 34640 0 0 {name=l27826 lab=BL29}
N 5760 34600 5740 34600 {}
C {lab_pin.sym} 5740 34600 0 0 {name=l27827 lab=BLB29}
N 5760 34560 5740 34560 {}
C {lab_pin.sym} 5740 34560 0 0 {name=l27828 lab=WL173}
N 5840 34640 5860 34640 {}
C {lab_pin.sym} 5860 34640 0 0 {name=l27829 lab=VDD}
N 5840 34560 5860 34560 {}
C {lab_pin.sym} 5860 34560 0 0 {name=l27830 lab=VSS}
C {bitcell_6t.sym} 6000 34600 0 0 {name=Xr173c30}
N 5960 34640 5940 34640 {}
C {lab_pin.sym} 5940 34640 0 0 {name=l27831 lab=BL30}
N 5960 34600 5940 34600 {}
C {lab_pin.sym} 5940 34600 0 0 {name=l27832 lab=BLB30}
N 5960 34560 5940 34560 {}
C {lab_pin.sym} 5940 34560 0 0 {name=l27833 lab=WL173}
N 6040 34640 6060 34640 {}
C {lab_pin.sym} 6060 34640 0 0 {name=l27834 lab=VDD}
N 6040 34560 6060 34560 {}
C {lab_pin.sym} 6060 34560 0 0 {name=l27835 lab=VSS}
C {bitcell_6t.sym} 6200 34600 0 0 {name=Xr173c31}
N 6160 34640 6140 34640 {}
C {lab_pin.sym} 6140 34640 0 0 {name=l27836 lab=BL31}
N 6160 34600 6140 34600 {}
C {lab_pin.sym} 6140 34600 0 0 {name=l27837 lab=BLB31}
N 6160 34560 6140 34560 {}
C {lab_pin.sym} 6140 34560 0 0 {name=l27838 lab=WL173}
N 6240 34640 6260 34640 {}
C {lab_pin.sym} 6260 34640 0 0 {name=l27839 lab=VDD}
N 6240 34560 6260 34560 {}
C {lab_pin.sym} 6260 34560 0 0 {name=l27840 lab=VSS}
C {bitcell_6t.sym} 0 34800 0 0 {name=Xr174c0}
N -40 34840 -60 34840 {}
C {lab_pin.sym} -60 34840 0 0 {name=l27841 lab=BL0}
N -40 34800 -60 34800 {}
C {lab_pin.sym} -60 34800 0 0 {name=l27842 lab=BLB0}
N -40 34760 -60 34760 {}
C {lab_pin.sym} -60 34760 0 0 {name=l27843 lab=WL174}
N 40 34840 60 34840 {}
C {lab_pin.sym} 60 34840 0 0 {name=l27844 lab=VDD}
N 40 34760 60 34760 {}
C {lab_pin.sym} 60 34760 0 0 {name=l27845 lab=VSS}
C {bitcell_6t.sym} 200 34800 0 0 {name=Xr174c1}
N 160 34840 140 34840 {}
C {lab_pin.sym} 140 34840 0 0 {name=l27846 lab=BL1}
N 160 34800 140 34800 {}
C {lab_pin.sym} 140 34800 0 0 {name=l27847 lab=BLB1}
N 160 34760 140 34760 {}
C {lab_pin.sym} 140 34760 0 0 {name=l27848 lab=WL174}
N 240 34840 260 34840 {}
C {lab_pin.sym} 260 34840 0 0 {name=l27849 lab=VDD}
N 240 34760 260 34760 {}
C {lab_pin.sym} 260 34760 0 0 {name=l27850 lab=VSS}
C {bitcell_6t.sym} 400 34800 0 0 {name=Xr174c2}
N 360 34840 340 34840 {}
C {lab_pin.sym} 340 34840 0 0 {name=l27851 lab=BL2}
N 360 34800 340 34800 {}
C {lab_pin.sym} 340 34800 0 0 {name=l27852 lab=BLB2}
N 360 34760 340 34760 {}
C {lab_pin.sym} 340 34760 0 0 {name=l27853 lab=WL174}
N 440 34840 460 34840 {}
C {lab_pin.sym} 460 34840 0 0 {name=l27854 lab=VDD}
N 440 34760 460 34760 {}
C {lab_pin.sym} 460 34760 0 0 {name=l27855 lab=VSS}
C {bitcell_6t.sym} 600 34800 0 0 {name=Xr174c3}
N 560 34840 540 34840 {}
C {lab_pin.sym} 540 34840 0 0 {name=l27856 lab=BL3}
N 560 34800 540 34800 {}
C {lab_pin.sym} 540 34800 0 0 {name=l27857 lab=BLB3}
N 560 34760 540 34760 {}
C {lab_pin.sym} 540 34760 0 0 {name=l27858 lab=WL174}
N 640 34840 660 34840 {}
C {lab_pin.sym} 660 34840 0 0 {name=l27859 lab=VDD}
N 640 34760 660 34760 {}
C {lab_pin.sym} 660 34760 0 0 {name=l27860 lab=VSS}
C {bitcell_6t.sym} 800 34800 0 0 {name=Xr174c4}
N 760 34840 740 34840 {}
C {lab_pin.sym} 740 34840 0 0 {name=l27861 lab=BL4}
N 760 34800 740 34800 {}
C {lab_pin.sym} 740 34800 0 0 {name=l27862 lab=BLB4}
N 760 34760 740 34760 {}
C {lab_pin.sym} 740 34760 0 0 {name=l27863 lab=WL174}
N 840 34840 860 34840 {}
C {lab_pin.sym} 860 34840 0 0 {name=l27864 lab=VDD}
N 840 34760 860 34760 {}
C {lab_pin.sym} 860 34760 0 0 {name=l27865 lab=VSS}
C {bitcell_6t.sym} 1000 34800 0 0 {name=Xr174c5}
N 960 34840 940 34840 {}
C {lab_pin.sym} 940 34840 0 0 {name=l27866 lab=BL5}
N 960 34800 940 34800 {}
C {lab_pin.sym} 940 34800 0 0 {name=l27867 lab=BLB5}
N 960 34760 940 34760 {}
C {lab_pin.sym} 940 34760 0 0 {name=l27868 lab=WL174}
N 1040 34840 1060 34840 {}
C {lab_pin.sym} 1060 34840 0 0 {name=l27869 lab=VDD}
N 1040 34760 1060 34760 {}
C {lab_pin.sym} 1060 34760 0 0 {name=l27870 lab=VSS}
C {bitcell_6t.sym} 1200 34800 0 0 {name=Xr174c6}
N 1160 34840 1140 34840 {}
C {lab_pin.sym} 1140 34840 0 0 {name=l27871 lab=BL6}
N 1160 34800 1140 34800 {}
C {lab_pin.sym} 1140 34800 0 0 {name=l27872 lab=BLB6}
N 1160 34760 1140 34760 {}
C {lab_pin.sym} 1140 34760 0 0 {name=l27873 lab=WL174}
N 1240 34840 1260 34840 {}
C {lab_pin.sym} 1260 34840 0 0 {name=l27874 lab=VDD}
N 1240 34760 1260 34760 {}
C {lab_pin.sym} 1260 34760 0 0 {name=l27875 lab=VSS}
C {bitcell_6t.sym} 1400 34800 0 0 {name=Xr174c7}
N 1360 34840 1340 34840 {}
C {lab_pin.sym} 1340 34840 0 0 {name=l27876 lab=BL7}
N 1360 34800 1340 34800 {}
C {lab_pin.sym} 1340 34800 0 0 {name=l27877 lab=BLB7}
N 1360 34760 1340 34760 {}
C {lab_pin.sym} 1340 34760 0 0 {name=l27878 lab=WL174}
N 1440 34840 1460 34840 {}
C {lab_pin.sym} 1460 34840 0 0 {name=l27879 lab=VDD}
N 1440 34760 1460 34760 {}
C {lab_pin.sym} 1460 34760 0 0 {name=l27880 lab=VSS}
C {bitcell_6t.sym} 1600 34800 0 0 {name=Xr174c8}
N 1560 34840 1540 34840 {}
C {lab_pin.sym} 1540 34840 0 0 {name=l27881 lab=BL8}
N 1560 34800 1540 34800 {}
C {lab_pin.sym} 1540 34800 0 0 {name=l27882 lab=BLB8}
N 1560 34760 1540 34760 {}
C {lab_pin.sym} 1540 34760 0 0 {name=l27883 lab=WL174}
N 1640 34840 1660 34840 {}
C {lab_pin.sym} 1660 34840 0 0 {name=l27884 lab=VDD}
N 1640 34760 1660 34760 {}
C {lab_pin.sym} 1660 34760 0 0 {name=l27885 lab=VSS}
C {bitcell_6t.sym} 1800 34800 0 0 {name=Xr174c9}
N 1760 34840 1740 34840 {}
C {lab_pin.sym} 1740 34840 0 0 {name=l27886 lab=BL9}
N 1760 34800 1740 34800 {}
C {lab_pin.sym} 1740 34800 0 0 {name=l27887 lab=BLB9}
N 1760 34760 1740 34760 {}
C {lab_pin.sym} 1740 34760 0 0 {name=l27888 lab=WL174}
N 1840 34840 1860 34840 {}
C {lab_pin.sym} 1860 34840 0 0 {name=l27889 lab=VDD}
N 1840 34760 1860 34760 {}
C {lab_pin.sym} 1860 34760 0 0 {name=l27890 lab=VSS}
C {bitcell_6t.sym} 2000 34800 0 0 {name=Xr174c10}
N 1960 34840 1940 34840 {}
C {lab_pin.sym} 1940 34840 0 0 {name=l27891 lab=BL10}
N 1960 34800 1940 34800 {}
C {lab_pin.sym} 1940 34800 0 0 {name=l27892 lab=BLB10}
N 1960 34760 1940 34760 {}
C {lab_pin.sym} 1940 34760 0 0 {name=l27893 lab=WL174}
N 2040 34840 2060 34840 {}
C {lab_pin.sym} 2060 34840 0 0 {name=l27894 lab=VDD}
N 2040 34760 2060 34760 {}
C {lab_pin.sym} 2060 34760 0 0 {name=l27895 lab=VSS}
C {bitcell_6t.sym} 2200 34800 0 0 {name=Xr174c11}
N 2160 34840 2140 34840 {}
C {lab_pin.sym} 2140 34840 0 0 {name=l27896 lab=BL11}
N 2160 34800 2140 34800 {}
C {lab_pin.sym} 2140 34800 0 0 {name=l27897 lab=BLB11}
N 2160 34760 2140 34760 {}
C {lab_pin.sym} 2140 34760 0 0 {name=l27898 lab=WL174}
N 2240 34840 2260 34840 {}
C {lab_pin.sym} 2260 34840 0 0 {name=l27899 lab=VDD}
N 2240 34760 2260 34760 {}
C {lab_pin.sym} 2260 34760 0 0 {name=l27900 lab=VSS}
C {bitcell_6t.sym} 2400 34800 0 0 {name=Xr174c12}
N 2360 34840 2340 34840 {}
C {lab_pin.sym} 2340 34840 0 0 {name=l27901 lab=BL12}
N 2360 34800 2340 34800 {}
C {lab_pin.sym} 2340 34800 0 0 {name=l27902 lab=BLB12}
N 2360 34760 2340 34760 {}
C {lab_pin.sym} 2340 34760 0 0 {name=l27903 lab=WL174}
N 2440 34840 2460 34840 {}
C {lab_pin.sym} 2460 34840 0 0 {name=l27904 lab=VDD}
N 2440 34760 2460 34760 {}
C {lab_pin.sym} 2460 34760 0 0 {name=l27905 lab=VSS}
C {bitcell_6t.sym} 2600 34800 0 0 {name=Xr174c13}
N 2560 34840 2540 34840 {}
C {lab_pin.sym} 2540 34840 0 0 {name=l27906 lab=BL13}
N 2560 34800 2540 34800 {}
C {lab_pin.sym} 2540 34800 0 0 {name=l27907 lab=BLB13}
N 2560 34760 2540 34760 {}
C {lab_pin.sym} 2540 34760 0 0 {name=l27908 lab=WL174}
N 2640 34840 2660 34840 {}
C {lab_pin.sym} 2660 34840 0 0 {name=l27909 lab=VDD}
N 2640 34760 2660 34760 {}
C {lab_pin.sym} 2660 34760 0 0 {name=l27910 lab=VSS}
C {bitcell_6t.sym} 2800 34800 0 0 {name=Xr174c14}
N 2760 34840 2740 34840 {}
C {lab_pin.sym} 2740 34840 0 0 {name=l27911 lab=BL14}
N 2760 34800 2740 34800 {}
C {lab_pin.sym} 2740 34800 0 0 {name=l27912 lab=BLB14}
N 2760 34760 2740 34760 {}
C {lab_pin.sym} 2740 34760 0 0 {name=l27913 lab=WL174}
N 2840 34840 2860 34840 {}
C {lab_pin.sym} 2860 34840 0 0 {name=l27914 lab=VDD}
N 2840 34760 2860 34760 {}
C {lab_pin.sym} 2860 34760 0 0 {name=l27915 lab=VSS}
C {bitcell_6t.sym} 3000 34800 0 0 {name=Xr174c15}
N 2960 34840 2940 34840 {}
C {lab_pin.sym} 2940 34840 0 0 {name=l27916 lab=BL15}
N 2960 34800 2940 34800 {}
C {lab_pin.sym} 2940 34800 0 0 {name=l27917 lab=BLB15}
N 2960 34760 2940 34760 {}
C {lab_pin.sym} 2940 34760 0 0 {name=l27918 lab=WL174}
N 3040 34840 3060 34840 {}
C {lab_pin.sym} 3060 34840 0 0 {name=l27919 lab=VDD}
N 3040 34760 3060 34760 {}
C {lab_pin.sym} 3060 34760 0 0 {name=l27920 lab=VSS}
C {bitcell_6t.sym} 3200 34800 0 0 {name=Xr174c16}
N 3160 34840 3140 34840 {}
C {lab_pin.sym} 3140 34840 0 0 {name=l27921 lab=BL16}
N 3160 34800 3140 34800 {}
C {lab_pin.sym} 3140 34800 0 0 {name=l27922 lab=BLB16}
N 3160 34760 3140 34760 {}
C {lab_pin.sym} 3140 34760 0 0 {name=l27923 lab=WL174}
N 3240 34840 3260 34840 {}
C {lab_pin.sym} 3260 34840 0 0 {name=l27924 lab=VDD}
N 3240 34760 3260 34760 {}
C {lab_pin.sym} 3260 34760 0 0 {name=l27925 lab=VSS}
C {bitcell_6t.sym} 3400 34800 0 0 {name=Xr174c17}
N 3360 34840 3340 34840 {}
C {lab_pin.sym} 3340 34840 0 0 {name=l27926 lab=BL17}
N 3360 34800 3340 34800 {}
C {lab_pin.sym} 3340 34800 0 0 {name=l27927 lab=BLB17}
N 3360 34760 3340 34760 {}
C {lab_pin.sym} 3340 34760 0 0 {name=l27928 lab=WL174}
N 3440 34840 3460 34840 {}
C {lab_pin.sym} 3460 34840 0 0 {name=l27929 lab=VDD}
N 3440 34760 3460 34760 {}
C {lab_pin.sym} 3460 34760 0 0 {name=l27930 lab=VSS}
C {bitcell_6t.sym} 3600 34800 0 0 {name=Xr174c18}
N 3560 34840 3540 34840 {}
C {lab_pin.sym} 3540 34840 0 0 {name=l27931 lab=BL18}
N 3560 34800 3540 34800 {}
C {lab_pin.sym} 3540 34800 0 0 {name=l27932 lab=BLB18}
N 3560 34760 3540 34760 {}
C {lab_pin.sym} 3540 34760 0 0 {name=l27933 lab=WL174}
N 3640 34840 3660 34840 {}
C {lab_pin.sym} 3660 34840 0 0 {name=l27934 lab=VDD}
N 3640 34760 3660 34760 {}
C {lab_pin.sym} 3660 34760 0 0 {name=l27935 lab=VSS}
C {bitcell_6t.sym} 3800 34800 0 0 {name=Xr174c19}
N 3760 34840 3740 34840 {}
C {lab_pin.sym} 3740 34840 0 0 {name=l27936 lab=BL19}
N 3760 34800 3740 34800 {}
C {lab_pin.sym} 3740 34800 0 0 {name=l27937 lab=BLB19}
N 3760 34760 3740 34760 {}
C {lab_pin.sym} 3740 34760 0 0 {name=l27938 lab=WL174}
N 3840 34840 3860 34840 {}
C {lab_pin.sym} 3860 34840 0 0 {name=l27939 lab=VDD}
N 3840 34760 3860 34760 {}
C {lab_pin.sym} 3860 34760 0 0 {name=l27940 lab=VSS}
C {bitcell_6t.sym} 4000 34800 0 0 {name=Xr174c20}
N 3960 34840 3940 34840 {}
C {lab_pin.sym} 3940 34840 0 0 {name=l27941 lab=BL20}
N 3960 34800 3940 34800 {}
C {lab_pin.sym} 3940 34800 0 0 {name=l27942 lab=BLB20}
N 3960 34760 3940 34760 {}
C {lab_pin.sym} 3940 34760 0 0 {name=l27943 lab=WL174}
N 4040 34840 4060 34840 {}
C {lab_pin.sym} 4060 34840 0 0 {name=l27944 lab=VDD}
N 4040 34760 4060 34760 {}
C {lab_pin.sym} 4060 34760 0 0 {name=l27945 lab=VSS}
C {bitcell_6t.sym} 4200 34800 0 0 {name=Xr174c21}
N 4160 34840 4140 34840 {}
C {lab_pin.sym} 4140 34840 0 0 {name=l27946 lab=BL21}
N 4160 34800 4140 34800 {}
C {lab_pin.sym} 4140 34800 0 0 {name=l27947 lab=BLB21}
N 4160 34760 4140 34760 {}
C {lab_pin.sym} 4140 34760 0 0 {name=l27948 lab=WL174}
N 4240 34840 4260 34840 {}
C {lab_pin.sym} 4260 34840 0 0 {name=l27949 lab=VDD}
N 4240 34760 4260 34760 {}
C {lab_pin.sym} 4260 34760 0 0 {name=l27950 lab=VSS}
C {bitcell_6t.sym} 4400 34800 0 0 {name=Xr174c22}
N 4360 34840 4340 34840 {}
C {lab_pin.sym} 4340 34840 0 0 {name=l27951 lab=BL22}
N 4360 34800 4340 34800 {}
C {lab_pin.sym} 4340 34800 0 0 {name=l27952 lab=BLB22}
N 4360 34760 4340 34760 {}
C {lab_pin.sym} 4340 34760 0 0 {name=l27953 lab=WL174}
N 4440 34840 4460 34840 {}
C {lab_pin.sym} 4460 34840 0 0 {name=l27954 lab=VDD}
N 4440 34760 4460 34760 {}
C {lab_pin.sym} 4460 34760 0 0 {name=l27955 lab=VSS}
C {bitcell_6t.sym} 4600 34800 0 0 {name=Xr174c23}
N 4560 34840 4540 34840 {}
C {lab_pin.sym} 4540 34840 0 0 {name=l27956 lab=BL23}
N 4560 34800 4540 34800 {}
C {lab_pin.sym} 4540 34800 0 0 {name=l27957 lab=BLB23}
N 4560 34760 4540 34760 {}
C {lab_pin.sym} 4540 34760 0 0 {name=l27958 lab=WL174}
N 4640 34840 4660 34840 {}
C {lab_pin.sym} 4660 34840 0 0 {name=l27959 lab=VDD}
N 4640 34760 4660 34760 {}
C {lab_pin.sym} 4660 34760 0 0 {name=l27960 lab=VSS}
C {bitcell_6t.sym} 4800 34800 0 0 {name=Xr174c24}
N 4760 34840 4740 34840 {}
C {lab_pin.sym} 4740 34840 0 0 {name=l27961 lab=BL24}
N 4760 34800 4740 34800 {}
C {lab_pin.sym} 4740 34800 0 0 {name=l27962 lab=BLB24}
N 4760 34760 4740 34760 {}
C {lab_pin.sym} 4740 34760 0 0 {name=l27963 lab=WL174}
N 4840 34840 4860 34840 {}
C {lab_pin.sym} 4860 34840 0 0 {name=l27964 lab=VDD}
N 4840 34760 4860 34760 {}
C {lab_pin.sym} 4860 34760 0 0 {name=l27965 lab=VSS}
C {bitcell_6t.sym} 5000 34800 0 0 {name=Xr174c25}
N 4960 34840 4940 34840 {}
C {lab_pin.sym} 4940 34840 0 0 {name=l27966 lab=BL25}
N 4960 34800 4940 34800 {}
C {lab_pin.sym} 4940 34800 0 0 {name=l27967 lab=BLB25}
N 4960 34760 4940 34760 {}
C {lab_pin.sym} 4940 34760 0 0 {name=l27968 lab=WL174}
N 5040 34840 5060 34840 {}
C {lab_pin.sym} 5060 34840 0 0 {name=l27969 lab=VDD}
N 5040 34760 5060 34760 {}
C {lab_pin.sym} 5060 34760 0 0 {name=l27970 lab=VSS}
C {bitcell_6t.sym} 5200 34800 0 0 {name=Xr174c26}
N 5160 34840 5140 34840 {}
C {lab_pin.sym} 5140 34840 0 0 {name=l27971 lab=BL26}
N 5160 34800 5140 34800 {}
C {lab_pin.sym} 5140 34800 0 0 {name=l27972 lab=BLB26}
N 5160 34760 5140 34760 {}
C {lab_pin.sym} 5140 34760 0 0 {name=l27973 lab=WL174}
N 5240 34840 5260 34840 {}
C {lab_pin.sym} 5260 34840 0 0 {name=l27974 lab=VDD}
N 5240 34760 5260 34760 {}
C {lab_pin.sym} 5260 34760 0 0 {name=l27975 lab=VSS}
C {bitcell_6t.sym} 5400 34800 0 0 {name=Xr174c27}
N 5360 34840 5340 34840 {}
C {lab_pin.sym} 5340 34840 0 0 {name=l27976 lab=BL27}
N 5360 34800 5340 34800 {}
C {lab_pin.sym} 5340 34800 0 0 {name=l27977 lab=BLB27}
N 5360 34760 5340 34760 {}
C {lab_pin.sym} 5340 34760 0 0 {name=l27978 lab=WL174}
N 5440 34840 5460 34840 {}
C {lab_pin.sym} 5460 34840 0 0 {name=l27979 lab=VDD}
N 5440 34760 5460 34760 {}
C {lab_pin.sym} 5460 34760 0 0 {name=l27980 lab=VSS}
C {bitcell_6t.sym} 5600 34800 0 0 {name=Xr174c28}
N 5560 34840 5540 34840 {}
C {lab_pin.sym} 5540 34840 0 0 {name=l27981 lab=BL28}
N 5560 34800 5540 34800 {}
C {lab_pin.sym} 5540 34800 0 0 {name=l27982 lab=BLB28}
N 5560 34760 5540 34760 {}
C {lab_pin.sym} 5540 34760 0 0 {name=l27983 lab=WL174}
N 5640 34840 5660 34840 {}
C {lab_pin.sym} 5660 34840 0 0 {name=l27984 lab=VDD}
N 5640 34760 5660 34760 {}
C {lab_pin.sym} 5660 34760 0 0 {name=l27985 lab=VSS}
C {bitcell_6t.sym} 5800 34800 0 0 {name=Xr174c29}
N 5760 34840 5740 34840 {}
C {lab_pin.sym} 5740 34840 0 0 {name=l27986 lab=BL29}
N 5760 34800 5740 34800 {}
C {lab_pin.sym} 5740 34800 0 0 {name=l27987 lab=BLB29}
N 5760 34760 5740 34760 {}
C {lab_pin.sym} 5740 34760 0 0 {name=l27988 lab=WL174}
N 5840 34840 5860 34840 {}
C {lab_pin.sym} 5860 34840 0 0 {name=l27989 lab=VDD}
N 5840 34760 5860 34760 {}
C {lab_pin.sym} 5860 34760 0 0 {name=l27990 lab=VSS}
C {bitcell_6t.sym} 6000 34800 0 0 {name=Xr174c30}
N 5960 34840 5940 34840 {}
C {lab_pin.sym} 5940 34840 0 0 {name=l27991 lab=BL30}
N 5960 34800 5940 34800 {}
C {lab_pin.sym} 5940 34800 0 0 {name=l27992 lab=BLB30}
N 5960 34760 5940 34760 {}
C {lab_pin.sym} 5940 34760 0 0 {name=l27993 lab=WL174}
N 6040 34840 6060 34840 {}
C {lab_pin.sym} 6060 34840 0 0 {name=l27994 lab=VDD}
N 6040 34760 6060 34760 {}
C {lab_pin.sym} 6060 34760 0 0 {name=l27995 lab=VSS}
C {bitcell_6t.sym} 6200 34800 0 0 {name=Xr174c31}
N 6160 34840 6140 34840 {}
C {lab_pin.sym} 6140 34840 0 0 {name=l27996 lab=BL31}
N 6160 34800 6140 34800 {}
C {lab_pin.sym} 6140 34800 0 0 {name=l27997 lab=BLB31}
N 6160 34760 6140 34760 {}
C {lab_pin.sym} 6140 34760 0 0 {name=l27998 lab=WL174}
N 6240 34840 6260 34840 {}
C {lab_pin.sym} 6260 34840 0 0 {name=l27999 lab=VDD}
N 6240 34760 6260 34760 {}
C {lab_pin.sym} 6260 34760 0 0 {name=l28000 lab=VSS}
C {bitcell_6t.sym} 0 35000 0 0 {name=Xr175c0}
N -40 35040 -60 35040 {}
C {lab_pin.sym} -60 35040 0 0 {name=l28001 lab=BL0}
N -40 35000 -60 35000 {}
C {lab_pin.sym} -60 35000 0 0 {name=l28002 lab=BLB0}
N -40 34960 -60 34960 {}
C {lab_pin.sym} -60 34960 0 0 {name=l28003 lab=WL175}
N 40 35040 60 35040 {}
C {lab_pin.sym} 60 35040 0 0 {name=l28004 lab=VDD}
N 40 34960 60 34960 {}
C {lab_pin.sym} 60 34960 0 0 {name=l28005 lab=VSS}
C {bitcell_6t.sym} 200 35000 0 0 {name=Xr175c1}
N 160 35040 140 35040 {}
C {lab_pin.sym} 140 35040 0 0 {name=l28006 lab=BL1}
N 160 35000 140 35000 {}
C {lab_pin.sym} 140 35000 0 0 {name=l28007 lab=BLB1}
N 160 34960 140 34960 {}
C {lab_pin.sym} 140 34960 0 0 {name=l28008 lab=WL175}
N 240 35040 260 35040 {}
C {lab_pin.sym} 260 35040 0 0 {name=l28009 lab=VDD}
N 240 34960 260 34960 {}
C {lab_pin.sym} 260 34960 0 0 {name=l28010 lab=VSS}
C {bitcell_6t.sym} 400 35000 0 0 {name=Xr175c2}
N 360 35040 340 35040 {}
C {lab_pin.sym} 340 35040 0 0 {name=l28011 lab=BL2}
N 360 35000 340 35000 {}
C {lab_pin.sym} 340 35000 0 0 {name=l28012 lab=BLB2}
N 360 34960 340 34960 {}
C {lab_pin.sym} 340 34960 0 0 {name=l28013 lab=WL175}
N 440 35040 460 35040 {}
C {lab_pin.sym} 460 35040 0 0 {name=l28014 lab=VDD}
N 440 34960 460 34960 {}
C {lab_pin.sym} 460 34960 0 0 {name=l28015 lab=VSS}
C {bitcell_6t.sym} 600 35000 0 0 {name=Xr175c3}
N 560 35040 540 35040 {}
C {lab_pin.sym} 540 35040 0 0 {name=l28016 lab=BL3}
N 560 35000 540 35000 {}
C {lab_pin.sym} 540 35000 0 0 {name=l28017 lab=BLB3}
N 560 34960 540 34960 {}
C {lab_pin.sym} 540 34960 0 0 {name=l28018 lab=WL175}
N 640 35040 660 35040 {}
C {lab_pin.sym} 660 35040 0 0 {name=l28019 lab=VDD}
N 640 34960 660 34960 {}
C {lab_pin.sym} 660 34960 0 0 {name=l28020 lab=VSS}
C {bitcell_6t.sym} 800 35000 0 0 {name=Xr175c4}
N 760 35040 740 35040 {}
C {lab_pin.sym} 740 35040 0 0 {name=l28021 lab=BL4}
N 760 35000 740 35000 {}
C {lab_pin.sym} 740 35000 0 0 {name=l28022 lab=BLB4}
N 760 34960 740 34960 {}
C {lab_pin.sym} 740 34960 0 0 {name=l28023 lab=WL175}
N 840 35040 860 35040 {}
C {lab_pin.sym} 860 35040 0 0 {name=l28024 lab=VDD}
N 840 34960 860 34960 {}
C {lab_pin.sym} 860 34960 0 0 {name=l28025 lab=VSS}
C {bitcell_6t.sym} 1000 35000 0 0 {name=Xr175c5}
N 960 35040 940 35040 {}
C {lab_pin.sym} 940 35040 0 0 {name=l28026 lab=BL5}
N 960 35000 940 35000 {}
C {lab_pin.sym} 940 35000 0 0 {name=l28027 lab=BLB5}
N 960 34960 940 34960 {}
C {lab_pin.sym} 940 34960 0 0 {name=l28028 lab=WL175}
N 1040 35040 1060 35040 {}
C {lab_pin.sym} 1060 35040 0 0 {name=l28029 lab=VDD}
N 1040 34960 1060 34960 {}
C {lab_pin.sym} 1060 34960 0 0 {name=l28030 lab=VSS}
C {bitcell_6t.sym} 1200 35000 0 0 {name=Xr175c6}
N 1160 35040 1140 35040 {}
C {lab_pin.sym} 1140 35040 0 0 {name=l28031 lab=BL6}
N 1160 35000 1140 35000 {}
C {lab_pin.sym} 1140 35000 0 0 {name=l28032 lab=BLB6}
N 1160 34960 1140 34960 {}
C {lab_pin.sym} 1140 34960 0 0 {name=l28033 lab=WL175}
N 1240 35040 1260 35040 {}
C {lab_pin.sym} 1260 35040 0 0 {name=l28034 lab=VDD}
N 1240 34960 1260 34960 {}
C {lab_pin.sym} 1260 34960 0 0 {name=l28035 lab=VSS}
C {bitcell_6t.sym} 1400 35000 0 0 {name=Xr175c7}
N 1360 35040 1340 35040 {}
C {lab_pin.sym} 1340 35040 0 0 {name=l28036 lab=BL7}
N 1360 35000 1340 35000 {}
C {lab_pin.sym} 1340 35000 0 0 {name=l28037 lab=BLB7}
N 1360 34960 1340 34960 {}
C {lab_pin.sym} 1340 34960 0 0 {name=l28038 lab=WL175}
N 1440 35040 1460 35040 {}
C {lab_pin.sym} 1460 35040 0 0 {name=l28039 lab=VDD}
N 1440 34960 1460 34960 {}
C {lab_pin.sym} 1460 34960 0 0 {name=l28040 lab=VSS}
C {bitcell_6t.sym} 1600 35000 0 0 {name=Xr175c8}
N 1560 35040 1540 35040 {}
C {lab_pin.sym} 1540 35040 0 0 {name=l28041 lab=BL8}
N 1560 35000 1540 35000 {}
C {lab_pin.sym} 1540 35000 0 0 {name=l28042 lab=BLB8}
N 1560 34960 1540 34960 {}
C {lab_pin.sym} 1540 34960 0 0 {name=l28043 lab=WL175}
N 1640 35040 1660 35040 {}
C {lab_pin.sym} 1660 35040 0 0 {name=l28044 lab=VDD}
N 1640 34960 1660 34960 {}
C {lab_pin.sym} 1660 34960 0 0 {name=l28045 lab=VSS}
C {bitcell_6t.sym} 1800 35000 0 0 {name=Xr175c9}
N 1760 35040 1740 35040 {}
C {lab_pin.sym} 1740 35040 0 0 {name=l28046 lab=BL9}
N 1760 35000 1740 35000 {}
C {lab_pin.sym} 1740 35000 0 0 {name=l28047 lab=BLB9}
N 1760 34960 1740 34960 {}
C {lab_pin.sym} 1740 34960 0 0 {name=l28048 lab=WL175}
N 1840 35040 1860 35040 {}
C {lab_pin.sym} 1860 35040 0 0 {name=l28049 lab=VDD}
N 1840 34960 1860 34960 {}
C {lab_pin.sym} 1860 34960 0 0 {name=l28050 lab=VSS}
C {bitcell_6t.sym} 2000 35000 0 0 {name=Xr175c10}
N 1960 35040 1940 35040 {}
C {lab_pin.sym} 1940 35040 0 0 {name=l28051 lab=BL10}
N 1960 35000 1940 35000 {}
C {lab_pin.sym} 1940 35000 0 0 {name=l28052 lab=BLB10}
N 1960 34960 1940 34960 {}
C {lab_pin.sym} 1940 34960 0 0 {name=l28053 lab=WL175}
N 2040 35040 2060 35040 {}
C {lab_pin.sym} 2060 35040 0 0 {name=l28054 lab=VDD}
N 2040 34960 2060 34960 {}
C {lab_pin.sym} 2060 34960 0 0 {name=l28055 lab=VSS}
C {bitcell_6t.sym} 2200 35000 0 0 {name=Xr175c11}
N 2160 35040 2140 35040 {}
C {lab_pin.sym} 2140 35040 0 0 {name=l28056 lab=BL11}
N 2160 35000 2140 35000 {}
C {lab_pin.sym} 2140 35000 0 0 {name=l28057 lab=BLB11}
N 2160 34960 2140 34960 {}
C {lab_pin.sym} 2140 34960 0 0 {name=l28058 lab=WL175}
N 2240 35040 2260 35040 {}
C {lab_pin.sym} 2260 35040 0 0 {name=l28059 lab=VDD}
N 2240 34960 2260 34960 {}
C {lab_pin.sym} 2260 34960 0 0 {name=l28060 lab=VSS}
C {bitcell_6t.sym} 2400 35000 0 0 {name=Xr175c12}
N 2360 35040 2340 35040 {}
C {lab_pin.sym} 2340 35040 0 0 {name=l28061 lab=BL12}
N 2360 35000 2340 35000 {}
C {lab_pin.sym} 2340 35000 0 0 {name=l28062 lab=BLB12}
N 2360 34960 2340 34960 {}
C {lab_pin.sym} 2340 34960 0 0 {name=l28063 lab=WL175}
N 2440 35040 2460 35040 {}
C {lab_pin.sym} 2460 35040 0 0 {name=l28064 lab=VDD}
N 2440 34960 2460 34960 {}
C {lab_pin.sym} 2460 34960 0 0 {name=l28065 lab=VSS}
C {bitcell_6t.sym} 2600 35000 0 0 {name=Xr175c13}
N 2560 35040 2540 35040 {}
C {lab_pin.sym} 2540 35040 0 0 {name=l28066 lab=BL13}
N 2560 35000 2540 35000 {}
C {lab_pin.sym} 2540 35000 0 0 {name=l28067 lab=BLB13}
N 2560 34960 2540 34960 {}
C {lab_pin.sym} 2540 34960 0 0 {name=l28068 lab=WL175}
N 2640 35040 2660 35040 {}
C {lab_pin.sym} 2660 35040 0 0 {name=l28069 lab=VDD}
N 2640 34960 2660 34960 {}
C {lab_pin.sym} 2660 34960 0 0 {name=l28070 lab=VSS}
C {bitcell_6t.sym} 2800 35000 0 0 {name=Xr175c14}
N 2760 35040 2740 35040 {}
C {lab_pin.sym} 2740 35040 0 0 {name=l28071 lab=BL14}
N 2760 35000 2740 35000 {}
C {lab_pin.sym} 2740 35000 0 0 {name=l28072 lab=BLB14}
N 2760 34960 2740 34960 {}
C {lab_pin.sym} 2740 34960 0 0 {name=l28073 lab=WL175}
N 2840 35040 2860 35040 {}
C {lab_pin.sym} 2860 35040 0 0 {name=l28074 lab=VDD}
N 2840 34960 2860 34960 {}
C {lab_pin.sym} 2860 34960 0 0 {name=l28075 lab=VSS}
C {bitcell_6t.sym} 3000 35000 0 0 {name=Xr175c15}
N 2960 35040 2940 35040 {}
C {lab_pin.sym} 2940 35040 0 0 {name=l28076 lab=BL15}
N 2960 35000 2940 35000 {}
C {lab_pin.sym} 2940 35000 0 0 {name=l28077 lab=BLB15}
N 2960 34960 2940 34960 {}
C {lab_pin.sym} 2940 34960 0 0 {name=l28078 lab=WL175}
N 3040 35040 3060 35040 {}
C {lab_pin.sym} 3060 35040 0 0 {name=l28079 lab=VDD}
N 3040 34960 3060 34960 {}
C {lab_pin.sym} 3060 34960 0 0 {name=l28080 lab=VSS}
C {bitcell_6t.sym} 3200 35000 0 0 {name=Xr175c16}
N 3160 35040 3140 35040 {}
C {lab_pin.sym} 3140 35040 0 0 {name=l28081 lab=BL16}
N 3160 35000 3140 35000 {}
C {lab_pin.sym} 3140 35000 0 0 {name=l28082 lab=BLB16}
N 3160 34960 3140 34960 {}
C {lab_pin.sym} 3140 34960 0 0 {name=l28083 lab=WL175}
N 3240 35040 3260 35040 {}
C {lab_pin.sym} 3260 35040 0 0 {name=l28084 lab=VDD}
N 3240 34960 3260 34960 {}
C {lab_pin.sym} 3260 34960 0 0 {name=l28085 lab=VSS}
C {bitcell_6t.sym} 3400 35000 0 0 {name=Xr175c17}
N 3360 35040 3340 35040 {}
C {lab_pin.sym} 3340 35040 0 0 {name=l28086 lab=BL17}
N 3360 35000 3340 35000 {}
C {lab_pin.sym} 3340 35000 0 0 {name=l28087 lab=BLB17}
N 3360 34960 3340 34960 {}
C {lab_pin.sym} 3340 34960 0 0 {name=l28088 lab=WL175}
N 3440 35040 3460 35040 {}
C {lab_pin.sym} 3460 35040 0 0 {name=l28089 lab=VDD}
N 3440 34960 3460 34960 {}
C {lab_pin.sym} 3460 34960 0 0 {name=l28090 lab=VSS}
C {bitcell_6t.sym} 3600 35000 0 0 {name=Xr175c18}
N 3560 35040 3540 35040 {}
C {lab_pin.sym} 3540 35040 0 0 {name=l28091 lab=BL18}
N 3560 35000 3540 35000 {}
C {lab_pin.sym} 3540 35000 0 0 {name=l28092 lab=BLB18}
N 3560 34960 3540 34960 {}
C {lab_pin.sym} 3540 34960 0 0 {name=l28093 lab=WL175}
N 3640 35040 3660 35040 {}
C {lab_pin.sym} 3660 35040 0 0 {name=l28094 lab=VDD}
N 3640 34960 3660 34960 {}
C {lab_pin.sym} 3660 34960 0 0 {name=l28095 lab=VSS}
C {bitcell_6t.sym} 3800 35000 0 0 {name=Xr175c19}
N 3760 35040 3740 35040 {}
C {lab_pin.sym} 3740 35040 0 0 {name=l28096 lab=BL19}
N 3760 35000 3740 35000 {}
C {lab_pin.sym} 3740 35000 0 0 {name=l28097 lab=BLB19}
N 3760 34960 3740 34960 {}
C {lab_pin.sym} 3740 34960 0 0 {name=l28098 lab=WL175}
N 3840 35040 3860 35040 {}
C {lab_pin.sym} 3860 35040 0 0 {name=l28099 lab=VDD}
N 3840 34960 3860 34960 {}
C {lab_pin.sym} 3860 34960 0 0 {name=l28100 lab=VSS}
C {bitcell_6t.sym} 4000 35000 0 0 {name=Xr175c20}
N 3960 35040 3940 35040 {}
C {lab_pin.sym} 3940 35040 0 0 {name=l28101 lab=BL20}
N 3960 35000 3940 35000 {}
C {lab_pin.sym} 3940 35000 0 0 {name=l28102 lab=BLB20}
N 3960 34960 3940 34960 {}
C {lab_pin.sym} 3940 34960 0 0 {name=l28103 lab=WL175}
N 4040 35040 4060 35040 {}
C {lab_pin.sym} 4060 35040 0 0 {name=l28104 lab=VDD}
N 4040 34960 4060 34960 {}
C {lab_pin.sym} 4060 34960 0 0 {name=l28105 lab=VSS}
C {bitcell_6t.sym} 4200 35000 0 0 {name=Xr175c21}
N 4160 35040 4140 35040 {}
C {lab_pin.sym} 4140 35040 0 0 {name=l28106 lab=BL21}
N 4160 35000 4140 35000 {}
C {lab_pin.sym} 4140 35000 0 0 {name=l28107 lab=BLB21}
N 4160 34960 4140 34960 {}
C {lab_pin.sym} 4140 34960 0 0 {name=l28108 lab=WL175}
N 4240 35040 4260 35040 {}
C {lab_pin.sym} 4260 35040 0 0 {name=l28109 lab=VDD}
N 4240 34960 4260 34960 {}
C {lab_pin.sym} 4260 34960 0 0 {name=l28110 lab=VSS}
C {bitcell_6t.sym} 4400 35000 0 0 {name=Xr175c22}
N 4360 35040 4340 35040 {}
C {lab_pin.sym} 4340 35040 0 0 {name=l28111 lab=BL22}
N 4360 35000 4340 35000 {}
C {lab_pin.sym} 4340 35000 0 0 {name=l28112 lab=BLB22}
N 4360 34960 4340 34960 {}
C {lab_pin.sym} 4340 34960 0 0 {name=l28113 lab=WL175}
N 4440 35040 4460 35040 {}
C {lab_pin.sym} 4460 35040 0 0 {name=l28114 lab=VDD}
N 4440 34960 4460 34960 {}
C {lab_pin.sym} 4460 34960 0 0 {name=l28115 lab=VSS}
C {bitcell_6t.sym} 4600 35000 0 0 {name=Xr175c23}
N 4560 35040 4540 35040 {}
C {lab_pin.sym} 4540 35040 0 0 {name=l28116 lab=BL23}
N 4560 35000 4540 35000 {}
C {lab_pin.sym} 4540 35000 0 0 {name=l28117 lab=BLB23}
N 4560 34960 4540 34960 {}
C {lab_pin.sym} 4540 34960 0 0 {name=l28118 lab=WL175}
N 4640 35040 4660 35040 {}
C {lab_pin.sym} 4660 35040 0 0 {name=l28119 lab=VDD}
N 4640 34960 4660 34960 {}
C {lab_pin.sym} 4660 34960 0 0 {name=l28120 lab=VSS}
C {bitcell_6t.sym} 4800 35000 0 0 {name=Xr175c24}
N 4760 35040 4740 35040 {}
C {lab_pin.sym} 4740 35040 0 0 {name=l28121 lab=BL24}
N 4760 35000 4740 35000 {}
C {lab_pin.sym} 4740 35000 0 0 {name=l28122 lab=BLB24}
N 4760 34960 4740 34960 {}
C {lab_pin.sym} 4740 34960 0 0 {name=l28123 lab=WL175}
N 4840 35040 4860 35040 {}
C {lab_pin.sym} 4860 35040 0 0 {name=l28124 lab=VDD}
N 4840 34960 4860 34960 {}
C {lab_pin.sym} 4860 34960 0 0 {name=l28125 lab=VSS}
C {bitcell_6t.sym} 5000 35000 0 0 {name=Xr175c25}
N 4960 35040 4940 35040 {}
C {lab_pin.sym} 4940 35040 0 0 {name=l28126 lab=BL25}
N 4960 35000 4940 35000 {}
C {lab_pin.sym} 4940 35000 0 0 {name=l28127 lab=BLB25}
N 4960 34960 4940 34960 {}
C {lab_pin.sym} 4940 34960 0 0 {name=l28128 lab=WL175}
N 5040 35040 5060 35040 {}
C {lab_pin.sym} 5060 35040 0 0 {name=l28129 lab=VDD}
N 5040 34960 5060 34960 {}
C {lab_pin.sym} 5060 34960 0 0 {name=l28130 lab=VSS}
C {bitcell_6t.sym} 5200 35000 0 0 {name=Xr175c26}
N 5160 35040 5140 35040 {}
C {lab_pin.sym} 5140 35040 0 0 {name=l28131 lab=BL26}
N 5160 35000 5140 35000 {}
C {lab_pin.sym} 5140 35000 0 0 {name=l28132 lab=BLB26}
N 5160 34960 5140 34960 {}
C {lab_pin.sym} 5140 34960 0 0 {name=l28133 lab=WL175}
N 5240 35040 5260 35040 {}
C {lab_pin.sym} 5260 35040 0 0 {name=l28134 lab=VDD}
N 5240 34960 5260 34960 {}
C {lab_pin.sym} 5260 34960 0 0 {name=l28135 lab=VSS}
C {bitcell_6t.sym} 5400 35000 0 0 {name=Xr175c27}
N 5360 35040 5340 35040 {}
C {lab_pin.sym} 5340 35040 0 0 {name=l28136 lab=BL27}
N 5360 35000 5340 35000 {}
C {lab_pin.sym} 5340 35000 0 0 {name=l28137 lab=BLB27}
N 5360 34960 5340 34960 {}
C {lab_pin.sym} 5340 34960 0 0 {name=l28138 lab=WL175}
N 5440 35040 5460 35040 {}
C {lab_pin.sym} 5460 35040 0 0 {name=l28139 lab=VDD}
N 5440 34960 5460 34960 {}
C {lab_pin.sym} 5460 34960 0 0 {name=l28140 lab=VSS}
C {bitcell_6t.sym} 5600 35000 0 0 {name=Xr175c28}
N 5560 35040 5540 35040 {}
C {lab_pin.sym} 5540 35040 0 0 {name=l28141 lab=BL28}
N 5560 35000 5540 35000 {}
C {lab_pin.sym} 5540 35000 0 0 {name=l28142 lab=BLB28}
N 5560 34960 5540 34960 {}
C {lab_pin.sym} 5540 34960 0 0 {name=l28143 lab=WL175}
N 5640 35040 5660 35040 {}
C {lab_pin.sym} 5660 35040 0 0 {name=l28144 lab=VDD}
N 5640 34960 5660 34960 {}
C {lab_pin.sym} 5660 34960 0 0 {name=l28145 lab=VSS}
C {bitcell_6t.sym} 5800 35000 0 0 {name=Xr175c29}
N 5760 35040 5740 35040 {}
C {lab_pin.sym} 5740 35040 0 0 {name=l28146 lab=BL29}
N 5760 35000 5740 35000 {}
C {lab_pin.sym} 5740 35000 0 0 {name=l28147 lab=BLB29}
N 5760 34960 5740 34960 {}
C {lab_pin.sym} 5740 34960 0 0 {name=l28148 lab=WL175}
N 5840 35040 5860 35040 {}
C {lab_pin.sym} 5860 35040 0 0 {name=l28149 lab=VDD}
N 5840 34960 5860 34960 {}
C {lab_pin.sym} 5860 34960 0 0 {name=l28150 lab=VSS}
C {bitcell_6t.sym} 6000 35000 0 0 {name=Xr175c30}
N 5960 35040 5940 35040 {}
C {lab_pin.sym} 5940 35040 0 0 {name=l28151 lab=BL30}
N 5960 35000 5940 35000 {}
C {lab_pin.sym} 5940 35000 0 0 {name=l28152 lab=BLB30}
N 5960 34960 5940 34960 {}
C {lab_pin.sym} 5940 34960 0 0 {name=l28153 lab=WL175}
N 6040 35040 6060 35040 {}
C {lab_pin.sym} 6060 35040 0 0 {name=l28154 lab=VDD}
N 6040 34960 6060 34960 {}
C {lab_pin.sym} 6060 34960 0 0 {name=l28155 lab=VSS}
C {bitcell_6t.sym} 6200 35000 0 0 {name=Xr175c31}
N 6160 35040 6140 35040 {}
C {lab_pin.sym} 6140 35040 0 0 {name=l28156 lab=BL31}
N 6160 35000 6140 35000 {}
C {lab_pin.sym} 6140 35000 0 0 {name=l28157 lab=BLB31}
N 6160 34960 6140 34960 {}
C {lab_pin.sym} 6140 34960 0 0 {name=l28158 lab=WL175}
N 6240 35040 6260 35040 {}
C {lab_pin.sym} 6260 35040 0 0 {name=l28159 lab=VDD}
N 6240 34960 6260 34960 {}
C {lab_pin.sym} 6260 34960 0 0 {name=l28160 lab=VSS}
C {bitcell_6t.sym} 0 35200 0 0 {name=Xr176c0}
N -40 35240 -60 35240 {}
C {lab_pin.sym} -60 35240 0 0 {name=l28161 lab=BL0}
N -40 35200 -60 35200 {}
C {lab_pin.sym} -60 35200 0 0 {name=l28162 lab=BLB0}
N -40 35160 -60 35160 {}
C {lab_pin.sym} -60 35160 0 0 {name=l28163 lab=WL176}
N 40 35240 60 35240 {}
C {lab_pin.sym} 60 35240 0 0 {name=l28164 lab=VDD}
N 40 35160 60 35160 {}
C {lab_pin.sym} 60 35160 0 0 {name=l28165 lab=VSS}
C {bitcell_6t.sym} 200 35200 0 0 {name=Xr176c1}
N 160 35240 140 35240 {}
C {lab_pin.sym} 140 35240 0 0 {name=l28166 lab=BL1}
N 160 35200 140 35200 {}
C {lab_pin.sym} 140 35200 0 0 {name=l28167 lab=BLB1}
N 160 35160 140 35160 {}
C {lab_pin.sym} 140 35160 0 0 {name=l28168 lab=WL176}
N 240 35240 260 35240 {}
C {lab_pin.sym} 260 35240 0 0 {name=l28169 lab=VDD}
N 240 35160 260 35160 {}
C {lab_pin.sym} 260 35160 0 0 {name=l28170 lab=VSS}
C {bitcell_6t.sym} 400 35200 0 0 {name=Xr176c2}
N 360 35240 340 35240 {}
C {lab_pin.sym} 340 35240 0 0 {name=l28171 lab=BL2}
N 360 35200 340 35200 {}
C {lab_pin.sym} 340 35200 0 0 {name=l28172 lab=BLB2}
N 360 35160 340 35160 {}
C {lab_pin.sym} 340 35160 0 0 {name=l28173 lab=WL176}
N 440 35240 460 35240 {}
C {lab_pin.sym} 460 35240 0 0 {name=l28174 lab=VDD}
N 440 35160 460 35160 {}
C {lab_pin.sym} 460 35160 0 0 {name=l28175 lab=VSS}
C {bitcell_6t.sym} 600 35200 0 0 {name=Xr176c3}
N 560 35240 540 35240 {}
C {lab_pin.sym} 540 35240 0 0 {name=l28176 lab=BL3}
N 560 35200 540 35200 {}
C {lab_pin.sym} 540 35200 0 0 {name=l28177 lab=BLB3}
N 560 35160 540 35160 {}
C {lab_pin.sym} 540 35160 0 0 {name=l28178 lab=WL176}
N 640 35240 660 35240 {}
C {lab_pin.sym} 660 35240 0 0 {name=l28179 lab=VDD}
N 640 35160 660 35160 {}
C {lab_pin.sym} 660 35160 0 0 {name=l28180 lab=VSS}
C {bitcell_6t.sym} 800 35200 0 0 {name=Xr176c4}
N 760 35240 740 35240 {}
C {lab_pin.sym} 740 35240 0 0 {name=l28181 lab=BL4}
N 760 35200 740 35200 {}
C {lab_pin.sym} 740 35200 0 0 {name=l28182 lab=BLB4}
N 760 35160 740 35160 {}
C {lab_pin.sym} 740 35160 0 0 {name=l28183 lab=WL176}
N 840 35240 860 35240 {}
C {lab_pin.sym} 860 35240 0 0 {name=l28184 lab=VDD}
N 840 35160 860 35160 {}
C {lab_pin.sym} 860 35160 0 0 {name=l28185 lab=VSS}
C {bitcell_6t.sym} 1000 35200 0 0 {name=Xr176c5}
N 960 35240 940 35240 {}
C {lab_pin.sym} 940 35240 0 0 {name=l28186 lab=BL5}
N 960 35200 940 35200 {}
C {lab_pin.sym} 940 35200 0 0 {name=l28187 lab=BLB5}
N 960 35160 940 35160 {}
C {lab_pin.sym} 940 35160 0 0 {name=l28188 lab=WL176}
N 1040 35240 1060 35240 {}
C {lab_pin.sym} 1060 35240 0 0 {name=l28189 lab=VDD}
N 1040 35160 1060 35160 {}
C {lab_pin.sym} 1060 35160 0 0 {name=l28190 lab=VSS}
C {bitcell_6t.sym} 1200 35200 0 0 {name=Xr176c6}
N 1160 35240 1140 35240 {}
C {lab_pin.sym} 1140 35240 0 0 {name=l28191 lab=BL6}
N 1160 35200 1140 35200 {}
C {lab_pin.sym} 1140 35200 0 0 {name=l28192 lab=BLB6}
N 1160 35160 1140 35160 {}
C {lab_pin.sym} 1140 35160 0 0 {name=l28193 lab=WL176}
N 1240 35240 1260 35240 {}
C {lab_pin.sym} 1260 35240 0 0 {name=l28194 lab=VDD}
N 1240 35160 1260 35160 {}
C {lab_pin.sym} 1260 35160 0 0 {name=l28195 lab=VSS}
C {bitcell_6t.sym} 1400 35200 0 0 {name=Xr176c7}
N 1360 35240 1340 35240 {}
C {lab_pin.sym} 1340 35240 0 0 {name=l28196 lab=BL7}
N 1360 35200 1340 35200 {}
C {lab_pin.sym} 1340 35200 0 0 {name=l28197 lab=BLB7}
N 1360 35160 1340 35160 {}
C {lab_pin.sym} 1340 35160 0 0 {name=l28198 lab=WL176}
N 1440 35240 1460 35240 {}
C {lab_pin.sym} 1460 35240 0 0 {name=l28199 lab=VDD}
N 1440 35160 1460 35160 {}
C {lab_pin.sym} 1460 35160 0 0 {name=l28200 lab=VSS}
C {bitcell_6t.sym} 1600 35200 0 0 {name=Xr176c8}
N 1560 35240 1540 35240 {}
C {lab_pin.sym} 1540 35240 0 0 {name=l28201 lab=BL8}
N 1560 35200 1540 35200 {}
C {lab_pin.sym} 1540 35200 0 0 {name=l28202 lab=BLB8}
N 1560 35160 1540 35160 {}
C {lab_pin.sym} 1540 35160 0 0 {name=l28203 lab=WL176}
N 1640 35240 1660 35240 {}
C {lab_pin.sym} 1660 35240 0 0 {name=l28204 lab=VDD}
N 1640 35160 1660 35160 {}
C {lab_pin.sym} 1660 35160 0 0 {name=l28205 lab=VSS}
C {bitcell_6t.sym} 1800 35200 0 0 {name=Xr176c9}
N 1760 35240 1740 35240 {}
C {lab_pin.sym} 1740 35240 0 0 {name=l28206 lab=BL9}
N 1760 35200 1740 35200 {}
C {lab_pin.sym} 1740 35200 0 0 {name=l28207 lab=BLB9}
N 1760 35160 1740 35160 {}
C {lab_pin.sym} 1740 35160 0 0 {name=l28208 lab=WL176}
N 1840 35240 1860 35240 {}
C {lab_pin.sym} 1860 35240 0 0 {name=l28209 lab=VDD}
N 1840 35160 1860 35160 {}
C {lab_pin.sym} 1860 35160 0 0 {name=l28210 lab=VSS}
C {bitcell_6t.sym} 2000 35200 0 0 {name=Xr176c10}
N 1960 35240 1940 35240 {}
C {lab_pin.sym} 1940 35240 0 0 {name=l28211 lab=BL10}
N 1960 35200 1940 35200 {}
C {lab_pin.sym} 1940 35200 0 0 {name=l28212 lab=BLB10}
N 1960 35160 1940 35160 {}
C {lab_pin.sym} 1940 35160 0 0 {name=l28213 lab=WL176}
N 2040 35240 2060 35240 {}
C {lab_pin.sym} 2060 35240 0 0 {name=l28214 lab=VDD}
N 2040 35160 2060 35160 {}
C {lab_pin.sym} 2060 35160 0 0 {name=l28215 lab=VSS}
C {bitcell_6t.sym} 2200 35200 0 0 {name=Xr176c11}
N 2160 35240 2140 35240 {}
C {lab_pin.sym} 2140 35240 0 0 {name=l28216 lab=BL11}
N 2160 35200 2140 35200 {}
C {lab_pin.sym} 2140 35200 0 0 {name=l28217 lab=BLB11}
N 2160 35160 2140 35160 {}
C {lab_pin.sym} 2140 35160 0 0 {name=l28218 lab=WL176}
N 2240 35240 2260 35240 {}
C {lab_pin.sym} 2260 35240 0 0 {name=l28219 lab=VDD}
N 2240 35160 2260 35160 {}
C {lab_pin.sym} 2260 35160 0 0 {name=l28220 lab=VSS}
C {bitcell_6t.sym} 2400 35200 0 0 {name=Xr176c12}
N 2360 35240 2340 35240 {}
C {lab_pin.sym} 2340 35240 0 0 {name=l28221 lab=BL12}
N 2360 35200 2340 35200 {}
C {lab_pin.sym} 2340 35200 0 0 {name=l28222 lab=BLB12}
N 2360 35160 2340 35160 {}
C {lab_pin.sym} 2340 35160 0 0 {name=l28223 lab=WL176}
N 2440 35240 2460 35240 {}
C {lab_pin.sym} 2460 35240 0 0 {name=l28224 lab=VDD}
N 2440 35160 2460 35160 {}
C {lab_pin.sym} 2460 35160 0 0 {name=l28225 lab=VSS}
C {bitcell_6t.sym} 2600 35200 0 0 {name=Xr176c13}
N 2560 35240 2540 35240 {}
C {lab_pin.sym} 2540 35240 0 0 {name=l28226 lab=BL13}
N 2560 35200 2540 35200 {}
C {lab_pin.sym} 2540 35200 0 0 {name=l28227 lab=BLB13}
N 2560 35160 2540 35160 {}
C {lab_pin.sym} 2540 35160 0 0 {name=l28228 lab=WL176}
N 2640 35240 2660 35240 {}
C {lab_pin.sym} 2660 35240 0 0 {name=l28229 lab=VDD}
N 2640 35160 2660 35160 {}
C {lab_pin.sym} 2660 35160 0 0 {name=l28230 lab=VSS}
C {bitcell_6t.sym} 2800 35200 0 0 {name=Xr176c14}
N 2760 35240 2740 35240 {}
C {lab_pin.sym} 2740 35240 0 0 {name=l28231 lab=BL14}
N 2760 35200 2740 35200 {}
C {lab_pin.sym} 2740 35200 0 0 {name=l28232 lab=BLB14}
N 2760 35160 2740 35160 {}
C {lab_pin.sym} 2740 35160 0 0 {name=l28233 lab=WL176}
N 2840 35240 2860 35240 {}
C {lab_pin.sym} 2860 35240 0 0 {name=l28234 lab=VDD}
N 2840 35160 2860 35160 {}
C {lab_pin.sym} 2860 35160 0 0 {name=l28235 lab=VSS}
C {bitcell_6t.sym} 3000 35200 0 0 {name=Xr176c15}
N 2960 35240 2940 35240 {}
C {lab_pin.sym} 2940 35240 0 0 {name=l28236 lab=BL15}
N 2960 35200 2940 35200 {}
C {lab_pin.sym} 2940 35200 0 0 {name=l28237 lab=BLB15}
N 2960 35160 2940 35160 {}
C {lab_pin.sym} 2940 35160 0 0 {name=l28238 lab=WL176}
N 3040 35240 3060 35240 {}
C {lab_pin.sym} 3060 35240 0 0 {name=l28239 lab=VDD}
N 3040 35160 3060 35160 {}
C {lab_pin.sym} 3060 35160 0 0 {name=l28240 lab=VSS}
C {bitcell_6t.sym} 3200 35200 0 0 {name=Xr176c16}
N 3160 35240 3140 35240 {}
C {lab_pin.sym} 3140 35240 0 0 {name=l28241 lab=BL16}
N 3160 35200 3140 35200 {}
C {lab_pin.sym} 3140 35200 0 0 {name=l28242 lab=BLB16}
N 3160 35160 3140 35160 {}
C {lab_pin.sym} 3140 35160 0 0 {name=l28243 lab=WL176}
N 3240 35240 3260 35240 {}
C {lab_pin.sym} 3260 35240 0 0 {name=l28244 lab=VDD}
N 3240 35160 3260 35160 {}
C {lab_pin.sym} 3260 35160 0 0 {name=l28245 lab=VSS}
C {bitcell_6t.sym} 3400 35200 0 0 {name=Xr176c17}
N 3360 35240 3340 35240 {}
C {lab_pin.sym} 3340 35240 0 0 {name=l28246 lab=BL17}
N 3360 35200 3340 35200 {}
C {lab_pin.sym} 3340 35200 0 0 {name=l28247 lab=BLB17}
N 3360 35160 3340 35160 {}
C {lab_pin.sym} 3340 35160 0 0 {name=l28248 lab=WL176}
N 3440 35240 3460 35240 {}
C {lab_pin.sym} 3460 35240 0 0 {name=l28249 lab=VDD}
N 3440 35160 3460 35160 {}
C {lab_pin.sym} 3460 35160 0 0 {name=l28250 lab=VSS}
C {bitcell_6t.sym} 3600 35200 0 0 {name=Xr176c18}
N 3560 35240 3540 35240 {}
C {lab_pin.sym} 3540 35240 0 0 {name=l28251 lab=BL18}
N 3560 35200 3540 35200 {}
C {lab_pin.sym} 3540 35200 0 0 {name=l28252 lab=BLB18}
N 3560 35160 3540 35160 {}
C {lab_pin.sym} 3540 35160 0 0 {name=l28253 lab=WL176}
N 3640 35240 3660 35240 {}
C {lab_pin.sym} 3660 35240 0 0 {name=l28254 lab=VDD}
N 3640 35160 3660 35160 {}
C {lab_pin.sym} 3660 35160 0 0 {name=l28255 lab=VSS}
C {bitcell_6t.sym} 3800 35200 0 0 {name=Xr176c19}
N 3760 35240 3740 35240 {}
C {lab_pin.sym} 3740 35240 0 0 {name=l28256 lab=BL19}
N 3760 35200 3740 35200 {}
C {lab_pin.sym} 3740 35200 0 0 {name=l28257 lab=BLB19}
N 3760 35160 3740 35160 {}
C {lab_pin.sym} 3740 35160 0 0 {name=l28258 lab=WL176}
N 3840 35240 3860 35240 {}
C {lab_pin.sym} 3860 35240 0 0 {name=l28259 lab=VDD}
N 3840 35160 3860 35160 {}
C {lab_pin.sym} 3860 35160 0 0 {name=l28260 lab=VSS}
C {bitcell_6t.sym} 4000 35200 0 0 {name=Xr176c20}
N 3960 35240 3940 35240 {}
C {lab_pin.sym} 3940 35240 0 0 {name=l28261 lab=BL20}
N 3960 35200 3940 35200 {}
C {lab_pin.sym} 3940 35200 0 0 {name=l28262 lab=BLB20}
N 3960 35160 3940 35160 {}
C {lab_pin.sym} 3940 35160 0 0 {name=l28263 lab=WL176}
N 4040 35240 4060 35240 {}
C {lab_pin.sym} 4060 35240 0 0 {name=l28264 lab=VDD}
N 4040 35160 4060 35160 {}
C {lab_pin.sym} 4060 35160 0 0 {name=l28265 lab=VSS}
C {bitcell_6t.sym} 4200 35200 0 0 {name=Xr176c21}
N 4160 35240 4140 35240 {}
C {lab_pin.sym} 4140 35240 0 0 {name=l28266 lab=BL21}
N 4160 35200 4140 35200 {}
C {lab_pin.sym} 4140 35200 0 0 {name=l28267 lab=BLB21}
N 4160 35160 4140 35160 {}
C {lab_pin.sym} 4140 35160 0 0 {name=l28268 lab=WL176}
N 4240 35240 4260 35240 {}
C {lab_pin.sym} 4260 35240 0 0 {name=l28269 lab=VDD}
N 4240 35160 4260 35160 {}
C {lab_pin.sym} 4260 35160 0 0 {name=l28270 lab=VSS}
C {bitcell_6t.sym} 4400 35200 0 0 {name=Xr176c22}
N 4360 35240 4340 35240 {}
C {lab_pin.sym} 4340 35240 0 0 {name=l28271 lab=BL22}
N 4360 35200 4340 35200 {}
C {lab_pin.sym} 4340 35200 0 0 {name=l28272 lab=BLB22}
N 4360 35160 4340 35160 {}
C {lab_pin.sym} 4340 35160 0 0 {name=l28273 lab=WL176}
N 4440 35240 4460 35240 {}
C {lab_pin.sym} 4460 35240 0 0 {name=l28274 lab=VDD}
N 4440 35160 4460 35160 {}
C {lab_pin.sym} 4460 35160 0 0 {name=l28275 lab=VSS}
C {bitcell_6t.sym} 4600 35200 0 0 {name=Xr176c23}
N 4560 35240 4540 35240 {}
C {lab_pin.sym} 4540 35240 0 0 {name=l28276 lab=BL23}
N 4560 35200 4540 35200 {}
C {lab_pin.sym} 4540 35200 0 0 {name=l28277 lab=BLB23}
N 4560 35160 4540 35160 {}
C {lab_pin.sym} 4540 35160 0 0 {name=l28278 lab=WL176}
N 4640 35240 4660 35240 {}
C {lab_pin.sym} 4660 35240 0 0 {name=l28279 lab=VDD}
N 4640 35160 4660 35160 {}
C {lab_pin.sym} 4660 35160 0 0 {name=l28280 lab=VSS}
C {bitcell_6t.sym} 4800 35200 0 0 {name=Xr176c24}
N 4760 35240 4740 35240 {}
C {lab_pin.sym} 4740 35240 0 0 {name=l28281 lab=BL24}
N 4760 35200 4740 35200 {}
C {lab_pin.sym} 4740 35200 0 0 {name=l28282 lab=BLB24}
N 4760 35160 4740 35160 {}
C {lab_pin.sym} 4740 35160 0 0 {name=l28283 lab=WL176}
N 4840 35240 4860 35240 {}
C {lab_pin.sym} 4860 35240 0 0 {name=l28284 lab=VDD}
N 4840 35160 4860 35160 {}
C {lab_pin.sym} 4860 35160 0 0 {name=l28285 lab=VSS}
C {bitcell_6t.sym} 5000 35200 0 0 {name=Xr176c25}
N 4960 35240 4940 35240 {}
C {lab_pin.sym} 4940 35240 0 0 {name=l28286 lab=BL25}
N 4960 35200 4940 35200 {}
C {lab_pin.sym} 4940 35200 0 0 {name=l28287 lab=BLB25}
N 4960 35160 4940 35160 {}
C {lab_pin.sym} 4940 35160 0 0 {name=l28288 lab=WL176}
N 5040 35240 5060 35240 {}
C {lab_pin.sym} 5060 35240 0 0 {name=l28289 lab=VDD}
N 5040 35160 5060 35160 {}
C {lab_pin.sym} 5060 35160 0 0 {name=l28290 lab=VSS}
C {bitcell_6t.sym} 5200 35200 0 0 {name=Xr176c26}
N 5160 35240 5140 35240 {}
C {lab_pin.sym} 5140 35240 0 0 {name=l28291 lab=BL26}
N 5160 35200 5140 35200 {}
C {lab_pin.sym} 5140 35200 0 0 {name=l28292 lab=BLB26}
N 5160 35160 5140 35160 {}
C {lab_pin.sym} 5140 35160 0 0 {name=l28293 lab=WL176}
N 5240 35240 5260 35240 {}
C {lab_pin.sym} 5260 35240 0 0 {name=l28294 lab=VDD}
N 5240 35160 5260 35160 {}
C {lab_pin.sym} 5260 35160 0 0 {name=l28295 lab=VSS}
C {bitcell_6t.sym} 5400 35200 0 0 {name=Xr176c27}
N 5360 35240 5340 35240 {}
C {lab_pin.sym} 5340 35240 0 0 {name=l28296 lab=BL27}
N 5360 35200 5340 35200 {}
C {lab_pin.sym} 5340 35200 0 0 {name=l28297 lab=BLB27}
N 5360 35160 5340 35160 {}
C {lab_pin.sym} 5340 35160 0 0 {name=l28298 lab=WL176}
N 5440 35240 5460 35240 {}
C {lab_pin.sym} 5460 35240 0 0 {name=l28299 lab=VDD}
N 5440 35160 5460 35160 {}
C {lab_pin.sym} 5460 35160 0 0 {name=l28300 lab=VSS}
C {bitcell_6t.sym} 5600 35200 0 0 {name=Xr176c28}
N 5560 35240 5540 35240 {}
C {lab_pin.sym} 5540 35240 0 0 {name=l28301 lab=BL28}
N 5560 35200 5540 35200 {}
C {lab_pin.sym} 5540 35200 0 0 {name=l28302 lab=BLB28}
N 5560 35160 5540 35160 {}
C {lab_pin.sym} 5540 35160 0 0 {name=l28303 lab=WL176}
N 5640 35240 5660 35240 {}
C {lab_pin.sym} 5660 35240 0 0 {name=l28304 lab=VDD}
N 5640 35160 5660 35160 {}
C {lab_pin.sym} 5660 35160 0 0 {name=l28305 lab=VSS}
C {bitcell_6t.sym} 5800 35200 0 0 {name=Xr176c29}
N 5760 35240 5740 35240 {}
C {lab_pin.sym} 5740 35240 0 0 {name=l28306 lab=BL29}
N 5760 35200 5740 35200 {}
C {lab_pin.sym} 5740 35200 0 0 {name=l28307 lab=BLB29}
N 5760 35160 5740 35160 {}
C {lab_pin.sym} 5740 35160 0 0 {name=l28308 lab=WL176}
N 5840 35240 5860 35240 {}
C {lab_pin.sym} 5860 35240 0 0 {name=l28309 lab=VDD}
N 5840 35160 5860 35160 {}
C {lab_pin.sym} 5860 35160 0 0 {name=l28310 lab=VSS}
C {bitcell_6t.sym} 6000 35200 0 0 {name=Xr176c30}
N 5960 35240 5940 35240 {}
C {lab_pin.sym} 5940 35240 0 0 {name=l28311 lab=BL30}
N 5960 35200 5940 35200 {}
C {lab_pin.sym} 5940 35200 0 0 {name=l28312 lab=BLB30}
N 5960 35160 5940 35160 {}
C {lab_pin.sym} 5940 35160 0 0 {name=l28313 lab=WL176}
N 6040 35240 6060 35240 {}
C {lab_pin.sym} 6060 35240 0 0 {name=l28314 lab=VDD}
N 6040 35160 6060 35160 {}
C {lab_pin.sym} 6060 35160 0 0 {name=l28315 lab=VSS}
C {bitcell_6t.sym} 6200 35200 0 0 {name=Xr176c31}
N 6160 35240 6140 35240 {}
C {lab_pin.sym} 6140 35240 0 0 {name=l28316 lab=BL31}
N 6160 35200 6140 35200 {}
C {lab_pin.sym} 6140 35200 0 0 {name=l28317 lab=BLB31}
N 6160 35160 6140 35160 {}
C {lab_pin.sym} 6140 35160 0 0 {name=l28318 lab=WL176}
N 6240 35240 6260 35240 {}
C {lab_pin.sym} 6260 35240 0 0 {name=l28319 lab=VDD}
N 6240 35160 6260 35160 {}
C {lab_pin.sym} 6260 35160 0 0 {name=l28320 lab=VSS}
C {bitcell_6t.sym} 0 35400 0 0 {name=Xr177c0}
N -40 35440 -60 35440 {}
C {lab_pin.sym} -60 35440 0 0 {name=l28321 lab=BL0}
N -40 35400 -60 35400 {}
C {lab_pin.sym} -60 35400 0 0 {name=l28322 lab=BLB0}
N -40 35360 -60 35360 {}
C {lab_pin.sym} -60 35360 0 0 {name=l28323 lab=WL177}
N 40 35440 60 35440 {}
C {lab_pin.sym} 60 35440 0 0 {name=l28324 lab=VDD}
N 40 35360 60 35360 {}
C {lab_pin.sym} 60 35360 0 0 {name=l28325 lab=VSS}
C {bitcell_6t.sym} 200 35400 0 0 {name=Xr177c1}
N 160 35440 140 35440 {}
C {lab_pin.sym} 140 35440 0 0 {name=l28326 lab=BL1}
N 160 35400 140 35400 {}
C {lab_pin.sym} 140 35400 0 0 {name=l28327 lab=BLB1}
N 160 35360 140 35360 {}
C {lab_pin.sym} 140 35360 0 0 {name=l28328 lab=WL177}
N 240 35440 260 35440 {}
C {lab_pin.sym} 260 35440 0 0 {name=l28329 lab=VDD}
N 240 35360 260 35360 {}
C {lab_pin.sym} 260 35360 0 0 {name=l28330 lab=VSS}
C {bitcell_6t.sym} 400 35400 0 0 {name=Xr177c2}
N 360 35440 340 35440 {}
C {lab_pin.sym} 340 35440 0 0 {name=l28331 lab=BL2}
N 360 35400 340 35400 {}
C {lab_pin.sym} 340 35400 0 0 {name=l28332 lab=BLB2}
N 360 35360 340 35360 {}
C {lab_pin.sym} 340 35360 0 0 {name=l28333 lab=WL177}
N 440 35440 460 35440 {}
C {lab_pin.sym} 460 35440 0 0 {name=l28334 lab=VDD}
N 440 35360 460 35360 {}
C {lab_pin.sym} 460 35360 0 0 {name=l28335 lab=VSS}
C {bitcell_6t.sym} 600 35400 0 0 {name=Xr177c3}
N 560 35440 540 35440 {}
C {lab_pin.sym} 540 35440 0 0 {name=l28336 lab=BL3}
N 560 35400 540 35400 {}
C {lab_pin.sym} 540 35400 0 0 {name=l28337 lab=BLB3}
N 560 35360 540 35360 {}
C {lab_pin.sym} 540 35360 0 0 {name=l28338 lab=WL177}
N 640 35440 660 35440 {}
C {lab_pin.sym} 660 35440 0 0 {name=l28339 lab=VDD}
N 640 35360 660 35360 {}
C {lab_pin.sym} 660 35360 0 0 {name=l28340 lab=VSS}
C {bitcell_6t.sym} 800 35400 0 0 {name=Xr177c4}
N 760 35440 740 35440 {}
C {lab_pin.sym} 740 35440 0 0 {name=l28341 lab=BL4}
N 760 35400 740 35400 {}
C {lab_pin.sym} 740 35400 0 0 {name=l28342 lab=BLB4}
N 760 35360 740 35360 {}
C {lab_pin.sym} 740 35360 0 0 {name=l28343 lab=WL177}
N 840 35440 860 35440 {}
C {lab_pin.sym} 860 35440 0 0 {name=l28344 lab=VDD}
N 840 35360 860 35360 {}
C {lab_pin.sym} 860 35360 0 0 {name=l28345 lab=VSS}
C {bitcell_6t.sym} 1000 35400 0 0 {name=Xr177c5}
N 960 35440 940 35440 {}
C {lab_pin.sym} 940 35440 0 0 {name=l28346 lab=BL5}
N 960 35400 940 35400 {}
C {lab_pin.sym} 940 35400 0 0 {name=l28347 lab=BLB5}
N 960 35360 940 35360 {}
C {lab_pin.sym} 940 35360 0 0 {name=l28348 lab=WL177}
N 1040 35440 1060 35440 {}
C {lab_pin.sym} 1060 35440 0 0 {name=l28349 lab=VDD}
N 1040 35360 1060 35360 {}
C {lab_pin.sym} 1060 35360 0 0 {name=l28350 lab=VSS}
C {bitcell_6t.sym} 1200 35400 0 0 {name=Xr177c6}
N 1160 35440 1140 35440 {}
C {lab_pin.sym} 1140 35440 0 0 {name=l28351 lab=BL6}
N 1160 35400 1140 35400 {}
C {lab_pin.sym} 1140 35400 0 0 {name=l28352 lab=BLB6}
N 1160 35360 1140 35360 {}
C {lab_pin.sym} 1140 35360 0 0 {name=l28353 lab=WL177}
N 1240 35440 1260 35440 {}
C {lab_pin.sym} 1260 35440 0 0 {name=l28354 lab=VDD}
N 1240 35360 1260 35360 {}
C {lab_pin.sym} 1260 35360 0 0 {name=l28355 lab=VSS}
C {bitcell_6t.sym} 1400 35400 0 0 {name=Xr177c7}
N 1360 35440 1340 35440 {}
C {lab_pin.sym} 1340 35440 0 0 {name=l28356 lab=BL7}
N 1360 35400 1340 35400 {}
C {lab_pin.sym} 1340 35400 0 0 {name=l28357 lab=BLB7}
N 1360 35360 1340 35360 {}
C {lab_pin.sym} 1340 35360 0 0 {name=l28358 lab=WL177}
N 1440 35440 1460 35440 {}
C {lab_pin.sym} 1460 35440 0 0 {name=l28359 lab=VDD}
N 1440 35360 1460 35360 {}
C {lab_pin.sym} 1460 35360 0 0 {name=l28360 lab=VSS}
C {bitcell_6t.sym} 1600 35400 0 0 {name=Xr177c8}
N 1560 35440 1540 35440 {}
C {lab_pin.sym} 1540 35440 0 0 {name=l28361 lab=BL8}
N 1560 35400 1540 35400 {}
C {lab_pin.sym} 1540 35400 0 0 {name=l28362 lab=BLB8}
N 1560 35360 1540 35360 {}
C {lab_pin.sym} 1540 35360 0 0 {name=l28363 lab=WL177}
N 1640 35440 1660 35440 {}
C {lab_pin.sym} 1660 35440 0 0 {name=l28364 lab=VDD}
N 1640 35360 1660 35360 {}
C {lab_pin.sym} 1660 35360 0 0 {name=l28365 lab=VSS}
C {bitcell_6t.sym} 1800 35400 0 0 {name=Xr177c9}
N 1760 35440 1740 35440 {}
C {lab_pin.sym} 1740 35440 0 0 {name=l28366 lab=BL9}
N 1760 35400 1740 35400 {}
C {lab_pin.sym} 1740 35400 0 0 {name=l28367 lab=BLB9}
N 1760 35360 1740 35360 {}
C {lab_pin.sym} 1740 35360 0 0 {name=l28368 lab=WL177}
N 1840 35440 1860 35440 {}
C {lab_pin.sym} 1860 35440 0 0 {name=l28369 lab=VDD}
N 1840 35360 1860 35360 {}
C {lab_pin.sym} 1860 35360 0 0 {name=l28370 lab=VSS}
C {bitcell_6t.sym} 2000 35400 0 0 {name=Xr177c10}
N 1960 35440 1940 35440 {}
C {lab_pin.sym} 1940 35440 0 0 {name=l28371 lab=BL10}
N 1960 35400 1940 35400 {}
C {lab_pin.sym} 1940 35400 0 0 {name=l28372 lab=BLB10}
N 1960 35360 1940 35360 {}
C {lab_pin.sym} 1940 35360 0 0 {name=l28373 lab=WL177}
N 2040 35440 2060 35440 {}
C {lab_pin.sym} 2060 35440 0 0 {name=l28374 lab=VDD}
N 2040 35360 2060 35360 {}
C {lab_pin.sym} 2060 35360 0 0 {name=l28375 lab=VSS}
C {bitcell_6t.sym} 2200 35400 0 0 {name=Xr177c11}
N 2160 35440 2140 35440 {}
C {lab_pin.sym} 2140 35440 0 0 {name=l28376 lab=BL11}
N 2160 35400 2140 35400 {}
C {lab_pin.sym} 2140 35400 0 0 {name=l28377 lab=BLB11}
N 2160 35360 2140 35360 {}
C {lab_pin.sym} 2140 35360 0 0 {name=l28378 lab=WL177}
N 2240 35440 2260 35440 {}
C {lab_pin.sym} 2260 35440 0 0 {name=l28379 lab=VDD}
N 2240 35360 2260 35360 {}
C {lab_pin.sym} 2260 35360 0 0 {name=l28380 lab=VSS}
C {bitcell_6t.sym} 2400 35400 0 0 {name=Xr177c12}
N 2360 35440 2340 35440 {}
C {lab_pin.sym} 2340 35440 0 0 {name=l28381 lab=BL12}
N 2360 35400 2340 35400 {}
C {lab_pin.sym} 2340 35400 0 0 {name=l28382 lab=BLB12}
N 2360 35360 2340 35360 {}
C {lab_pin.sym} 2340 35360 0 0 {name=l28383 lab=WL177}
N 2440 35440 2460 35440 {}
C {lab_pin.sym} 2460 35440 0 0 {name=l28384 lab=VDD}
N 2440 35360 2460 35360 {}
C {lab_pin.sym} 2460 35360 0 0 {name=l28385 lab=VSS}
C {bitcell_6t.sym} 2600 35400 0 0 {name=Xr177c13}
N 2560 35440 2540 35440 {}
C {lab_pin.sym} 2540 35440 0 0 {name=l28386 lab=BL13}
N 2560 35400 2540 35400 {}
C {lab_pin.sym} 2540 35400 0 0 {name=l28387 lab=BLB13}
N 2560 35360 2540 35360 {}
C {lab_pin.sym} 2540 35360 0 0 {name=l28388 lab=WL177}
N 2640 35440 2660 35440 {}
C {lab_pin.sym} 2660 35440 0 0 {name=l28389 lab=VDD}
N 2640 35360 2660 35360 {}
C {lab_pin.sym} 2660 35360 0 0 {name=l28390 lab=VSS}
C {bitcell_6t.sym} 2800 35400 0 0 {name=Xr177c14}
N 2760 35440 2740 35440 {}
C {lab_pin.sym} 2740 35440 0 0 {name=l28391 lab=BL14}
N 2760 35400 2740 35400 {}
C {lab_pin.sym} 2740 35400 0 0 {name=l28392 lab=BLB14}
N 2760 35360 2740 35360 {}
C {lab_pin.sym} 2740 35360 0 0 {name=l28393 lab=WL177}
N 2840 35440 2860 35440 {}
C {lab_pin.sym} 2860 35440 0 0 {name=l28394 lab=VDD}
N 2840 35360 2860 35360 {}
C {lab_pin.sym} 2860 35360 0 0 {name=l28395 lab=VSS}
C {bitcell_6t.sym} 3000 35400 0 0 {name=Xr177c15}
N 2960 35440 2940 35440 {}
C {lab_pin.sym} 2940 35440 0 0 {name=l28396 lab=BL15}
N 2960 35400 2940 35400 {}
C {lab_pin.sym} 2940 35400 0 0 {name=l28397 lab=BLB15}
N 2960 35360 2940 35360 {}
C {lab_pin.sym} 2940 35360 0 0 {name=l28398 lab=WL177}
N 3040 35440 3060 35440 {}
C {lab_pin.sym} 3060 35440 0 0 {name=l28399 lab=VDD}
N 3040 35360 3060 35360 {}
C {lab_pin.sym} 3060 35360 0 0 {name=l28400 lab=VSS}
C {bitcell_6t.sym} 3200 35400 0 0 {name=Xr177c16}
N 3160 35440 3140 35440 {}
C {lab_pin.sym} 3140 35440 0 0 {name=l28401 lab=BL16}
N 3160 35400 3140 35400 {}
C {lab_pin.sym} 3140 35400 0 0 {name=l28402 lab=BLB16}
N 3160 35360 3140 35360 {}
C {lab_pin.sym} 3140 35360 0 0 {name=l28403 lab=WL177}
N 3240 35440 3260 35440 {}
C {lab_pin.sym} 3260 35440 0 0 {name=l28404 lab=VDD}
N 3240 35360 3260 35360 {}
C {lab_pin.sym} 3260 35360 0 0 {name=l28405 lab=VSS}
C {bitcell_6t.sym} 3400 35400 0 0 {name=Xr177c17}
N 3360 35440 3340 35440 {}
C {lab_pin.sym} 3340 35440 0 0 {name=l28406 lab=BL17}
N 3360 35400 3340 35400 {}
C {lab_pin.sym} 3340 35400 0 0 {name=l28407 lab=BLB17}
N 3360 35360 3340 35360 {}
C {lab_pin.sym} 3340 35360 0 0 {name=l28408 lab=WL177}
N 3440 35440 3460 35440 {}
C {lab_pin.sym} 3460 35440 0 0 {name=l28409 lab=VDD}
N 3440 35360 3460 35360 {}
C {lab_pin.sym} 3460 35360 0 0 {name=l28410 lab=VSS}
C {bitcell_6t.sym} 3600 35400 0 0 {name=Xr177c18}
N 3560 35440 3540 35440 {}
C {lab_pin.sym} 3540 35440 0 0 {name=l28411 lab=BL18}
N 3560 35400 3540 35400 {}
C {lab_pin.sym} 3540 35400 0 0 {name=l28412 lab=BLB18}
N 3560 35360 3540 35360 {}
C {lab_pin.sym} 3540 35360 0 0 {name=l28413 lab=WL177}
N 3640 35440 3660 35440 {}
C {lab_pin.sym} 3660 35440 0 0 {name=l28414 lab=VDD}
N 3640 35360 3660 35360 {}
C {lab_pin.sym} 3660 35360 0 0 {name=l28415 lab=VSS}
C {bitcell_6t.sym} 3800 35400 0 0 {name=Xr177c19}
N 3760 35440 3740 35440 {}
C {lab_pin.sym} 3740 35440 0 0 {name=l28416 lab=BL19}
N 3760 35400 3740 35400 {}
C {lab_pin.sym} 3740 35400 0 0 {name=l28417 lab=BLB19}
N 3760 35360 3740 35360 {}
C {lab_pin.sym} 3740 35360 0 0 {name=l28418 lab=WL177}
N 3840 35440 3860 35440 {}
C {lab_pin.sym} 3860 35440 0 0 {name=l28419 lab=VDD}
N 3840 35360 3860 35360 {}
C {lab_pin.sym} 3860 35360 0 0 {name=l28420 lab=VSS}
C {bitcell_6t.sym} 4000 35400 0 0 {name=Xr177c20}
N 3960 35440 3940 35440 {}
C {lab_pin.sym} 3940 35440 0 0 {name=l28421 lab=BL20}
N 3960 35400 3940 35400 {}
C {lab_pin.sym} 3940 35400 0 0 {name=l28422 lab=BLB20}
N 3960 35360 3940 35360 {}
C {lab_pin.sym} 3940 35360 0 0 {name=l28423 lab=WL177}
N 4040 35440 4060 35440 {}
C {lab_pin.sym} 4060 35440 0 0 {name=l28424 lab=VDD}
N 4040 35360 4060 35360 {}
C {lab_pin.sym} 4060 35360 0 0 {name=l28425 lab=VSS}
C {bitcell_6t.sym} 4200 35400 0 0 {name=Xr177c21}
N 4160 35440 4140 35440 {}
C {lab_pin.sym} 4140 35440 0 0 {name=l28426 lab=BL21}
N 4160 35400 4140 35400 {}
C {lab_pin.sym} 4140 35400 0 0 {name=l28427 lab=BLB21}
N 4160 35360 4140 35360 {}
C {lab_pin.sym} 4140 35360 0 0 {name=l28428 lab=WL177}
N 4240 35440 4260 35440 {}
C {lab_pin.sym} 4260 35440 0 0 {name=l28429 lab=VDD}
N 4240 35360 4260 35360 {}
C {lab_pin.sym} 4260 35360 0 0 {name=l28430 lab=VSS}
C {bitcell_6t.sym} 4400 35400 0 0 {name=Xr177c22}
N 4360 35440 4340 35440 {}
C {lab_pin.sym} 4340 35440 0 0 {name=l28431 lab=BL22}
N 4360 35400 4340 35400 {}
C {lab_pin.sym} 4340 35400 0 0 {name=l28432 lab=BLB22}
N 4360 35360 4340 35360 {}
C {lab_pin.sym} 4340 35360 0 0 {name=l28433 lab=WL177}
N 4440 35440 4460 35440 {}
C {lab_pin.sym} 4460 35440 0 0 {name=l28434 lab=VDD}
N 4440 35360 4460 35360 {}
C {lab_pin.sym} 4460 35360 0 0 {name=l28435 lab=VSS}
C {bitcell_6t.sym} 4600 35400 0 0 {name=Xr177c23}
N 4560 35440 4540 35440 {}
C {lab_pin.sym} 4540 35440 0 0 {name=l28436 lab=BL23}
N 4560 35400 4540 35400 {}
C {lab_pin.sym} 4540 35400 0 0 {name=l28437 lab=BLB23}
N 4560 35360 4540 35360 {}
C {lab_pin.sym} 4540 35360 0 0 {name=l28438 lab=WL177}
N 4640 35440 4660 35440 {}
C {lab_pin.sym} 4660 35440 0 0 {name=l28439 lab=VDD}
N 4640 35360 4660 35360 {}
C {lab_pin.sym} 4660 35360 0 0 {name=l28440 lab=VSS}
C {bitcell_6t.sym} 4800 35400 0 0 {name=Xr177c24}
N 4760 35440 4740 35440 {}
C {lab_pin.sym} 4740 35440 0 0 {name=l28441 lab=BL24}
N 4760 35400 4740 35400 {}
C {lab_pin.sym} 4740 35400 0 0 {name=l28442 lab=BLB24}
N 4760 35360 4740 35360 {}
C {lab_pin.sym} 4740 35360 0 0 {name=l28443 lab=WL177}
N 4840 35440 4860 35440 {}
C {lab_pin.sym} 4860 35440 0 0 {name=l28444 lab=VDD}
N 4840 35360 4860 35360 {}
C {lab_pin.sym} 4860 35360 0 0 {name=l28445 lab=VSS}
C {bitcell_6t.sym} 5000 35400 0 0 {name=Xr177c25}
N 4960 35440 4940 35440 {}
C {lab_pin.sym} 4940 35440 0 0 {name=l28446 lab=BL25}
N 4960 35400 4940 35400 {}
C {lab_pin.sym} 4940 35400 0 0 {name=l28447 lab=BLB25}
N 4960 35360 4940 35360 {}
C {lab_pin.sym} 4940 35360 0 0 {name=l28448 lab=WL177}
N 5040 35440 5060 35440 {}
C {lab_pin.sym} 5060 35440 0 0 {name=l28449 lab=VDD}
N 5040 35360 5060 35360 {}
C {lab_pin.sym} 5060 35360 0 0 {name=l28450 lab=VSS}
C {bitcell_6t.sym} 5200 35400 0 0 {name=Xr177c26}
N 5160 35440 5140 35440 {}
C {lab_pin.sym} 5140 35440 0 0 {name=l28451 lab=BL26}
N 5160 35400 5140 35400 {}
C {lab_pin.sym} 5140 35400 0 0 {name=l28452 lab=BLB26}
N 5160 35360 5140 35360 {}
C {lab_pin.sym} 5140 35360 0 0 {name=l28453 lab=WL177}
N 5240 35440 5260 35440 {}
C {lab_pin.sym} 5260 35440 0 0 {name=l28454 lab=VDD}
N 5240 35360 5260 35360 {}
C {lab_pin.sym} 5260 35360 0 0 {name=l28455 lab=VSS}
C {bitcell_6t.sym} 5400 35400 0 0 {name=Xr177c27}
N 5360 35440 5340 35440 {}
C {lab_pin.sym} 5340 35440 0 0 {name=l28456 lab=BL27}
N 5360 35400 5340 35400 {}
C {lab_pin.sym} 5340 35400 0 0 {name=l28457 lab=BLB27}
N 5360 35360 5340 35360 {}
C {lab_pin.sym} 5340 35360 0 0 {name=l28458 lab=WL177}
N 5440 35440 5460 35440 {}
C {lab_pin.sym} 5460 35440 0 0 {name=l28459 lab=VDD}
N 5440 35360 5460 35360 {}
C {lab_pin.sym} 5460 35360 0 0 {name=l28460 lab=VSS}
C {bitcell_6t.sym} 5600 35400 0 0 {name=Xr177c28}
N 5560 35440 5540 35440 {}
C {lab_pin.sym} 5540 35440 0 0 {name=l28461 lab=BL28}
N 5560 35400 5540 35400 {}
C {lab_pin.sym} 5540 35400 0 0 {name=l28462 lab=BLB28}
N 5560 35360 5540 35360 {}
C {lab_pin.sym} 5540 35360 0 0 {name=l28463 lab=WL177}
N 5640 35440 5660 35440 {}
C {lab_pin.sym} 5660 35440 0 0 {name=l28464 lab=VDD}
N 5640 35360 5660 35360 {}
C {lab_pin.sym} 5660 35360 0 0 {name=l28465 lab=VSS}
C {bitcell_6t.sym} 5800 35400 0 0 {name=Xr177c29}
N 5760 35440 5740 35440 {}
C {lab_pin.sym} 5740 35440 0 0 {name=l28466 lab=BL29}
N 5760 35400 5740 35400 {}
C {lab_pin.sym} 5740 35400 0 0 {name=l28467 lab=BLB29}
N 5760 35360 5740 35360 {}
C {lab_pin.sym} 5740 35360 0 0 {name=l28468 lab=WL177}
N 5840 35440 5860 35440 {}
C {lab_pin.sym} 5860 35440 0 0 {name=l28469 lab=VDD}
N 5840 35360 5860 35360 {}
C {lab_pin.sym} 5860 35360 0 0 {name=l28470 lab=VSS}
C {bitcell_6t.sym} 6000 35400 0 0 {name=Xr177c30}
N 5960 35440 5940 35440 {}
C {lab_pin.sym} 5940 35440 0 0 {name=l28471 lab=BL30}
N 5960 35400 5940 35400 {}
C {lab_pin.sym} 5940 35400 0 0 {name=l28472 lab=BLB30}
N 5960 35360 5940 35360 {}
C {lab_pin.sym} 5940 35360 0 0 {name=l28473 lab=WL177}
N 6040 35440 6060 35440 {}
C {lab_pin.sym} 6060 35440 0 0 {name=l28474 lab=VDD}
N 6040 35360 6060 35360 {}
C {lab_pin.sym} 6060 35360 0 0 {name=l28475 lab=VSS}
C {bitcell_6t.sym} 6200 35400 0 0 {name=Xr177c31}
N 6160 35440 6140 35440 {}
C {lab_pin.sym} 6140 35440 0 0 {name=l28476 lab=BL31}
N 6160 35400 6140 35400 {}
C {lab_pin.sym} 6140 35400 0 0 {name=l28477 lab=BLB31}
N 6160 35360 6140 35360 {}
C {lab_pin.sym} 6140 35360 0 0 {name=l28478 lab=WL177}
N 6240 35440 6260 35440 {}
C {lab_pin.sym} 6260 35440 0 0 {name=l28479 lab=VDD}
N 6240 35360 6260 35360 {}
C {lab_pin.sym} 6260 35360 0 0 {name=l28480 lab=VSS}
C {bitcell_6t.sym} 0 35600 0 0 {name=Xr178c0}
N -40 35640 -60 35640 {}
C {lab_pin.sym} -60 35640 0 0 {name=l28481 lab=BL0}
N -40 35600 -60 35600 {}
C {lab_pin.sym} -60 35600 0 0 {name=l28482 lab=BLB0}
N -40 35560 -60 35560 {}
C {lab_pin.sym} -60 35560 0 0 {name=l28483 lab=WL178}
N 40 35640 60 35640 {}
C {lab_pin.sym} 60 35640 0 0 {name=l28484 lab=VDD}
N 40 35560 60 35560 {}
C {lab_pin.sym} 60 35560 0 0 {name=l28485 lab=VSS}
C {bitcell_6t.sym} 200 35600 0 0 {name=Xr178c1}
N 160 35640 140 35640 {}
C {lab_pin.sym} 140 35640 0 0 {name=l28486 lab=BL1}
N 160 35600 140 35600 {}
C {lab_pin.sym} 140 35600 0 0 {name=l28487 lab=BLB1}
N 160 35560 140 35560 {}
C {lab_pin.sym} 140 35560 0 0 {name=l28488 lab=WL178}
N 240 35640 260 35640 {}
C {lab_pin.sym} 260 35640 0 0 {name=l28489 lab=VDD}
N 240 35560 260 35560 {}
C {lab_pin.sym} 260 35560 0 0 {name=l28490 lab=VSS}
C {bitcell_6t.sym} 400 35600 0 0 {name=Xr178c2}
N 360 35640 340 35640 {}
C {lab_pin.sym} 340 35640 0 0 {name=l28491 lab=BL2}
N 360 35600 340 35600 {}
C {lab_pin.sym} 340 35600 0 0 {name=l28492 lab=BLB2}
N 360 35560 340 35560 {}
C {lab_pin.sym} 340 35560 0 0 {name=l28493 lab=WL178}
N 440 35640 460 35640 {}
C {lab_pin.sym} 460 35640 0 0 {name=l28494 lab=VDD}
N 440 35560 460 35560 {}
C {lab_pin.sym} 460 35560 0 0 {name=l28495 lab=VSS}
C {bitcell_6t.sym} 600 35600 0 0 {name=Xr178c3}
N 560 35640 540 35640 {}
C {lab_pin.sym} 540 35640 0 0 {name=l28496 lab=BL3}
N 560 35600 540 35600 {}
C {lab_pin.sym} 540 35600 0 0 {name=l28497 lab=BLB3}
N 560 35560 540 35560 {}
C {lab_pin.sym} 540 35560 0 0 {name=l28498 lab=WL178}
N 640 35640 660 35640 {}
C {lab_pin.sym} 660 35640 0 0 {name=l28499 lab=VDD}
N 640 35560 660 35560 {}
C {lab_pin.sym} 660 35560 0 0 {name=l28500 lab=VSS}
C {bitcell_6t.sym} 800 35600 0 0 {name=Xr178c4}
N 760 35640 740 35640 {}
C {lab_pin.sym} 740 35640 0 0 {name=l28501 lab=BL4}
N 760 35600 740 35600 {}
C {lab_pin.sym} 740 35600 0 0 {name=l28502 lab=BLB4}
N 760 35560 740 35560 {}
C {lab_pin.sym} 740 35560 0 0 {name=l28503 lab=WL178}
N 840 35640 860 35640 {}
C {lab_pin.sym} 860 35640 0 0 {name=l28504 lab=VDD}
N 840 35560 860 35560 {}
C {lab_pin.sym} 860 35560 0 0 {name=l28505 lab=VSS}
C {bitcell_6t.sym} 1000 35600 0 0 {name=Xr178c5}
N 960 35640 940 35640 {}
C {lab_pin.sym} 940 35640 0 0 {name=l28506 lab=BL5}
N 960 35600 940 35600 {}
C {lab_pin.sym} 940 35600 0 0 {name=l28507 lab=BLB5}
N 960 35560 940 35560 {}
C {lab_pin.sym} 940 35560 0 0 {name=l28508 lab=WL178}
N 1040 35640 1060 35640 {}
C {lab_pin.sym} 1060 35640 0 0 {name=l28509 lab=VDD}
N 1040 35560 1060 35560 {}
C {lab_pin.sym} 1060 35560 0 0 {name=l28510 lab=VSS}
C {bitcell_6t.sym} 1200 35600 0 0 {name=Xr178c6}
N 1160 35640 1140 35640 {}
C {lab_pin.sym} 1140 35640 0 0 {name=l28511 lab=BL6}
N 1160 35600 1140 35600 {}
C {lab_pin.sym} 1140 35600 0 0 {name=l28512 lab=BLB6}
N 1160 35560 1140 35560 {}
C {lab_pin.sym} 1140 35560 0 0 {name=l28513 lab=WL178}
N 1240 35640 1260 35640 {}
C {lab_pin.sym} 1260 35640 0 0 {name=l28514 lab=VDD}
N 1240 35560 1260 35560 {}
C {lab_pin.sym} 1260 35560 0 0 {name=l28515 lab=VSS}
C {bitcell_6t.sym} 1400 35600 0 0 {name=Xr178c7}
N 1360 35640 1340 35640 {}
C {lab_pin.sym} 1340 35640 0 0 {name=l28516 lab=BL7}
N 1360 35600 1340 35600 {}
C {lab_pin.sym} 1340 35600 0 0 {name=l28517 lab=BLB7}
N 1360 35560 1340 35560 {}
C {lab_pin.sym} 1340 35560 0 0 {name=l28518 lab=WL178}
N 1440 35640 1460 35640 {}
C {lab_pin.sym} 1460 35640 0 0 {name=l28519 lab=VDD}
N 1440 35560 1460 35560 {}
C {lab_pin.sym} 1460 35560 0 0 {name=l28520 lab=VSS}
C {bitcell_6t.sym} 1600 35600 0 0 {name=Xr178c8}
N 1560 35640 1540 35640 {}
C {lab_pin.sym} 1540 35640 0 0 {name=l28521 lab=BL8}
N 1560 35600 1540 35600 {}
C {lab_pin.sym} 1540 35600 0 0 {name=l28522 lab=BLB8}
N 1560 35560 1540 35560 {}
C {lab_pin.sym} 1540 35560 0 0 {name=l28523 lab=WL178}
N 1640 35640 1660 35640 {}
C {lab_pin.sym} 1660 35640 0 0 {name=l28524 lab=VDD}
N 1640 35560 1660 35560 {}
C {lab_pin.sym} 1660 35560 0 0 {name=l28525 lab=VSS}
C {bitcell_6t.sym} 1800 35600 0 0 {name=Xr178c9}
N 1760 35640 1740 35640 {}
C {lab_pin.sym} 1740 35640 0 0 {name=l28526 lab=BL9}
N 1760 35600 1740 35600 {}
C {lab_pin.sym} 1740 35600 0 0 {name=l28527 lab=BLB9}
N 1760 35560 1740 35560 {}
C {lab_pin.sym} 1740 35560 0 0 {name=l28528 lab=WL178}
N 1840 35640 1860 35640 {}
C {lab_pin.sym} 1860 35640 0 0 {name=l28529 lab=VDD}
N 1840 35560 1860 35560 {}
C {lab_pin.sym} 1860 35560 0 0 {name=l28530 lab=VSS}
C {bitcell_6t.sym} 2000 35600 0 0 {name=Xr178c10}
N 1960 35640 1940 35640 {}
C {lab_pin.sym} 1940 35640 0 0 {name=l28531 lab=BL10}
N 1960 35600 1940 35600 {}
C {lab_pin.sym} 1940 35600 0 0 {name=l28532 lab=BLB10}
N 1960 35560 1940 35560 {}
C {lab_pin.sym} 1940 35560 0 0 {name=l28533 lab=WL178}
N 2040 35640 2060 35640 {}
C {lab_pin.sym} 2060 35640 0 0 {name=l28534 lab=VDD}
N 2040 35560 2060 35560 {}
C {lab_pin.sym} 2060 35560 0 0 {name=l28535 lab=VSS}
C {bitcell_6t.sym} 2200 35600 0 0 {name=Xr178c11}
N 2160 35640 2140 35640 {}
C {lab_pin.sym} 2140 35640 0 0 {name=l28536 lab=BL11}
N 2160 35600 2140 35600 {}
C {lab_pin.sym} 2140 35600 0 0 {name=l28537 lab=BLB11}
N 2160 35560 2140 35560 {}
C {lab_pin.sym} 2140 35560 0 0 {name=l28538 lab=WL178}
N 2240 35640 2260 35640 {}
C {lab_pin.sym} 2260 35640 0 0 {name=l28539 lab=VDD}
N 2240 35560 2260 35560 {}
C {lab_pin.sym} 2260 35560 0 0 {name=l28540 lab=VSS}
C {bitcell_6t.sym} 2400 35600 0 0 {name=Xr178c12}
N 2360 35640 2340 35640 {}
C {lab_pin.sym} 2340 35640 0 0 {name=l28541 lab=BL12}
N 2360 35600 2340 35600 {}
C {lab_pin.sym} 2340 35600 0 0 {name=l28542 lab=BLB12}
N 2360 35560 2340 35560 {}
C {lab_pin.sym} 2340 35560 0 0 {name=l28543 lab=WL178}
N 2440 35640 2460 35640 {}
C {lab_pin.sym} 2460 35640 0 0 {name=l28544 lab=VDD}
N 2440 35560 2460 35560 {}
C {lab_pin.sym} 2460 35560 0 0 {name=l28545 lab=VSS}
C {bitcell_6t.sym} 2600 35600 0 0 {name=Xr178c13}
N 2560 35640 2540 35640 {}
C {lab_pin.sym} 2540 35640 0 0 {name=l28546 lab=BL13}
N 2560 35600 2540 35600 {}
C {lab_pin.sym} 2540 35600 0 0 {name=l28547 lab=BLB13}
N 2560 35560 2540 35560 {}
C {lab_pin.sym} 2540 35560 0 0 {name=l28548 lab=WL178}
N 2640 35640 2660 35640 {}
C {lab_pin.sym} 2660 35640 0 0 {name=l28549 lab=VDD}
N 2640 35560 2660 35560 {}
C {lab_pin.sym} 2660 35560 0 0 {name=l28550 lab=VSS}
C {bitcell_6t.sym} 2800 35600 0 0 {name=Xr178c14}
N 2760 35640 2740 35640 {}
C {lab_pin.sym} 2740 35640 0 0 {name=l28551 lab=BL14}
N 2760 35600 2740 35600 {}
C {lab_pin.sym} 2740 35600 0 0 {name=l28552 lab=BLB14}
N 2760 35560 2740 35560 {}
C {lab_pin.sym} 2740 35560 0 0 {name=l28553 lab=WL178}
N 2840 35640 2860 35640 {}
C {lab_pin.sym} 2860 35640 0 0 {name=l28554 lab=VDD}
N 2840 35560 2860 35560 {}
C {lab_pin.sym} 2860 35560 0 0 {name=l28555 lab=VSS}
C {bitcell_6t.sym} 3000 35600 0 0 {name=Xr178c15}
N 2960 35640 2940 35640 {}
C {lab_pin.sym} 2940 35640 0 0 {name=l28556 lab=BL15}
N 2960 35600 2940 35600 {}
C {lab_pin.sym} 2940 35600 0 0 {name=l28557 lab=BLB15}
N 2960 35560 2940 35560 {}
C {lab_pin.sym} 2940 35560 0 0 {name=l28558 lab=WL178}
N 3040 35640 3060 35640 {}
C {lab_pin.sym} 3060 35640 0 0 {name=l28559 lab=VDD}
N 3040 35560 3060 35560 {}
C {lab_pin.sym} 3060 35560 0 0 {name=l28560 lab=VSS}
C {bitcell_6t.sym} 3200 35600 0 0 {name=Xr178c16}
N 3160 35640 3140 35640 {}
C {lab_pin.sym} 3140 35640 0 0 {name=l28561 lab=BL16}
N 3160 35600 3140 35600 {}
C {lab_pin.sym} 3140 35600 0 0 {name=l28562 lab=BLB16}
N 3160 35560 3140 35560 {}
C {lab_pin.sym} 3140 35560 0 0 {name=l28563 lab=WL178}
N 3240 35640 3260 35640 {}
C {lab_pin.sym} 3260 35640 0 0 {name=l28564 lab=VDD}
N 3240 35560 3260 35560 {}
C {lab_pin.sym} 3260 35560 0 0 {name=l28565 lab=VSS}
C {bitcell_6t.sym} 3400 35600 0 0 {name=Xr178c17}
N 3360 35640 3340 35640 {}
C {lab_pin.sym} 3340 35640 0 0 {name=l28566 lab=BL17}
N 3360 35600 3340 35600 {}
C {lab_pin.sym} 3340 35600 0 0 {name=l28567 lab=BLB17}
N 3360 35560 3340 35560 {}
C {lab_pin.sym} 3340 35560 0 0 {name=l28568 lab=WL178}
N 3440 35640 3460 35640 {}
C {lab_pin.sym} 3460 35640 0 0 {name=l28569 lab=VDD}
N 3440 35560 3460 35560 {}
C {lab_pin.sym} 3460 35560 0 0 {name=l28570 lab=VSS}
C {bitcell_6t.sym} 3600 35600 0 0 {name=Xr178c18}
N 3560 35640 3540 35640 {}
C {lab_pin.sym} 3540 35640 0 0 {name=l28571 lab=BL18}
N 3560 35600 3540 35600 {}
C {lab_pin.sym} 3540 35600 0 0 {name=l28572 lab=BLB18}
N 3560 35560 3540 35560 {}
C {lab_pin.sym} 3540 35560 0 0 {name=l28573 lab=WL178}
N 3640 35640 3660 35640 {}
C {lab_pin.sym} 3660 35640 0 0 {name=l28574 lab=VDD}
N 3640 35560 3660 35560 {}
C {lab_pin.sym} 3660 35560 0 0 {name=l28575 lab=VSS}
C {bitcell_6t.sym} 3800 35600 0 0 {name=Xr178c19}
N 3760 35640 3740 35640 {}
C {lab_pin.sym} 3740 35640 0 0 {name=l28576 lab=BL19}
N 3760 35600 3740 35600 {}
C {lab_pin.sym} 3740 35600 0 0 {name=l28577 lab=BLB19}
N 3760 35560 3740 35560 {}
C {lab_pin.sym} 3740 35560 0 0 {name=l28578 lab=WL178}
N 3840 35640 3860 35640 {}
C {lab_pin.sym} 3860 35640 0 0 {name=l28579 lab=VDD}
N 3840 35560 3860 35560 {}
C {lab_pin.sym} 3860 35560 0 0 {name=l28580 lab=VSS}
C {bitcell_6t.sym} 4000 35600 0 0 {name=Xr178c20}
N 3960 35640 3940 35640 {}
C {lab_pin.sym} 3940 35640 0 0 {name=l28581 lab=BL20}
N 3960 35600 3940 35600 {}
C {lab_pin.sym} 3940 35600 0 0 {name=l28582 lab=BLB20}
N 3960 35560 3940 35560 {}
C {lab_pin.sym} 3940 35560 0 0 {name=l28583 lab=WL178}
N 4040 35640 4060 35640 {}
C {lab_pin.sym} 4060 35640 0 0 {name=l28584 lab=VDD}
N 4040 35560 4060 35560 {}
C {lab_pin.sym} 4060 35560 0 0 {name=l28585 lab=VSS}
C {bitcell_6t.sym} 4200 35600 0 0 {name=Xr178c21}
N 4160 35640 4140 35640 {}
C {lab_pin.sym} 4140 35640 0 0 {name=l28586 lab=BL21}
N 4160 35600 4140 35600 {}
C {lab_pin.sym} 4140 35600 0 0 {name=l28587 lab=BLB21}
N 4160 35560 4140 35560 {}
C {lab_pin.sym} 4140 35560 0 0 {name=l28588 lab=WL178}
N 4240 35640 4260 35640 {}
C {lab_pin.sym} 4260 35640 0 0 {name=l28589 lab=VDD}
N 4240 35560 4260 35560 {}
C {lab_pin.sym} 4260 35560 0 0 {name=l28590 lab=VSS}
C {bitcell_6t.sym} 4400 35600 0 0 {name=Xr178c22}
N 4360 35640 4340 35640 {}
C {lab_pin.sym} 4340 35640 0 0 {name=l28591 lab=BL22}
N 4360 35600 4340 35600 {}
C {lab_pin.sym} 4340 35600 0 0 {name=l28592 lab=BLB22}
N 4360 35560 4340 35560 {}
C {lab_pin.sym} 4340 35560 0 0 {name=l28593 lab=WL178}
N 4440 35640 4460 35640 {}
C {lab_pin.sym} 4460 35640 0 0 {name=l28594 lab=VDD}
N 4440 35560 4460 35560 {}
C {lab_pin.sym} 4460 35560 0 0 {name=l28595 lab=VSS}
C {bitcell_6t.sym} 4600 35600 0 0 {name=Xr178c23}
N 4560 35640 4540 35640 {}
C {lab_pin.sym} 4540 35640 0 0 {name=l28596 lab=BL23}
N 4560 35600 4540 35600 {}
C {lab_pin.sym} 4540 35600 0 0 {name=l28597 lab=BLB23}
N 4560 35560 4540 35560 {}
C {lab_pin.sym} 4540 35560 0 0 {name=l28598 lab=WL178}
N 4640 35640 4660 35640 {}
C {lab_pin.sym} 4660 35640 0 0 {name=l28599 lab=VDD}
N 4640 35560 4660 35560 {}
C {lab_pin.sym} 4660 35560 0 0 {name=l28600 lab=VSS}
C {bitcell_6t.sym} 4800 35600 0 0 {name=Xr178c24}
N 4760 35640 4740 35640 {}
C {lab_pin.sym} 4740 35640 0 0 {name=l28601 lab=BL24}
N 4760 35600 4740 35600 {}
C {lab_pin.sym} 4740 35600 0 0 {name=l28602 lab=BLB24}
N 4760 35560 4740 35560 {}
C {lab_pin.sym} 4740 35560 0 0 {name=l28603 lab=WL178}
N 4840 35640 4860 35640 {}
C {lab_pin.sym} 4860 35640 0 0 {name=l28604 lab=VDD}
N 4840 35560 4860 35560 {}
C {lab_pin.sym} 4860 35560 0 0 {name=l28605 lab=VSS}
C {bitcell_6t.sym} 5000 35600 0 0 {name=Xr178c25}
N 4960 35640 4940 35640 {}
C {lab_pin.sym} 4940 35640 0 0 {name=l28606 lab=BL25}
N 4960 35600 4940 35600 {}
C {lab_pin.sym} 4940 35600 0 0 {name=l28607 lab=BLB25}
N 4960 35560 4940 35560 {}
C {lab_pin.sym} 4940 35560 0 0 {name=l28608 lab=WL178}
N 5040 35640 5060 35640 {}
C {lab_pin.sym} 5060 35640 0 0 {name=l28609 lab=VDD}
N 5040 35560 5060 35560 {}
C {lab_pin.sym} 5060 35560 0 0 {name=l28610 lab=VSS}
C {bitcell_6t.sym} 5200 35600 0 0 {name=Xr178c26}
N 5160 35640 5140 35640 {}
C {lab_pin.sym} 5140 35640 0 0 {name=l28611 lab=BL26}
N 5160 35600 5140 35600 {}
C {lab_pin.sym} 5140 35600 0 0 {name=l28612 lab=BLB26}
N 5160 35560 5140 35560 {}
C {lab_pin.sym} 5140 35560 0 0 {name=l28613 lab=WL178}
N 5240 35640 5260 35640 {}
C {lab_pin.sym} 5260 35640 0 0 {name=l28614 lab=VDD}
N 5240 35560 5260 35560 {}
C {lab_pin.sym} 5260 35560 0 0 {name=l28615 lab=VSS}
C {bitcell_6t.sym} 5400 35600 0 0 {name=Xr178c27}
N 5360 35640 5340 35640 {}
C {lab_pin.sym} 5340 35640 0 0 {name=l28616 lab=BL27}
N 5360 35600 5340 35600 {}
C {lab_pin.sym} 5340 35600 0 0 {name=l28617 lab=BLB27}
N 5360 35560 5340 35560 {}
C {lab_pin.sym} 5340 35560 0 0 {name=l28618 lab=WL178}
N 5440 35640 5460 35640 {}
C {lab_pin.sym} 5460 35640 0 0 {name=l28619 lab=VDD}
N 5440 35560 5460 35560 {}
C {lab_pin.sym} 5460 35560 0 0 {name=l28620 lab=VSS}
C {bitcell_6t.sym} 5600 35600 0 0 {name=Xr178c28}
N 5560 35640 5540 35640 {}
C {lab_pin.sym} 5540 35640 0 0 {name=l28621 lab=BL28}
N 5560 35600 5540 35600 {}
C {lab_pin.sym} 5540 35600 0 0 {name=l28622 lab=BLB28}
N 5560 35560 5540 35560 {}
C {lab_pin.sym} 5540 35560 0 0 {name=l28623 lab=WL178}
N 5640 35640 5660 35640 {}
C {lab_pin.sym} 5660 35640 0 0 {name=l28624 lab=VDD}
N 5640 35560 5660 35560 {}
C {lab_pin.sym} 5660 35560 0 0 {name=l28625 lab=VSS}
C {bitcell_6t.sym} 5800 35600 0 0 {name=Xr178c29}
N 5760 35640 5740 35640 {}
C {lab_pin.sym} 5740 35640 0 0 {name=l28626 lab=BL29}
N 5760 35600 5740 35600 {}
C {lab_pin.sym} 5740 35600 0 0 {name=l28627 lab=BLB29}
N 5760 35560 5740 35560 {}
C {lab_pin.sym} 5740 35560 0 0 {name=l28628 lab=WL178}
N 5840 35640 5860 35640 {}
C {lab_pin.sym} 5860 35640 0 0 {name=l28629 lab=VDD}
N 5840 35560 5860 35560 {}
C {lab_pin.sym} 5860 35560 0 0 {name=l28630 lab=VSS}
C {bitcell_6t.sym} 6000 35600 0 0 {name=Xr178c30}
N 5960 35640 5940 35640 {}
C {lab_pin.sym} 5940 35640 0 0 {name=l28631 lab=BL30}
N 5960 35600 5940 35600 {}
C {lab_pin.sym} 5940 35600 0 0 {name=l28632 lab=BLB30}
N 5960 35560 5940 35560 {}
C {lab_pin.sym} 5940 35560 0 0 {name=l28633 lab=WL178}
N 6040 35640 6060 35640 {}
C {lab_pin.sym} 6060 35640 0 0 {name=l28634 lab=VDD}
N 6040 35560 6060 35560 {}
C {lab_pin.sym} 6060 35560 0 0 {name=l28635 lab=VSS}
C {bitcell_6t.sym} 6200 35600 0 0 {name=Xr178c31}
N 6160 35640 6140 35640 {}
C {lab_pin.sym} 6140 35640 0 0 {name=l28636 lab=BL31}
N 6160 35600 6140 35600 {}
C {lab_pin.sym} 6140 35600 0 0 {name=l28637 lab=BLB31}
N 6160 35560 6140 35560 {}
C {lab_pin.sym} 6140 35560 0 0 {name=l28638 lab=WL178}
N 6240 35640 6260 35640 {}
C {lab_pin.sym} 6260 35640 0 0 {name=l28639 lab=VDD}
N 6240 35560 6260 35560 {}
C {lab_pin.sym} 6260 35560 0 0 {name=l28640 lab=VSS}
C {bitcell_6t.sym} 0 35800 0 0 {name=Xr179c0}
N -40 35840 -60 35840 {}
C {lab_pin.sym} -60 35840 0 0 {name=l28641 lab=BL0}
N -40 35800 -60 35800 {}
C {lab_pin.sym} -60 35800 0 0 {name=l28642 lab=BLB0}
N -40 35760 -60 35760 {}
C {lab_pin.sym} -60 35760 0 0 {name=l28643 lab=WL179}
N 40 35840 60 35840 {}
C {lab_pin.sym} 60 35840 0 0 {name=l28644 lab=VDD}
N 40 35760 60 35760 {}
C {lab_pin.sym} 60 35760 0 0 {name=l28645 lab=VSS}
C {bitcell_6t.sym} 200 35800 0 0 {name=Xr179c1}
N 160 35840 140 35840 {}
C {lab_pin.sym} 140 35840 0 0 {name=l28646 lab=BL1}
N 160 35800 140 35800 {}
C {lab_pin.sym} 140 35800 0 0 {name=l28647 lab=BLB1}
N 160 35760 140 35760 {}
C {lab_pin.sym} 140 35760 0 0 {name=l28648 lab=WL179}
N 240 35840 260 35840 {}
C {lab_pin.sym} 260 35840 0 0 {name=l28649 lab=VDD}
N 240 35760 260 35760 {}
C {lab_pin.sym} 260 35760 0 0 {name=l28650 lab=VSS}
C {bitcell_6t.sym} 400 35800 0 0 {name=Xr179c2}
N 360 35840 340 35840 {}
C {lab_pin.sym} 340 35840 0 0 {name=l28651 lab=BL2}
N 360 35800 340 35800 {}
C {lab_pin.sym} 340 35800 0 0 {name=l28652 lab=BLB2}
N 360 35760 340 35760 {}
C {lab_pin.sym} 340 35760 0 0 {name=l28653 lab=WL179}
N 440 35840 460 35840 {}
C {lab_pin.sym} 460 35840 0 0 {name=l28654 lab=VDD}
N 440 35760 460 35760 {}
C {lab_pin.sym} 460 35760 0 0 {name=l28655 lab=VSS}
C {bitcell_6t.sym} 600 35800 0 0 {name=Xr179c3}
N 560 35840 540 35840 {}
C {lab_pin.sym} 540 35840 0 0 {name=l28656 lab=BL3}
N 560 35800 540 35800 {}
C {lab_pin.sym} 540 35800 0 0 {name=l28657 lab=BLB3}
N 560 35760 540 35760 {}
C {lab_pin.sym} 540 35760 0 0 {name=l28658 lab=WL179}
N 640 35840 660 35840 {}
C {lab_pin.sym} 660 35840 0 0 {name=l28659 lab=VDD}
N 640 35760 660 35760 {}
C {lab_pin.sym} 660 35760 0 0 {name=l28660 lab=VSS}
C {bitcell_6t.sym} 800 35800 0 0 {name=Xr179c4}
N 760 35840 740 35840 {}
C {lab_pin.sym} 740 35840 0 0 {name=l28661 lab=BL4}
N 760 35800 740 35800 {}
C {lab_pin.sym} 740 35800 0 0 {name=l28662 lab=BLB4}
N 760 35760 740 35760 {}
C {lab_pin.sym} 740 35760 0 0 {name=l28663 lab=WL179}
N 840 35840 860 35840 {}
C {lab_pin.sym} 860 35840 0 0 {name=l28664 lab=VDD}
N 840 35760 860 35760 {}
C {lab_pin.sym} 860 35760 0 0 {name=l28665 lab=VSS}
C {bitcell_6t.sym} 1000 35800 0 0 {name=Xr179c5}
N 960 35840 940 35840 {}
C {lab_pin.sym} 940 35840 0 0 {name=l28666 lab=BL5}
N 960 35800 940 35800 {}
C {lab_pin.sym} 940 35800 0 0 {name=l28667 lab=BLB5}
N 960 35760 940 35760 {}
C {lab_pin.sym} 940 35760 0 0 {name=l28668 lab=WL179}
N 1040 35840 1060 35840 {}
C {lab_pin.sym} 1060 35840 0 0 {name=l28669 lab=VDD}
N 1040 35760 1060 35760 {}
C {lab_pin.sym} 1060 35760 0 0 {name=l28670 lab=VSS}
C {bitcell_6t.sym} 1200 35800 0 0 {name=Xr179c6}
N 1160 35840 1140 35840 {}
C {lab_pin.sym} 1140 35840 0 0 {name=l28671 lab=BL6}
N 1160 35800 1140 35800 {}
C {lab_pin.sym} 1140 35800 0 0 {name=l28672 lab=BLB6}
N 1160 35760 1140 35760 {}
C {lab_pin.sym} 1140 35760 0 0 {name=l28673 lab=WL179}
N 1240 35840 1260 35840 {}
C {lab_pin.sym} 1260 35840 0 0 {name=l28674 lab=VDD}
N 1240 35760 1260 35760 {}
C {lab_pin.sym} 1260 35760 0 0 {name=l28675 lab=VSS}
C {bitcell_6t.sym} 1400 35800 0 0 {name=Xr179c7}
N 1360 35840 1340 35840 {}
C {lab_pin.sym} 1340 35840 0 0 {name=l28676 lab=BL7}
N 1360 35800 1340 35800 {}
C {lab_pin.sym} 1340 35800 0 0 {name=l28677 lab=BLB7}
N 1360 35760 1340 35760 {}
C {lab_pin.sym} 1340 35760 0 0 {name=l28678 lab=WL179}
N 1440 35840 1460 35840 {}
C {lab_pin.sym} 1460 35840 0 0 {name=l28679 lab=VDD}
N 1440 35760 1460 35760 {}
C {lab_pin.sym} 1460 35760 0 0 {name=l28680 lab=VSS}
C {bitcell_6t.sym} 1600 35800 0 0 {name=Xr179c8}
N 1560 35840 1540 35840 {}
C {lab_pin.sym} 1540 35840 0 0 {name=l28681 lab=BL8}
N 1560 35800 1540 35800 {}
C {lab_pin.sym} 1540 35800 0 0 {name=l28682 lab=BLB8}
N 1560 35760 1540 35760 {}
C {lab_pin.sym} 1540 35760 0 0 {name=l28683 lab=WL179}
N 1640 35840 1660 35840 {}
C {lab_pin.sym} 1660 35840 0 0 {name=l28684 lab=VDD}
N 1640 35760 1660 35760 {}
C {lab_pin.sym} 1660 35760 0 0 {name=l28685 lab=VSS}
C {bitcell_6t.sym} 1800 35800 0 0 {name=Xr179c9}
N 1760 35840 1740 35840 {}
C {lab_pin.sym} 1740 35840 0 0 {name=l28686 lab=BL9}
N 1760 35800 1740 35800 {}
C {lab_pin.sym} 1740 35800 0 0 {name=l28687 lab=BLB9}
N 1760 35760 1740 35760 {}
C {lab_pin.sym} 1740 35760 0 0 {name=l28688 lab=WL179}
N 1840 35840 1860 35840 {}
C {lab_pin.sym} 1860 35840 0 0 {name=l28689 lab=VDD}
N 1840 35760 1860 35760 {}
C {lab_pin.sym} 1860 35760 0 0 {name=l28690 lab=VSS}
C {bitcell_6t.sym} 2000 35800 0 0 {name=Xr179c10}
N 1960 35840 1940 35840 {}
C {lab_pin.sym} 1940 35840 0 0 {name=l28691 lab=BL10}
N 1960 35800 1940 35800 {}
C {lab_pin.sym} 1940 35800 0 0 {name=l28692 lab=BLB10}
N 1960 35760 1940 35760 {}
C {lab_pin.sym} 1940 35760 0 0 {name=l28693 lab=WL179}
N 2040 35840 2060 35840 {}
C {lab_pin.sym} 2060 35840 0 0 {name=l28694 lab=VDD}
N 2040 35760 2060 35760 {}
C {lab_pin.sym} 2060 35760 0 0 {name=l28695 lab=VSS}
C {bitcell_6t.sym} 2200 35800 0 0 {name=Xr179c11}
N 2160 35840 2140 35840 {}
C {lab_pin.sym} 2140 35840 0 0 {name=l28696 lab=BL11}
N 2160 35800 2140 35800 {}
C {lab_pin.sym} 2140 35800 0 0 {name=l28697 lab=BLB11}
N 2160 35760 2140 35760 {}
C {lab_pin.sym} 2140 35760 0 0 {name=l28698 lab=WL179}
N 2240 35840 2260 35840 {}
C {lab_pin.sym} 2260 35840 0 0 {name=l28699 lab=VDD}
N 2240 35760 2260 35760 {}
C {lab_pin.sym} 2260 35760 0 0 {name=l28700 lab=VSS}
C {bitcell_6t.sym} 2400 35800 0 0 {name=Xr179c12}
N 2360 35840 2340 35840 {}
C {lab_pin.sym} 2340 35840 0 0 {name=l28701 lab=BL12}
N 2360 35800 2340 35800 {}
C {lab_pin.sym} 2340 35800 0 0 {name=l28702 lab=BLB12}
N 2360 35760 2340 35760 {}
C {lab_pin.sym} 2340 35760 0 0 {name=l28703 lab=WL179}
N 2440 35840 2460 35840 {}
C {lab_pin.sym} 2460 35840 0 0 {name=l28704 lab=VDD}
N 2440 35760 2460 35760 {}
C {lab_pin.sym} 2460 35760 0 0 {name=l28705 lab=VSS}
C {bitcell_6t.sym} 2600 35800 0 0 {name=Xr179c13}
N 2560 35840 2540 35840 {}
C {lab_pin.sym} 2540 35840 0 0 {name=l28706 lab=BL13}
N 2560 35800 2540 35800 {}
C {lab_pin.sym} 2540 35800 0 0 {name=l28707 lab=BLB13}
N 2560 35760 2540 35760 {}
C {lab_pin.sym} 2540 35760 0 0 {name=l28708 lab=WL179}
N 2640 35840 2660 35840 {}
C {lab_pin.sym} 2660 35840 0 0 {name=l28709 lab=VDD}
N 2640 35760 2660 35760 {}
C {lab_pin.sym} 2660 35760 0 0 {name=l28710 lab=VSS}
C {bitcell_6t.sym} 2800 35800 0 0 {name=Xr179c14}
N 2760 35840 2740 35840 {}
C {lab_pin.sym} 2740 35840 0 0 {name=l28711 lab=BL14}
N 2760 35800 2740 35800 {}
C {lab_pin.sym} 2740 35800 0 0 {name=l28712 lab=BLB14}
N 2760 35760 2740 35760 {}
C {lab_pin.sym} 2740 35760 0 0 {name=l28713 lab=WL179}
N 2840 35840 2860 35840 {}
C {lab_pin.sym} 2860 35840 0 0 {name=l28714 lab=VDD}
N 2840 35760 2860 35760 {}
C {lab_pin.sym} 2860 35760 0 0 {name=l28715 lab=VSS}
C {bitcell_6t.sym} 3000 35800 0 0 {name=Xr179c15}
N 2960 35840 2940 35840 {}
C {lab_pin.sym} 2940 35840 0 0 {name=l28716 lab=BL15}
N 2960 35800 2940 35800 {}
C {lab_pin.sym} 2940 35800 0 0 {name=l28717 lab=BLB15}
N 2960 35760 2940 35760 {}
C {lab_pin.sym} 2940 35760 0 0 {name=l28718 lab=WL179}
N 3040 35840 3060 35840 {}
C {lab_pin.sym} 3060 35840 0 0 {name=l28719 lab=VDD}
N 3040 35760 3060 35760 {}
C {lab_pin.sym} 3060 35760 0 0 {name=l28720 lab=VSS}
C {bitcell_6t.sym} 3200 35800 0 0 {name=Xr179c16}
N 3160 35840 3140 35840 {}
C {lab_pin.sym} 3140 35840 0 0 {name=l28721 lab=BL16}
N 3160 35800 3140 35800 {}
C {lab_pin.sym} 3140 35800 0 0 {name=l28722 lab=BLB16}
N 3160 35760 3140 35760 {}
C {lab_pin.sym} 3140 35760 0 0 {name=l28723 lab=WL179}
N 3240 35840 3260 35840 {}
C {lab_pin.sym} 3260 35840 0 0 {name=l28724 lab=VDD}
N 3240 35760 3260 35760 {}
C {lab_pin.sym} 3260 35760 0 0 {name=l28725 lab=VSS}
C {bitcell_6t.sym} 3400 35800 0 0 {name=Xr179c17}
N 3360 35840 3340 35840 {}
C {lab_pin.sym} 3340 35840 0 0 {name=l28726 lab=BL17}
N 3360 35800 3340 35800 {}
C {lab_pin.sym} 3340 35800 0 0 {name=l28727 lab=BLB17}
N 3360 35760 3340 35760 {}
C {lab_pin.sym} 3340 35760 0 0 {name=l28728 lab=WL179}
N 3440 35840 3460 35840 {}
C {lab_pin.sym} 3460 35840 0 0 {name=l28729 lab=VDD}
N 3440 35760 3460 35760 {}
C {lab_pin.sym} 3460 35760 0 0 {name=l28730 lab=VSS}
C {bitcell_6t.sym} 3600 35800 0 0 {name=Xr179c18}
N 3560 35840 3540 35840 {}
C {lab_pin.sym} 3540 35840 0 0 {name=l28731 lab=BL18}
N 3560 35800 3540 35800 {}
C {lab_pin.sym} 3540 35800 0 0 {name=l28732 lab=BLB18}
N 3560 35760 3540 35760 {}
C {lab_pin.sym} 3540 35760 0 0 {name=l28733 lab=WL179}
N 3640 35840 3660 35840 {}
C {lab_pin.sym} 3660 35840 0 0 {name=l28734 lab=VDD}
N 3640 35760 3660 35760 {}
C {lab_pin.sym} 3660 35760 0 0 {name=l28735 lab=VSS}
C {bitcell_6t.sym} 3800 35800 0 0 {name=Xr179c19}
N 3760 35840 3740 35840 {}
C {lab_pin.sym} 3740 35840 0 0 {name=l28736 lab=BL19}
N 3760 35800 3740 35800 {}
C {lab_pin.sym} 3740 35800 0 0 {name=l28737 lab=BLB19}
N 3760 35760 3740 35760 {}
C {lab_pin.sym} 3740 35760 0 0 {name=l28738 lab=WL179}
N 3840 35840 3860 35840 {}
C {lab_pin.sym} 3860 35840 0 0 {name=l28739 lab=VDD}
N 3840 35760 3860 35760 {}
C {lab_pin.sym} 3860 35760 0 0 {name=l28740 lab=VSS}
C {bitcell_6t.sym} 4000 35800 0 0 {name=Xr179c20}
N 3960 35840 3940 35840 {}
C {lab_pin.sym} 3940 35840 0 0 {name=l28741 lab=BL20}
N 3960 35800 3940 35800 {}
C {lab_pin.sym} 3940 35800 0 0 {name=l28742 lab=BLB20}
N 3960 35760 3940 35760 {}
C {lab_pin.sym} 3940 35760 0 0 {name=l28743 lab=WL179}
N 4040 35840 4060 35840 {}
C {lab_pin.sym} 4060 35840 0 0 {name=l28744 lab=VDD}
N 4040 35760 4060 35760 {}
C {lab_pin.sym} 4060 35760 0 0 {name=l28745 lab=VSS}
C {bitcell_6t.sym} 4200 35800 0 0 {name=Xr179c21}
N 4160 35840 4140 35840 {}
C {lab_pin.sym} 4140 35840 0 0 {name=l28746 lab=BL21}
N 4160 35800 4140 35800 {}
C {lab_pin.sym} 4140 35800 0 0 {name=l28747 lab=BLB21}
N 4160 35760 4140 35760 {}
C {lab_pin.sym} 4140 35760 0 0 {name=l28748 lab=WL179}
N 4240 35840 4260 35840 {}
C {lab_pin.sym} 4260 35840 0 0 {name=l28749 lab=VDD}
N 4240 35760 4260 35760 {}
C {lab_pin.sym} 4260 35760 0 0 {name=l28750 lab=VSS}
C {bitcell_6t.sym} 4400 35800 0 0 {name=Xr179c22}
N 4360 35840 4340 35840 {}
C {lab_pin.sym} 4340 35840 0 0 {name=l28751 lab=BL22}
N 4360 35800 4340 35800 {}
C {lab_pin.sym} 4340 35800 0 0 {name=l28752 lab=BLB22}
N 4360 35760 4340 35760 {}
C {lab_pin.sym} 4340 35760 0 0 {name=l28753 lab=WL179}
N 4440 35840 4460 35840 {}
C {lab_pin.sym} 4460 35840 0 0 {name=l28754 lab=VDD}
N 4440 35760 4460 35760 {}
C {lab_pin.sym} 4460 35760 0 0 {name=l28755 lab=VSS}
C {bitcell_6t.sym} 4600 35800 0 0 {name=Xr179c23}
N 4560 35840 4540 35840 {}
C {lab_pin.sym} 4540 35840 0 0 {name=l28756 lab=BL23}
N 4560 35800 4540 35800 {}
C {lab_pin.sym} 4540 35800 0 0 {name=l28757 lab=BLB23}
N 4560 35760 4540 35760 {}
C {lab_pin.sym} 4540 35760 0 0 {name=l28758 lab=WL179}
N 4640 35840 4660 35840 {}
C {lab_pin.sym} 4660 35840 0 0 {name=l28759 lab=VDD}
N 4640 35760 4660 35760 {}
C {lab_pin.sym} 4660 35760 0 0 {name=l28760 lab=VSS}
C {bitcell_6t.sym} 4800 35800 0 0 {name=Xr179c24}
N 4760 35840 4740 35840 {}
C {lab_pin.sym} 4740 35840 0 0 {name=l28761 lab=BL24}
N 4760 35800 4740 35800 {}
C {lab_pin.sym} 4740 35800 0 0 {name=l28762 lab=BLB24}
N 4760 35760 4740 35760 {}
C {lab_pin.sym} 4740 35760 0 0 {name=l28763 lab=WL179}
N 4840 35840 4860 35840 {}
C {lab_pin.sym} 4860 35840 0 0 {name=l28764 lab=VDD}
N 4840 35760 4860 35760 {}
C {lab_pin.sym} 4860 35760 0 0 {name=l28765 lab=VSS}
C {bitcell_6t.sym} 5000 35800 0 0 {name=Xr179c25}
N 4960 35840 4940 35840 {}
C {lab_pin.sym} 4940 35840 0 0 {name=l28766 lab=BL25}
N 4960 35800 4940 35800 {}
C {lab_pin.sym} 4940 35800 0 0 {name=l28767 lab=BLB25}
N 4960 35760 4940 35760 {}
C {lab_pin.sym} 4940 35760 0 0 {name=l28768 lab=WL179}
N 5040 35840 5060 35840 {}
C {lab_pin.sym} 5060 35840 0 0 {name=l28769 lab=VDD}
N 5040 35760 5060 35760 {}
C {lab_pin.sym} 5060 35760 0 0 {name=l28770 lab=VSS}
C {bitcell_6t.sym} 5200 35800 0 0 {name=Xr179c26}
N 5160 35840 5140 35840 {}
C {lab_pin.sym} 5140 35840 0 0 {name=l28771 lab=BL26}
N 5160 35800 5140 35800 {}
C {lab_pin.sym} 5140 35800 0 0 {name=l28772 lab=BLB26}
N 5160 35760 5140 35760 {}
C {lab_pin.sym} 5140 35760 0 0 {name=l28773 lab=WL179}
N 5240 35840 5260 35840 {}
C {lab_pin.sym} 5260 35840 0 0 {name=l28774 lab=VDD}
N 5240 35760 5260 35760 {}
C {lab_pin.sym} 5260 35760 0 0 {name=l28775 lab=VSS}
C {bitcell_6t.sym} 5400 35800 0 0 {name=Xr179c27}
N 5360 35840 5340 35840 {}
C {lab_pin.sym} 5340 35840 0 0 {name=l28776 lab=BL27}
N 5360 35800 5340 35800 {}
C {lab_pin.sym} 5340 35800 0 0 {name=l28777 lab=BLB27}
N 5360 35760 5340 35760 {}
C {lab_pin.sym} 5340 35760 0 0 {name=l28778 lab=WL179}
N 5440 35840 5460 35840 {}
C {lab_pin.sym} 5460 35840 0 0 {name=l28779 lab=VDD}
N 5440 35760 5460 35760 {}
C {lab_pin.sym} 5460 35760 0 0 {name=l28780 lab=VSS}
C {bitcell_6t.sym} 5600 35800 0 0 {name=Xr179c28}
N 5560 35840 5540 35840 {}
C {lab_pin.sym} 5540 35840 0 0 {name=l28781 lab=BL28}
N 5560 35800 5540 35800 {}
C {lab_pin.sym} 5540 35800 0 0 {name=l28782 lab=BLB28}
N 5560 35760 5540 35760 {}
C {lab_pin.sym} 5540 35760 0 0 {name=l28783 lab=WL179}
N 5640 35840 5660 35840 {}
C {lab_pin.sym} 5660 35840 0 0 {name=l28784 lab=VDD}
N 5640 35760 5660 35760 {}
C {lab_pin.sym} 5660 35760 0 0 {name=l28785 lab=VSS}
C {bitcell_6t.sym} 5800 35800 0 0 {name=Xr179c29}
N 5760 35840 5740 35840 {}
C {lab_pin.sym} 5740 35840 0 0 {name=l28786 lab=BL29}
N 5760 35800 5740 35800 {}
C {lab_pin.sym} 5740 35800 0 0 {name=l28787 lab=BLB29}
N 5760 35760 5740 35760 {}
C {lab_pin.sym} 5740 35760 0 0 {name=l28788 lab=WL179}
N 5840 35840 5860 35840 {}
C {lab_pin.sym} 5860 35840 0 0 {name=l28789 lab=VDD}
N 5840 35760 5860 35760 {}
C {lab_pin.sym} 5860 35760 0 0 {name=l28790 lab=VSS}
C {bitcell_6t.sym} 6000 35800 0 0 {name=Xr179c30}
N 5960 35840 5940 35840 {}
C {lab_pin.sym} 5940 35840 0 0 {name=l28791 lab=BL30}
N 5960 35800 5940 35800 {}
C {lab_pin.sym} 5940 35800 0 0 {name=l28792 lab=BLB30}
N 5960 35760 5940 35760 {}
C {lab_pin.sym} 5940 35760 0 0 {name=l28793 lab=WL179}
N 6040 35840 6060 35840 {}
C {lab_pin.sym} 6060 35840 0 0 {name=l28794 lab=VDD}
N 6040 35760 6060 35760 {}
C {lab_pin.sym} 6060 35760 0 0 {name=l28795 lab=VSS}
C {bitcell_6t.sym} 6200 35800 0 0 {name=Xr179c31}
N 6160 35840 6140 35840 {}
C {lab_pin.sym} 6140 35840 0 0 {name=l28796 lab=BL31}
N 6160 35800 6140 35800 {}
C {lab_pin.sym} 6140 35800 0 0 {name=l28797 lab=BLB31}
N 6160 35760 6140 35760 {}
C {lab_pin.sym} 6140 35760 0 0 {name=l28798 lab=WL179}
N 6240 35840 6260 35840 {}
C {lab_pin.sym} 6260 35840 0 0 {name=l28799 lab=VDD}
N 6240 35760 6260 35760 {}
C {lab_pin.sym} 6260 35760 0 0 {name=l28800 lab=VSS}
C {bitcell_6t.sym} 0 36000 0 0 {name=Xr180c0}
N -40 36040 -60 36040 {}
C {lab_pin.sym} -60 36040 0 0 {name=l28801 lab=BL0}
N -40 36000 -60 36000 {}
C {lab_pin.sym} -60 36000 0 0 {name=l28802 lab=BLB0}
N -40 35960 -60 35960 {}
C {lab_pin.sym} -60 35960 0 0 {name=l28803 lab=WL180}
N 40 36040 60 36040 {}
C {lab_pin.sym} 60 36040 0 0 {name=l28804 lab=VDD}
N 40 35960 60 35960 {}
C {lab_pin.sym} 60 35960 0 0 {name=l28805 lab=VSS}
C {bitcell_6t.sym} 200 36000 0 0 {name=Xr180c1}
N 160 36040 140 36040 {}
C {lab_pin.sym} 140 36040 0 0 {name=l28806 lab=BL1}
N 160 36000 140 36000 {}
C {lab_pin.sym} 140 36000 0 0 {name=l28807 lab=BLB1}
N 160 35960 140 35960 {}
C {lab_pin.sym} 140 35960 0 0 {name=l28808 lab=WL180}
N 240 36040 260 36040 {}
C {lab_pin.sym} 260 36040 0 0 {name=l28809 lab=VDD}
N 240 35960 260 35960 {}
C {lab_pin.sym} 260 35960 0 0 {name=l28810 lab=VSS}
C {bitcell_6t.sym} 400 36000 0 0 {name=Xr180c2}
N 360 36040 340 36040 {}
C {lab_pin.sym} 340 36040 0 0 {name=l28811 lab=BL2}
N 360 36000 340 36000 {}
C {lab_pin.sym} 340 36000 0 0 {name=l28812 lab=BLB2}
N 360 35960 340 35960 {}
C {lab_pin.sym} 340 35960 0 0 {name=l28813 lab=WL180}
N 440 36040 460 36040 {}
C {lab_pin.sym} 460 36040 0 0 {name=l28814 lab=VDD}
N 440 35960 460 35960 {}
C {lab_pin.sym} 460 35960 0 0 {name=l28815 lab=VSS}
C {bitcell_6t.sym} 600 36000 0 0 {name=Xr180c3}
N 560 36040 540 36040 {}
C {lab_pin.sym} 540 36040 0 0 {name=l28816 lab=BL3}
N 560 36000 540 36000 {}
C {lab_pin.sym} 540 36000 0 0 {name=l28817 lab=BLB3}
N 560 35960 540 35960 {}
C {lab_pin.sym} 540 35960 0 0 {name=l28818 lab=WL180}
N 640 36040 660 36040 {}
C {lab_pin.sym} 660 36040 0 0 {name=l28819 lab=VDD}
N 640 35960 660 35960 {}
C {lab_pin.sym} 660 35960 0 0 {name=l28820 lab=VSS}
C {bitcell_6t.sym} 800 36000 0 0 {name=Xr180c4}
N 760 36040 740 36040 {}
C {lab_pin.sym} 740 36040 0 0 {name=l28821 lab=BL4}
N 760 36000 740 36000 {}
C {lab_pin.sym} 740 36000 0 0 {name=l28822 lab=BLB4}
N 760 35960 740 35960 {}
C {lab_pin.sym} 740 35960 0 0 {name=l28823 lab=WL180}
N 840 36040 860 36040 {}
C {lab_pin.sym} 860 36040 0 0 {name=l28824 lab=VDD}
N 840 35960 860 35960 {}
C {lab_pin.sym} 860 35960 0 0 {name=l28825 lab=VSS}
C {bitcell_6t.sym} 1000 36000 0 0 {name=Xr180c5}
N 960 36040 940 36040 {}
C {lab_pin.sym} 940 36040 0 0 {name=l28826 lab=BL5}
N 960 36000 940 36000 {}
C {lab_pin.sym} 940 36000 0 0 {name=l28827 lab=BLB5}
N 960 35960 940 35960 {}
C {lab_pin.sym} 940 35960 0 0 {name=l28828 lab=WL180}
N 1040 36040 1060 36040 {}
C {lab_pin.sym} 1060 36040 0 0 {name=l28829 lab=VDD}
N 1040 35960 1060 35960 {}
C {lab_pin.sym} 1060 35960 0 0 {name=l28830 lab=VSS}
C {bitcell_6t.sym} 1200 36000 0 0 {name=Xr180c6}
N 1160 36040 1140 36040 {}
C {lab_pin.sym} 1140 36040 0 0 {name=l28831 lab=BL6}
N 1160 36000 1140 36000 {}
C {lab_pin.sym} 1140 36000 0 0 {name=l28832 lab=BLB6}
N 1160 35960 1140 35960 {}
C {lab_pin.sym} 1140 35960 0 0 {name=l28833 lab=WL180}
N 1240 36040 1260 36040 {}
C {lab_pin.sym} 1260 36040 0 0 {name=l28834 lab=VDD}
N 1240 35960 1260 35960 {}
C {lab_pin.sym} 1260 35960 0 0 {name=l28835 lab=VSS}
C {bitcell_6t.sym} 1400 36000 0 0 {name=Xr180c7}
N 1360 36040 1340 36040 {}
C {lab_pin.sym} 1340 36040 0 0 {name=l28836 lab=BL7}
N 1360 36000 1340 36000 {}
C {lab_pin.sym} 1340 36000 0 0 {name=l28837 lab=BLB7}
N 1360 35960 1340 35960 {}
C {lab_pin.sym} 1340 35960 0 0 {name=l28838 lab=WL180}
N 1440 36040 1460 36040 {}
C {lab_pin.sym} 1460 36040 0 0 {name=l28839 lab=VDD}
N 1440 35960 1460 35960 {}
C {lab_pin.sym} 1460 35960 0 0 {name=l28840 lab=VSS}
C {bitcell_6t.sym} 1600 36000 0 0 {name=Xr180c8}
N 1560 36040 1540 36040 {}
C {lab_pin.sym} 1540 36040 0 0 {name=l28841 lab=BL8}
N 1560 36000 1540 36000 {}
C {lab_pin.sym} 1540 36000 0 0 {name=l28842 lab=BLB8}
N 1560 35960 1540 35960 {}
C {lab_pin.sym} 1540 35960 0 0 {name=l28843 lab=WL180}
N 1640 36040 1660 36040 {}
C {lab_pin.sym} 1660 36040 0 0 {name=l28844 lab=VDD}
N 1640 35960 1660 35960 {}
C {lab_pin.sym} 1660 35960 0 0 {name=l28845 lab=VSS}
C {bitcell_6t.sym} 1800 36000 0 0 {name=Xr180c9}
N 1760 36040 1740 36040 {}
C {lab_pin.sym} 1740 36040 0 0 {name=l28846 lab=BL9}
N 1760 36000 1740 36000 {}
C {lab_pin.sym} 1740 36000 0 0 {name=l28847 lab=BLB9}
N 1760 35960 1740 35960 {}
C {lab_pin.sym} 1740 35960 0 0 {name=l28848 lab=WL180}
N 1840 36040 1860 36040 {}
C {lab_pin.sym} 1860 36040 0 0 {name=l28849 lab=VDD}
N 1840 35960 1860 35960 {}
C {lab_pin.sym} 1860 35960 0 0 {name=l28850 lab=VSS}
C {bitcell_6t.sym} 2000 36000 0 0 {name=Xr180c10}
N 1960 36040 1940 36040 {}
C {lab_pin.sym} 1940 36040 0 0 {name=l28851 lab=BL10}
N 1960 36000 1940 36000 {}
C {lab_pin.sym} 1940 36000 0 0 {name=l28852 lab=BLB10}
N 1960 35960 1940 35960 {}
C {lab_pin.sym} 1940 35960 0 0 {name=l28853 lab=WL180}
N 2040 36040 2060 36040 {}
C {lab_pin.sym} 2060 36040 0 0 {name=l28854 lab=VDD}
N 2040 35960 2060 35960 {}
C {lab_pin.sym} 2060 35960 0 0 {name=l28855 lab=VSS}
C {bitcell_6t.sym} 2200 36000 0 0 {name=Xr180c11}
N 2160 36040 2140 36040 {}
C {lab_pin.sym} 2140 36040 0 0 {name=l28856 lab=BL11}
N 2160 36000 2140 36000 {}
C {lab_pin.sym} 2140 36000 0 0 {name=l28857 lab=BLB11}
N 2160 35960 2140 35960 {}
C {lab_pin.sym} 2140 35960 0 0 {name=l28858 lab=WL180}
N 2240 36040 2260 36040 {}
C {lab_pin.sym} 2260 36040 0 0 {name=l28859 lab=VDD}
N 2240 35960 2260 35960 {}
C {lab_pin.sym} 2260 35960 0 0 {name=l28860 lab=VSS}
C {bitcell_6t.sym} 2400 36000 0 0 {name=Xr180c12}
N 2360 36040 2340 36040 {}
C {lab_pin.sym} 2340 36040 0 0 {name=l28861 lab=BL12}
N 2360 36000 2340 36000 {}
C {lab_pin.sym} 2340 36000 0 0 {name=l28862 lab=BLB12}
N 2360 35960 2340 35960 {}
C {lab_pin.sym} 2340 35960 0 0 {name=l28863 lab=WL180}
N 2440 36040 2460 36040 {}
C {lab_pin.sym} 2460 36040 0 0 {name=l28864 lab=VDD}
N 2440 35960 2460 35960 {}
C {lab_pin.sym} 2460 35960 0 0 {name=l28865 lab=VSS}
C {bitcell_6t.sym} 2600 36000 0 0 {name=Xr180c13}
N 2560 36040 2540 36040 {}
C {lab_pin.sym} 2540 36040 0 0 {name=l28866 lab=BL13}
N 2560 36000 2540 36000 {}
C {lab_pin.sym} 2540 36000 0 0 {name=l28867 lab=BLB13}
N 2560 35960 2540 35960 {}
C {lab_pin.sym} 2540 35960 0 0 {name=l28868 lab=WL180}
N 2640 36040 2660 36040 {}
C {lab_pin.sym} 2660 36040 0 0 {name=l28869 lab=VDD}
N 2640 35960 2660 35960 {}
C {lab_pin.sym} 2660 35960 0 0 {name=l28870 lab=VSS}
C {bitcell_6t.sym} 2800 36000 0 0 {name=Xr180c14}
N 2760 36040 2740 36040 {}
C {lab_pin.sym} 2740 36040 0 0 {name=l28871 lab=BL14}
N 2760 36000 2740 36000 {}
C {lab_pin.sym} 2740 36000 0 0 {name=l28872 lab=BLB14}
N 2760 35960 2740 35960 {}
C {lab_pin.sym} 2740 35960 0 0 {name=l28873 lab=WL180}
N 2840 36040 2860 36040 {}
C {lab_pin.sym} 2860 36040 0 0 {name=l28874 lab=VDD}
N 2840 35960 2860 35960 {}
C {lab_pin.sym} 2860 35960 0 0 {name=l28875 lab=VSS}
C {bitcell_6t.sym} 3000 36000 0 0 {name=Xr180c15}
N 2960 36040 2940 36040 {}
C {lab_pin.sym} 2940 36040 0 0 {name=l28876 lab=BL15}
N 2960 36000 2940 36000 {}
C {lab_pin.sym} 2940 36000 0 0 {name=l28877 lab=BLB15}
N 2960 35960 2940 35960 {}
C {lab_pin.sym} 2940 35960 0 0 {name=l28878 lab=WL180}
N 3040 36040 3060 36040 {}
C {lab_pin.sym} 3060 36040 0 0 {name=l28879 lab=VDD}
N 3040 35960 3060 35960 {}
C {lab_pin.sym} 3060 35960 0 0 {name=l28880 lab=VSS}
C {bitcell_6t.sym} 3200 36000 0 0 {name=Xr180c16}
N 3160 36040 3140 36040 {}
C {lab_pin.sym} 3140 36040 0 0 {name=l28881 lab=BL16}
N 3160 36000 3140 36000 {}
C {lab_pin.sym} 3140 36000 0 0 {name=l28882 lab=BLB16}
N 3160 35960 3140 35960 {}
C {lab_pin.sym} 3140 35960 0 0 {name=l28883 lab=WL180}
N 3240 36040 3260 36040 {}
C {lab_pin.sym} 3260 36040 0 0 {name=l28884 lab=VDD}
N 3240 35960 3260 35960 {}
C {lab_pin.sym} 3260 35960 0 0 {name=l28885 lab=VSS}
C {bitcell_6t.sym} 3400 36000 0 0 {name=Xr180c17}
N 3360 36040 3340 36040 {}
C {lab_pin.sym} 3340 36040 0 0 {name=l28886 lab=BL17}
N 3360 36000 3340 36000 {}
C {lab_pin.sym} 3340 36000 0 0 {name=l28887 lab=BLB17}
N 3360 35960 3340 35960 {}
C {lab_pin.sym} 3340 35960 0 0 {name=l28888 lab=WL180}
N 3440 36040 3460 36040 {}
C {lab_pin.sym} 3460 36040 0 0 {name=l28889 lab=VDD}
N 3440 35960 3460 35960 {}
C {lab_pin.sym} 3460 35960 0 0 {name=l28890 lab=VSS}
C {bitcell_6t.sym} 3600 36000 0 0 {name=Xr180c18}
N 3560 36040 3540 36040 {}
C {lab_pin.sym} 3540 36040 0 0 {name=l28891 lab=BL18}
N 3560 36000 3540 36000 {}
C {lab_pin.sym} 3540 36000 0 0 {name=l28892 lab=BLB18}
N 3560 35960 3540 35960 {}
C {lab_pin.sym} 3540 35960 0 0 {name=l28893 lab=WL180}
N 3640 36040 3660 36040 {}
C {lab_pin.sym} 3660 36040 0 0 {name=l28894 lab=VDD}
N 3640 35960 3660 35960 {}
C {lab_pin.sym} 3660 35960 0 0 {name=l28895 lab=VSS}
C {bitcell_6t.sym} 3800 36000 0 0 {name=Xr180c19}
N 3760 36040 3740 36040 {}
C {lab_pin.sym} 3740 36040 0 0 {name=l28896 lab=BL19}
N 3760 36000 3740 36000 {}
C {lab_pin.sym} 3740 36000 0 0 {name=l28897 lab=BLB19}
N 3760 35960 3740 35960 {}
C {lab_pin.sym} 3740 35960 0 0 {name=l28898 lab=WL180}
N 3840 36040 3860 36040 {}
C {lab_pin.sym} 3860 36040 0 0 {name=l28899 lab=VDD}
N 3840 35960 3860 35960 {}
C {lab_pin.sym} 3860 35960 0 0 {name=l28900 lab=VSS}
C {bitcell_6t.sym} 4000 36000 0 0 {name=Xr180c20}
N 3960 36040 3940 36040 {}
C {lab_pin.sym} 3940 36040 0 0 {name=l28901 lab=BL20}
N 3960 36000 3940 36000 {}
C {lab_pin.sym} 3940 36000 0 0 {name=l28902 lab=BLB20}
N 3960 35960 3940 35960 {}
C {lab_pin.sym} 3940 35960 0 0 {name=l28903 lab=WL180}
N 4040 36040 4060 36040 {}
C {lab_pin.sym} 4060 36040 0 0 {name=l28904 lab=VDD}
N 4040 35960 4060 35960 {}
C {lab_pin.sym} 4060 35960 0 0 {name=l28905 lab=VSS}
C {bitcell_6t.sym} 4200 36000 0 0 {name=Xr180c21}
N 4160 36040 4140 36040 {}
C {lab_pin.sym} 4140 36040 0 0 {name=l28906 lab=BL21}
N 4160 36000 4140 36000 {}
C {lab_pin.sym} 4140 36000 0 0 {name=l28907 lab=BLB21}
N 4160 35960 4140 35960 {}
C {lab_pin.sym} 4140 35960 0 0 {name=l28908 lab=WL180}
N 4240 36040 4260 36040 {}
C {lab_pin.sym} 4260 36040 0 0 {name=l28909 lab=VDD}
N 4240 35960 4260 35960 {}
C {lab_pin.sym} 4260 35960 0 0 {name=l28910 lab=VSS}
C {bitcell_6t.sym} 4400 36000 0 0 {name=Xr180c22}
N 4360 36040 4340 36040 {}
C {lab_pin.sym} 4340 36040 0 0 {name=l28911 lab=BL22}
N 4360 36000 4340 36000 {}
C {lab_pin.sym} 4340 36000 0 0 {name=l28912 lab=BLB22}
N 4360 35960 4340 35960 {}
C {lab_pin.sym} 4340 35960 0 0 {name=l28913 lab=WL180}
N 4440 36040 4460 36040 {}
C {lab_pin.sym} 4460 36040 0 0 {name=l28914 lab=VDD}
N 4440 35960 4460 35960 {}
C {lab_pin.sym} 4460 35960 0 0 {name=l28915 lab=VSS}
C {bitcell_6t.sym} 4600 36000 0 0 {name=Xr180c23}
N 4560 36040 4540 36040 {}
C {lab_pin.sym} 4540 36040 0 0 {name=l28916 lab=BL23}
N 4560 36000 4540 36000 {}
C {lab_pin.sym} 4540 36000 0 0 {name=l28917 lab=BLB23}
N 4560 35960 4540 35960 {}
C {lab_pin.sym} 4540 35960 0 0 {name=l28918 lab=WL180}
N 4640 36040 4660 36040 {}
C {lab_pin.sym} 4660 36040 0 0 {name=l28919 lab=VDD}
N 4640 35960 4660 35960 {}
C {lab_pin.sym} 4660 35960 0 0 {name=l28920 lab=VSS}
C {bitcell_6t.sym} 4800 36000 0 0 {name=Xr180c24}
N 4760 36040 4740 36040 {}
C {lab_pin.sym} 4740 36040 0 0 {name=l28921 lab=BL24}
N 4760 36000 4740 36000 {}
C {lab_pin.sym} 4740 36000 0 0 {name=l28922 lab=BLB24}
N 4760 35960 4740 35960 {}
C {lab_pin.sym} 4740 35960 0 0 {name=l28923 lab=WL180}
N 4840 36040 4860 36040 {}
C {lab_pin.sym} 4860 36040 0 0 {name=l28924 lab=VDD}
N 4840 35960 4860 35960 {}
C {lab_pin.sym} 4860 35960 0 0 {name=l28925 lab=VSS}
C {bitcell_6t.sym} 5000 36000 0 0 {name=Xr180c25}
N 4960 36040 4940 36040 {}
C {lab_pin.sym} 4940 36040 0 0 {name=l28926 lab=BL25}
N 4960 36000 4940 36000 {}
C {lab_pin.sym} 4940 36000 0 0 {name=l28927 lab=BLB25}
N 4960 35960 4940 35960 {}
C {lab_pin.sym} 4940 35960 0 0 {name=l28928 lab=WL180}
N 5040 36040 5060 36040 {}
C {lab_pin.sym} 5060 36040 0 0 {name=l28929 lab=VDD}
N 5040 35960 5060 35960 {}
C {lab_pin.sym} 5060 35960 0 0 {name=l28930 lab=VSS}
C {bitcell_6t.sym} 5200 36000 0 0 {name=Xr180c26}
N 5160 36040 5140 36040 {}
C {lab_pin.sym} 5140 36040 0 0 {name=l28931 lab=BL26}
N 5160 36000 5140 36000 {}
C {lab_pin.sym} 5140 36000 0 0 {name=l28932 lab=BLB26}
N 5160 35960 5140 35960 {}
C {lab_pin.sym} 5140 35960 0 0 {name=l28933 lab=WL180}
N 5240 36040 5260 36040 {}
C {lab_pin.sym} 5260 36040 0 0 {name=l28934 lab=VDD}
N 5240 35960 5260 35960 {}
C {lab_pin.sym} 5260 35960 0 0 {name=l28935 lab=VSS}
C {bitcell_6t.sym} 5400 36000 0 0 {name=Xr180c27}
N 5360 36040 5340 36040 {}
C {lab_pin.sym} 5340 36040 0 0 {name=l28936 lab=BL27}
N 5360 36000 5340 36000 {}
C {lab_pin.sym} 5340 36000 0 0 {name=l28937 lab=BLB27}
N 5360 35960 5340 35960 {}
C {lab_pin.sym} 5340 35960 0 0 {name=l28938 lab=WL180}
N 5440 36040 5460 36040 {}
C {lab_pin.sym} 5460 36040 0 0 {name=l28939 lab=VDD}
N 5440 35960 5460 35960 {}
C {lab_pin.sym} 5460 35960 0 0 {name=l28940 lab=VSS}
C {bitcell_6t.sym} 5600 36000 0 0 {name=Xr180c28}
N 5560 36040 5540 36040 {}
C {lab_pin.sym} 5540 36040 0 0 {name=l28941 lab=BL28}
N 5560 36000 5540 36000 {}
C {lab_pin.sym} 5540 36000 0 0 {name=l28942 lab=BLB28}
N 5560 35960 5540 35960 {}
C {lab_pin.sym} 5540 35960 0 0 {name=l28943 lab=WL180}
N 5640 36040 5660 36040 {}
C {lab_pin.sym} 5660 36040 0 0 {name=l28944 lab=VDD}
N 5640 35960 5660 35960 {}
C {lab_pin.sym} 5660 35960 0 0 {name=l28945 lab=VSS}
C {bitcell_6t.sym} 5800 36000 0 0 {name=Xr180c29}
N 5760 36040 5740 36040 {}
C {lab_pin.sym} 5740 36040 0 0 {name=l28946 lab=BL29}
N 5760 36000 5740 36000 {}
C {lab_pin.sym} 5740 36000 0 0 {name=l28947 lab=BLB29}
N 5760 35960 5740 35960 {}
C {lab_pin.sym} 5740 35960 0 0 {name=l28948 lab=WL180}
N 5840 36040 5860 36040 {}
C {lab_pin.sym} 5860 36040 0 0 {name=l28949 lab=VDD}
N 5840 35960 5860 35960 {}
C {lab_pin.sym} 5860 35960 0 0 {name=l28950 lab=VSS}
C {bitcell_6t.sym} 6000 36000 0 0 {name=Xr180c30}
N 5960 36040 5940 36040 {}
C {lab_pin.sym} 5940 36040 0 0 {name=l28951 lab=BL30}
N 5960 36000 5940 36000 {}
C {lab_pin.sym} 5940 36000 0 0 {name=l28952 lab=BLB30}
N 5960 35960 5940 35960 {}
C {lab_pin.sym} 5940 35960 0 0 {name=l28953 lab=WL180}
N 6040 36040 6060 36040 {}
C {lab_pin.sym} 6060 36040 0 0 {name=l28954 lab=VDD}
N 6040 35960 6060 35960 {}
C {lab_pin.sym} 6060 35960 0 0 {name=l28955 lab=VSS}
C {bitcell_6t.sym} 6200 36000 0 0 {name=Xr180c31}
N 6160 36040 6140 36040 {}
C {lab_pin.sym} 6140 36040 0 0 {name=l28956 lab=BL31}
N 6160 36000 6140 36000 {}
C {lab_pin.sym} 6140 36000 0 0 {name=l28957 lab=BLB31}
N 6160 35960 6140 35960 {}
C {lab_pin.sym} 6140 35960 0 0 {name=l28958 lab=WL180}
N 6240 36040 6260 36040 {}
C {lab_pin.sym} 6260 36040 0 0 {name=l28959 lab=VDD}
N 6240 35960 6260 35960 {}
C {lab_pin.sym} 6260 35960 0 0 {name=l28960 lab=VSS}
C {bitcell_6t.sym} 0 36200 0 0 {name=Xr181c0}
N -40 36240 -60 36240 {}
C {lab_pin.sym} -60 36240 0 0 {name=l28961 lab=BL0}
N -40 36200 -60 36200 {}
C {lab_pin.sym} -60 36200 0 0 {name=l28962 lab=BLB0}
N -40 36160 -60 36160 {}
C {lab_pin.sym} -60 36160 0 0 {name=l28963 lab=WL181}
N 40 36240 60 36240 {}
C {lab_pin.sym} 60 36240 0 0 {name=l28964 lab=VDD}
N 40 36160 60 36160 {}
C {lab_pin.sym} 60 36160 0 0 {name=l28965 lab=VSS}
C {bitcell_6t.sym} 200 36200 0 0 {name=Xr181c1}
N 160 36240 140 36240 {}
C {lab_pin.sym} 140 36240 0 0 {name=l28966 lab=BL1}
N 160 36200 140 36200 {}
C {lab_pin.sym} 140 36200 0 0 {name=l28967 lab=BLB1}
N 160 36160 140 36160 {}
C {lab_pin.sym} 140 36160 0 0 {name=l28968 lab=WL181}
N 240 36240 260 36240 {}
C {lab_pin.sym} 260 36240 0 0 {name=l28969 lab=VDD}
N 240 36160 260 36160 {}
C {lab_pin.sym} 260 36160 0 0 {name=l28970 lab=VSS}
C {bitcell_6t.sym} 400 36200 0 0 {name=Xr181c2}
N 360 36240 340 36240 {}
C {lab_pin.sym} 340 36240 0 0 {name=l28971 lab=BL2}
N 360 36200 340 36200 {}
C {lab_pin.sym} 340 36200 0 0 {name=l28972 lab=BLB2}
N 360 36160 340 36160 {}
C {lab_pin.sym} 340 36160 0 0 {name=l28973 lab=WL181}
N 440 36240 460 36240 {}
C {lab_pin.sym} 460 36240 0 0 {name=l28974 lab=VDD}
N 440 36160 460 36160 {}
C {lab_pin.sym} 460 36160 0 0 {name=l28975 lab=VSS}
C {bitcell_6t.sym} 600 36200 0 0 {name=Xr181c3}
N 560 36240 540 36240 {}
C {lab_pin.sym} 540 36240 0 0 {name=l28976 lab=BL3}
N 560 36200 540 36200 {}
C {lab_pin.sym} 540 36200 0 0 {name=l28977 lab=BLB3}
N 560 36160 540 36160 {}
C {lab_pin.sym} 540 36160 0 0 {name=l28978 lab=WL181}
N 640 36240 660 36240 {}
C {lab_pin.sym} 660 36240 0 0 {name=l28979 lab=VDD}
N 640 36160 660 36160 {}
C {lab_pin.sym} 660 36160 0 0 {name=l28980 lab=VSS}
C {bitcell_6t.sym} 800 36200 0 0 {name=Xr181c4}
N 760 36240 740 36240 {}
C {lab_pin.sym} 740 36240 0 0 {name=l28981 lab=BL4}
N 760 36200 740 36200 {}
C {lab_pin.sym} 740 36200 0 0 {name=l28982 lab=BLB4}
N 760 36160 740 36160 {}
C {lab_pin.sym} 740 36160 0 0 {name=l28983 lab=WL181}
N 840 36240 860 36240 {}
C {lab_pin.sym} 860 36240 0 0 {name=l28984 lab=VDD}
N 840 36160 860 36160 {}
C {lab_pin.sym} 860 36160 0 0 {name=l28985 lab=VSS}
C {bitcell_6t.sym} 1000 36200 0 0 {name=Xr181c5}
N 960 36240 940 36240 {}
C {lab_pin.sym} 940 36240 0 0 {name=l28986 lab=BL5}
N 960 36200 940 36200 {}
C {lab_pin.sym} 940 36200 0 0 {name=l28987 lab=BLB5}
N 960 36160 940 36160 {}
C {lab_pin.sym} 940 36160 0 0 {name=l28988 lab=WL181}
N 1040 36240 1060 36240 {}
C {lab_pin.sym} 1060 36240 0 0 {name=l28989 lab=VDD}
N 1040 36160 1060 36160 {}
C {lab_pin.sym} 1060 36160 0 0 {name=l28990 lab=VSS}
C {bitcell_6t.sym} 1200 36200 0 0 {name=Xr181c6}
N 1160 36240 1140 36240 {}
C {lab_pin.sym} 1140 36240 0 0 {name=l28991 lab=BL6}
N 1160 36200 1140 36200 {}
C {lab_pin.sym} 1140 36200 0 0 {name=l28992 lab=BLB6}
N 1160 36160 1140 36160 {}
C {lab_pin.sym} 1140 36160 0 0 {name=l28993 lab=WL181}
N 1240 36240 1260 36240 {}
C {lab_pin.sym} 1260 36240 0 0 {name=l28994 lab=VDD}
N 1240 36160 1260 36160 {}
C {lab_pin.sym} 1260 36160 0 0 {name=l28995 lab=VSS}
C {bitcell_6t.sym} 1400 36200 0 0 {name=Xr181c7}
N 1360 36240 1340 36240 {}
C {lab_pin.sym} 1340 36240 0 0 {name=l28996 lab=BL7}
N 1360 36200 1340 36200 {}
C {lab_pin.sym} 1340 36200 0 0 {name=l28997 lab=BLB7}
N 1360 36160 1340 36160 {}
C {lab_pin.sym} 1340 36160 0 0 {name=l28998 lab=WL181}
N 1440 36240 1460 36240 {}
C {lab_pin.sym} 1460 36240 0 0 {name=l28999 lab=VDD}
N 1440 36160 1460 36160 {}
C {lab_pin.sym} 1460 36160 0 0 {name=l29000 lab=VSS}
C {bitcell_6t.sym} 1600 36200 0 0 {name=Xr181c8}
N 1560 36240 1540 36240 {}
C {lab_pin.sym} 1540 36240 0 0 {name=l29001 lab=BL8}
N 1560 36200 1540 36200 {}
C {lab_pin.sym} 1540 36200 0 0 {name=l29002 lab=BLB8}
N 1560 36160 1540 36160 {}
C {lab_pin.sym} 1540 36160 0 0 {name=l29003 lab=WL181}
N 1640 36240 1660 36240 {}
C {lab_pin.sym} 1660 36240 0 0 {name=l29004 lab=VDD}
N 1640 36160 1660 36160 {}
C {lab_pin.sym} 1660 36160 0 0 {name=l29005 lab=VSS}
C {bitcell_6t.sym} 1800 36200 0 0 {name=Xr181c9}
N 1760 36240 1740 36240 {}
C {lab_pin.sym} 1740 36240 0 0 {name=l29006 lab=BL9}
N 1760 36200 1740 36200 {}
C {lab_pin.sym} 1740 36200 0 0 {name=l29007 lab=BLB9}
N 1760 36160 1740 36160 {}
C {lab_pin.sym} 1740 36160 0 0 {name=l29008 lab=WL181}
N 1840 36240 1860 36240 {}
C {lab_pin.sym} 1860 36240 0 0 {name=l29009 lab=VDD}
N 1840 36160 1860 36160 {}
C {lab_pin.sym} 1860 36160 0 0 {name=l29010 lab=VSS}
C {bitcell_6t.sym} 2000 36200 0 0 {name=Xr181c10}
N 1960 36240 1940 36240 {}
C {lab_pin.sym} 1940 36240 0 0 {name=l29011 lab=BL10}
N 1960 36200 1940 36200 {}
C {lab_pin.sym} 1940 36200 0 0 {name=l29012 lab=BLB10}
N 1960 36160 1940 36160 {}
C {lab_pin.sym} 1940 36160 0 0 {name=l29013 lab=WL181}
N 2040 36240 2060 36240 {}
C {lab_pin.sym} 2060 36240 0 0 {name=l29014 lab=VDD}
N 2040 36160 2060 36160 {}
C {lab_pin.sym} 2060 36160 0 0 {name=l29015 lab=VSS}
C {bitcell_6t.sym} 2200 36200 0 0 {name=Xr181c11}
N 2160 36240 2140 36240 {}
C {lab_pin.sym} 2140 36240 0 0 {name=l29016 lab=BL11}
N 2160 36200 2140 36200 {}
C {lab_pin.sym} 2140 36200 0 0 {name=l29017 lab=BLB11}
N 2160 36160 2140 36160 {}
C {lab_pin.sym} 2140 36160 0 0 {name=l29018 lab=WL181}
N 2240 36240 2260 36240 {}
C {lab_pin.sym} 2260 36240 0 0 {name=l29019 lab=VDD}
N 2240 36160 2260 36160 {}
C {lab_pin.sym} 2260 36160 0 0 {name=l29020 lab=VSS}
C {bitcell_6t.sym} 2400 36200 0 0 {name=Xr181c12}
N 2360 36240 2340 36240 {}
C {lab_pin.sym} 2340 36240 0 0 {name=l29021 lab=BL12}
N 2360 36200 2340 36200 {}
C {lab_pin.sym} 2340 36200 0 0 {name=l29022 lab=BLB12}
N 2360 36160 2340 36160 {}
C {lab_pin.sym} 2340 36160 0 0 {name=l29023 lab=WL181}
N 2440 36240 2460 36240 {}
C {lab_pin.sym} 2460 36240 0 0 {name=l29024 lab=VDD}
N 2440 36160 2460 36160 {}
C {lab_pin.sym} 2460 36160 0 0 {name=l29025 lab=VSS}
C {bitcell_6t.sym} 2600 36200 0 0 {name=Xr181c13}
N 2560 36240 2540 36240 {}
C {lab_pin.sym} 2540 36240 0 0 {name=l29026 lab=BL13}
N 2560 36200 2540 36200 {}
C {lab_pin.sym} 2540 36200 0 0 {name=l29027 lab=BLB13}
N 2560 36160 2540 36160 {}
C {lab_pin.sym} 2540 36160 0 0 {name=l29028 lab=WL181}
N 2640 36240 2660 36240 {}
C {lab_pin.sym} 2660 36240 0 0 {name=l29029 lab=VDD}
N 2640 36160 2660 36160 {}
C {lab_pin.sym} 2660 36160 0 0 {name=l29030 lab=VSS}
C {bitcell_6t.sym} 2800 36200 0 0 {name=Xr181c14}
N 2760 36240 2740 36240 {}
C {lab_pin.sym} 2740 36240 0 0 {name=l29031 lab=BL14}
N 2760 36200 2740 36200 {}
C {lab_pin.sym} 2740 36200 0 0 {name=l29032 lab=BLB14}
N 2760 36160 2740 36160 {}
C {lab_pin.sym} 2740 36160 0 0 {name=l29033 lab=WL181}
N 2840 36240 2860 36240 {}
C {lab_pin.sym} 2860 36240 0 0 {name=l29034 lab=VDD}
N 2840 36160 2860 36160 {}
C {lab_pin.sym} 2860 36160 0 0 {name=l29035 lab=VSS}
C {bitcell_6t.sym} 3000 36200 0 0 {name=Xr181c15}
N 2960 36240 2940 36240 {}
C {lab_pin.sym} 2940 36240 0 0 {name=l29036 lab=BL15}
N 2960 36200 2940 36200 {}
C {lab_pin.sym} 2940 36200 0 0 {name=l29037 lab=BLB15}
N 2960 36160 2940 36160 {}
C {lab_pin.sym} 2940 36160 0 0 {name=l29038 lab=WL181}
N 3040 36240 3060 36240 {}
C {lab_pin.sym} 3060 36240 0 0 {name=l29039 lab=VDD}
N 3040 36160 3060 36160 {}
C {lab_pin.sym} 3060 36160 0 0 {name=l29040 lab=VSS}
C {bitcell_6t.sym} 3200 36200 0 0 {name=Xr181c16}
N 3160 36240 3140 36240 {}
C {lab_pin.sym} 3140 36240 0 0 {name=l29041 lab=BL16}
N 3160 36200 3140 36200 {}
C {lab_pin.sym} 3140 36200 0 0 {name=l29042 lab=BLB16}
N 3160 36160 3140 36160 {}
C {lab_pin.sym} 3140 36160 0 0 {name=l29043 lab=WL181}
N 3240 36240 3260 36240 {}
C {lab_pin.sym} 3260 36240 0 0 {name=l29044 lab=VDD}
N 3240 36160 3260 36160 {}
C {lab_pin.sym} 3260 36160 0 0 {name=l29045 lab=VSS}
C {bitcell_6t.sym} 3400 36200 0 0 {name=Xr181c17}
N 3360 36240 3340 36240 {}
C {lab_pin.sym} 3340 36240 0 0 {name=l29046 lab=BL17}
N 3360 36200 3340 36200 {}
C {lab_pin.sym} 3340 36200 0 0 {name=l29047 lab=BLB17}
N 3360 36160 3340 36160 {}
C {lab_pin.sym} 3340 36160 0 0 {name=l29048 lab=WL181}
N 3440 36240 3460 36240 {}
C {lab_pin.sym} 3460 36240 0 0 {name=l29049 lab=VDD}
N 3440 36160 3460 36160 {}
C {lab_pin.sym} 3460 36160 0 0 {name=l29050 lab=VSS}
C {bitcell_6t.sym} 3600 36200 0 0 {name=Xr181c18}
N 3560 36240 3540 36240 {}
C {lab_pin.sym} 3540 36240 0 0 {name=l29051 lab=BL18}
N 3560 36200 3540 36200 {}
C {lab_pin.sym} 3540 36200 0 0 {name=l29052 lab=BLB18}
N 3560 36160 3540 36160 {}
C {lab_pin.sym} 3540 36160 0 0 {name=l29053 lab=WL181}
N 3640 36240 3660 36240 {}
C {lab_pin.sym} 3660 36240 0 0 {name=l29054 lab=VDD}
N 3640 36160 3660 36160 {}
C {lab_pin.sym} 3660 36160 0 0 {name=l29055 lab=VSS}
C {bitcell_6t.sym} 3800 36200 0 0 {name=Xr181c19}
N 3760 36240 3740 36240 {}
C {lab_pin.sym} 3740 36240 0 0 {name=l29056 lab=BL19}
N 3760 36200 3740 36200 {}
C {lab_pin.sym} 3740 36200 0 0 {name=l29057 lab=BLB19}
N 3760 36160 3740 36160 {}
C {lab_pin.sym} 3740 36160 0 0 {name=l29058 lab=WL181}
N 3840 36240 3860 36240 {}
C {lab_pin.sym} 3860 36240 0 0 {name=l29059 lab=VDD}
N 3840 36160 3860 36160 {}
C {lab_pin.sym} 3860 36160 0 0 {name=l29060 lab=VSS}
C {bitcell_6t.sym} 4000 36200 0 0 {name=Xr181c20}
N 3960 36240 3940 36240 {}
C {lab_pin.sym} 3940 36240 0 0 {name=l29061 lab=BL20}
N 3960 36200 3940 36200 {}
C {lab_pin.sym} 3940 36200 0 0 {name=l29062 lab=BLB20}
N 3960 36160 3940 36160 {}
C {lab_pin.sym} 3940 36160 0 0 {name=l29063 lab=WL181}
N 4040 36240 4060 36240 {}
C {lab_pin.sym} 4060 36240 0 0 {name=l29064 lab=VDD}
N 4040 36160 4060 36160 {}
C {lab_pin.sym} 4060 36160 0 0 {name=l29065 lab=VSS}
C {bitcell_6t.sym} 4200 36200 0 0 {name=Xr181c21}
N 4160 36240 4140 36240 {}
C {lab_pin.sym} 4140 36240 0 0 {name=l29066 lab=BL21}
N 4160 36200 4140 36200 {}
C {lab_pin.sym} 4140 36200 0 0 {name=l29067 lab=BLB21}
N 4160 36160 4140 36160 {}
C {lab_pin.sym} 4140 36160 0 0 {name=l29068 lab=WL181}
N 4240 36240 4260 36240 {}
C {lab_pin.sym} 4260 36240 0 0 {name=l29069 lab=VDD}
N 4240 36160 4260 36160 {}
C {lab_pin.sym} 4260 36160 0 0 {name=l29070 lab=VSS}
C {bitcell_6t.sym} 4400 36200 0 0 {name=Xr181c22}
N 4360 36240 4340 36240 {}
C {lab_pin.sym} 4340 36240 0 0 {name=l29071 lab=BL22}
N 4360 36200 4340 36200 {}
C {lab_pin.sym} 4340 36200 0 0 {name=l29072 lab=BLB22}
N 4360 36160 4340 36160 {}
C {lab_pin.sym} 4340 36160 0 0 {name=l29073 lab=WL181}
N 4440 36240 4460 36240 {}
C {lab_pin.sym} 4460 36240 0 0 {name=l29074 lab=VDD}
N 4440 36160 4460 36160 {}
C {lab_pin.sym} 4460 36160 0 0 {name=l29075 lab=VSS}
C {bitcell_6t.sym} 4600 36200 0 0 {name=Xr181c23}
N 4560 36240 4540 36240 {}
C {lab_pin.sym} 4540 36240 0 0 {name=l29076 lab=BL23}
N 4560 36200 4540 36200 {}
C {lab_pin.sym} 4540 36200 0 0 {name=l29077 lab=BLB23}
N 4560 36160 4540 36160 {}
C {lab_pin.sym} 4540 36160 0 0 {name=l29078 lab=WL181}
N 4640 36240 4660 36240 {}
C {lab_pin.sym} 4660 36240 0 0 {name=l29079 lab=VDD}
N 4640 36160 4660 36160 {}
C {lab_pin.sym} 4660 36160 0 0 {name=l29080 lab=VSS}
C {bitcell_6t.sym} 4800 36200 0 0 {name=Xr181c24}
N 4760 36240 4740 36240 {}
C {lab_pin.sym} 4740 36240 0 0 {name=l29081 lab=BL24}
N 4760 36200 4740 36200 {}
C {lab_pin.sym} 4740 36200 0 0 {name=l29082 lab=BLB24}
N 4760 36160 4740 36160 {}
C {lab_pin.sym} 4740 36160 0 0 {name=l29083 lab=WL181}
N 4840 36240 4860 36240 {}
C {lab_pin.sym} 4860 36240 0 0 {name=l29084 lab=VDD}
N 4840 36160 4860 36160 {}
C {lab_pin.sym} 4860 36160 0 0 {name=l29085 lab=VSS}
C {bitcell_6t.sym} 5000 36200 0 0 {name=Xr181c25}
N 4960 36240 4940 36240 {}
C {lab_pin.sym} 4940 36240 0 0 {name=l29086 lab=BL25}
N 4960 36200 4940 36200 {}
C {lab_pin.sym} 4940 36200 0 0 {name=l29087 lab=BLB25}
N 4960 36160 4940 36160 {}
C {lab_pin.sym} 4940 36160 0 0 {name=l29088 lab=WL181}
N 5040 36240 5060 36240 {}
C {lab_pin.sym} 5060 36240 0 0 {name=l29089 lab=VDD}
N 5040 36160 5060 36160 {}
C {lab_pin.sym} 5060 36160 0 0 {name=l29090 lab=VSS}
C {bitcell_6t.sym} 5200 36200 0 0 {name=Xr181c26}
N 5160 36240 5140 36240 {}
C {lab_pin.sym} 5140 36240 0 0 {name=l29091 lab=BL26}
N 5160 36200 5140 36200 {}
C {lab_pin.sym} 5140 36200 0 0 {name=l29092 lab=BLB26}
N 5160 36160 5140 36160 {}
C {lab_pin.sym} 5140 36160 0 0 {name=l29093 lab=WL181}
N 5240 36240 5260 36240 {}
C {lab_pin.sym} 5260 36240 0 0 {name=l29094 lab=VDD}
N 5240 36160 5260 36160 {}
C {lab_pin.sym} 5260 36160 0 0 {name=l29095 lab=VSS}
C {bitcell_6t.sym} 5400 36200 0 0 {name=Xr181c27}
N 5360 36240 5340 36240 {}
C {lab_pin.sym} 5340 36240 0 0 {name=l29096 lab=BL27}
N 5360 36200 5340 36200 {}
C {lab_pin.sym} 5340 36200 0 0 {name=l29097 lab=BLB27}
N 5360 36160 5340 36160 {}
C {lab_pin.sym} 5340 36160 0 0 {name=l29098 lab=WL181}
N 5440 36240 5460 36240 {}
C {lab_pin.sym} 5460 36240 0 0 {name=l29099 lab=VDD}
N 5440 36160 5460 36160 {}
C {lab_pin.sym} 5460 36160 0 0 {name=l29100 lab=VSS}
C {bitcell_6t.sym} 5600 36200 0 0 {name=Xr181c28}
N 5560 36240 5540 36240 {}
C {lab_pin.sym} 5540 36240 0 0 {name=l29101 lab=BL28}
N 5560 36200 5540 36200 {}
C {lab_pin.sym} 5540 36200 0 0 {name=l29102 lab=BLB28}
N 5560 36160 5540 36160 {}
C {lab_pin.sym} 5540 36160 0 0 {name=l29103 lab=WL181}
N 5640 36240 5660 36240 {}
C {lab_pin.sym} 5660 36240 0 0 {name=l29104 lab=VDD}
N 5640 36160 5660 36160 {}
C {lab_pin.sym} 5660 36160 0 0 {name=l29105 lab=VSS}
C {bitcell_6t.sym} 5800 36200 0 0 {name=Xr181c29}
N 5760 36240 5740 36240 {}
C {lab_pin.sym} 5740 36240 0 0 {name=l29106 lab=BL29}
N 5760 36200 5740 36200 {}
C {lab_pin.sym} 5740 36200 0 0 {name=l29107 lab=BLB29}
N 5760 36160 5740 36160 {}
C {lab_pin.sym} 5740 36160 0 0 {name=l29108 lab=WL181}
N 5840 36240 5860 36240 {}
C {lab_pin.sym} 5860 36240 0 0 {name=l29109 lab=VDD}
N 5840 36160 5860 36160 {}
C {lab_pin.sym} 5860 36160 0 0 {name=l29110 lab=VSS}
C {bitcell_6t.sym} 6000 36200 0 0 {name=Xr181c30}
N 5960 36240 5940 36240 {}
C {lab_pin.sym} 5940 36240 0 0 {name=l29111 lab=BL30}
N 5960 36200 5940 36200 {}
C {lab_pin.sym} 5940 36200 0 0 {name=l29112 lab=BLB30}
N 5960 36160 5940 36160 {}
C {lab_pin.sym} 5940 36160 0 0 {name=l29113 lab=WL181}
N 6040 36240 6060 36240 {}
C {lab_pin.sym} 6060 36240 0 0 {name=l29114 lab=VDD}
N 6040 36160 6060 36160 {}
C {lab_pin.sym} 6060 36160 0 0 {name=l29115 lab=VSS}
C {bitcell_6t.sym} 6200 36200 0 0 {name=Xr181c31}
N 6160 36240 6140 36240 {}
C {lab_pin.sym} 6140 36240 0 0 {name=l29116 lab=BL31}
N 6160 36200 6140 36200 {}
C {lab_pin.sym} 6140 36200 0 0 {name=l29117 lab=BLB31}
N 6160 36160 6140 36160 {}
C {lab_pin.sym} 6140 36160 0 0 {name=l29118 lab=WL181}
N 6240 36240 6260 36240 {}
C {lab_pin.sym} 6260 36240 0 0 {name=l29119 lab=VDD}
N 6240 36160 6260 36160 {}
C {lab_pin.sym} 6260 36160 0 0 {name=l29120 lab=VSS}
C {bitcell_6t.sym} 0 36400 0 0 {name=Xr182c0}
N -40 36440 -60 36440 {}
C {lab_pin.sym} -60 36440 0 0 {name=l29121 lab=BL0}
N -40 36400 -60 36400 {}
C {lab_pin.sym} -60 36400 0 0 {name=l29122 lab=BLB0}
N -40 36360 -60 36360 {}
C {lab_pin.sym} -60 36360 0 0 {name=l29123 lab=WL182}
N 40 36440 60 36440 {}
C {lab_pin.sym} 60 36440 0 0 {name=l29124 lab=VDD}
N 40 36360 60 36360 {}
C {lab_pin.sym} 60 36360 0 0 {name=l29125 lab=VSS}
C {bitcell_6t.sym} 200 36400 0 0 {name=Xr182c1}
N 160 36440 140 36440 {}
C {lab_pin.sym} 140 36440 0 0 {name=l29126 lab=BL1}
N 160 36400 140 36400 {}
C {lab_pin.sym} 140 36400 0 0 {name=l29127 lab=BLB1}
N 160 36360 140 36360 {}
C {lab_pin.sym} 140 36360 0 0 {name=l29128 lab=WL182}
N 240 36440 260 36440 {}
C {lab_pin.sym} 260 36440 0 0 {name=l29129 lab=VDD}
N 240 36360 260 36360 {}
C {lab_pin.sym} 260 36360 0 0 {name=l29130 lab=VSS}
C {bitcell_6t.sym} 400 36400 0 0 {name=Xr182c2}
N 360 36440 340 36440 {}
C {lab_pin.sym} 340 36440 0 0 {name=l29131 lab=BL2}
N 360 36400 340 36400 {}
C {lab_pin.sym} 340 36400 0 0 {name=l29132 lab=BLB2}
N 360 36360 340 36360 {}
C {lab_pin.sym} 340 36360 0 0 {name=l29133 lab=WL182}
N 440 36440 460 36440 {}
C {lab_pin.sym} 460 36440 0 0 {name=l29134 lab=VDD}
N 440 36360 460 36360 {}
C {lab_pin.sym} 460 36360 0 0 {name=l29135 lab=VSS}
C {bitcell_6t.sym} 600 36400 0 0 {name=Xr182c3}
N 560 36440 540 36440 {}
C {lab_pin.sym} 540 36440 0 0 {name=l29136 lab=BL3}
N 560 36400 540 36400 {}
C {lab_pin.sym} 540 36400 0 0 {name=l29137 lab=BLB3}
N 560 36360 540 36360 {}
C {lab_pin.sym} 540 36360 0 0 {name=l29138 lab=WL182}
N 640 36440 660 36440 {}
C {lab_pin.sym} 660 36440 0 0 {name=l29139 lab=VDD}
N 640 36360 660 36360 {}
C {lab_pin.sym} 660 36360 0 0 {name=l29140 lab=VSS}
C {bitcell_6t.sym} 800 36400 0 0 {name=Xr182c4}
N 760 36440 740 36440 {}
C {lab_pin.sym} 740 36440 0 0 {name=l29141 lab=BL4}
N 760 36400 740 36400 {}
C {lab_pin.sym} 740 36400 0 0 {name=l29142 lab=BLB4}
N 760 36360 740 36360 {}
C {lab_pin.sym} 740 36360 0 0 {name=l29143 lab=WL182}
N 840 36440 860 36440 {}
C {lab_pin.sym} 860 36440 0 0 {name=l29144 lab=VDD}
N 840 36360 860 36360 {}
C {lab_pin.sym} 860 36360 0 0 {name=l29145 lab=VSS}
C {bitcell_6t.sym} 1000 36400 0 0 {name=Xr182c5}
N 960 36440 940 36440 {}
C {lab_pin.sym} 940 36440 0 0 {name=l29146 lab=BL5}
N 960 36400 940 36400 {}
C {lab_pin.sym} 940 36400 0 0 {name=l29147 lab=BLB5}
N 960 36360 940 36360 {}
C {lab_pin.sym} 940 36360 0 0 {name=l29148 lab=WL182}
N 1040 36440 1060 36440 {}
C {lab_pin.sym} 1060 36440 0 0 {name=l29149 lab=VDD}
N 1040 36360 1060 36360 {}
C {lab_pin.sym} 1060 36360 0 0 {name=l29150 lab=VSS}
C {bitcell_6t.sym} 1200 36400 0 0 {name=Xr182c6}
N 1160 36440 1140 36440 {}
C {lab_pin.sym} 1140 36440 0 0 {name=l29151 lab=BL6}
N 1160 36400 1140 36400 {}
C {lab_pin.sym} 1140 36400 0 0 {name=l29152 lab=BLB6}
N 1160 36360 1140 36360 {}
C {lab_pin.sym} 1140 36360 0 0 {name=l29153 lab=WL182}
N 1240 36440 1260 36440 {}
C {lab_pin.sym} 1260 36440 0 0 {name=l29154 lab=VDD}
N 1240 36360 1260 36360 {}
C {lab_pin.sym} 1260 36360 0 0 {name=l29155 lab=VSS}
C {bitcell_6t.sym} 1400 36400 0 0 {name=Xr182c7}
N 1360 36440 1340 36440 {}
C {lab_pin.sym} 1340 36440 0 0 {name=l29156 lab=BL7}
N 1360 36400 1340 36400 {}
C {lab_pin.sym} 1340 36400 0 0 {name=l29157 lab=BLB7}
N 1360 36360 1340 36360 {}
C {lab_pin.sym} 1340 36360 0 0 {name=l29158 lab=WL182}
N 1440 36440 1460 36440 {}
C {lab_pin.sym} 1460 36440 0 0 {name=l29159 lab=VDD}
N 1440 36360 1460 36360 {}
C {lab_pin.sym} 1460 36360 0 0 {name=l29160 lab=VSS}
C {bitcell_6t.sym} 1600 36400 0 0 {name=Xr182c8}
N 1560 36440 1540 36440 {}
C {lab_pin.sym} 1540 36440 0 0 {name=l29161 lab=BL8}
N 1560 36400 1540 36400 {}
C {lab_pin.sym} 1540 36400 0 0 {name=l29162 lab=BLB8}
N 1560 36360 1540 36360 {}
C {lab_pin.sym} 1540 36360 0 0 {name=l29163 lab=WL182}
N 1640 36440 1660 36440 {}
C {lab_pin.sym} 1660 36440 0 0 {name=l29164 lab=VDD}
N 1640 36360 1660 36360 {}
C {lab_pin.sym} 1660 36360 0 0 {name=l29165 lab=VSS}
C {bitcell_6t.sym} 1800 36400 0 0 {name=Xr182c9}
N 1760 36440 1740 36440 {}
C {lab_pin.sym} 1740 36440 0 0 {name=l29166 lab=BL9}
N 1760 36400 1740 36400 {}
C {lab_pin.sym} 1740 36400 0 0 {name=l29167 lab=BLB9}
N 1760 36360 1740 36360 {}
C {lab_pin.sym} 1740 36360 0 0 {name=l29168 lab=WL182}
N 1840 36440 1860 36440 {}
C {lab_pin.sym} 1860 36440 0 0 {name=l29169 lab=VDD}
N 1840 36360 1860 36360 {}
C {lab_pin.sym} 1860 36360 0 0 {name=l29170 lab=VSS}
C {bitcell_6t.sym} 2000 36400 0 0 {name=Xr182c10}
N 1960 36440 1940 36440 {}
C {lab_pin.sym} 1940 36440 0 0 {name=l29171 lab=BL10}
N 1960 36400 1940 36400 {}
C {lab_pin.sym} 1940 36400 0 0 {name=l29172 lab=BLB10}
N 1960 36360 1940 36360 {}
C {lab_pin.sym} 1940 36360 0 0 {name=l29173 lab=WL182}
N 2040 36440 2060 36440 {}
C {lab_pin.sym} 2060 36440 0 0 {name=l29174 lab=VDD}
N 2040 36360 2060 36360 {}
C {lab_pin.sym} 2060 36360 0 0 {name=l29175 lab=VSS}
C {bitcell_6t.sym} 2200 36400 0 0 {name=Xr182c11}
N 2160 36440 2140 36440 {}
C {lab_pin.sym} 2140 36440 0 0 {name=l29176 lab=BL11}
N 2160 36400 2140 36400 {}
C {lab_pin.sym} 2140 36400 0 0 {name=l29177 lab=BLB11}
N 2160 36360 2140 36360 {}
C {lab_pin.sym} 2140 36360 0 0 {name=l29178 lab=WL182}
N 2240 36440 2260 36440 {}
C {lab_pin.sym} 2260 36440 0 0 {name=l29179 lab=VDD}
N 2240 36360 2260 36360 {}
C {lab_pin.sym} 2260 36360 0 0 {name=l29180 lab=VSS}
C {bitcell_6t.sym} 2400 36400 0 0 {name=Xr182c12}
N 2360 36440 2340 36440 {}
C {lab_pin.sym} 2340 36440 0 0 {name=l29181 lab=BL12}
N 2360 36400 2340 36400 {}
C {lab_pin.sym} 2340 36400 0 0 {name=l29182 lab=BLB12}
N 2360 36360 2340 36360 {}
C {lab_pin.sym} 2340 36360 0 0 {name=l29183 lab=WL182}
N 2440 36440 2460 36440 {}
C {lab_pin.sym} 2460 36440 0 0 {name=l29184 lab=VDD}
N 2440 36360 2460 36360 {}
C {lab_pin.sym} 2460 36360 0 0 {name=l29185 lab=VSS}
C {bitcell_6t.sym} 2600 36400 0 0 {name=Xr182c13}
N 2560 36440 2540 36440 {}
C {lab_pin.sym} 2540 36440 0 0 {name=l29186 lab=BL13}
N 2560 36400 2540 36400 {}
C {lab_pin.sym} 2540 36400 0 0 {name=l29187 lab=BLB13}
N 2560 36360 2540 36360 {}
C {lab_pin.sym} 2540 36360 0 0 {name=l29188 lab=WL182}
N 2640 36440 2660 36440 {}
C {lab_pin.sym} 2660 36440 0 0 {name=l29189 lab=VDD}
N 2640 36360 2660 36360 {}
C {lab_pin.sym} 2660 36360 0 0 {name=l29190 lab=VSS}
C {bitcell_6t.sym} 2800 36400 0 0 {name=Xr182c14}
N 2760 36440 2740 36440 {}
C {lab_pin.sym} 2740 36440 0 0 {name=l29191 lab=BL14}
N 2760 36400 2740 36400 {}
C {lab_pin.sym} 2740 36400 0 0 {name=l29192 lab=BLB14}
N 2760 36360 2740 36360 {}
C {lab_pin.sym} 2740 36360 0 0 {name=l29193 lab=WL182}
N 2840 36440 2860 36440 {}
C {lab_pin.sym} 2860 36440 0 0 {name=l29194 lab=VDD}
N 2840 36360 2860 36360 {}
C {lab_pin.sym} 2860 36360 0 0 {name=l29195 lab=VSS}
C {bitcell_6t.sym} 3000 36400 0 0 {name=Xr182c15}
N 2960 36440 2940 36440 {}
C {lab_pin.sym} 2940 36440 0 0 {name=l29196 lab=BL15}
N 2960 36400 2940 36400 {}
C {lab_pin.sym} 2940 36400 0 0 {name=l29197 lab=BLB15}
N 2960 36360 2940 36360 {}
C {lab_pin.sym} 2940 36360 0 0 {name=l29198 lab=WL182}
N 3040 36440 3060 36440 {}
C {lab_pin.sym} 3060 36440 0 0 {name=l29199 lab=VDD}
N 3040 36360 3060 36360 {}
C {lab_pin.sym} 3060 36360 0 0 {name=l29200 lab=VSS}
C {bitcell_6t.sym} 3200 36400 0 0 {name=Xr182c16}
N 3160 36440 3140 36440 {}
C {lab_pin.sym} 3140 36440 0 0 {name=l29201 lab=BL16}
N 3160 36400 3140 36400 {}
C {lab_pin.sym} 3140 36400 0 0 {name=l29202 lab=BLB16}
N 3160 36360 3140 36360 {}
C {lab_pin.sym} 3140 36360 0 0 {name=l29203 lab=WL182}
N 3240 36440 3260 36440 {}
C {lab_pin.sym} 3260 36440 0 0 {name=l29204 lab=VDD}
N 3240 36360 3260 36360 {}
C {lab_pin.sym} 3260 36360 0 0 {name=l29205 lab=VSS}
C {bitcell_6t.sym} 3400 36400 0 0 {name=Xr182c17}
N 3360 36440 3340 36440 {}
C {lab_pin.sym} 3340 36440 0 0 {name=l29206 lab=BL17}
N 3360 36400 3340 36400 {}
C {lab_pin.sym} 3340 36400 0 0 {name=l29207 lab=BLB17}
N 3360 36360 3340 36360 {}
C {lab_pin.sym} 3340 36360 0 0 {name=l29208 lab=WL182}
N 3440 36440 3460 36440 {}
C {lab_pin.sym} 3460 36440 0 0 {name=l29209 lab=VDD}
N 3440 36360 3460 36360 {}
C {lab_pin.sym} 3460 36360 0 0 {name=l29210 lab=VSS}
C {bitcell_6t.sym} 3600 36400 0 0 {name=Xr182c18}
N 3560 36440 3540 36440 {}
C {lab_pin.sym} 3540 36440 0 0 {name=l29211 lab=BL18}
N 3560 36400 3540 36400 {}
C {lab_pin.sym} 3540 36400 0 0 {name=l29212 lab=BLB18}
N 3560 36360 3540 36360 {}
C {lab_pin.sym} 3540 36360 0 0 {name=l29213 lab=WL182}
N 3640 36440 3660 36440 {}
C {lab_pin.sym} 3660 36440 0 0 {name=l29214 lab=VDD}
N 3640 36360 3660 36360 {}
C {lab_pin.sym} 3660 36360 0 0 {name=l29215 lab=VSS}
C {bitcell_6t.sym} 3800 36400 0 0 {name=Xr182c19}
N 3760 36440 3740 36440 {}
C {lab_pin.sym} 3740 36440 0 0 {name=l29216 lab=BL19}
N 3760 36400 3740 36400 {}
C {lab_pin.sym} 3740 36400 0 0 {name=l29217 lab=BLB19}
N 3760 36360 3740 36360 {}
C {lab_pin.sym} 3740 36360 0 0 {name=l29218 lab=WL182}
N 3840 36440 3860 36440 {}
C {lab_pin.sym} 3860 36440 0 0 {name=l29219 lab=VDD}
N 3840 36360 3860 36360 {}
C {lab_pin.sym} 3860 36360 0 0 {name=l29220 lab=VSS}
C {bitcell_6t.sym} 4000 36400 0 0 {name=Xr182c20}
N 3960 36440 3940 36440 {}
C {lab_pin.sym} 3940 36440 0 0 {name=l29221 lab=BL20}
N 3960 36400 3940 36400 {}
C {lab_pin.sym} 3940 36400 0 0 {name=l29222 lab=BLB20}
N 3960 36360 3940 36360 {}
C {lab_pin.sym} 3940 36360 0 0 {name=l29223 lab=WL182}
N 4040 36440 4060 36440 {}
C {lab_pin.sym} 4060 36440 0 0 {name=l29224 lab=VDD}
N 4040 36360 4060 36360 {}
C {lab_pin.sym} 4060 36360 0 0 {name=l29225 lab=VSS}
C {bitcell_6t.sym} 4200 36400 0 0 {name=Xr182c21}
N 4160 36440 4140 36440 {}
C {lab_pin.sym} 4140 36440 0 0 {name=l29226 lab=BL21}
N 4160 36400 4140 36400 {}
C {lab_pin.sym} 4140 36400 0 0 {name=l29227 lab=BLB21}
N 4160 36360 4140 36360 {}
C {lab_pin.sym} 4140 36360 0 0 {name=l29228 lab=WL182}
N 4240 36440 4260 36440 {}
C {lab_pin.sym} 4260 36440 0 0 {name=l29229 lab=VDD}
N 4240 36360 4260 36360 {}
C {lab_pin.sym} 4260 36360 0 0 {name=l29230 lab=VSS}
C {bitcell_6t.sym} 4400 36400 0 0 {name=Xr182c22}
N 4360 36440 4340 36440 {}
C {lab_pin.sym} 4340 36440 0 0 {name=l29231 lab=BL22}
N 4360 36400 4340 36400 {}
C {lab_pin.sym} 4340 36400 0 0 {name=l29232 lab=BLB22}
N 4360 36360 4340 36360 {}
C {lab_pin.sym} 4340 36360 0 0 {name=l29233 lab=WL182}
N 4440 36440 4460 36440 {}
C {lab_pin.sym} 4460 36440 0 0 {name=l29234 lab=VDD}
N 4440 36360 4460 36360 {}
C {lab_pin.sym} 4460 36360 0 0 {name=l29235 lab=VSS}
C {bitcell_6t.sym} 4600 36400 0 0 {name=Xr182c23}
N 4560 36440 4540 36440 {}
C {lab_pin.sym} 4540 36440 0 0 {name=l29236 lab=BL23}
N 4560 36400 4540 36400 {}
C {lab_pin.sym} 4540 36400 0 0 {name=l29237 lab=BLB23}
N 4560 36360 4540 36360 {}
C {lab_pin.sym} 4540 36360 0 0 {name=l29238 lab=WL182}
N 4640 36440 4660 36440 {}
C {lab_pin.sym} 4660 36440 0 0 {name=l29239 lab=VDD}
N 4640 36360 4660 36360 {}
C {lab_pin.sym} 4660 36360 0 0 {name=l29240 lab=VSS}
C {bitcell_6t.sym} 4800 36400 0 0 {name=Xr182c24}
N 4760 36440 4740 36440 {}
C {lab_pin.sym} 4740 36440 0 0 {name=l29241 lab=BL24}
N 4760 36400 4740 36400 {}
C {lab_pin.sym} 4740 36400 0 0 {name=l29242 lab=BLB24}
N 4760 36360 4740 36360 {}
C {lab_pin.sym} 4740 36360 0 0 {name=l29243 lab=WL182}
N 4840 36440 4860 36440 {}
C {lab_pin.sym} 4860 36440 0 0 {name=l29244 lab=VDD}
N 4840 36360 4860 36360 {}
C {lab_pin.sym} 4860 36360 0 0 {name=l29245 lab=VSS}
C {bitcell_6t.sym} 5000 36400 0 0 {name=Xr182c25}
N 4960 36440 4940 36440 {}
C {lab_pin.sym} 4940 36440 0 0 {name=l29246 lab=BL25}
N 4960 36400 4940 36400 {}
C {lab_pin.sym} 4940 36400 0 0 {name=l29247 lab=BLB25}
N 4960 36360 4940 36360 {}
C {lab_pin.sym} 4940 36360 0 0 {name=l29248 lab=WL182}
N 5040 36440 5060 36440 {}
C {lab_pin.sym} 5060 36440 0 0 {name=l29249 lab=VDD}
N 5040 36360 5060 36360 {}
C {lab_pin.sym} 5060 36360 0 0 {name=l29250 lab=VSS}
C {bitcell_6t.sym} 5200 36400 0 0 {name=Xr182c26}
N 5160 36440 5140 36440 {}
C {lab_pin.sym} 5140 36440 0 0 {name=l29251 lab=BL26}
N 5160 36400 5140 36400 {}
C {lab_pin.sym} 5140 36400 0 0 {name=l29252 lab=BLB26}
N 5160 36360 5140 36360 {}
C {lab_pin.sym} 5140 36360 0 0 {name=l29253 lab=WL182}
N 5240 36440 5260 36440 {}
C {lab_pin.sym} 5260 36440 0 0 {name=l29254 lab=VDD}
N 5240 36360 5260 36360 {}
C {lab_pin.sym} 5260 36360 0 0 {name=l29255 lab=VSS}
C {bitcell_6t.sym} 5400 36400 0 0 {name=Xr182c27}
N 5360 36440 5340 36440 {}
C {lab_pin.sym} 5340 36440 0 0 {name=l29256 lab=BL27}
N 5360 36400 5340 36400 {}
C {lab_pin.sym} 5340 36400 0 0 {name=l29257 lab=BLB27}
N 5360 36360 5340 36360 {}
C {lab_pin.sym} 5340 36360 0 0 {name=l29258 lab=WL182}
N 5440 36440 5460 36440 {}
C {lab_pin.sym} 5460 36440 0 0 {name=l29259 lab=VDD}
N 5440 36360 5460 36360 {}
C {lab_pin.sym} 5460 36360 0 0 {name=l29260 lab=VSS}
C {bitcell_6t.sym} 5600 36400 0 0 {name=Xr182c28}
N 5560 36440 5540 36440 {}
C {lab_pin.sym} 5540 36440 0 0 {name=l29261 lab=BL28}
N 5560 36400 5540 36400 {}
C {lab_pin.sym} 5540 36400 0 0 {name=l29262 lab=BLB28}
N 5560 36360 5540 36360 {}
C {lab_pin.sym} 5540 36360 0 0 {name=l29263 lab=WL182}
N 5640 36440 5660 36440 {}
C {lab_pin.sym} 5660 36440 0 0 {name=l29264 lab=VDD}
N 5640 36360 5660 36360 {}
C {lab_pin.sym} 5660 36360 0 0 {name=l29265 lab=VSS}
C {bitcell_6t.sym} 5800 36400 0 0 {name=Xr182c29}
N 5760 36440 5740 36440 {}
C {lab_pin.sym} 5740 36440 0 0 {name=l29266 lab=BL29}
N 5760 36400 5740 36400 {}
C {lab_pin.sym} 5740 36400 0 0 {name=l29267 lab=BLB29}
N 5760 36360 5740 36360 {}
C {lab_pin.sym} 5740 36360 0 0 {name=l29268 lab=WL182}
N 5840 36440 5860 36440 {}
C {lab_pin.sym} 5860 36440 0 0 {name=l29269 lab=VDD}
N 5840 36360 5860 36360 {}
C {lab_pin.sym} 5860 36360 0 0 {name=l29270 lab=VSS}
C {bitcell_6t.sym} 6000 36400 0 0 {name=Xr182c30}
N 5960 36440 5940 36440 {}
C {lab_pin.sym} 5940 36440 0 0 {name=l29271 lab=BL30}
N 5960 36400 5940 36400 {}
C {lab_pin.sym} 5940 36400 0 0 {name=l29272 lab=BLB30}
N 5960 36360 5940 36360 {}
C {lab_pin.sym} 5940 36360 0 0 {name=l29273 lab=WL182}
N 6040 36440 6060 36440 {}
C {lab_pin.sym} 6060 36440 0 0 {name=l29274 lab=VDD}
N 6040 36360 6060 36360 {}
C {lab_pin.sym} 6060 36360 0 0 {name=l29275 lab=VSS}
C {bitcell_6t.sym} 6200 36400 0 0 {name=Xr182c31}
N 6160 36440 6140 36440 {}
C {lab_pin.sym} 6140 36440 0 0 {name=l29276 lab=BL31}
N 6160 36400 6140 36400 {}
C {lab_pin.sym} 6140 36400 0 0 {name=l29277 lab=BLB31}
N 6160 36360 6140 36360 {}
C {lab_pin.sym} 6140 36360 0 0 {name=l29278 lab=WL182}
N 6240 36440 6260 36440 {}
C {lab_pin.sym} 6260 36440 0 0 {name=l29279 lab=VDD}
N 6240 36360 6260 36360 {}
C {lab_pin.sym} 6260 36360 0 0 {name=l29280 lab=VSS}
C {bitcell_6t.sym} 0 36600 0 0 {name=Xr183c0}
N -40 36640 -60 36640 {}
C {lab_pin.sym} -60 36640 0 0 {name=l29281 lab=BL0}
N -40 36600 -60 36600 {}
C {lab_pin.sym} -60 36600 0 0 {name=l29282 lab=BLB0}
N -40 36560 -60 36560 {}
C {lab_pin.sym} -60 36560 0 0 {name=l29283 lab=WL183}
N 40 36640 60 36640 {}
C {lab_pin.sym} 60 36640 0 0 {name=l29284 lab=VDD}
N 40 36560 60 36560 {}
C {lab_pin.sym} 60 36560 0 0 {name=l29285 lab=VSS}
C {bitcell_6t.sym} 200 36600 0 0 {name=Xr183c1}
N 160 36640 140 36640 {}
C {lab_pin.sym} 140 36640 0 0 {name=l29286 lab=BL1}
N 160 36600 140 36600 {}
C {lab_pin.sym} 140 36600 0 0 {name=l29287 lab=BLB1}
N 160 36560 140 36560 {}
C {lab_pin.sym} 140 36560 0 0 {name=l29288 lab=WL183}
N 240 36640 260 36640 {}
C {lab_pin.sym} 260 36640 0 0 {name=l29289 lab=VDD}
N 240 36560 260 36560 {}
C {lab_pin.sym} 260 36560 0 0 {name=l29290 lab=VSS}
C {bitcell_6t.sym} 400 36600 0 0 {name=Xr183c2}
N 360 36640 340 36640 {}
C {lab_pin.sym} 340 36640 0 0 {name=l29291 lab=BL2}
N 360 36600 340 36600 {}
C {lab_pin.sym} 340 36600 0 0 {name=l29292 lab=BLB2}
N 360 36560 340 36560 {}
C {lab_pin.sym} 340 36560 0 0 {name=l29293 lab=WL183}
N 440 36640 460 36640 {}
C {lab_pin.sym} 460 36640 0 0 {name=l29294 lab=VDD}
N 440 36560 460 36560 {}
C {lab_pin.sym} 460 36560 0 0 {name=l29295 lab=VSS}
C {bitcell_6t.sym} 600 36600 0 0 {name=Xr183c3}
N 560 36640 540 36640 {}
C {lab_pin.sym} 540 36640 0 0 {name=l29296 lab=BL3}
N 560 36600 540 36600 {}
C {lab_pin.sym} 540 36600 0 0 {name=l29297 lab=BLB3}
N 560 36560 540 36560 {}
C {lab_pin.sym} 540 36560 0 0 {name=l29298 lab=WL183}
N 640 36640 660 36640 {}
C {lab_pin.sym} 660 36640 0 0 {name=l29299 lab=VDD}
N 640 36560 660 36560 {}
C {lab_pin.sym} 660 36560 0 0 {name=l29300 lab=VSS}
C {bitcell_6t.sym} 800 36600 0 0 {name=Xr183c4}
N 760 36640 740 36640 {}
C {lab_pin.sym} 740 36640 0 0 {name=l29301 lab=BL4}
N 760 36600 740 36600 {}
C {lab_pin.sym} 740 36600 0 0 {name=l29302 lab=BLB4}
N 760 36560 740 36560 {}
C {lab_pin.sym} 740 36560 0 0 {name=l29303 lab=WL183}
N 840 36640 860 36640 {}
C {lab_pin.sym} 860 36640 0 0 {name=l29304 lab=VDD}
N 840 36560 860 36560 {}
C {lab_pin.sym} 860 36560 0 0 {name=l29305 lab=VSS}
C {bitcell_6t.sym} 1000 36600 0 0 {name=Xr183c5}
N 960 36640 940 36640 {}
C {lab_pin.sym} 940 36640 0 0 {name=l29306 lab=BL5}
N 960 36600 940 36600 {}
C {lab_pin.sym} 940 36600 0 0 {name=l29307 lab=BLB5}
N 960 36560 940 36560 {}
C {lab_pin.sym} 940 36560 0 0 {name=l29308 lab=WL183}
N 1040 36640 1060 36640 {}
C {lab_pin.sym} 1060 36640 0 0 {name=l29309 lab=VDD}
N 1040 36560 1060 36560 {}
C {lab_pin.sym} 1060 36560 0 0 {name=l29310 lab=VSS}
C {bitcell_6t.sym} 1200 36600 0 0 {name=Xr183c6}
N 1160 36640 1140 36640 {}
C {lab_pin.sym} 1140 36640 0 0 {name=l29311 lab=BL6}
N 1160 36600 1140 36600 {}
C {lab_pin.sym} 1140 36600 0 0 {name=l29312 lab=BLB6}
N 1160 36560 1140 36560 {}
C {lab_pin.sym} 1140 36560 0 0 {name=l29313 lab=WL183}
N 1240 36640 1260 36640 {}
C {lab_pin.sym} 1260 36640 0 0 {name=l29314 lab=VDD}
N 1240 36560 1260 36560 {}
C {lab_pin.sym} 1260 36560 0 0 {name=l29315 lab=VSS}
C {bitcell_6t.sym} 1400 36600 0 0 {name=Xr183c7}
N 1360 36640 1340 36640 {}
C {lab_pin.sym} 1340 36640 0 0 {name=l29316 lab=BL7}
N 1360 36600 1340 36600 {}
C {lab_pin.sym} 1340 36600 0 0 {name=l29317 lab=BLB7}
N 1360 36560 1340 36560 {}
C {lab_pin.sym} 1340 36560 0 0 {name=l29318 lab=WL183}
N 1440 36640 1460 36640 {}
C {lab_pin.sym} 1460 36640 0 0 {name=l29319 lab=VDD}
N 1440 36560 1460 36560 {}
C {lab_pin.sym} 1460 36560 0 0 {name=l29320 lab=VSS}
C {bitcell_6t.sym} 1600 36600 0 0 {name=Xr183c8}
N 1560 36640 1540 36640 {}
C {lab_pin.sym} 1540 36640 0 0 {name=l29321 lab=BL8}
N 1560 36600 1540 36600 {}
C {lab_pin.sym} 1540 36600 0 0 {name=l29322 lab=BLB8}
N 1560 36560 1540 36560 {}
C {lab_pin.sym} 1540 36560 0 0 {name=l29323 lab=WL183}
N 1640 36640 1660 36640 {}
C {lab_pin.sym} 1660 36640 0 0 {name=l29324 lab=VDD}
N 1640 36560 1660 36560 {}
C {lab_pin.sym} 1660 36560 0 0 {name=l29325 lab=VSS}
C {bitcell_6t.sym} 1800 36600 0 0 {name=Xr183c9}
N 1760 36640 1740 36640 {}
C {lab_pin.sym} 1740 36640 0 0 {name=l29326 lab=BL9}
N 1760 36600 1740 36600 {}
C {lab_pin.sym} 1740 36600 0 0 {name=l29327 lab=BLB9}
N 1760 36560 1740 36560 {}
C {lab_pin.sym} 1740 36560 0 0 {name=l29328 lab=WL183}
N 1840 36640 1860 36640 {}
C {lab_pin.sym} 1860 36640 0 0 {name=l29329 lab=VDD}
N 1840 36560 1860 36560 {}
C {lab_pin.sym} 1860 36560 0 0 {name=l29330 lab=VSS}
C {bitcell_6t.sym} 2000 36600 0 0 {name=Xr183c10}
N 1960 36640 1940 36640 {}
C {lab_pin.sym} 1940 36640 0 0 {name=l29331 lab=BL10}
N 1960 36600 1940 36600 {}
C {lab_pin.sym} 1940 36600 0 0 {name=l29332 lab=BLB10}
N 1960 36560 1940 36560 {}
C {lab_pin.sym} 1940 36560 0 0 {name=l29333 lab=WL183}
N 2040 36640 2060 36640 {}
C {lab_pin.sym} 2060 36640 0 0 {name=l29334 lab=VDD}
N 2040 36560 2060 36560 {}
C {lab_pin.sym} 2060 36560 0 0 {name=l29335 lab=VSS}
C {bitcell_6t.sym} 2200 36600 0 0 {name=Xr183c11}
N 2160 36640 2140 36640 {}
C {lab_pin.sym} 2140 36640 0 0 {name=l29336 lab=BL11}
N 2160 36600 2140 36600 {}
C {lab_pin.sym} 2140 36600 0 0 {name=l29337 lab=BLB11}
N 2160 36560 2140 36560 {}
C {lab_pin.sym} 2140 36560 0 0 {name=l29338 lab=WL183}
N 2240 36640 2260 36640 {}
C {lab_pin.sym} 2260 36640 0 0 {name=l29339 lab=VDD}
N 2240 36560 2260 36560 {}
C {lab_pin.sym} 2260 36560 0 0 {name=l29340 lab=VSS}
C {bitcell_6t.sym} 2400 36600 0 0 {name=Xr183c12}
N 2360 36640 2340 36640 {}
C {lab_pin.sym} 2340 36640 0 0 {name=l29341 lab=BL12}
N 2360 36600 2340 36600 {}
C {lab_pin.sym} 2340 36600 0 0 {name=l29342 lab=BLB12}
N 2360 36560 2340 36560 {}
C {lab_pin.sym} 2340 36560 0 0 {name=l29343 lab=WL183}
N 2440 36640 2460 36640 {}
C {lab_pin.sym} 2460 36640 0 0 {name=l29344 lab=VDD}
N 2440 36560 2460 36560 {}
C {lab_pin.sym} 2460 36560 0 0 {name=l29345 lab=VSS}
C {bitcell_6t.sym} 2600 36600 0 0 {name=Xr183c13}
N 2560 36640 2540 36640 {}
C {lab_pin.sym} 2540 36640 0 0 {name=l29346 lab=BL13}
N 2560 36600 2540 36600 {}
C {lab_pin.sym} 2540 36600 0 0 {name=l29347 lab=BLB13}
N 2560 36560 2540 36560 {}
C {lab_pin.sym} 2540 36560 0 0 {name=l29348 lab=WL183}
N 2640 36640 2660 36640 {}
C {lab_pin.sym} 2660 36640 0 0 {name=l29349 lab=VDD}
N 2640 36560 2660 36560 {}
C {lab_pin.sym} 2660 36560 0 0 {name=l29350 lab=VSS}
C {bitcell_6t.sym} 2800 36600 0 0 {name=Xr183c14}
N 2760 36640 2740 36640 {}
C {lab_pin.sym} 2740 36640 0 0 {name=l29351 lab=BL14}
N 2760 36600 2740 36600 {}
C {lab_pin.sym} 2740 36600 0 0 {name=l29352 lab=BLB14}
N 2760 36560 2740 36560 {}
C {lab_pin.sym} 2740 36560 0 0 {name=l29353 lab=WL183}
N 2840 36640 2860 36640 {}
C {lab_pin.sym} 2860 36640 0 0 {name=l29354 lab=VDD}
N 2840 36560 2860 36560 {}
C {lab_pin.sym} 2860 36560 0 0 {name=l29355 lab=VSS}
C {bitcell_6t.sym} 3000 36600 0 0 {name=Xr183c15}
N 2960 36640 2940 36640 {}
C {lab_pin.sym} 2940 36640 0 0 {name=l29356 lab=BL15}
N 2960 36600 2940 36600 {}
C {lab_pin.sym} 2940 36600 0 0 {name=l29357 lab=BLB15}
N 2960 36560 2940 36560 {}
C {lab_pin.sym} 2940 36560 0 0 {name=l29358 lab=WL183}
N 3040 36640 3060 36640 {}
C {lab_pin.sym} 3060 36640 0 0 {name=l29359 lab=VDD}
N 3040 36560 3060 36560 {}
C {lab_pin.sym} 3060 36560 0 0 {name=l29360 lab=VSS}
C {bitcell_6t.sym} 3200 36600 0 0 {name=Xr183c16}
N 3160 36640 3140 36640 {}
C {lab_pin.sym} 3140 36640 0 0 {name=l29361 lab=BL16}
N 3160 36600 3140 36600 {}
C {lab_pin.sym} 3140 36600 0 0 {name=l29362 lab=BLB16}
N 3160 36560 3140 36560 {}
C {lab_pin.sym} 3140 36560 0 0 {name=l29363 lab=WL183}
N 3240 36640 3260 36640 {}
C {lab_pin.sym} 3260 36640 0 0 {name=l29364 lab=VDD}
N 3240 36560 3260 36560 {}
C {lab_pin.sym} 3260 36560 0 0 {name=l29365 lab=VSS}
C {bitcell_6t.sym} 3400 36600 0 0 {name=Xr183c17}
N 3360 36640 3340 36640 {}
C {lab_pin.sym} 3340 36640 0 0 {name=l29366 lab=BL17}
N 3360 36600 3340 36600 {}
C {lab_pin.sym} 3340 36600 0 0 {name=l29367 lab=BLB17}
N 3360 36560 3340 36560 {}
C {lab_pin.sym} 3340 36560 0 0 {name=l29368 lab=WL183}
N 3440 36640 3460 36640 {}
C {lab_pin.sym} 3460 36640 0 0 {name=l29369 lab=VDD}
N 3440 36560 3460 36560 {}
C {lab_pin.sym} 3460 36560 0 0 {name=l29370 lab=VSS}
C {bitcell_6t.sym} 3600 36600 0 0 {name=Xr183c18}
N 3560 36640 3540 36640 {}
C {lab_pin.sym} 3540 36640 0 0 {name=l29371 lab=BL18}
N 3560 36600 3540 36600 {}
C {lab_pin.sym} 3540 36600 0 0 {name=l29372 lab=BLB18}
N 3560 36560 3540 36560 {}
C {lab_pin.sym} 3540 36560 0 0 {name=l29373 lab=WL183}
N 3640 36640 3660 36640 {}
C {lab_pin.sym} 3660 36640 0 0 {name=l29374 lab=VDD}
N 3640 36560 3660 36560 {}
C {lab_pin.sym} 3660 36560 0 0 {name=l29375 lab=VSS}
C {bitcell_6t.sym} 3800 36600 0 0 {name=Xr183c19}
N 3760 36640 3740 36640 {}
C {lab_pin.sym} 3740 36640 0 0 {name=l29376 lab=BL19}
N 3760 36600 3740 36600 {}
C {lab_pin.sym} 3740 36600 0 0 {name=l29377 lab=BLB19}
N 3760 36560 3740 36560 {}
C {lab_pin.sym} 3740 36560 0 0 {name=l29378 lab=WL183}
N 3840 36640 3860 36640 {}
C {lab_pin.sym} 3860 36640 0 0 {name=l29379 lab=VDD}
N 3840 36560 3860 36560 {}
C {lab_pin.sym} 3860 36560 0 0 {name=l29380 lab=VSS}
C {bitcell_6t.sym} 4000 36600 0 0 {name=Xr183c20}
N 3960 36640 3940 36640 {}
C {lab_pin.sym} 3940 36640 0 0 {name=l29381 lab=BL20}
N 3960 36600 3940 36600 {}
C {lab_pin.sym} 3940 36600 0 0 {name=l29382 lab=BLB20}
N 3960 36560 3940 36560 {}
C {lab_pin.sym} 3940 36560 0 0 {name=l29383 lab=WL183}
N 4040 36640 4060 36640 {}
C {lab_pin.sym} 4060 36640 0 0 {name=l29384 lab=VDD}
N 4040 36560 4060 36560 {}
C {lab_pin.sym} 4060 36560 0 0 {name=l29385 lab=VSS}
C {bitcell_6t.sym} 4200 36600 0 0 {name=Xr183c21}
N 4160 36640 4140 36640 {}
C {lab_pin.sym} 4140 36640 0 0 {name=l29386 lab=BL21}
N 4160 36600 4140 36600 {}
C {lab_pin.sym} 4140 36600 0 0 {name=l29387 lab=BLB21}
N 4160 36560 4140 36560 {}
C {lab_pin.sym} 4140 36560 0 0 {name=l29388 lab=WL183}
N 4240 36640 4260 36640 {}
C {lab_pin.sym} 4260 36640 0 0 {name=l29389 lab=VDD}
N 4240 36560 4260 36560 {}
C {lab_pin.sym} 4260 36560 0 0 {name=l29390 lab=VSS}
C {bitcell_6t.sym} 4400 36600 0 0 {name=Xr183c22}
N 4360 36640 4340 36640 {}
C {lab_pin.sym} 4340 36640 0 0 {name=l29391 lab=BL22}
N 4360 36600 4340 36600 {}
C {lab_pin.sym} 4340 36600 0 0 {name=l29392 lab=BLB22}
N 4360 36560 4340 36560 {}
C {lab_pin.sym} 4340 36560 0 0 {name=l29393 lab=WL183}
N 4440 36640 4460 36640 {}
C {lab_pin.sym} 4460 36640 0 0 {name=l29394 lab=VDD}
N 4440 36560 4460 36560 {}
C {lab_pin.sym} 4460 36560 0 0 {name=l29395 lab=VSS}
C {bitcell_6t.sym} 4600 36600 0 0 {name=Xr183c23}
N 4560 36640 4540 36640 {}
C {lab_pin.sym} 4540 36640 0 0 {name=l29396 lab=BL23}
N 4560 36600 4540 36600 {}
C {lab_pin.sym} 4540 36600 0 0 {name=l29397 lab=BLB23}
N 4560 36560 4540 36560 {}
C {lab_pin.sym} 4540 36560 0 0 {name=l29398 lab=WL183}
N 4640 36640 4660 36640 {}
C {lab_pin.sym} 4660 36640 0 0 {name=l29399 lab=VDD}
N 4640 36560 4660 36560 {}
C {lab_pin.sym} 4660 36560 0 0 {name=l29400 lab=VSS}
C {bitcell_6t.sym} 4800 36600 0 0 {name=Xr183c24}
N 4760 36640 4740 36640 {}
C {lab_pin.sym} 4740 36640 0 0 {name=l29401 lab=BL24}
N 4760 36600 4740 36600 {}
C {lab_pin.sym} 4740 36600 0 0 {name=l29402 lab=BLB24}
N 4760 36560 4740 36560 {}
C {lab_pin.sym} 4740 36560 0 0 {name=l29403 lab=WL183}
N 4840 36640 4860 36640 {}
C {lab_pin.sym} 4860 36640 0 0 {name=l29404 lab=VDD}
N 4840 36560 4860 36560 {}
C {lab_pin.sym} 4860 36560 0 0 {name=l29405 lab=VSS}
C {bitcell_6t.sym} 5000 36600 0 0 {name=Xr183c25}
N 4960 36640 4940 36640 {}
C {lab_pin.sym} 4940 36640 0 0 {name=l29406 lab=BL25}
N 4960 36600 4940 36600 {}
C {lab_pin.sym} 4940 36600 0 0 {name=l29407 lab=BLB25}
N 4960 36560 4940 36560 {}
C {lab_pin.sym} 4940 36560 0 0 {name=l29408 lab=WL183}
N 5040 36640 5060 36640 {}
C {lab_pin.sym} 5060 36640 0 0 {name=l29409 lab=VDD}
N 5040 36560 5060 36560 {}
C {lab_pin.sym} 5060 36560 0 0 {name=l29410 lab=VSS}
C {bitcell_6t.sym} 5200 36600 0 0 {name=Xr183c26}
N 5160 36640 5140 36640 {}
C {lab_pin.sym} 5140 36640 0 0 {name=l29411 lab=BL26}
N 5160 36600 5140 36600 {}
C {lab_pin.sym} 5140 36600 0 0 {name=l29412 lab=BLB26}
N 5160 36560 5140 36560 {}
C {lab_pin.sym} 5140 36560 0 0 {name=l29413 lab=WL183}
N 5240 36640 5260 36640 {}
C {lab_pin.sym} 5260 36640 0 0 {name=l29414 lab=VDD}
N 5240 36560 5260 36560 {}
C {lab_pin.sym} 5260 36560 0 0 {name=l29415 lab=VSS}
C {bitcell_6t.sym} 5400 36600 0 0 {name=Xr183c27}
N 5360 36640 5340 36640 {}
C {lab_pin.sym} 5340 36640 0 0 {name=l29416 lab=BL27}
N 5360 36600 5340 36600 {}
C {lab_pin.sym} 5340 36600 0 0 {name=l29417 lab=BLB27}
N 5360 36560 5340 36560 {}
C {lab_pin.sym} 5340 36560 0 0 {name=l29418 lab=WL183}
N 5440 36640 5460 36640 {}
C {lab_pin.sym} 5460 36640 0 0 {name=l29419 lab=VDD}
N 5440 36560 5460 36560 {}
C {lab_pin.sym} 5460 36560 0 0 {name=l29420 lab=VSS}
C {bitcell_6t.sym} 5600 36600 0 0 {name=Xr183c28}
N 5560 36640 5540 36640 {}
C {lab_pin.sym} 5540 36640 0 0 {name=l29421 lab=BL28}
N 5560 36600 5540 36600 {}
C {lab_pin.sym} 5540 36600 0 0 {name=l29422 lab=BLB28}
N 5560 36560 5540 36560 {}
C {lab_pin.sym} 5540 36560 0 0 {name=l29423 lab=WL183}
N 5640 36640 5660 36640 {}
C {lab_pin.sym} 5660 36640 0 0 {name=l29424 lab=VDD}
N 5640 36560 5660 36560 {}
C {lab_pin.sym} 5660 36560 0 0 {name=l29425 lab=VSS}
C {bitcell_6t.sym} 5800 36600 0 0 {name=Xr183c29}
N 5760 36640 5740 36640 {}
C {lab_pin.sym} 5740 36640 0 0 {name=l29426 lab=BL29}
N 5760 36600 5740 36600 {}
C {lab_pin.sym} 5740 36600 0 0 {name=l29427 lab=BLB29}
N 5760 36560 5740 36560 {}
C {lab_pin.sym} 5740 36560 0 0 {name=l29428 lab=WL183}
N 5840 36640 5860 36640 {}
C {lab_pin.sym} 5860 36640 0 0 {name=l29429 lab=VDD}
N 5840 36560 5860 36560 {}
C {lab_pin.sym} 5860 36560 0 0 {name=l29430 lab=VSS}
C {bitcell_6t.sym} 6000 36600 0 0 {name=Xr183c30}
N 5960 36640 5940 36640 {}
C {lab_pin.sym} 5940 36640 0 0 {name=l29431 lab=BL30}
N 5960 36600 5940 36600 {}
C {lab_pin.sym} 5940 36600 0 0 {name=l29432 lab=BLB30}
N 5960 36560 5940 36560 {}
C {lab_pin.sym} 5940 36560 0 0 {name=l29433 lab=WL183}
N 6040 36640 6060 36640 {}
C {lab_pin.sym} 6060 36640 0 0 {name=l29434 lab=VDD}
N 6040 36560 6060 36560 {}
C {lab_pin.sym} 6060 36560 0 0 {name=l29435 lab=VSS}
C {bitcell_6t.sym} 6200 36600 0 0 {name=Xr183c31}
N 6160 36640 6140 36640 {}
C {lab_pin.sym} 6140 36640 0 0 {name=l29436 lab=BL31}
N 6160 36600 6140 36600 {}
C {lab_pin.sym} 6140 36600 0 0 {name=l29437 lab=BLB31}
N 6160 36560 6140 36560 {}
C {lab_pin.sym} 6140 36560 0 0 {name=l29438 lab=WL183}
N 6240 36640 6260 36640 {}
C {lab_pin.sym} 6260 36640 0 0 {name=l29439 lab=VDD}
N 6240 36560 6260 36560 {}
C {lab_pin.sym} 6260 36560 0 0 {name=l29440 lab=VSS}
C {bitcell_6t.sym} 0 36800 0 0 {name=Xr184c0}
N -40 36840 -60 36840 {}
C {lab_pin.sym} -60 36840 0 0 {name=l29441 lab=BL0}
N -40 36800 -60 36800 {}
C {lab_pin.sym} -60 36800 0 0 {name=l29442 lab=BLB0}
N -40 36760 -60 36760 {}
C {lab_pin.sym} -60 36760 0 0 {name=l29443 lab=WL184}
N 40 36840 60 36840 {}
C {lab_pin.sym} 60 36840 0 0 {name=l29444 lab=VDD}
N 40 36760 60 36760 {}
C {lab_pin.sym} 60 36760 0 0 {name=l29445 lab=VSS}
C {bitcell_6t.sym} 200 36800 0 0 {name=Xr184c1}
N 160 36840 140 36840 {}
C {lab_pin.sym} 140 36840 0 0 {name=l29446 lab=BL1}
N 160 36800 140 36800 {}
C {lab_pin.sym} 140 36800 0 0 {name=l29447 lab=BLB1}
N 160 36760 140 36760 {}
C {lab_pin.sym} 140 36760 0 0 {name=l29448 lab=WL184}
N 240 36840 260 36840 {}
C {lab_pin.sym} 260 36840 0 0 {name=l29449 lab=VDD}
N 240 36760 260 36760 {}
C {lab_pin.sym} 260 36760 0 0 {name=l29450 lab=VSS}
C {bitcell_6t.sym} 400 36800 0 0 {name=Xr184c2}
N 360 36840 340 36840 {}
C {lab_pin.sym} 340 36840 0 0 {name=l29451 lab=BL2}
N 360 36800 340 36800 {}
C {lab_pin.sym} 340 36800 0 0 {name=l29452 lab=BLB2}
N 360 36760 340 36760 {}
C {lab_pin.sym} 340 36760 0 0 {name=l29453 lab=WL184}
N 440 36840 460 36840 {}
C {lab_pin.sym} 460 36840 0 0 {name=l29454 lab=VDD}
N 440 36760 460 36760 {}
C {lab_pin.sym} 460 36760 0 0 {name=l29455 lab=VSS}
C {bitcell_6t.sym} 600 36800 0 0 {name=Xr184c3}
N 560 36840 540 36840 {}
C {lab_pin.sym} 540 36840 0 0 {name=l29456 lab=BL3}
N 560 36800 540 36800 {}
C {lab_pin.sym} 540 36800 0 0 {name=l29457 lab=BLB3}
N 560 36760 540 36760 {}
C {lab_pin.sym} 540 36760 0 0 {name=l29458 lab=WL184}
N 640 36840 660 36840 {}
C {lab_pin.sym} 660 36840 0 0 {name=l29459 lab=VDD}
N 640 36760 660 36760 {}
C {lab_pin.sym} 660 36760 0 0 {name=l29460 lab=VSS}
C {bitcell_6t.sym} 800 36800 0 0 {name=Xr184c4}
N 760 36840 740 36840 {}
C {lab_pin.sym} 740 36840 0 0 {name=l29461 lab=BL4}
N 760 36800 740 36800 {}
C {lab_pin.sym} 740 36800 0 0 {name=l29462 lab=BLB4}
N 760 36760 740 36760 {}
C {lab_pin.sym} 740 36760 0 0 {name=l29463 lab=WL184}
N 840 36840 860 36840 {}
C {lab_pin.sym} 860 36840 0 0 {name=l29464 lab=VDD}
N 840 36760 860 36760 {}
C {lab_pin.sym} 860 36760 0 0 {name=l29465 lab=VSS}
C {bitcell_6t.sym} 1000 36800 0 0 {name=Xr184c5}
N 960 36840 940 36840 {}
C {lab_pin.sym} 940 36840 0 0 {name=l29466 lab=BL5}
N 960 36800 940 36800 {}
C {lab_pin.sym} 940 36800 0 0 {name=l29467 lab=BLB5}
N 960 36760 940 36760 {}
C {lab_pin.sym} 940 36760 0 0 {name=l29468 lab=WL184}
N 1040 36840 1060 36840 {}
C {lab_pin.sym} 1060 36840 0 0 {name=l29469 lab=VDD}
N 1040 36760 1060 36760 {}
C {lab_pin.sym} 1060 36760 0 0 {name=l29470 lab=VSS}
C {bitcell_6t.sym} 1200 36800 0 0 {name=Xr184c6}
N 1160 36840 1140 36840 {}
C {lab_pin.sym} 1140 36840 0 0 {name=l29471 lab=BL6}
N 1160 36800 1140 36800 {}
C {lab_pin.sym} 1140 36800 0 0 {name=l29472 lab=BLB6}
N 1160 36760 1140 36760 {}
C {lab_pin.sym} 1140 36760 0 0 {name=l29473 lab=WL184}
N 1240 36840 1260 36840 {}
C {lab_pin.sym} 1260 36840 0 0 {name=l29474 lab=VDD}
N 1240 36760 1260 36760 {}
C {lab_pin.sym} 1260 36760 0 0 {name=l29475 lab=VSS}
C {bitcell_6t.sym} 1400 36800 0 0 {name=Xr184c7}
N 1360 36840 1340 36840 {}
C {lab_pin.sym} 1340 36840 0 0 {name=l29476 lab=BL7}
N 1360 36800 1340 36800 {}
C {lab_pin.sym} 1340 36800 0 0 {name=l29477 lab=BLB7}
N 1360 36760 1340 36760 {}
C {lab_pin.sym} 1340 36760 0 0 {name=l29478 lab=WL184}
N 1440 36840 1460 36840 {}
C {lab_pin.sym} 1460 36840 0 0 {name=l29479 lab=VDD}
N 1440 36760 1460 36760 {}
C {lab_pin.sym} 1460 36760 0 0 {name=l29480 lab=VSS}
C {bitcell_6t.sym} 1600 36800 0 0 {name=Xr184c8}
N 1560 36840 1540 36840 {}
C {lab_pin.sym} 1540 36840 0 0 {name=l29481 lab=BL8}
N 1560 36800 1540 36800 {}
C {lab_pin.sym} 1540 36800 0 0 {name=l29482 lab=BLB8}
N 1560 36760 1540 36760 {}
C {lab_pin.sym} 1540 36760 0 0 {name=l29483 lab=WL184}
N 1640 36840 1660 36840 {}
C {lab_pin.sym} 1660 36840 0 0 {name=l29484 lab=VDD}
N 1640 36760 1660 36760 {}
C {lab_pin.sym} 1660 36760 0 0 {name=l29485 lab=VSS}
C {bitcell_6t.sym} 1800 36800 0 0 {name=Xr184c9}
N 1760 36840 1740 36840 {}
C {lab_pin.sym} 1740 36840 0 0 {name=l29486 lab=BL9}
N 1760 36800 1740 36800 {}
C {lab_pin.sym} 1740 36800 0 0 {name=l29487 lab=BLB9}
N 1760 36760 1740 36760 {}
C {lab_pin.sym} 1740 36760 0 0 {name=l29488 lab=WL184}
N 1840 36840 1860 36840 {}
C {lab_pin.sym} 1860 36840 0 0 {name=l29489 lab=VDD}
N 1840 36760 1860 36760 {}
C {lab_pin.sym} 1860 36760 0 0 {name=l29490 lab=VSS}
C {bitcell_6t.sym} 2000 36800 0 0 {name=Xr184c10}
N 1960 36840 1940 36840 {}
C {lab_pin.sym} 1940 36840 0 0 {name=l29491 lab=BL10}
N 1960 36800 1940 36800 {}
C {lab_pin.sym} 1940 36800 0 0 {name=l29492 lab=BLB10}
N 1960 36760 1940 36760 {}
C {lab_pin.sym} 1940 36760 0 0 {name=l29493 lab=WL184}
N 2040 36840 2060 36840 {}
C {lab_pin.sym} 2060 36840 0 0 {name=l29494 lab=VDD}
N 2040 36760 2060 36760 {}
C {lab_pin.sym} 2060 36760 0 0 {name=l29495 lab=VSS}
C {bitcell_6t.sym} 2200 36800 0 0 {name=Xr184c11}
N 2160 36840 2140 36840 {}
C {lab_pin.sym} 2140 36840 0 0 {name=l29496 lab=BL11}
N 2160 36800 2140 36800 {}
C {lab_pin.sym} 2140 36800 0 0 {name=l29497 lab=BLB11}
N 2160 36760 2140 36760 {}
C {lab_pin.sym} 2140 36760 0 0 {name=l29498 lab=WL184}
N 2240 36840 2260 36840 {}
C {lab_pin.sym} 2260 36840 0 0 {name=l29499 lab=VDD}
N 2240 36760 2260 36760 {}
C {lab_pin.sym} 2260 36760 0 0 {name=l29500 lab=VSS}
C {bitcell_6t.sym} 2400 36800 0 0 {name=Xr184c12}
N 2360 36840 2340 36840 {}
C {lab_pin.sym} 2340 36840 0 0 {name=l29501 lab=BL12}
N 2360 36800 2340 36800 {}
C {lab_pin.sym} 2340 36800 0 0 {name=l29502 lab=BLB12}
N 2360 36760 2340 36760 {}
C {lab_pin.sym} 2340 36760 0 0 {name=l29503 lab=WL184}
N 2440 36840 2460 36840 {}
C {lab_pin.sym} 2460 36840 0 0 {name=l29504 lab=VDD}
N 2440 36760 2460 36760 {}
C {lab_pin.sym} 2460 36760 0 0 {name=l29505 lab=VSS}
C {bitcell_6t.sym} 2600 36800 0 0 {name=Xr184c13}
N 2560 36840 2540 36840 {}
C {lab_pin.sym} 2540 36840 0 0 {name=l29506 lab=BL13}
N 2560 36800 2540 36800 {}
C {lab_pin.sym} 2540 36800 0 0 {name=l29507 lab=BLB13}
N 2560 36760 2540 36760 {}
C {lab_pin.sym} 2540 36760 0 0 {name=l29508 lab=WL184}
N 2640 36840 2660 36840 {}
C {lab_pin.sym} 2660 36840 0 0 {name=l29509 lab=VDD}
N 2640 36760 2660 36760 {}
C {lab_pin.sym} 2660 36760 0 0 {name=l29510 lab=VSS}
C {bitcell_6t.sym} 2800 36800 0 0 {name=Xr184c14}
N 2760 36840 2740 36840 {}
C {lab_pin.sym} 2740 36840 0 0 {name=l29511 lab=BL14}
N 2760 36800 2740 36800 {}
C {lab_pin.sym} 2740 36800 0 0 {name=l29512 lab=BLB14}
N 2760 36760 2740 36760 {}
C {lab_pin.sym} 2740 36760 0 0 {name=l29513 lab=WL184}
N 2840 36840 2860 36840 {}
C {lab_pin.sym} 2860 36840 0 0 {name=l29514 lab=VDD}
N 2840 36760 2860 36760 {}
C {lab_pin.sym} 2860 36760 0 0 {name=l29515 lab=VSS}
C {bitcell_6t.sym} 3000 36800 0 0 {name=Xr184c15}
N 2960 36840 2940 36840 {}
C {lab_pin.sym} 2940 36840 0 0 {name=l29516 lab=BL15}
N 2960 36800 2940 36800 {}
C {lab_pin.sym} 2940 36800 0 0 {name=l29517 lab=BLB15}
N 2960 36760 2940 36760 {}
C {lab_pin.sym} 2940 36760 0 0 {name=l29518 lab=WL184}
N 3040 36840 3060 36840 {}
C {lab_pin.sym} 3060 36840 0 0 {name=l29519 lab=VDD}
N 3040 36760 3060 36760 {}
C {lab_pin.sym} 3060 36760 0 0 {name=l29520 lab=VSS}
C {bitcell_6t.sym} 3200 36800 0 0 {name=Xr184c16}
N 3160 36840 3140 36840 {}
C {lab_pin.sym} 3140 36840 0 0 {name=l29521 lab=BL16}
N 3160 36800 3140 36800 {}
C {lab_pin.sym} 3140 36800 0 0 {name=l29522 lab=BLB16}
N 3160 36760 3140 36760 {}
C {lab_pin.sym} 3140 36760 0 0 {name=l29523 lab=WL184}
N 3240 36840 3260 36840 {}
C {lab_pin.sym} 3260 36840 0 0 {name=l29524 lab=VDD}
N 3240 36760 3260 36760 {}
C {lab_pin.sym} 3260 36760 0 0 {name=l29525 lab=VSS}
C {bitcell_6t.sym} 3400 36800 0 0 {name=Xr184c17}
N 3360 36840 3340 36840 {}
C {lab_pin.sym} 3340 36840 0 0 {name=l29526 lab=BL17}
N 3360 36800 3340 36800 {}
C {lab_pin.sym} 3340 36800 0 0 {name=l29527 lab=BLB17}
N 3360 36760 3340 36760 {}
C {lab_pin.sym} 3340 36760 0 0 {name=l29528 lab=WL184}
N 3440 36840 3460 36840 {}
C {lab_pin.sym} 3460 36840 0 0 {name=l29529 lab=VDD}
N 3440 36760 3460 36760 {}
C {lab_pin.sym} 3460 36760 0 0 {name=l29530 lab=VSS}
C {bitcell_6t.sym} 3600 36800 0 0 {name=Xr184c18}
N 3560 36840 3540 36840 {}
C {lab_pin.sym} 3540 36840 0 0 {name=l29531 lab=BL18}
N 3560 36800 3540 36800 {}
C {lab_pin.sym} 3540 36800 0 0 {name=l29532 lab=BLB18}
N 3560 36760 3540 36760 {}
C {lab_pin.sym} 3540 36760 0 0 {name=l29533 lab=WL184}
N 3640 36840 3660 36840 {}
C {lab_pin.sym} 3660 36840 0 0 {name=l29534 lab=VDD}
N 3640 36760 3660 36760 {}
C {lab_pin.sym} 3660 36760 0 0 {name=l29535 lab=VSS}
C {bitcell_6t.sym} 3800 36800 0 0 {name=Xr184c19}
N 3760 36840 3740 36840 {}
C {lab_pin.sym} 3740 36840 0 0 {name=l29536 lab=BL19}
N 3760 36800 3740 36800 {}
C {lab_pin.sym} 3740 36800 0 0 {name=l29537 lab=BLB19}
N 3760 36760 3740 36760 {}
C {lab_pin.sym} 3740 36760 0 0 {name=l29538 lab=WL184}
N 3840 36840 3860 36840 {}
C {lab_pin.sym} 3860 36840 0 0 {name=l29539 lab=VDD}
N 3840 36760 3860 36760 {}
C {lab_pin.sym} 3860 36760 0 0 {name=l29540 lab=VSS}
C {bitcell_6t.sym} 4000 36800 0 0 {name=Xr184c20}
N 3960 36840 3940 36840 {}
C {lab_pin.sym} 3940 36840 0 0 {name=l29541 lab=BL20}
N 3960 36800 3940 36800 {}
C {lab_pin.sym} 3940 36800 0 0 {name=l29542 lab=BLB20}
N 3960 36760 3940 36760 {}
C {lab_pin.sym} 3940 36760 0 0 {name=l29543 lab=WL184}
N 4040 36840 4060 36840 {}
C {lab_pin.sym} 4060 36840 0 0 {name=l29544 lab=VDD}
N 4040 36760 4060 36760 {}
C {lab_pin.sym} 4060 36760 0 0 {name=l29545 lab=VSS}
C {bitcell_6t.sym} 4200 36800 0 0 {name=Xr184c21}
N 4160 36840 4140 36840 {}
C {lab_pin.sym} 4140 36840 0 0 {name=l29546 lab=BL21}
N 4160 36800 4140 36800 {}
C {lab_pin.sym} 4140 36800 0 0 {name=l29547 lab=BLB21}
N 4160 36760 4140 36760 {}
C {lab_pin.sym} 4140 36760 0 0 {name=l29548 lab=WL184}
N 4240 36840 4260 36840 {}
C {lab_pin.sym} 4260 36840 0 0 {name=l29549 lab=VDD}
N 4240 36760 4260 36760 {}
C {lab_pin.sym} 4260 36760 0 0 {name=l29550 lab=VSS}
C {bitcell_6t.sym} 4400 36800 0 0 {name=Xr184c22}
N 4360 36840 4340 36840 {}
C {lab_pin.sym} 4340 36840 0 0 {name=l29551 lab=BL22}
N 4360 36800 4340 36800 {}
C {lab_pin.sym} 4340 36800 0 0 {name=l29552 lab=BLB22}
N 4360 36760 4340 36760 {}
C {lab_pin.sym} 4340 36760 0 0 {name=l29553 lab=WL184}
N 4440 36840 4460 36840 {}
C {lab_pin.sym} 4460 36840 0 0 {name=l29554 lab=VDD}
N 4440 36760 4460 36760 {}
C {lab_pin.sym} 4460 36760 0 0 {name=l29555 lab=VSS}
C {bitcell_6t.sym} 4600 36800 0 0 {name=Xr184c23}
N 4560 36840 4540 36840 {}
C {lab_pin.sym} 4540 36840 0 0 {name=l29556 lab=BL23}
N 4560 36800 4540 36800 {}
C {lab_pin.sym} 4540 36800 0 0 {name=l29557 lab=BLB23}
N 4560 36760 4540 36760 {}
C {lab_pin.sym} 4540 36760 0 0 {name=l29558 lab=WL184}
N 4640 36840 4660 36840 {}
C {lab_pin.sym} 4660 36840 0 0 {name=l29559 lab=VDD}
N 4640 36760 4660 36760 {}
C {lab_pin.sym} 4660 36760 0 0 {name=l29560 lab=VSS}
C {bitcell_6t.sym} 4800 36800 0 0 {name=Xr184c24}
N 4760 36840 4740 36840 {}
C {lab_pin.sym} 4740 36840 0 0 {name=l29561 lab=BL24}
N 4760 36800 4740 36800 {}
C {lab_pin.sym} 4740 36800 0 0 {name=l29562 lab=BLB24}
N 4760 36760 4740 36760 {}
C {lab_pin.sym} 4740 36760 0 0 {name=l29563 lab=WL184}
N 4840 36840 4860 36840 {}
C {lab_pin.sym} 4860 36840 0 0 {name=l29564 lab=VDD}
N 4840 36760 4860 36760 {}
C {lab_pin.sym} 4860 36760 0 0 {name=l29565 lab=VSS}
C {bitcell_6t.sym} 5000 36800 0 0 {name=Xr184c25}
N 4960 36840 4940 36840 {}
C {lab_pin.sym} 4940 36840 0 0 {name=l29566 lab=BL25}
N 4960 36800 4940 36800 {}
C {lab_pin.sym} 4940 36800 0 0 {name=l29567 lab=BLB25}
N 4960 36760 4940 36760 {}
C {lab_pin.sym} 4940 36760 0 0 {name=l29568 lab=WL184}
N 5040 36840 5060 36840 {}
C {lab_pin.sym} 5060 36840 0 0 {name=l29569 lab=VDD}
N 5040 36760 5060 36760 {}
C {lab_pin.sym} 5060 36760 0 0 {name=l29570 lab=VSS}
C {bitcell_6t.sym} 5200 36800 0 0 {name=Xr184c26}
N 5160 36840 5140 36840 {}
C {lab_pin.sym} 5140 36840 0 0 {name=l29571 lab=BL26}
N 5160 36800 5140 36800 {}
C {lab_pin.sym} 5140 36800 0 0 {name=l29572 lab=BLB26}
N 5160 36760 5140 36760 {}
C {lab_pin.sym} 5140 36760 0 0 {name=l29573 lab=WL184}
N 5240 36840 5260 36840 {}
C {lab_pin.sym} 5260 36840 0 0 {name=l29574 lab=VDD}
N 5240 36760 5260 36760 {}
C {lab_pin.sym} 5260 36760 0 0 {name=l29575 lab=VSS}
C {bitcell_6t.sym} 5400 36800 0 0 {name=Xr184c27}
N 5360 36840 5340 36840 {}
C {lab_pin.sym} 5340 36840 0 0 {name=l29576 lab=BL27}
N 5360 36800 5340 36800 {}
C {lab_pin.sym} 5340 36800 0 0 {name=l29577 lab=BLB27}
N 5360 36760 5340 36760 {}
C {lab_pin.sym} 5340 36760 0 0 {name=l29578 lab=WL184}
N 5440 36840 5460 36840 {}
C {lab_pin.sym} 5460 36840 0 0 {name=l29579 lab=VDD}
N 5440 36760 5460 36760 {}
C {lab_pin.sym} 5460 36760 0 0 {name=l29580 lab=VSS}
C {bitcell_6t.sym} 5600 36800 0 0 {name=Xr184c28}
N 5560 36840 5540 36840 {}
C {lab_pin.sym} 5540 36840 0 0 {name=l29581 lab=BL28}
N 5560 36800 5540 36800 {}
C {lab_pin.sym} 5540 36800 0 0 {name=l29582 lab=BLB28}
N 5560 36760 5540 36760 {}
C {lab_pin.sym} 5540 36760 0 0 {name=l29583 lab=WL184}
N 5640 36840 5660 36840 {}
C {lab_pin.sym} 5660 36840 0 0 {name=l29584 lab=VDD}
N 5640 36760 5660 36760 {}
C {lab_pin.sym} 5660 36760 0 0 {name=l29585 lab=VSS}
C {bitcell_6t.sym} 5800 36800 0 0 {name=Xr184c29}
N 5760 36840 5740 36840 {}
C {lab_pin.sym} 5740 36840 0 0 {name=l29586 lab=BL29}
N 5760 36800 5740 36800 {}
C {lab_pin.sym} 5740 36800 0 0 {name=l29587 lab=BLB29}
N 5760 36760 5740 36760 {}
C {lab_pin.sym} 5740 36760 0 0 {name=l29588 lab=WL184}
N 5840 36840 5860 36840 {}
C {lab_pin.sym} 5860 36840 0 0 {name=l29589 lab=VDD}
N 5840 36760 5860 36760 {}
C {lab_pin.sym} 5860 36760 0 0 {name=l29590 lab=VSS}
C {bitcell_6t.sym} 6000 36800 0 0 {name=Xr184c30}
N 5960 36840 5940 36840 {}
C {lab_pin.sym} 5940 36840 0 0 {name=l29591 lab=BL30}
N 5960 36800 5940 36800 {}
C {lab_pin.sym} 5940 36800 0 0 {name=l29592 lab=BLB30}
N 5960 36760 5940 36760 {}
C {lab_pin.sym} 5940 36760 0 0 {name=l29593 lab=WL184}
N 6040 36840 6060 36840 {}
C {lab_pin.sym} 6060 36840 0 0 {name=l29594 lab=VDD}
N 6040 36760 6060 36760 {}
C {lab_pin.sym} 6060 36760 0 0 {name=l29595 lab=VSS}
C {bitcell_6t.sym} 6200 36800 0 0 {name=Xr184c31}
N 6160 36840 6140 36840 {}
C {lab_pin.sym} 6140 36840 0 0 {name=l29596 lab=BL31}
N 6160 36800 6140 36800 {}
C {lab_pin.sym} 6140 36800 0 0 {name=l29597 lab=BLB31}
N 6160 36760 6140 36760 {}
C {lab_pin.sym} 6140 36760 0 0 {name=l29598 lab=WL184}
N 6240 36840 6260 36840 {}
C {lab_pin.sym} 6260 36840 0 0 {name=l29599 lab=VDD}
N 6240 36760 6260 36760 {}
C {lab_pin.sym} 6260 36760 0 0 {name=l29600 lab=VSS}
C {bitcell_6t.sym} 0 37000 0 0 {name=Xr185c0}
N -40 37040 -60 37040 {}
C {lab_pin.sym} -60 37040 0 0 {name=l29601 lab=BL0}
N -40 37000 -60 37000 {}
C {lab_pin.sym} -60 37000 0 0 {name=l29602 lab=BLB0}
N -40 36960 -60 36960 {}
C {lab_pin.sym} -60 36960 0 0 {name=l29603 lab=WL185}
N 40 37040 60 37040 {}
C {lab_pin.sym} 60 37040 0 0 {name=l29604 lab=VDD}
N 40 36960 60 36960 {}
C {lab_pin.sym} 60 36960 0 0 {name=l29605 lab=VSS}
C {bitcell_6t.sym} 200 37000 0 0 {name=Xr185c1}
N 160 37040 140 37040 {}
C {lab_pin.sym} 140 37040 0 0 {name=l29606 lab=BL1}
N 160 37000 140 37000 {}
C {lab_pin.sym} 140 37000 0 0 {name=l29607 lab=BLB1}
N 160 36960 140 36960 {}
C {lab_pin.sym} 140 36960 0 0 {name=l29608 lab=WL185}
N 240 37040 260 37040 {}
C {lab_pin.sym} 260 37040 0 0 {name=l29609 lab=VDD}
N 240 36960 260 36960 {}
C {lab_pin.sym} 260 36960 0 0 {name=l29610 lab=VSS}
C {bitcell_6t.sym} 400 37000 0 0 {name=Xr185c2}
N 360 37040 340 37040 {}
C {lab_pin.sym} 340 37040 0 0 {name=l29611 lab=BL2}
N 360 37000 340 37000 {}
C {lab_pin.sym} 340 37000 0 0 {name=l29612 lab=BLB2}
N 360 36960 340 36960 {}
C {lab_pin.sym} 340 36960 0 0 {name=l29613 lab=WL185}
N 440 37040 460 37040 {}
C {lab_pin.sym} 460 37040 0 0 {name=l29614 lab=VDD}
N 440 36960 460 36960 {}
C {lab_pin.sym} 460 36960 0 0 {name=l29615 lab=VSS}
C {bitcell_6t.sym} 600 37000 0 0 {name=Xr185c3}
N 560 37040 540 37040 {}
C {lab_pin.sym} 540 37040 0 0 {name=l29616 lab=BL3}
N 560 37000 540 37000 {}
C {lab_pin.sym} 540 37000 0 0 {name=l29617 lab=BLB3}
N 560 36960 540 36960 {}
C {lab_pin.sym} 540 36960 0 0 {name=l29618 lab=WL185}
N 640 37040 660 37040 {}
C {lab_pin.sym} 660 37040 0 0 {name=l29619 lab=VDD}
N 640 36960 660 36960 {}
C {lab_pin.sym} 660 36960 0 0 {name=l29620 lab=VSS}
C {bitcell_6t.sym} 800 37000 0 0 {name=Xr185c4}
N 760 37040 740 37040 {}
C {lab_pin.sym} 740 37040 0 0 {name=l29621 lab=BL4}
N 760 37000 740 37000 {}
C {lab_pin.sym} 740 37000 0 0 {name=l29622 lab=BLB4}
N 760 36960 740 36960 {}
C {lab_pin.sym} 740 36960 0 0 {name=l29623 lab=WL185}
N 840 37040 860 37040 {}
C {lab_pin.sym} 860 37040 0 0 {name=l29624 lab=VDD}
N 840 36960 860 36960 {}
C {lab_pin.sym} 860 36960 0 0 {name=l29625 lab=VSS}
C {bitcell_6t.sym} 1000 37000 0 0 {name=Xr185c5}
N 960 37040 940 37040 {}
C {lab_pin.sym} 940 37040 0 0 {name=l29626 lab=BL5}
N 960 37000 940 37000 {}
C {lab_pin.sym} 940 37000 0 0 {name=l29627 lab=BLB5}
N 960 36960 940 36960 {}
C {lab_pin.sym} 940 36960 0 0 {name=l29628 lab=WL185}
N 1040 37040 1060 37040 {}
C {lab_pin.sym} 1060 37040 0 0 {name=l29629 lab=VDD}
N 1040 36960 1060 36960 {}
C {lab_pin.sym} 1060 36960 0 0 {name=l29630 lab=VSS}
C {bitcell_6t.sym} 1200 37000 0 0 {name=Xr185c6}
N 1160 37040 1140 37040 {}
C {lab_pin.sym} 1140 37040 0 0 {name=l29631 lab=BL6}
N 1160 37000 1140 37000 {}
C {lab_pin.sym} 1140 37000 0 0 {name=l29632 lab=BLB6}
N 1160 36960 1140 36960 {}
C {lab_pin.sym} 1140 36960 0 0 {name=l29633 lab=WL185}
N 1240 37040 1260 37040 {}
C {lab_pin.sym} 1260 37040 0 0 {name=l29634 lab=VDD}
N 1240 36960 1260 36960 {}
C {lab_pin.sym} 1260 36960 0 0 {name=l29635 lab=VSS}
C {bitcell_6t.sym} 1400 37000 0 0 {name=Xr185c7}
N 1360 37040 1340 37040 {}
C {lab_pin.sym} 1340 37040 0 0 {name=l29636 lab=BL7}
N 1360 37000 1340 37000 {}
C {lab_pin.sym} 1340 37000 0 0 {name=l29637 lab=BLB7}
N 1360 36960 1340 36960 {}
C {lab_pin.sym} 1340 36960 0 0 {name=l29638 lab=WL185}
N 1440 37040 1460 37040 {}
C {lab_pin.sym} 1460 37040 0 0 {name=l29639 lab=VDD}
N 1440 36960 1460 36960 {}
C {lab_pin.sym} 1460 36960 0 0 {name=l29640 lab=VSS}
C {bitcell_6t.sym} 1600 37000 0 0 {name=Xr185c8}
N 1560 37040 1540 37040 {}
C {lab_pin.sym} 1540 37040 0 0 {name=l29641 lab=BL8}
N 1560 37000 1540 37000 {}
C {lab_pin.sym} 1540 37000 0 0 {name=l29642 lab=BLB8}
N 1560 36960 1540 36960 {}
C {lab_pin.sym} 1540 36960 0 0 {name=l29643 lab=WL185}
N 1640 37040 1660 37040 {}
C {lab_pin.sym} 1660 37040 0 0 {name=l29644 lab=VDD}
N 1640 36960 1660 36960 {}
C {lab_pin.sym} 1660 36960 0 0 {name=l29645 lab=VSS}
C {bitcell_6t.sym} 1800 37000 0 0 {name=Xr185c9}
N 1760 37040 1740 37040 {}
C {lab_pin.sym} 1740 37040 0 0 {name=l29646 lab=BL9}
N 1760 37000 1740 37000 {}
C {lab_pin.sym} 1740 37000 0 0 {name=l29647 lab=BLB9}
N 1760 36960 1740 36960 {}
C {lab_pin.sym} 1740 36960 0 0 {name=l29648 lab=WL185}
N 1840 37040 1860 37040 {}
C {lab_pin.sym} 1860 37040 0 0 {name=l29649 lab=VDD}
N 1840 36960 1860 36960 {}
C {lab_pin.sym} 1860 36960 0 0 {name=l29650 lab=VSS}
C {bitcell_6t.sym} 2000 37000 0 0 {name=Xr185c10}
N 1960 37040 1940 37040 {}
C {lab_pin.sym} 1940 37040 0 0 {name=l29651 lab=BL10}
N 1960 37000 1940 37000 {}
C {lab_pin.sym} 1940 37000 0 0 {name=l29652 lab=BLB10}
N 1960 36960 1940 36960 {}
C {lab_pin.sym} 1940 36960 0 0 {name=l29653 lab=WL185}
N 2040 37040 2060 37040 {}
C {lab_pin.sym} 2060 37040 0 0 {name=l29654 lab=VDD}
N 2040 36960 2060 36960 {}
C {lab_pin.sym} 2060 36960 0 0 {name=l29655 lab=VSS}
C {bitcell_6t.sym} 2200 37000 0 0 {name=Xr185c11}
N 2160 37040 2140 37040 {}
C {lab_pin.sym} 2140 37040 0 0 {name=l29656 lab=BL11}
N 2160 37000 2140 37000 {}
C {lab_pin.sym} 2140 37000 0 0 {name=l29657 lab=BLB11}
N 2160 36960 2140 36960 {}
C {lab_pin.sym} 2140 36960 0 0 {name=l29658 lab=WL185}
N 2240 37040 2260 37040 {}
C {lab_pin.sym} 2260 37040 0 0 {name=l29659 lab=VDD}
N 2240 36960 2260 36960 {}
C {lab_pin.sym} 2260 36960 0 0 {name=l29660 lab=VSS}
C {bitcell_6t.sym} 2400 37000 0 0 {name=Xr185c12}
N 2360 37040 2340 37040 {}
C {lab_pin.sym} 2340 37040 0 0 {name=l29661 lab=BL12}
N 2360 37000 2340 37000 {}
C {lab_pin.sym} 2340 37000 0 0 {name=l29662 lab=BLB12}
N 2360 36960 2340 36960 {}
C {lab_pin.sym} 2340 36960 0 0 {name=l29663 lab=WL185}
N 2440 37040 2460 37040 {}
C {lab_pin.sym} 2460 37040 0 0 {name=l29664 lab=VDD}
N 2440 36960 2460 36960 {}
C {lab_pin.sym} 2460 36960 0 0 {name=l29665 lab=VSS}
C {bitcell_6t.sym} 2600 37000 0 0 {name=Xr185c13}
N 2560 37040 2540 37040 {}
C {lab_pin.sym} 2540 37040 0 0 {name=l29666 lab=BL13}
N 2560 37000 2540 37000 {}
C {lab_pin.sym} 2540 37000 0 0 {name=l29667 lab=BLB13}
N 2560 36960 2540 36960 {}
C {lab_pin.sym} 2540 36960 0 0 {name=l29668 lab=WL185}
N 2640 37040 2660 37040 {}
C {lab_pin.sym} 2660 37040 0 0 {name=l29669 lab=VDD}
N 2640 36960 2660 36960 {}
C {lab_pin.sym} 2660 36960 0 0 {name=l29670 lab=VSS}
C {bitcell_6t.sym} 2800 37000 0 0 {name=Xr185c14}
N 2760 37040 2740 37040 {}
C {lab_pin.sym} 2740 37040 0 0 {name=l29671 lab=BL14}
N 2760 37000 2740 37000 {}
C {lab_pin.sym} 2740 37000 0 0 {name=l29672 lab=BLB14}
N 2760 36960 2740 36960 {}
C {lab_pin.sym} 2740 36960 0 0 {name=l29673 lab=WL185}
N 2840 37040 2860 37040 {}
C {lab_pin.sym} 2860 37040 0 0 {name=l29674 lab=VDD}
N 2840 36960 2860 36960 {}
C {lab_pin.sym} 2860 36960 0 0 {name=l29675 lab=VSS}
C {bitcell_6t.sym} 3000 37000 0 0 {name=Xr185c15}
N 2960 37040 2940 37040 {}
C {lab_pin.sym} 2940 37040 0 0 {name=l29676 lab=BL15}
N 2960 37000 2940 37000 {}
C {lab_pin.sym} 2940 37000 0 0 {name=l29677 lab=BLB15}
N 2960 36960 2940 36960 {}
C {lab_pin.sym} 2940 36960 0 0 {name=l29678 lab=WL185}
N 3040 37040 3060 37040 {}
C {lab_pin.sym} 3060 37040 0 0 {name=l29679 lab=VDD}
N 3040 36960 3060 36960 {}
C {lab_pin.sym} 3060 36960 0 0 {name=l29680 lab=VSS}
C {bitcell_6t.sym} 3200 37000 0 0 {name=Xr185c16}
N 3160 37040 3140 37040 {}
C {lab_pin.sym} 3140 37040 0 0 {name=l29681 lab=BL16}
N 3160 37000 3140 37000 {}
C {lab_pin.sym} 3140 37000 0 0 {name=l29682 lab=BLB16}
N 3160 36960 3140 36960 {}
C {lab_pin.sym} 3140 36960 0 0 {name=l29683 lab=WL185}
N 3240 37040 3260 37040 {}
C {lab_pin.sym} 3260 37040 0 0 {name=l29684 lab=VDD}
N 3240 36960 3260 36960 {}
C {lab_pin.sym} 3260 36960 0 0 {name=l29685 lab=VSS}
C {bitcell_6t.sym} 3400 37000 0 0 {name=Xr185c17}
N 3360 37040 3340 37040 {}
C {lab_pin.sym} 3340 37040 0 0 {name=l29686 lab=BL17}
N 3360 37000 3340 37000 {}
C {lab_pin.sym} 3340 37000 0 0 {name=l29687 lab=BLB17}
N 3360 36960 3340 36960 {}
C {lab_pin.sym} 3340 36960 0 0 {name=l29688 lab=WL185}
N 3440 37040 3460 37040 {}
C {lab_pin.sym} 3460 37040 0 0 {name=l29689 lab=VDD}
N 3440 36960 3460 36960 {}
C {lab_pin.sym} 3460 36960 0 0 {name=l29690 lab=VSS}
C {bitcell_6t.sym} 3600 37000 0 0 {name=Xr185c18}
N 3560 37040 3540 37040 {}
C {lab_pin.sym} 3540 37040 0 0 {name=l29691 lab=BL18}
N 3560 37000 3540 37000 {}
C {lab_pin.sym} 3540 37000 0 0 {name=l29692 lab=BLB18}
N 3560 36960 3540 36960 {}
C {lab_pin.sym} 3540 36960 0 0 {name=l29693 lab=WL185}
N 3640 37040 3660 37040 {}
C {lab_pin.sym} 3660 37040 0 0 {name=l29694 lab=VDD}
N 3640 36960 3660 36960 {}
C {lab_pin.sym} 3660 36960 0 0 {name=l29695 lab=VSS}
C {bitcell_6t.sym} 3800 37000 0 0 {name=Xr185c19}
N 3760 37040 3740 37040 {}
C {lab_pin.sym} 3740 37040 0 0 {name=l29696 lab=BL19}
N 3760 37000 3740 37000 {}
C {lab_pin.sym} 3740 37000 0 0 {name=l29697 lab=BLB19}
N 3760 36960 3740 36960 {}
C {lab_pin.sym} 3740 36960 0 0 {name=l29698 lab=WL185}
N 3840 37040 3860 37040 {}
C {lab_pin.sym} 3860 37040 0 0 {name=l29699 lab=VDD}
N 3840 36960 3860 36960 {}
C {lab_pin.sym} 3860 36960 0 0 {name=l29700 lab=VSS}
C {bitcell_6t.sym} 4000 37000 0 0 {name=Xr185c20}
N 3960 37040 3940 37040 {}
C {lab_pin.sym} 3940 37040 0 0 {name=l29701 lab=BL20}
N 3960 37000 3940 37000 {}
C {lab_pin.sym} 3940 37000 0 0 {name=l29702 lab=BLB20}
N 3960 36960 3940 36960 {}
C {lab_pin.sym} 3940 36960 0 0 {name=l29703 lab=WL185}
N 4040 37040 4060 37040 {}
C {lab_pin.sym} 4060 37040 0 0 {name=l29704 lab=VDD}
N 4040 36960 4060 36960 {}
C {lab_pin.sym} 4060 36960 0 0 {name=l29705 lab=VSS}
C {bitcell_6t.sym} 4200 37000 0 0 {name=Xr185c21}
N 4160 37040 4140 37040 {}
C {lab_pin.sym} 4140 37040 0 0 {name=l29706 lab=BL21}
N 4160 37000 4140 37000 {}
C {lab_pin.sym} 4140 37000 0 0 {name=l29707 lab=BLB21}
N 4160 36960 4140 36960 {}
C {lab_pin.sym} 4140 36960 0 0 {name=l29708 lab=WL185}
N 4240 37040 4260 37040 {}
C {lab_pin.sym} 4260 37040 0 0 {name=l29709 lab=VDD}
N 4240 36960 4260 36960 {}
C {lab_pin.sym} 4260 36960 0 0 {name=l29710 lab=VSS}
C {bitcell_6t.sym} 4400 37000 0 0 {name=Xr185c22}
N 4360 37040 4340 37040 {}
C {lab_pin.sym} 4340 37040 0 0 {name=l29711 lab=BL22}
N 4360 37000 4340 37000 {}
C {lab_pin.sym} 4340 37000 0 0 {name=l29712 lab=BLB22}
N 4360 36960 4340 36960 {}
C {lab_pin.sym} 4340 36960 0 0 {name=l29713 lab=WL185}
N 4440 37040 4460 37040 {}
C {lab_pin.sym} 4460 37040 0 0 {name=l29714 lab=VDD}
N 4440 36960 4460 36960 {}
C {lab_pin.sym} 4460 36960 0 0 {name=l29715 lab=VSS}
C {bitcell_6t.sym} 4600 37000 0 0 {name=Xr185c23}
N 4560 37040 4540 37040 {}
C {lab_pin.sym} 4540 37040 0 0 {name=l29716 lab=BL23}
N 4560 37000 4540 37000 {}
C {lab_pin.sym} 4540 37000 0 0 {name=l29717 lab=BLB23}
N 4560 36960 4540 36960 {}
C {lab_pin.sym} 4540 36960 0 0 {name=l29718 lab=WL185}
N 4640 37040 4660 37040 {}
C {lab_pin.sym} 4660 37040 0 0 {name=l29719 lab=VDD}
N 4640 36960 4660 36960 {}
C {lab_pin.sym} 4660 36960 0 0 {name=l29720 lab=VSS}
C {bitcell_6t.sym} 4800 37000 0 0 {name=Xr185c24}
N 4760 37040 4740 37040 {}
C {lab_pin.sym} 4740 37040 0 0 {name=l29721 lab=BL24}
N 4760 37000 4740 37000 {}
C {lab_pin.sym} 4740 37000 0 0 {name=l29722 lab=BLB24}
N 4760 36960 4740 36960 {}
C {lab_pin.sym} 4740 36960 0 0 {name=l29723 lab=WL185}
N 4840 37040 4860 37040 {}
C {lab_pin.sym} 4860 37040 0 0 {name=l29724 lab=VDD}
N 4840 36960 4860 36960 {}
C {lab_pin.sym} 4860 36960 0 0 {name=l29725 lab=VSS}
C {bitcell_6t.sym} 5000 37000 0 0 {name=Xr185c25}
N 4960 37040 4940 37040 {}
C {lab_pin.sym} 4940 37040 0 0 {name=l29726 lab=BL25}
N 4960 37000 4940 37000 {}
C {lab_pin.sym} 4940 37000 0 0 {name=l29727 lab=BLB25}
N 4960 36960 4940 36960 {}
C {lab_pin.sym} 4940 36960 0 0 {name=l29728 lab=WL185}
N 5040 37040 5060 37040 {}
C {lab_pin.sym} 5060 37040 0 0 {name=l29729 lab=VDD}
N 5040 36960 5060 36960 {}
C {lab_pin.sym} 5060 36960 0 0 {name=l29730 lab=VSS}
C {bitcell_6t.sym} 5200 37000 0 0 {name=Xr185c26}
N 5160 37040 5140 37040 {}
C {lab_pin.sym} 5140 37040 0 0 {name=l29731 lab=BL26}
N 5160 37000 5140 37000 {}
C {lab_pin.sym} 5140 37000 0 0 {name=l29732 lab=BLB26}
N 5160 36960 5140 36960 {}
C {lab_pin.sym} 5140 36960 0 0 {name=l29733 lab=WL185}
N 5240 37040 5260 37040 {}
C {lab_pin.sym} 5260 37040 0 0 {name=l29734 lab=VDD}
N 5240 36960 5260 36960 {}
C {lab_pin.sym} 5260 36960 0 0 {name=l29735 lab=VSS}
C {bitcell_6t.sym} 5400 37000 0 0 {name=Xr185c27}
N 5360 37040 5340 37040 {}
C {lab_pin.sym} 5340 37040 0 0 {name=l29736 lab=BL27}
N 5360 37000 5340 37000 {}
C {lab_pin.sym} 5340 37000 0 0 {name=l29737 lab=BLB27}
N 5360 36960 5340 36960 {}
C {lab_pin.sym} 5340 36960 0 0 {name=l29738 lab=WL185}
N 5440 37040 5460 37040 {}
C {lab_pin.sym} 5460 37040 0 0 {name=l29739 lab=VDD}
N 5440 36960 5460 36960 {}
C {lab_pin.sym} 5460 36960 0 0 {name=l29740 lab=VSS}
C {bitcell_6t.sym} 5600 37000 0 0 {name=Xr185c28}
N 5560 37040 5540 37040 {}
C {lab_pin.sym} 5540 37040 0 0 {name=l29741 lab=BL28}
N 5560 37000 5540 37000 {}
C {lab_pin.sym} 5540 37000 0 0 {name=l29742 lab=BLB28}
N 5560 36960 5540 36960 {}
C {lab_pin.sym} 5540 36960 0 0 {name=l29743 lab=WL185}
N 5640 37040 5660 37040 {}
C {lab_pin.sym} 5660 37040 0 0 {name=l29744 lab=VDD}
N 5640 36960 5660 36960 {}
C {lab_pin.sym} 5660 36960 0 0 {name=l29745 lab=VSS}
C {bitcell_6t.sym} 5800 37000 0 0 {name=Xr185c29}
N 5760 37040 5740 37040 {}
C {lab_pin.sym} 5740 37040 0 0 {name=l29746 lab=BL29}
N 5760 37000 5740 37000 {}
C {lab_pin.sym} 5740 37000 0 0 {name=l29747 lab=BLB29}
N 5760 36960 5740 36960 {}
C {lab_pin.sym} 5740 36960 0 0 {name=l29748 lab=WL185}
N 5840 37040 5860 37040 {}
C {lab_pin.sym} 5860 37040 0 0 {name=l29749 lab=VDD}
N 5840 36960 5860 36960 {}
C {lab_pin.sym} 5860 36960 0 0 {name=l29750 lab=VSS}
C {bitcell_6t.sym} 6000 37000 0 0 {name=Xr185c30}
N 5960 37040 5940 37040 {}
C {lab_pin.sym} 5940 37040 0 0 {name=l29751 lab=BL30}
N 5960 37000 5940 37000 {}
C {lab_pin.sym} 5940 37000 0 0 {name=l29752 lab=BLB30}
N 5960 36960 5940 36960 {}
C {lab_pin.sym} 5940 36960 0 0 {name=l29753 lab=WL185}
N 6040 37040 6060 37040 {}
C {lab_pin.sym} 6060 37040 0 0 {name=l29754 lab=VDD}
N 6040 36960 6060 36960 {}
C {lab_pin.sym} 6060 36960 0 0 {name=l29755 lab=VSS}
C {bitcell_6t.sym} 6200 37000 0 0 {name=Xr185c31}
N 6160 37040 6140 37040 {}
C {lab_pin.sym} 6140 37040 0 0 {name=l29756 lab=BL31}
N 6160 37000 6140 37000 {}
C {lab_pin.sym} 6140 37000 0 0 {name=l29757 lab=BLB31}
N 6160 36960 6140 36960 {}
C {lab_pin.sym} 6140 36960 0 0 {name=l29758 lab=WL185}
N 6240 37040 6260 37040 {}
C {lab_pin.sym} 6260 37040 0 0 {name=l29759 lab=VDD}
N 6240 36960 6260 36960 {}
C {lab_pin.sym} 6260 36960 0 0 {name=l29760 lab=VSS}
C {bitcell_6t.sym} 0 37200 0 0 {name=Xr186c0}
N -40 37240 -60 37240 {}
C {lab_pin.sym} -60 37240 0 0 {name=l29761 lab=BL0}
N -40 37200 -60 37200 {}
C {lab_pin.sym} -60 37200 0 0 {name=l29762 lab=BLB0}
N -40 37160 -60 37160 {}
C {lab_pin.sym} -60 37160 0 0 {name=l29763 lab=WL186}
N 40 37240 60 37240 {}
C {lab_pin.sym} 60 37240 0 0 {name=l29764 lab=VDD}
N 40 37160 60 37160 {}
C {lab_pin.sym} 60 37160 0 0 {name=l29765 lab=VSS}
C {bitcell_6t.sym} 200 37200 0 0 {name=Xr186c1}
N 160 37240 140 37240 {}
C {lab_pin.sym} 140 37240 0 0 {name=l29766 lab=BL1}
N 160 37200 140 37200 {}
C {lab_pin.sym} 140 37200 0 0 {name=l29767 lab=BLB1}
N 160 37160 140 37160 {}
C {lab_pin.sym} 140 37160 0 0 {name=l29768 lab=WL186}
N 240 37240 260 37240 {}
C {lab_pin.sym} 260 37240 0 0 {name=l29769 lab=VDD}
N 240 37160 260 37160 {}
C {lab_pin.sym} 260 37160 0 0 {name=l29770 lab=VSS}
C {bitcell_6t.sym} 400 37200 0 0 {name=Xr186c2}
N 360 37240 340 37240 {}
C {lab_pin.sym} 340 37240 0 0 {name=l29771 lab=BL2}
N 360 37200 340 37200 {}
C {lab_pin.sym} 340 37200 0 0 {name=l29772 lab=BLB2}
N 360 37160 340 37160 {}
C {lab_pin.sym} 340 37160 0 0 {name=l29773 lab=WL186}
N 440 37240 460 37240 {}
C {lab_pin.sym} 460 37240 0 0 {name=l29774 lab=VDD}
N 440 37160 460 37160 {}
C {lab_pin.sym} 460 37160 0 0 {name=l29775 lab=VSS}
C {bitcell_6t.sym} 600 37200 0 0 {name=Xr186c3}
N 560 37240 540 37240 {}
C {lab_pin.sym} 540 37240 0 0 {name=l29776 lab=BL3}
N 560 37200 540 37200 {}
C {lab_pin.sym} 540 37200 0 0 {name=l29777 lab=BLB3}
N 560 37160 540 37160 {}
C {lab_pin.sym} 540 37160 0 0 {name=l29778 lab=WL186}
N 640 37240 660 37240 {}
C {lab_pin.sym} 660 37240 0 0 {name=l29779 lab=VDD}
N 640 37160 660 37160 {}
C {lab_pin.sym} 660 37160 0 0 {name=l29780 lab=VSS}
C {bitcell_6t.sym} 800 37200 0 0 {name=Xr186c4}
N 760 37240 740 37240 {}
C {lab_pin.sym} 740 37240 0 0 {name=l29781 lab=BL4}
N 760 37200 740 37200 {}
C {lab_pin.sym} 740 37200 0 0 {name=l29782 lab=BLB4}
N 760 37160 740 37160 {}
C {lab_pin.sym} 740 37160 0 0 {name=l29783 lab=WL186}
N 840 37240 860 37240 {}
C {lab_pin.sym} 860 37240 0 0 {name=l29784 lab=VDD}
N 840 37160 860 37160 {}
C {lab_pin.sym} 860 37160 0 0 {name=l29785 lab=VSS}
C {bitcell_6t.sym} 1000 37200 0 0 {name=Xr186c5}
N 960 37240 940 37240 {}
C {lab_pin.sym} 940 37240 0 0 {name=l29786 lab=BL5}
N 960 37200 940 37200 {}
C {lab_pin.sym} 940 37200 0 0 {name=l29787 lab=BLB5}
N 960 37160 940 37160 {}
C {lab_pin.sym} 940 37160 0 0 {name=l29788 lab=WL186}
N 1040 37240 1060 37240 {}
C {lab_pin.sym} 1060 37240 0 0 {name=l29789 lab=VDD}
N 1040 37160 1060 37160 {}
C {lab_pin.sym} 1060 37160 0 0 {name=l29790 lab=VSS}
C {bitcell_6t.sym} 1200 37200 0 0 {name=Xr186c6}
N 1160 37240 1140 37240 {}
C {lab_pin.sym} 1140 37240 0 0 {name=l29791 lab=BL6}
N 1160 37200 1140 37200 {}
C {lab_pin.sym} 1140 37200 0 0 {name=l29792 lab=BLB6}
N 1160 37160 1140 37160 {}
C {lab_pin.sym} 1140 37160 0 0 {name=l29793 lab=WL186}
N 1240 37240 1260 37240 {}
C {lab_pin.sym} 1260 37240 0 0 {name=l29794 lab=VDD}
N 1240 37160 1260 37160 {}
C {lab_pin.sym} 1260 37160 0 0 {name=l29795 lab=VSS}
C {bitcell_6t.sym} 1400 37200 0 0 {name=Xr186c7}
N 1360 37240 1340 37240 {}
C {lab_pin.sym} 1340 37240 0 0 {name=l29796 lab=BL7}
N 1360 37200 1340 37200 {}
C {lab_pin.sym} 1340 37200 0 0 {name=l29797 lab=BLB7}
N 1360 37160 1340 37160 {}
C {lab_pin.sym} 1340 37160 0 0 {name=l29798 lab=WL186}
N 1440 37240 1460 37240 {}
C {lab_pin.sym} 1460 37240 0 0 {name=l29799 lab=VDD}
N 1440 37160 1460 37160 {}
C {lab_pin.sym} 1460 37160 0 0 {name=l29800 lab=VSS}
C {bitcell_6t.sym} 1600 37200 0 0 {name=Xr186c8}
N 1560 37240 1540 37240 {}
C {lab_pin.sym} 1540 37240 0 0 {name=l29801 lab=BL8}
N 1560 37200 1540 37200 {}
C {lab_pin.sym} 1540 37200 0 0 {name=l29802 lab=BLB8}
N 1560 37160 1540 37160 {}
C {lab_pin.sym} 1540 37160 0 0 {name=l29803 lab=WL186}
N 1640 37240 1660 37240 {}
C {lab_pin.sym} 1660 37240 0 0 {name=l29804 lab=VDD}
N 1640 37160 1660 37160 {}
C {lab_pin.sym} 1660 37160 0 0 {name=l29805 lab=VSS}
C {bitcell_6t.sym} 1800 37200 0 0 {name=Xr186c9}
N 1760 37240 1740 37240 {}
C {lab_pin.sym} 1740 37240 0 0 {name=l29806 lab=BL9}
N 1760 37200 1740 37200 {}
C {lab_pin.sym} 1740 37200 0 0 {name=l29807 lab=BLB9}
N 1760 37160 1740 37160 {}
C {lab_pin.sym} 1740 37160 0 0 {name=l29808 lab=WL186}
N 1840 37240 1860 37240 {}
C {lab_pin.sym} 1860 37240 0 0 {name=l29809 lab=VDD}
N 1840 37160 1860 37160 {}
C {lab_pin.sym} 1860 37160 0 0 {name=l29810 lab=VSS}
C {bitcell_6t.sym} 2000 37200 0 0 {name=Xr186c10}
N 1960 37240 1940 37240 {}
C {lab_pin.sym} 1940 37240 0 0 {name=l29811 lab=BL10}
N 1960 37200 1940 37200 {}
C {lab_pin.sym} 1940 37200 0 0 {name=l29812 lab=BLB10}
N 1960 37160 1940 37160 {}
C {lab_pin.sym} 1940 37160 0 0 {name=l29813 lab=WL186}
N 2040 37240 2060 37240 {}
C {lab_pin.sym} 2060 37240 0 0 {name=l29814 lab=VDD}
N 2040 37160 2060 37160 {}
C {lab_pin.sym} 2060 37160 0 0 {name=l29815 lab=VSS}
C {bitcell_6t.sym} 2200 37200 0 0 {name=Xr186c11}
N 2160 37240 2140 37240 {}
C {lab_pin.sym} 2140 37240 0 0 {name=l29816 lab=BL11}
N 2160 37200 2140 37200 {}
C {lab_pin.sym} 2140 37200 0 0 {name=l29817 lab=BLB11}
N 2160 37160 2140 37160 {}
C {lab_pin.sym} 2140 37160 0 0 {name=l29818 lab=WL186}
N 2240 37240 2260 37240 {}
C {lab_pin.sym} 2260 37240 0 0 {name=l29819 lab=VDD}
N 2240 37160 2260 37160 {}
C {lab_pin.sym} 2260 37160 0 0 {name=l29820 lab=VSS}
C {bitcell_6t.sym} 2400 37200 0 0 {name=Xr186c12}
N 2360 37240 2340 37240 {}
C {lab_pin.sym} 2340 37240 0 0 {name=l29821 lab=BL12}
N 2360 37200 2340 37200 {}
C {lab_pin.sym} 2340 37200 0 0 {name=l29822 lab=BLB12}
N 2360 37160 2340 37160 {}
C {lab_pin.sym} 2340 37160 0 0 {name=l29823 lab=WL186}
N 2440 37240 2460 37240 {}
C {lab_pin.sym} 2460 37240 0 0 {name=l29824 lab=VDD}
N 2440 37160 2460 37160 {}
C {lab_pin.sym} 2460 37160 0 0 {name=l29825 lab=VSS}
C {bitcell_6t.sym} 2600 37200 0 0 {name=Xr186c13}
N 2560 37240 2540 37240 {}
C {lab_pin.sym} 2540 37240 0 0 {name=l29826 lab=BL13}
N 2560 37200 2540 37200 {}
C {lab_pin.sym} 2540 37200 0 0 {name=l29827 lab=BLB13}
N 2560 37160 2540 37160 {}
C {lab_pin.sym} 2540 37160 0 0 {name=l29828 lab=WL186}
N 2640 37240 2660 37240 {}
C {lab_pin.sym} 2660 37240 0 0 {name=l29829 lab=VDD}
N 2640 37160 2660 37160 {}
C {lab_pin.sym} 2660 37160 0 0 {name=l29830 lab=VSS}
C {bitcell_6t.sym} 2800 37200 0 0 {name=Xr186c14}
N 2760 37240 2740 37240 {}
C {lab_pin.sym} 2740 37240 0 0 {name=l29831 lab=BL14}
N 2760 37200 2740 37200 {}
C {lab_pin.sym} 2740 37200 0 0 {name=l29832 lab=BLB14}
N 2760 37160 2740 37160 {}
C {lab_pin.sym} 2740 37160 0 0 {name=l29833 lab=WL186}
N 2840 37240 2860 37240 {}
C {lab_pin.sym} 2860 37240 0 0 {name=l29834 lab=VDD}
N 2840 37160 2860 37160 {}
C {lab_pin.sym} 2860 37160 0 0 {name=l29835 lab=VSS}
C {bitcell_6t.sym} 3000 37200 0 0 {name=Xr186c15}
N 2960 37240 2940 37240 {}
C {lab_pin.sym} 2940 37240 0 0 {name=l29836 lab=BL15}
N 2960 37200 2940 37200 {}
C {lab_pin.sym} 2940 37200 0 0 {name=l29837 lab=BLB15}
N 2960 37160 2940 37160 {}
C {lab_pin.sym} 2940 37160 0 0 {name=l29838 lab=WL186}
N 3040 37240 3060 37240 {}
C {lab_pin.sym} 3060 37240 0 0 {name=l29839 lab=VDD}
N 3040 37160 3060 37160 {}
C {lab_pin.sym} 3060 37160 0 0 {name=l29840 lab=VSS}
C {bitcell_6t.sym} 3200 37200 0 0 {name=Xr186c16}
N 3160 37240 3140 37240 {}
C {lab_pin.sym} 3140 37240 0 0 {name=l29841 lab=BL16}
N 3160 37200 3140 37200 {}
C {lab_pin.sym} 3140 37200 0 0 {name=l29842 lab=BLB16}
N 3160 37160 3140 37160 {}
C {lab_pin.sym} 3140 37160 0 0 {name=l29843 lab=WL186}
N 3240 37240 3260 37240 {}
C {lab_pin.sym} 3260 37240 0 0 {name=l29844 lab=VDD}
N 3240 37160 3260 37160 {}
C {lab_pin.sym} 3260 37160 0 0 {name=l29845 lab=VSS}
C {bitcell_6t.sym} 3400 37200 0 0 {name=Xr186c17}
N 3360 37240 3340 37240 {}
C {lab_pin.sym} 3340 37240 0 0 {name=l29846 lab=BL17}
N 3360 37200 3340 37200 {}
C {lab_pin.sym} 3340 37200 0 0 {name=l29847 lab=BLB17}
N 3360 37160 3340 37160 {}
C {lab_pin.sym} 3340 37160 0 0 {name=l29848 lab=WL186}
N 3440 37240 3460 37240 {}
C {lab_pin.sym} 3460 37240 0 0 {name=l29849 lab=VDD}
N 3440 37160 3460 37160 {}
C {lab_pin.sym} 3460 37160 0 0 {name=l29850 lab=VSS}
C {bitcell_6t.sym} 3600 37200 0 0 {name=Xr186c18}
N 3560 37240 3540 37240 {}
C {lab_pin.sym} 3540 37240 0 0 {name=l29851 lab=BL18}
N 3560 37200 3540 37200 {}
C {lab_pin.sym} 3540 37200 0 0 {name=l29852 lab=BLB18}
N 3560 37160 3540 37160 {}
C {lab_pin.sym} 3540 37160 0 0 {name=l29853 lab=WL186}
N 3640 37240 3660 37240 {}
C {lab_pin.sym} 3660 37240 0 0 {name=l29854 lab=VDD}
N 3640 37160 3660 37160 {}
C {lab_pin.sym} 3660 37160 0 0 {name=l29855 lab=VSS}
C {bitcell_6t.sym} 3800 37200 0 0 {name=Xr186c19}
N 3760 37240 3740 37240 {}
C {lab_pin.sym} 3740 37240 0 0 {name=l29856 lab=BL19}
N 3760 37200 3740 37200 {}
C {lab_pin.sym} 3740 37200 0 0 {name=l29857 lab=BLB19}
N 3760 37160 3740 37160 {}
C {lab_pin.sym} 3740 37160 0 0 {name=l29858 lab=WL186}
N 3840 37240 3860 37240 {}
C {lab_pin.sym} 3860 37240 0 0 {name=l29859 lab=VDD}
N 3840 37160 3860 37160 {}
C {lab_pin.sym} 3860 37160 0 0 {name=l29860 lab=VSS}
C {bitcell_6t.sym} 4000 37200 0 0 {name=Xr186c20}
N 3960 37240 3940 37240 {}
C {lab_pin.sym} 3940 37240 0 0 {name=l29861 lab=BL20}
N 3960 37200 3940 37200 {}
C {lab_pin.sym} 3940 37200 0 0 {name=l29862 lab=BLB20}
N 3960 37160 3940 37160 {}
C {lab_pin.sym} 3940 37160 0 0 {name=l29863 lab=WL186}
N 4040 37240 4060 37240 {}
C {lab_pin.sym} 4060 37240 0 0 {name=l29864 lab=VDD}
N 4040 37160 4060 37160 {}
C {lab_pin.sym} 4060 37160 0 0 {name=l29865 lab=VSS}
C {bitcell_6t.sym} 4200 37200 0 0 {name=Xr186c21}
N 4160 37240 4140 37240 {}
C {lab_pin.sym} 4140 37240 0 0 {name=l29866 lab=BL21}
N 4160 37200 4140 37200 {}
C {lab_pin.sym} 4140 37200 0 0 {name=l29867 lab=BLB21}
N 4160 37160 4140 37160 {}
C {lab_pin.sym} 4140 37160 0 0 {name=l29868 lab=WL186}
N 4240 37240 4260 37240 {}
C {lab_pin.sym} 4260 37240 0 0 {name=l29869 lab=VDD}
N 4240 37160 4260 37160 {}
C {lab_pin.sym} 4260 37160 0 0 {name=l29870 lab=VSS}
C {bitcell_6t.sym} 4400 37200 0 0 {name=Xr186c22}
N 4360 37240 4340 37240 {}
C {lab_pin.sym} 4340 37240 0 0 {name=l29871 lab=BL22}
N 4360 37200 4340 37200 {}
C {lab_pin.sym} 4340 37200 0 0 {name=l29872 lab=BLB22}
N 4360 37160 4340 37160 {}
C {lab_pin.sym} 4340 37160 0 0 {name=l29873 lab=WL186}
N 4440 37240 4460 37240 {}
C {lab_pin.sym} 4460 37240 0 0 {name=l29874 lab=VDD}
N 4440 37160 4460 37160 {}
C {lab_pin.sym} 4460 37160 0 0 {name=l29875 lab=VSS}
C {bitcell_6t.sym} 4600 37200 0 0 {name=Xr186c23}
N 4560 37240 4540 37240 {}
C {lab_pin.sym} 4540 37240 0 0 {name=l29876 lab=BL23}
N 4560 37200 4540 37200 {}
C {lab_pin.sym} 4540 37200 0 0 {name=l29877 lab=BLB23}
N 4560 37160 4540 37160 {}
C {lab_pin.sym} 4540 37160 0 0 {name=l29878 lab=WL186}
N 4640 37240 4660 37240 {}
C {lab_pin.sym} 4660 37240 0 0 {name=l29879 lab=VDD}
N 4640 37160 4660 37160 {}
C {lab_pin.sym} 4660 37160 0 0 {name=l29880 lab=VSS}
C {bitcell_6t.sym} 4800 37200 0 0 {name=Xr186c24}
N 4760 37240 4740 37240 {}
C {lab_pin.sym} 4740 37240 0 0 {name=l29881 lab=BL24}
N 4760 37200 4740 37200 {}
C {lab_pin.sym} 4740 37200 0 0 {name=l29882 lab=BLB24}
N 4760 37160 4740 37160 {}
C {lab_pin.sym} 4740 37160 0 0 {name=l29883 lab=WL186}
N 4840 37240 4860 37240 {}
C {lab_pin.sym} 4860 37240 0 0 {name=l29884 lab=VDD}
N 4840 37160 4860 37160 {}
C {lab_pin.sym} 4860 37160 0 0 {name=l29885 lab=VSS}
C {bitcell_6t.sym} 5000 37200 0 0 {name=Xr186c25}
N 4960 37240 4940 37240 {}
C {lab_pin.sym} 4940 37240 0 0 {name=l29886 lab=BL25}
N 4960 37200 4940 37200 {}
C {lab_pin.sym} 4940 37200 0 0 {name=l29887 lab=BLB25}
N 4960 37160 4940 37160 {}
C {lab_pin.sym} 4940 37160 0 0 {name=l29888 lab=WL186}
N 5040 37240 5060 37240 {}
C {lab_pin.sym} 5060 37240 0 0 {name=l29889 lab=VDD}
N 5040 37160 5060 37160 {}
C {lab_pin.sym} 5060 37160 0 0 {name=l29890 lab=VSS}
C {bitcell_6t.sym} 5200 37200 0 0 {name=Xr186c26}
N 5160 37240 5140 37240 {}
C {lab_pin.sym} 5140 37240 0 0 {name=l29891 lab=BL26}
N 5160 37200 5140 37200 {}
C {lab_pin.sym} 5140 37200 0 0 {name=l29892 lab=BLB26}
N 5160 37160 5140 37160 {}
C {lab_pin.sym} 5140 37160 0 0 {name=l29893 lab=WL186}
N 5240 37240 5260 37240 {}
C {lab_pin.sym} 5260 37240 0 0 {name=l29894 lab=VDD}
N 5240 37160 5260 37160 {}
C {lab_pin.sym} 5260 37160 0 0 {name=l29895 lab=VSS}
C {bitcell_6t.sym} 5400 37200 0 0 {name=Xr186c27}
N 5360 37240 5340 37240 {}
C {lab_pin.sym} 5340 37240 0 0 {name=l29896 lab=BL27}
N 5360 37200 5340 37200 {}
C {lab_pin.sym} 5340 37200 0 0 {name=l29897 lab=BLB27}
N 5360 37160 5340 37160 {}
C {lab_pin.sym} 5340 37160 0 0 {name=l29898 lab=WL186}
N 5440 37240 5460 37240 {}
C {lab_pin.sym} 5460 37240 0 0 {name=l29899 lab=VDD}
N 5440 37160 5460 37160 {}
C {lab_pin.sym} 5460 37160 0 0 {name=l29900 lab=VSS}
C {bitcell_6t.sym} 5600 37200 0 0 {name=Xr186c28}
N 5560 37240 5540 37240 {}
C {lab_pin.sym} 5540 37240 0 0 {name=l29901 lab=BL28}
N 5560 37200 5540 37200 {}
C {lab_pin.sym} 5540 37200 0 0 {name=l29902 lab=BLB28}
N 5560 37160 5540 37160 {}
C {lab_pin.sym} 5540 37160 0 0 {name=l29903 lab=WL186}
N 5640 37240 5660 37240 {}
C {lab_pin.sym} 5660 37240 0 0 {name=l29904 lab=VDD}
N 5640 37160 5660 37160 {}
C {lab_pin.sym} 5660 37160 0 0 {name=l29905 lab=VSS}
C {bitcell_6t.sym} 5800 37200 0 0 {name=Xr186c29}
N 5760 37240 5740 37240 {}
C {lab_pin.sym} 5740 37240 0 0 {name=l29906 lab=BL29}
N 5760 37200 5740 37200 {}
C {lab_pin.sym} 5740 37200 0 0 {name=l29907 lab=BLB29}
N 5760 37160 5740 37160 {}
C {lab_pin.sym} 5740 37160 0 0 {name=l29908 lab=WL186}
N 5840 37240 5860 37240 {}
C {lab_pin.sym} 5860 37240 0 0 {name=l29909 lab=VDD}
N 5840 37160 5860 37160 {}
C {lab_pin.sym} 5860 37160 0 0 {name=l29910 lab=VSS}
C {bitcell_6t.sym} 6000 37200 0 0 {name=Xr186c30}
N 5960 37240 5940 37240 {}
C {lab_pin.sym} 5940 37240 0 0 {name=l29911 lab=BL30}
N 5960 37200 5940 37200 {}
C {lab_pin.sym} 5940 37200 0 0 {name=l29912 lab=BLB30}
N 5960 37160 5940 37160 {}
C {lab_pin.sym} 5940 37160 0 0 {name=l29913 lab=WL186}
N 6040 37240 6060 37240 {}
C {lab_pin.sym} 6060 37240 0 0 {name=l29914 lab=VDD}
N 6040 37160 6060 37160 {}
C {lab_pin.sym} 6060 37160 0 0 {name=l29915 lab=VSS}
C {bitcell_6t.sym} 6200 37200 0 0 {name=Xr186c31}
N 6160 37240 6140 37240 {}
C {lab_pin.sym} 6140 37240 0 0 {name=l29916 lab=BL31}
N 6160 37200 6140 37200 {}
C {lab_pin.sym} 6140 37200 0 0 {name=l29917 lab=BLB31}
N 6160 37160 6140 37160 {}
C {lab_pin.sym} 6140 37160 0 0 {name=l29918 lab=WL186}
N 6240 37240 6260 37240 {}
C {lab_pin.sym} 6260 37240 0 0 {name=l29919 lab=VDD}
N 6240 37160 6260 37160 {}
C {lab_pin.sym} 6260 37160 0 0 {name=l29920 lab=VSS}
C {bitcell_6t.sym} 0 37400 0 0 {name=Xr187c0}
N -40 37440 -60 37440 {}
C {lab_pin.sym} -60 37440 0 0 {name=l29921 lab=BL0}
N -40 37400 -60 37400 {}
C {lab_pin.sym} -60 37400 0 0 {name=l29922 lab=BLB0}
N -40 37360 -60 37360 {}
C {lab_pin.sym} -60 37360 0 0 {name=l29923 lab=WL187}
N 40 37440 60 37440 {}
C {lab_pin.sym} 60 37440 0 0 {name=l29924 lab=VDD}
N 40 37360 60 37360 {}
C {lab_pin.sym} 60 37360 0 0 {name=l29925 lab=VSS}
C {bitcell_6t.sym} 200 37400 0 0 {name=Xr187c1}
N 160 37440 140 37440 {}
C {lab_pin.sym} 140 37440 0 0 {name=l29926 lab=BL1}
N 160 37400 140 37400 {}
C {lab_pin.sym} 140 37400 0 0 {name=l29927 lab=BLB1}
N 160 37360 140 37360 {}
C {lab_pin.sym} 140 37360 0 0 {name=l29928 lab=WL187}
N 240 37440 260 37440 {}
C {lab_pin.sym} 260 37440 0 0 {name=l29929 lab=VDD}
N 240 37360 260 37360 {}
C {lab_pin.sym} 260 37360 0 0 {name=l29930 lab=VSS}
C {bitcell_6t.sym} 400 37400 0 0 {name=Xr187c2}
N 360 37440 340 37440 {}
C {lab_pin.sym} 340 37440 0 0 {name=l29931 lab=BL2}
N 360 37400 340 37400 {}
C {lab_pin.sym} 340 37400 0 0 {name=l29932 lab=BLB2}
N 360 37360 340 37360 {}
C {lab_pin.sym} 340 37360 0 0 {name=l29933 lab=WL187}
N 440 37440 460 37440 {}
C {lab_pin.sym} 460 37440 0 0 {name=l29934 lab=VDD}
N 440 37360 460 37360 {}
C {lab_pin.sym} 460 37360 0 0 {name=l29935 lab=VSS}
C {bitcell_6t.sym} 600 37400 0 0 {name=Xr187c3}
N 560 37440 540 37440 {}
C {lab_pin.sym} 540 37440 0 0 {name=l29936 lab=BL3}
N 560 37400 540 37400 {}
C {lab_pin.sym} 540 37400 0 0 {name=l29937 lab=BLB3}
N 560 37360 540 37360 {}
C {lab_pin.sym} 540 37360 0 0 {name=l29938 lab=WL187}
N 640 37440 660 37440 {}
C {lab_pin.sym} 660 37440 0 0 {name=l29939 lab=VDD}
N 640 37360 660 37360 {}
C {lab_pin.sym} 660 37360 0 0 {name=l29940 lab=VSS}
C {bitcell_6t.sym} 800 37400 0 0 {name=Xr187c4}
N 760 37440 740 37440 {}
C {lab_pin.sym} 740 37440 0 0 {name=l29941 lab=BL4}
N 760 37400 740 37400 {}
C {lab_pin.sym} 740 37400 0 0 {name=l29942 lab=BLB4}
N 760 37360 740 37360 {}
C {lab_pin.sym} 740 37360 0 0 {name=l29943 lab=WL187}
N 840 37440 860 37440 {}
C {lab_pin.sym} 860 37440 0 0 {name=l29944 lab=VDD}
N 840 37360 860 37360 {}
C {lab_pin.sym} 860 37360 0 0 {name=l29945 lab=VSS}
C {bitcell_6t.sym} 1000 37400 0 0 {name=Xr187c5}
N 960 37440 940 37440 {}
C {lab_pin.sym} 940 37440 0 0 {name=l29946 lab=BL5}
N 960 37400 940 37400 {}
C {lab_pin.sym} 940 37400 0 0 {name=l29947 lab=BLB5}
N 960 37360 940 37360 {}
C {lab_pin.sym} 940 37360 0 0 {name=l29948 lab=WL187}
N 1040 37440 1060 37440 {}
C {lab_pin.sym} 1060 37440 0 0 {name=l29949 lab=VDD}
N 1040 37360 1060 37360 {}
C {lab_pin.sym} 1060 37360 0 0 {name=l29950 lab=VSS}
C {bitcell_6t.sym} 1200 37400 0 0 {name=Xr187c6}
N 1160 37440 1140 37440 {}
C {lab_pin.sym} 1140 37440 0 0 {name=l29951 lab=BL6}
N 1160 37400 1140 37400 {}
C {lab_pin.sym} 1140 37400 0 0 {name=l29952 lab=BLB6}
N 1160 37360 1140 37360 {}
C {lab_pin.sym} 1140 37360 0 0 {name=l29953 lab=WL187}
N 1240 37440 1260 37440 {}
C {lab_pin.sym} 1260 37440 0 0 {name=l29954 lab=VDD}
N 1240 37360 1260 37360 {}
C {lab_pin.sym} 1260 37360 0 0 {name=l29955 lab=VSS}
C {bitcell_6t.sym} 1400 37400 0 0 {name=Xr187c7}
N 1360 37440 1340 37440 {}
C {lab_pin.sym} 1340 37440 0 0 {name=l29956 lab=BL7}
N 1360 37400 1340 37400 {}
C {lab_pin.sym} 1340 37400 0 0 {name=l29957 lab=BLB7}
N 1360 37360 1340 37360 {}
C {lab_pin.sym} 1340 37360 0 0 {name=l29958 lab=WL187}
N 1440 37440 1460 37440 {}
C {lab_pin.sym} 1460 37440 0 0 {name=l29959 lab=VDD}
N 1440 37360 1460 37360 {}
C {lab_pin.sym} 1460 37360 0 0 {name=l29960 lab=VSS}
C {bitcell_6t.sym} 1600 37400 0 0 {name=Xr187c8}
N 1560 37440 1540 37440 {}
C {lab_pin.sym} 1540 37440 0 0 {name=l29961 lab=BL8}
N 1560 37400 1540 37400 {}
C {lab_pin.sym} 1540 37400 0 0 {name=l29962 lab=BLB8}
N 1560 37360 1540 37360 {}
C {lab_pin.sym} 1540 37360 0 0 {name=l29963 lab=WL187}
N 1640 37440 1660 37440 {}
C {lab_pin.sym} 1660 37440 0 0 {name=l29964 lab=VDD}
N 1640 37360 1660 37360 {}
C {lab_pin.sym} 1660 37360 0 0 {name=l29965 lab=VSS}
C {bitcell_6t.sym} 1800 37400 0 0 {name=Xr187c9}
N 1760 37440 1740 37440 {}
C {lab_pin.sym} 1740 37440 0 0 {name=l29966 lab=BL9}
N 1760 37400 1740 37400 {}
C {lab_pin.sym} 1740 37400 0 0 {name=l29967 lab=BLB9}
N 1760 37360 1740 37360 {}
C {lab_pin.sym} 1740 37360 0 0 {name=l29968 lab=WL187}
N 1840 37440 1860 37440 {}
C {lab_pin.sym} 1860 37440 0 0 {name=l29969 lab=VDD}
N 1840 37360 1860 37360 {}
C {lab_pin.sym} 1860 37360 0 0 {name=l29970 lab=VSS}
C {bitcell_6t.sym} 2000 37400 0 0 {name=Xr187c10}
N 1960 37440 1940 37440 {}
C {lab_pin.sym} 1940 37440 0 0 {name=l29971 lab=BL10}
N 1960 37400 1940 37400 {}
C {lab_pin.sym} 1940 37400 0 0 {name=l29972 lab=BLB10}
N 1960 37360 1940 37360 {}
C {lab_pin.sym} 1940 37360 0 0 {name=l29973 lab=WL187}
N 2040 37440 2060 37440 {}
C {lab_pin.sym} 2060 37440 0 0 {name=l29974 lab=VDD}
N 2040 37360 2060 37360 {}
C {lab_pin.sym} 2060 37360 0 0 {name=l29975 lab=VSS}
C {bitcell_6t.sym} 2200 37400 0 0 {name=Xr187c11}
N 2160 37440 2140 37440 {}
C {lab_pin.sym} 2140 37440 0 0 {name=l29976 lab=BL11}
N 2160 37400 2140 37400 {}
C {lab_pin.sym} 2140 37400 0 0 {name=l29977 lab=BLB11}
N 2160 37360 2140 37360 {}
C {lab_pin.sym} 2140 37360 0 0 {name=l29978 lab=WL187}
N 2240 37440 2260 37440 {}
C {lab_pin.sym} 2260 37440 0 0 {name=l29979 lab=VDD}
N 2240 37360 2260 37360 {}
C {lab_pin.sym} 2260 37360 0 0 {name=l29980 lab=VSS}
C {bitcell_6t.sym} 2400 37400 0 0 {name=Xr187c12}
N 2360 37440 2340 37440 {}
C {lab_pin.sym} 2340 37440 0 0 {name=l29981 lab=BL12}
N 2360 37400 2340 37400 {}
C {lab_pin.sym} 2340 37400 0 0 {name=l29982 lab=BLB12}
N 2360 37360 2340 37360 {}
C {lab_pin.sym} 2340 37360 0 0 {name=l29983 lab=WL187}
N 2440 37440 2460 37440 {}
C {lab_pin.sym} 2460 37440 0 0 {name=l29984 lab=VDD}
N 2440 37360 2460 37360 {}
C {lab_pin.sym} 2460 37360 0 0 {name=l29985 lab=VSS}
C {bitcell_6t.sym} 2600 37400 0 0 {name=Xr187c13}
N 2560 37440 2540 37440 {}
C {lab_pin.sym} 2540 37440 0 0 {name=l29986 lab=BL13}
N 2560 37400 2540 37400 {}
C {lab_pin.sym} 2540 37400 0 0 {name=l29987 lab=BLB13}
N 2560 37360 2540 37360 {}
C {lab_pin.sym} 2540 37360 0 0 {name=l29988 lab=WL187}
N 2640 37440 2660 37440 {}
C {lab_pin.sym} 2660 37440 0 0 {name=l29989 lab=VDD}
N 2640 37360 2660 37360 {}
C {lab_pin.sym} 2660 37360 0 0 {name=l29990 lab=VSS}
C {bitcell_6t.sym} 2800 37400 0 0 {name=Xr187c14}
N 2760 37440 2740 37440 {}
C {lab_pin.sym} 2740 37440 0 0 {name=l29991 lab=BL14}
N 2760 37400 2740 37400 {}
C {lab_pin.sym} 2740 37400 0 0 {name=l29992 lab=BLB14}
N 2760 37360 2740 37360 {}
C {lab_pin.sym} 2740 37360 0 0 {name=l29993 lab=WL187}
N 2840 37440 2860 37440 {}
C {lab_pin.sym} 2860 37440 0 0 {name=l29994 lab=VDD}
N 2840 37360 2860 37360 {}
C {lab_pin.sym} 2860 37360 0 0 {name=l29995 lab=VSS}
C {bitcell_6t.sym} 3000 37400 0 0 {name=Xr187c15}
N 2960 37440 2940 37440 {}
C {lab_pin.sym} 2940 37440 0 0 {name=l29996 lab=BL15}
N 2960 37400 2940 37400 {}
C {lab_pin.sym} 2940 37400 0 0 {name=l29997 lab=BLB15}
N 2960 37360 2940 37360 {}
C {lab_pin.sym} 2940 37360 0 0 {name=l29998 lab=WL187}
N 3040 37440 3060 37440 {}
C {lab_pin.sym} 3060 37440 0 0 {name=l29999 lab=VDD}
N 3040 37360 3060 37360 {}
C {lab_pin.sym} 3060 37360 0 0 {name=l30000 lab=VSS}
C {bitcell_6t.sym} 3200 37400 0 0 {name=Xr187c16}
N 3160 37440 3140 37440 {}
C {lab_pin.sym} 3140 37440 0 0 {name=l30001 lab=BL16}
N 3160 37400 3140 37400 {}
C {lab_pin.sym} 3140 37400 0 0 {name=l30002 lab=BLB16}
N 3160 37360 3140 37360 {}
C {lab_pin.sym} 3140 37360 0 0 {name=l30003 lab=WL187}
N 3240 37440 3260 37440 {}
C {lab_pin.sym} 3260 37440 0 0 {name=l30004 lab=VDD}
N 3240 37360 3260 37360 {}
C {lab_pin.sym} 3260 37360 0 0 {name=l30005 lab=VSS}
C {bitcell_6t.sym} 3400 37400 0 0 {name=Xr187c17}
N 3360 37440 3340 37440 {}
C {lab_pin.sym} 3340 37440 0 0 {name=l30006 lab=BL17}
N 3360 37400 3340 37400 {}
C {lab_pin.sym} 3340 37400 0 0 {name=l30007 lab=BLB17}
N 3360 37360 3340 37360 {}
C {lab_pin.sym} 3340 37360 0 0 {name=l30008 lab=WL187}
N 3440 37440 3460 37440 {}
C {lab_pin.sym} 3460 37440 0 0 {name=l30009 lab=VDD}
N 3440 37360 3460 37360 {}
C {lab_pin.sym} 3460 37360 0 0 {name=l30010 lab=VSS}
C {bitcell_6t.sym} 3600 37400 0 0 {name=Xr187c18}
N 3560 37440 3540 37440 {}
C {lab_pin.sym} 3540 37440 0 0 {name=l30011 lab=BL18}
N 3560 37400 3540 37400 {}
C {lab_pin.sym} 3540 37400 0 0 {name=l30012 lab=BLB18}
N 3560 37360 3540 37360 {}
C {lab_pin.sym} 3540 37360 0 0 {name=l30013 lab=WL187}
N 3640 37440 3660 37440 {}
C {lab_pin.sym} 3660 37440 0 0 {name=l30014 lab=VDD}
N 3640 37360 3660 37360 {}
C {lab_pin.sym} 3660 37360 0 0 {name=l30015 lab=VSS}
C {bitcell_6t.sym} 3800 37400 0 0 {name=Xr187c19}
N 3760 37440 3740 37440 {}
C {lab_pin.sym} 3740 37440 0 0 {name=l30016 lab=BL19}
N 3760 37400 3740 37400 {}
C {lab_pin.sym} 3740 37400 0 0 {name=l30017 lab=BLB19}
N 3760 37360 3740 37360 {}
C {lab_pin.sym} 3740 37360 0 0 {name=l30018 lab=WL187}
N 3840 37440 3860 37440 {}
C {lab_pin.sym} 3860 37440 0 0 {name=l30019 lab=VDD}
N 3840 37360 3860 37360 {}
C {lab_pin.sym} 3860 37360 0 0 {name=l30020 lab=VSS}
C {bitcell_6t.sym} 4000 37400 0 0 {name=Xr187c20}
N 3960 37440 3940 37440 {}
C {lab_pin.sym} 3940 37440 0 0 {name=l30021 lab=BL20}
N 3960 37400 3940 37400 {}
C {lab_pin.sym} 3940 37400 0 0 {name=l30022 lab=BLB20}
N 3960 37360 3940 37360 {}
C {lab_pin.sym} 3940 37360 0 0 {name=l30023 lab=WL187}
N 4040 37440 4060 37440 {}
C {lab_pin.sym} 4060 37440 0 0 {name=l30024 lab=VDD}
N 4040 37360 4060 37360 {}
C {lab_pin.sym} 4060 37360 0 0 {name=l30025 lab=VSS}
C {bitcell_6t.sym} 4200 37400 0 0 {name=Xr187c21}
N 4160 37440 4140 37440 {}
C {lab_pin.sym} 4140 37440 0 0 {name=l30026 lab=BL21}
N 4160 37400 4140 37400 {}
C {lab_pin.sym} 4140 37400 0 0 {name=l30027 lab=BLB21}
N 4160 37360 4140 37360 {}
C {lab_pin.sym} 4140 37360 0 0 {name=l30028 lab=WL187}
N 4240 37440 4260 37440 {}
C {lab_pin.sym} 4260 37440 0 0 {name=l30029 lab=VDD}
N 4240 37360 4260 37360 {}
C {lab_pin.sym} 4260 37360 0 0 {name=l30030 lab=VSS}
C {bitcell_6t.sym} 4400 37400 0 0 {name=Xr187c22}
N 4360 37440 4340 37440 {}
C {lab_pin.sym} 4340 37440 0 0 {name=l30031 lab=BL22}
N 4360 37400 4340 37400 {}
C {lab_pin.sym} 4340 37400 0 0 {name=l30032 lab=BLB22}
N 4360 37360 4340 37360 {}
C {lab_pin.sym} 4340 37360 0 0 {name=l30033 lab=WL187}
N 4440 37440 4460 37440 {}
C {lab_pin.sym} 4460 37440 0 0 {name=l30034 lab=VDD}
N 4440 37360 4460 37360 {}
C {lab_pin.sym} 4460 37360 0 0 {name=l30035 lab=VSS}
C {bitcell_6t.sym} 4600 37400 0 0 {name=Xr187c23}
N 4560 37440 4540 37440 {}
C {lab_pin.sym} 4540 37440 0 0 {name=l30036 lab=BL23}
N 4560 37400 4540 37400 {}
C {lab_pin.sym} 4540 37400 0 0 {name=l30037 lab=BLB23}
N 4560 37360 4540 37360 {}
C {lab_pin.sym} 4540 37360 0 0 {name=l30038 lab=WL187}
N 4640 37440 4660 37440 {}
C {lab_pin.sym} 4660 37440 0 0 {name=l30039 lab=VDD}
N 4640 37360 4660 37360 {}
C {lab_pin.sym} 4660 37360 0 0 {name=l30040 lab=VSS}
C {bitcell_6t.sym} 4800 37400 0 0 {name=Xr187c24}
N 4760 37440 4740 37440 {}
C {lab_pin.sym} 4740 37440 0 0 {name=l30041 lab=BL24}
N 4760 37400 4740 37400 {}
C {lab_pin.sym} 4740 37400 0 0 {name=l30042 lab=BLB24}
N 4760 37360 4740 37360 {}
C {lab_pin.sym} 4740 37360 0 0 {name=l30043 lab=WL187}
N 4840 37440 4860 37440 {}
C {lab_pin.sym} 4860 37440 0 0 {name=l30044 lab=VDD}
N 4840 37360 4860 37360 {}
C {lab_pin.sym} 4860 37360 0 0 {name=l30045 lab=VSS}
C {bitcell_6t.sym} 5000 37400 0 0 {name=Xr187c25}
N 4960 37440 4940 37440 {}
C {lab_pin.sym} 4940 37440 0 0 {name=l30046 lab=BL25}
N 4960 37400 4940 37400 {}
C {lab_pin.sym} 4940 37400 0 0 {name=l30047 lab=BLB25}
N 4960 37360 4940 37360 {}
C {lab_pin.sym} 4940 37360 0 0 {name=l30048 lab=WL187}
N 5040 37440 5060 37440 {}
C {lab_pin.sym} 5060 37440 0 0 {name=l30049 lab=VDD}
N 5040 37360 5060 37360 {}
C {lab_pin.sym} 5060 37360 0 0 {name=l30050 lab=VSS}
C {bitcell_6t.sym} 5200 37400 0 0 {name=Xr187c26}
N 5160 37440 5140 37440 {}
C {lab_pin.sym} 5140 37440 0 0 {name=l30051 lab=BL26}
N 5160 37400 5140 37400 {}
C {lab_pin.sym} 5140 37400 0 0 {name=l30052 lab=BLB26}
N 5160 37360 5140 37360 {}
C {lab_pin.sym} 5140 37360 0 0 {name=l30053 lab=WL187}
N 5240 37440 5260 37440 {}
C {lab_pin.sym} 5260 37440 0 0 {name=l30054 lab=VDD}
N 5240 37360 5260 37360 {}
C {lab_pin.sym} 5260 37360 0 0 {name=l30055 lab=VSS}
C {bitcell_6t.sym} 5400 37400 0 0 {name=Xr187c27}
N 5360 37440 5340 37440 {}
C {lab_pin.sym} 5340 37440 0 0 {name=l30056 lab=BL27}
N 5360 37400 5340 37400 {}
C {lab_pin.sym} 5340 37400 0 0 {name=l30057 lab=BLB27}
N 5360 37360 5340 37360 {}
C {lab_pin.sym} 5340 37360 0 0 {name=l30058 lab=WL187}
N 5440 37440 5460 37440 {}
C {lab_pin.sym} 5460 37440 0 0 {name=l30059 lab=VDD}
N 5440 37360 5460 37360 {}
C {lab_pin.sym} 5460 37360 0 0 {name=l30060 lab=VSS}
C {bitcell_6t.sym} 5600 37400 0 0 {name=Xr187c28}
N 5560 37440 5540 37440 {}
C {lab_pin.sym} 5540 37440 0 0 {name=l30061 lab=BL28}
N 5560 37400 5540 37400 {}
C {lab_pin.sym} 5540 37400 0 0 {name=l30062 lab=BLB28}
N 5560 37360 5540 37360 {}
C {lab_pin.sym} 5540 37360 0 0 {name=l30063 lab=WL187}
N 5640 37440 5660 37440 {}
C {lab_pin.sym} 5660 37440 0 0 {name=l30064 lab=VDD}
N 5640 37360 5660 37360 {}
C {lab_pin.sym} 5660 37360 0 0 {name=l30065 lab=VSS}
C {bitcell_6t.sym} 5800 37400 0 0 {name=Xr187c29}
N 5760 37440 5740 37440 {}
C {lab_pin.sym} 5740 37440 0 0 {name=l30066 lab=BL29}
N 5760 37400 5740 37400 {}
C {lab_pin.sym} 5740 37400 0 0 {name=l30067 lab=BLB29}
N 5760 37360 5740 37360 {}
C {lab_pin.sym} 5740 37360 0 0 {name=l30068 lab=WL187}
N 5840 37440 5860 37440 {}
C {lab_pin.sym} 5860 37440 0 0 {name=l30069 lab=VDD}
N 5840 37360 5860 37360 {}
C {lab_pin.sym} 5860 37360 0 0 {name=l30070 lab=VSS}
C {bitcell_6t.sym} 6000 37400 0 0 {name=Xr187c30}
N 5960 37440 5940 37440 {}
C {lab_pin.sym} 5940 37440 0 0 {name=l30071 lab=BL30}
N 5960 37400 5940 37400 {}
C {lab_pin.sym} 5940 37400 0 0 {name=l30072 lab=BLB30}
N 5960 37360 5940 37360 {}
C {lab_pin.sym} 5940 37360 0 0 {name=l30073 lab=WL187}
N 6040 37440 6060 37440 {}
C {lab_pin.sym} 6060 37440 0 0 {name=l30074 lab=VDD}
N 6040 37360 6060 37360 {}
C {lab_pin.sym} 6060 37360 0 0 {name=l30075 lab=VSS}
C {bitcell_6t.sym} 6200 37400 0 0 {name=Xr187c31}
N 6160 37440 6140 37440 {}
C {lab_pin.sym} 6140 37440 0 0 {name=l30076 lab=BL31}
N 6160 37400 6140 37400 {}
C {lab_pin.sym} 6140 37400 0 0 {name=l30077 lab=BLB31}
N 6160 37360 6140 37360 {}
C {lab_pin.sym} 6140 37360 0 0 {name=l30078 lab=WL187}
N 6240 37440 6260 37440 {}
C {lab_pin.sym} 6260 37440 0 0 {name=l30079 lab=VDD}
N 6240 37360 6260 37360 {}
C {lab_pin.sym} 6260 37360 0 0 {name=l30080 lab=VSS}
C {bitcell_6t.sym} 0 37600 0 0 {name=Xr188c0}
N -40 37640 -60 37640 {}
C {lab_pin.sym} -60 37640 0 0 {name=l30081 lab=BL0}
N -40 37600 -60 37600 {}
C {lab_pin.sym} -60 37600 0 0 {name=l30082 lab=BLB0}
N -40 37560 -60 37560 {}
C {lab_pin.sym} -60 37560 0 0 {name=l30083 lab=WL188}
N 40 37640 60 37640 {}
C {lab_pin.sym} 60 37640 0 0 {name=l30084 lab=VDD}
N 40 37560 60 37560 {}
C {lab_pin.sym} 60 37560 0 0 {name=l30085 lab=VSS}
C {bitcell_6t.sym} 200 37600 0 0 {name=Xr188c1}
N 160 37640 140 37640 {}
C {lab_pin.sym} 140 37640 0 0 {name=l30086 lab=BL1}
N 160 37600 140 37600 {}
C {lab_pin.sym} 140 37600 0 0 {name=l30087 lab=BLB1}
N 160 37560 140 37560 {}
C {lab_pin.sym} 140 37560 0 0 {name=l30088 lab=WL188}
N 240 37640 260 37640 {}
C {lab_pin.sym} 260 37640 0 0 {name=l30089 lab=VDD}
N 240 37560 260 37560 {}
C {lab_pin.sym} 260 37560 0 0 {name=l30090 lab=VSS}
C {bitcell_6t.sym} 400 37600 0 0 {name=Xr188c2}
N 360 37640 340 37640 {}
C {lab_pin.sym} 340 37640 0 0 {name=l30091 lab=BL2}
N 360 37600 340 37600 {}
C {lab_pin.sym} 340 37600 0 0 {name=l30092 lab=BLB2}
N 360 37560 340 37560 {}
C {lab_pin.sym} 340 37560 0 0 {name=l30093 lab=WL188}
N 440 37640 460 37640 {}
C {lab_pin.sym} 460 37640 0 0 {name=l30094 lab=VDD}
N 440 37560 460 37560 {}
C {lab_pin.sym} 460 37560 0 0 {name=l30095 lab=VSS}
C {bitcell_6t.sym} 600 37600 0 0 {name=Xr188c3}
N 560 37640 540 37640 {}
C {lab_pin.sym} 540 37640 0 0 {name=l30096 lab=BL3}
N 560 37600 540 37600 {}
C {lab_pin.sym} 540 37600 0 0 {name=l30097 lab=BLB3}
N 560 37560 540 37560 {}
C {lab_pin.sym} 540 37560 0 0 {name=l30098 lab=WL188}
N 640 37640 660 37640 {}
C {lab_pin.sym} 660 37640 0 0 {name=l30099 lab=VDD}
N 640 37560 660 37560 {}
C {lab_pin.sym} 660 37560 0 0 {name=l30100 lab=VSS}
C {bitcell_6t.sym} 800 37600 0 0 {name=Xr188c4}
N 760 37640 740 37640 {}
C {lab_pin.sym} 740 37640 0 0 {name=l30101 lab=BL4}
N 760 37600 740 37600 {}
C {lab_pin.sym} 740 37600 0 0 {name=l30102 lab=BLB4}
N 760 37560 740 37560 {}
C {lab_pin.sym} 740 37560 0 0 {name=l30103 lab=WL188}
N 840 37640 860 37640 {}
C {lab_pin.sym} 860 37640 0 0 {name=l30104 lab=VDD}
N 840 37560 860 37560 {}
C {lab_pin.sym} 860 37560 0 0 {name=l30105 lab=VSS}
C {bitcell_6t.sym} 1000 37600 0 0 {name=Xr188c5}
N 960 37640 940 37640 {}
C {lab_pin.sym} 940 37640 0 0 {name=l30106 lab=BL5}
N 960 37600 940 37600 {}
C {lab_pin.sym} 940 37600 0 0 {name=l30107 lab=BLB5}
N 960 37560 940 37560 {}
C {lab_pin.sym} 940 37560 0 0 {name=l30108 lab=WL188}
N 1040 37640 1060 37640 {}
C {lab_pin.sym} 1060 37640 0 0 {name=l30109 lab=VDD}
N 1040 37560 1060 37560 {}
C {lab_pin.sym} 1060 37560 0 0 {name=l30110 lab=VSS}
C {bitcell_6t.sym} 1200 37600 0 0 {name=Xr188c6}
N 1160 37640 1140 37640 {}
C {lab_pin.sym} 1140 37640 0 0 {name=l30111 lab=BL6}
N 1160 37600 1140 37600 {}
C {lab_pin.sym} 1140 37600 0 0 {name=l30112 lab=BLB6}
N 1160 37560 1140 37560 {}
C {lab_pin.sym} 1140 37560 0 0 {name=l30113 lab=WL188}
N 1240 37640 1260 37640 {}
C {lab_pin.sym} 1260 37640 0 0 {name=l30114 lab=VDD}
N 1240 37560 1260 37560 {}
C {lab_pin.sym} 1260 37560 0 0 {name=l30115 lab=VSS}
C {bitcell_6t.sym} 1400 37600 0 0 {name=Xr188c7}
N 1360 37640 1340 37640 {}
C {lab_pin.sym} 1340 37640 0 0 {name=l30116 lab=BL7}
N 1360 37600 1340 37600 {}
C {lab_pin.sym} 1340 37600 0 0 {name=l30117 lab=BLB7}
N 1360 37560 1340 37560 {}
C {lab_pin.sym} 1340 37560 0 0 {name=l30118 lab=WL188}
N 1440 37640 1460 37640 {}
C {lab_pin.sym} 1460 37640 0 0 {name=l30119 lab=VDD}
N 1440 37560 1460 37560 {}
C {lab_pin.sym} 1460 37560 0 0 {name=l30120 lab=VSS}
C {bitcell_6t.sym} 1600 37600 0 0 {name=Xr188c8}
N 1560 37640 1540 37640 {}
C {lab_pin.sym} 1540 37640 0 0 {name=l30121 lab=BL8}
N 1560 37600 1540 37600 {}
C {lab_pin.sym} 1540 37600 0 0 {name=l30122 lab=BLB8}
N 1560 37560 1540 37560 {}
C {lab_pin.sym} 1540 37560 0 0 {name=l30123 lab=WL188}
N 1640 37640 1660 37640 {}
C {lab_pin.sym} 1660 37640 0 0 {name=l30124 lab=VDD}
N 1640 37560 1660 37560 {}
C {lab_pin.sym} 1660 37560 0 0 {name=l30125 lab=VSS}
C {bitcell_6t.sym} 1800 37600 0 0 {name=Xr188c9}
N 1760 37640 1740 37640 {}
C {lab_pin.sym} 1740 37640 0 0 {name=l30126 lab=BL9}
N 1760 37600 1740 37600 {}
C {lab_pin.sym} 1740 37600 0 0 {name=l30127 lab=BLB9}
N 1760 37560 1740 37560 {}
C {lab_pin.sym} 1740 37560 0 0 {name=l30128 lab=WL188}
N 1840 37640 1860 37640 {}
C {lab_pin.sym} 1860 37640 0 0 {name=l30129 lab=VDD}
N 1840 37560 1860 37560 {}
C {lab_pin.sym} 1860 37560 0 0 {name=l30130 lab=VSS}
C {bitcell_6t.sym} 2000 37600 0 0 {name=Xr188c10}
N 1960 37640 1940 37640 {}
C {lab_pin.sym} 1940 37640 0 0 {name=l30131 lab=BL10}
N 1960 37600 1940 37600 {}
C {lab_pin.sym} 1940 37600 0 0 {name=l30132 lab=BLB10}
N 1960 37560 1940 37560 {}
C {lab_pin.sym} 1940 37560 0 0 {name=l30133 lab=WL188}
N 2040 37640 2060 37640 {}
C {lab_pin.sym} 2060 37640 0 0 {name=l30134 lab=VDD}
N 2040 37560 2060 37560 {}
C {lab_pin.sym} 2060 37560 0 0 {name=l30135 lab=VSS}
C {bitcell_6t.sym} 2200 37600 0 0 {name=Xr188c11}
N 2160 37640 2140 37640 {}
C {lab_pin.sym} 2140 37640 0 0 {name=l30136 lab=BL11}
N 2160 37600 2140 37600 {}
C {lab_pin.sym} 2140 37600 0 0 {name=l30137 lab=BLB11}
N 2160 37560 2140 37560 {}
C {lab_pin.sym} 2140 37560 0 0 {name=l30138 lab=WL188}
N 2240 37640 2260 37640 {}
C {lab_pin.sym} 2260 37640 0 0 {name=l30139 lab=VDD}
N 2240 37560 2260 37560 {}
C {lab_pin.sym} 2260 37560 0 0 {name=l30140 lab=VSS}
C {bitcell_6t.sym} 2400 37600 0 0 {name=Xr188c12}
N 2360 37640 2340 37640 {}
C {lab_pin.sym} 2340 37640 0 0 {name=l30141 lab=BL12}
N 2360 37600 2340 37600 {}
C {lab_pin.sym} 2340 37600 0 0 {name=l30142 lab=BLB12}
N 2360 37560 2340 37560 {}
C {lab_pin.sym} 2340 37560 0 0 {name=l30143 lab=WL188}
N 2440 37640 2460 37640 {}
C {lab_pin.sym} 2460 37640 0 0 {name=l30144 lab=VDD}
N 2440 37560 2460 37560 {}
C {lab_pin.sym} 2460 37560 0 0 {name=l30145 lab=VSS}
C {bitcell_6t.sym} 2600 37600 0 0 {name=Xr188c13}
N 2560 37640 2540 37640 {}
C {lab_pin.sym} 2540 37640 0 0 {name=l30146 lab=BL13}
N 2560 37600 2540 37600 {}
C {lab_pin.sym} 2540 37600 0 0 {name=l30147 lab=BLB13}
N 2560 37560 2540 37560 {}
C {lab_pin.sym} 2540 37560 0 0 {name=l30148 lab=WL188}
N 2640 37640 2660 37640 {}
C {lab_pin.sym} 2660 37640 0 0 {name=l30149 lab=VDD}
N 2640 37560 2660 37560 {}
C {lab_pin.sym} 2660 37560 0 0 {name=l30150 lab=VSS}
C {bitcell_6t.sym} 2800 37600 0 0 {name=Xr188c14}
N 2760 37640 2740 37640 {}
C {lab_pin.sym} 2740 37640 0 0 {name=l30151 lab=BL14}
N 2760 37600 2740 37600 {}
C {lab_pin.sym} 2740 37600 0 0 {name=l30152 lab=BLB14}
N 2760 37560 2740 37560 {}
C {lab_pin.sym} 2740 37560 0 0 {name=l30153 lab=WL188}
N 2840 37640 2860 37640 {}
C {lab_pin.sym} 2860 37640 0 0 {name=l30154 lab=VDD}
N 2840 37560 2860 37560 {}
C {lab_pin.sym} 2860 37560 0 0 {name=l30155 lab=VSS}
C {bitcell_6t.sym} 3000 37600 0 0 {name=Xr188c15}
N 2960 37640 2940 37640 {}
C {lab_pin.sym} 2940 37640 0 0 {name=l30156 lab=BL15}
N 2960 37600 2940 37600 {}
C {lab_pin.sym} 2940 37600 0 0 {name=l30157 lab=BLB15}
N 2960 37560 2940 37560 {}
C {lab_pin.sym} 2940 37560 0 0 {name=l30158 lab=WL188}
N 3040 37640 3060 37640 {}
C {lab_pin.sym} 3060 37640 0 0 {name=l30159 lab=VDD}
N 3040 37560 3060 37560 {}
C {lab_pin.sym} 3060 37560 0 0 {name=l30160 lab=VSS}
C {bitcell_6t.sym} 3200 37600 0 0 {name=Xr188c16}
N 3160 37640 3140 37640 {}
C {lab_pin.sym} 3140 37640 0 0 {name=l30161 lab=BL16}
N 3160 37600 3140 37600 {}
C {lab_pin.sym} 3140 37600 0 0 {name=l30162 lab=BLB16}
N 3160 37560 3140 37560 {}
C {lab_pin.sym} 3140 37560 0 0 {name=l30163 lab=WL188}
N 3240 37640 3260 37640 {}
C {lab_pin.sym} 3260 37640 0 0 {name=l30164 lab=VDD}
N 3240 37560 3260 37560 {}
C {lab_pin.sym} 3260 37560 0 0 {name=l30165 lab=VSS}
C {bitcell_6t.sym} 3400 37600 0 0 {name=Xr188c17}
N 3360 37640 3340 37640 {}
C {lab_pin.sym} 3340 37640 0 0 {name=l30166 lab=BL17}
N 3360 37600 3340 37600 {}
C {lab_pin.sym} 3340 37600 0 0 {name=l30167 lab=BLB17}
N 3360 37560 3340 37560 {}
C {lab_pin.sym} 3340 37560 0 0 {name=l30168 lab=WL188}
N 3440 37640 3460 37640 {}
C {lab_pin.sym} 3460 37640 0 0 {name=l30169 lab=VDD}
N 3440 37560 3460 37560 {}
C {lab_pin.sym} 3460 37560 0 0 {name=l30170 lab=VSS}
C {bitcell_6t.sym} 3600 37600 0 0 {name=Xr188c18}
N 3560 37640 3540 37640 {}
C {lab_pin.sym} 3540 37640 0 0 {name=l30171 lab=BL18}
N 3560 37600 3540 37600 {}
C {lab_pin.sym} 3540 37600 0 0 {name=l30172 lab=BLB18}
N 3560 37560 3540 37560 {}
C {lab_pin.sym} 3540 37560 0 0 {name=l30173 lab=WL188}
N 3640 37640 3660 37640 {}
C {lab_pin.sym} 3660 37640 0 0 {name=l30174 lab=VDD}
N 3640 37560 3660 37560 {}
C {lab_pin.sym} 3660 37560 0 0 {name=l30175 lab=VSS}
C {bitcell_6t.sym} 3800 37600 0 0 {name=Xr188c19}
N 3760 37640 3740 37640 {}
C {lab_pin.sym} 3740 37640 0 0 {name=l30176 lab=BL19}
N 3760 37600 3740 37600 {}
C {lab_pin.sym} 3740 37600 0 0 {name=l30177 lab=BLB19}
N 3760 37560 3740 37560 {}
C {lab_pin.sym} 3740 37560 0 0 {name=l30178 lab=WL188}
N 3840 37640 3860 37640 {}
C {lab_pin.sym} 3860 37640 0 0 {name=l30179 lab=VDD}
N 3840 37560 3860 37560 {}
C {lab_pin.sym} 3860 37560 0 0 {name=l30180 lab=VSS}
C {bitcell_6t.sym} 4000 37600 0 0 {name=Xr188c20}
N 3960 37640 3940 37640 {}
C {lab_pin.sym} 3940 37640 0 0 {name=l30181 lab=BL20}
N 3960 37600 3940 37600 {}
C {lab_pin.sym} 3940 37600 0 0 {name=l30182 lab=BLB20}
N 3960 37560 3940 37560 {}
C {lab_pin.sym} 3940 37560 0 0 {name=l30183 lab=WL188}
N 4040 37640 4060 37640 {}
C {lab_pin.sym} 4060 37640 0 0 {name=l30184 lab=VDD}
N 4040 37560 4060 37560 {}
C {lab_pin.sym} 4060 37560 0 0 {name=l30185 lab=VSS}
C {bitcell_6t.sym} 4200 37600 0 0 {name=Xr188c21}
N 4160 37640 4140 37640 {}
C {lab_pin.sym} 4140 37640 0 0 {name=l30186 lab=BL21}
N 4160 37600 4140 37600 {}
C {lab_pin.sym} 4140 37600 0 0 {name=l30187 lab=BLB21}
N 4160 37560 4140 37560 {}
C {lab_pin.sym} 4140 37560 0 0 {name=l30188 lab=WL188}
N 4240 37640 4260 37640 {}
C {lab_pin.sym} 4260 37640 0 0 {name=l30189 lab=VDD}
N 4240 37560 4260 37560 {}
C {lab_pin.sym} 4260 37560 0 0 {name=l30190 lab=VSS}
C {bitcell_6t.sym} 4400 37600 0 0 {name=Xr188c22}
N 4360 37640 4340 37640 {}
C {lab_pin.sym} 4340 37640 0 0 {name=l30191 lab=BL22}
N 4360 37600 4340 37600 {}
C {lab_pin.sym} 4340 37600 0 0 {name=l30192 lab=BLB22}
N 4360 37560 4340 37560 {}
C {lab_pin.sym} 4340 37560 0 0 {name=l30193 lab=WL188}
N 4440 37640 4460 37640 {}
C {lab_pin.sym} 4460 37640 0 0 {name=l30194 lab=VDD}
N 4440 37560 4460 37560 {}
C {lab_pin.sym} 4460 37560 0 0 {name=l30195 lab=VSS}
C {bitcell_6t.sym} 4600 37600 0 0 {name=Xr188c23}
N 4560 37640 4540 37640 {}
C {lab_pin.sym} 4540 37640 0 0 {name=l30196 lab=BL23}
N 4560 37600 4540 37600 {}
C {lab_pin.sym} 4540 37600 0 0 {name=l30197 lab=BLB23}
N 4560 37560 4540 37560 {}
C {lab_pin.sym} 4540 37560 0 0 {name=l30198 lab=WL188}
N 4640 37640 4660 37640 {}
C {lab_pin.sym} 4660 37640 0 0 {name=l30199 lab=VDD}
N 4640 37560 4660 37560 {}
C {lab_pin.sym} 4660 37560 0 0 {name=l30200 lab=VSS}
C {bitcell_6t.sym} 4800 37600 0 0 {name=Xr188c24}
N 4760 37640 4740 37640 {}
C {lab_pin.sym} 4740 37640 0 0 {name=l30201 lab=BL24}
N 4760 37600 4740 37600 {}
C {lab_pin.sym} 4740 37600 0 0 {name=l30202 lab=BLB24}
N 4760 37560 4740 37560 {}
C {lab_pin.sym} 4740 37560 0 0 {name=l30203 lab=WL188}
N 4840 37640 4860 37640 {}
C {lab_pin.sym} 4860 37640 0 0 {name=l30204 lab=VDD}
N 4840 37560 4860 37560 {}
C {lab_pin.sym} 4860 37560 0 0 {name=l30205 lab=VSS}
C {bitcell_6t.sym} 5000 37600 0 0 {name=Xr188c25}
N 4960 37640 4940 37640 {}
C {lab_pin.sym} 4940 37640 0 0 {name=l30206 lab=BL25}
N 4960 37600 4940 37600 {}
C {lab_pin.sym} 4940 37600 0 0 {name=l30207 lab=BLB25}
N 4960 37560 4940 37560 {}
C {lab_pin.sym} 4940 37560 0 0 {name=l30208 lab=WL188}
N 5040 37640 5060 37640 {}
C {lab_pin.sym} 5060 37640 0 0 {name=l30209 lab=VDD}
N 5040 37560 5060 37560 {}
C {lab_pin.sym} 5060 37560 0 0 {name=l30210 lab=VSS}
C {bitcell_6t.sym} 5200 37600 0 0 {name=Xr188c26}
N 5160 37640 5140 37640 {}
C {lab_pin.sym} 5140 37640 0 0 {name=l30211 lab=BL26}
N 5160 37600 5140 37600 {}
C {lab_pin.sym} 5140 37600 0 0 {name=l30212 lab=BLB26}
N 5160 37560 5140 37560 {}
C {lab_pin.sym} 5140 37560 0 0 {name=l30213 lab=WL188}
N 5240 37640 5260 37640 {}
C {lab_pin.sym} 5260 37640 0 0 {name=l30214 lab=VDD}
N 5240 37560 5260 37560 {}
C {lab_pin.sym} 5260 37560 0 0 {name=l30215 lab=VSS}
C {bitcell_6t.sym} 5400 37600 0 0 {name=Xr188c27}
N 5360 37640 5340 37640 {}
C {lab_pin.sym} 5340 37640 0 0 {name=l30216 lab=BL27}
N 5360 37600 5340 37600 {}
C {lab_pin.sym} 5340 37600 0 0 {name=l30217 lab=BLB27}
N 5360 37560 5340 37560 {}
C {lab_pin.sym} 5340 37560 0 0 {name=l30218 lab=WL188}
N 5440 37640 5460 37640 {}
C {lab_pin.sym} 5460 37640 0 0 {name=l30219 lab=VDD}
N 5440 37560 5460 37560 {}
C {lab_pin.sym} 5460 37560 0 0 {name=l30220 lab=VSS}
C {bitcell_6t.sym} 5600 37600 0 0 {name=Xr188c28}
N 5560 37640 5540 37640 {}
C {lab_pin.sym} 5540 37640 0 0 {name=l30221 lab=BL28}
N 5560 37600 5540 37600 {}
C {lab_pin.sym} 5540 37600 0 0 {name=l30222 lab=BLB28}
N 5560 37560 5540 37560 {}
C {lab_pin.sym} 5540 37560 0 0 {name=l30223 lab=WL188}
N 5640 37640 5660 37640 {}
C {lab_pin.sym} 5660 37640 0 0 {name=l30224 lab=VDD}
N 5640 37560 5660 37560 {}
C {lab_pin.sym} 5660 37560 0 0 {name=l30225 lab=VSS}
C {bitcell_6t.sym} 5800 37600 0 0 {name=Xr188c29}
N 5760 37640 5740 37640 {}
C {lab_pin.sym} 5740 37640 0 0 {name=l30226 lab=BL29}
N 5760 37600 5740 37600 {}
C {lab_pin.sym} 5740 37600 0 0 {name=l30227 lab=BLB29}
N 5760 37560 5740 37560 {}
C {lab_pin.sym} 5740 37560 0 0 {name=l30228 lab=WL188}
N 5840 37640 5860 37640 {}
C {lab_pin.sym} 5860 37640 0 0 {name=l30229 lab=VDD}
N 5840 37560 5860 37560 {}
C {lab_pin.sym} 5860 37560 0 0 {name=l30230 lab=VSS}
C {bitcell_6t.sym} 6000 37600 0 0 {name=Xr188c30}
N 5960 37640 5940 37640 {}
C {lab_pin.sym} 5940 37640 0 0 {name=l30231 lab=BL30}
N 5960 37600 5940 37600 {}
C {lab_pin.sym} 5940 37600 0 0 {name=l30232 lab=BLB30}
N 5960 37560 5940 37560 {}
C {lab_pin.sym} 5940 37560 0 0 {name=l30233 lab=WL188}
N 6040 37640 6060 37640 {}
C {lab_pin.sym} 6060 37640 0 0 {name=l30234 lab=VDD}
N 6040 37560 6060 37560 {}
C {lab_pin.sym} 6060 37560 0 0 {name=l30235 lab=VSS}
C {bitcell_6t.sym} 6200 37600 0 0 {name=Xr188c31}
N 6160 37640 6140 37640 {}
C {lab_pin.sym} 6140 37640 0 0 {name=l30236 lab=BL31}
N 6160 37600 6140 37600 {}
C {lab_pin.sym} 6140 37600 0 0 {name=l30237 lab=BLB31}
N 6160 37560 6140 37560 {}
C {lab_pin.sym} 6140 37560 0 0 {name=l30238 lab=WL188}
N 6240 37640 6260 37640 {}
C {lab_pin.sym} 6260 37640 0 0 {name=l30239 lab=VDD}
N 6240 37560 6260 37560 {}
C {lab_pin.sym} 6260 37560 0 0 {name=l30240 lab=VSS}
C {bitcell_6t.sym} 0 37800 0 0 {name=Xr189c0}
N -40 37840 -60 37840 {}
C {lab_pin.sym} -60 37840 0 0 {name=l30241 lab=BL0}
N -40 37800 -60 37800 {}
C {lab_pin.sym} -60 37800 0 0 {name=l30242 lab=BLB0}
N -40 37760 -60 37760 {}
C {lab_pin.sym} -60 37760 0 0 {name=l30243 lab=WL189}
N 40 37840 60 37840 {}
C {lab_pin.sym} 60 37840 0 0 {name=l30244 lab=VDD}
N 40 37760 60 37760 {}
C {lab_pin.sym} 60 37760 0 0 {name=l30245 lab=VSS}
C {bitcell_6t.sym} 200 37800 0 0 {name=Xr189c1}
N 160 37840 140 37840 {}
C {lab_pin.sym} 140 37840 0 0 {name=l30246 lab=BL1}
N 160 37800 140 37800 {}
C {lab_pin.sym} 140 37800 0 0 {name=l30247 lab=BLB1}
N 160 37760 140 37760 {}
C {lab_pin.sym} 140 37760 0 0 {name=l30248 lab=WL189}
N 240 37840 260 37840 {}
C {lab_pin.sym} 260 37840 0 0 {name=l30249 lab=VDD}
N 240 37760 260 37760 {}
C {lab_pin.sym} 260 37760 0 0 {name=l30250 lab=VSS}
C {bitcell_6t.sym} 400 37800 0 0 {name=Xr189c2}
N 360 37840 340 37840 {}
C {lab_pin.sym} 340 37840 0 0 {name=l30251 lab=BL2}
N 360 37800 340 37800 {}
C {lab_pin.sym} 340 37800 0 0 {name=l30252 lab=BLB2}
N 360 37760 340 37760 {}
C {lab_pin.sym} 340 37760 0 0 {name=l30253 lab=WL189}
N 440 37840 460 37840 {}
C {lab_pin.sym} 460 37840 0 0 {name=l30254 lab=VDD}
N 440 37760 460 37760 {}
C {lab_pin.sym} 460 37760 0 0 {name=l30255 lab=VSS}
C {bitcell_6t.sym} 600 37800 0 0 {name=Xr189c3}
N 560 37840 540 37840 {}
C {lab_pin.sym} 540 37840 0 0 {name=l30256 lab=BL3}
N 560 37800 540 37800 {}
C {lab_pin.sym} 540 37800 0 0 {name=l30257 lab=BLB3}
N 560 37760 540 37760 {}
C {lab_pin.sym} 540 37760 0 0 {name=l30258 lab=WL189}
N 640 37840 660 37840 {}
C {lab_pin.sym} 660 37840 0 0 {name=l30259 lab=VDD}
N 640 37760 660 37760 {}
C {lab_pin.sym} 660 37760 0 0 {name=l30260 lab=VSS}
C {bitcell_6t.sym} 800 37800 0 0 {name=Xr189c4}
N 760 37840 740 37840 {}
C {lab_pin.sym} 740 37840 0 0 {name=l30261 lab=BL4}
N 760 37800 740 37800 {}
C {lab_pin.sym} 740 37800 0 0 {name=l30262 lab=BLB4}
N 760 37760 740 37760 {}
C {lab_pin.sym} 740 37760 0 0 {name=l30263 lab=WL189}
N 840 37840 860 37840 {}
C {lab_pin.sym} 860 37840 0 0 {name=l30264 lab=VDD}
N 840 37760 860 37760 {}
C {lab_pin.sym} 860 37760 0 0 {name=l30265 lab=VSS}
C {bitcell_6t.sym} 1000 37800 0 0 {name=Xr189c5}
N 960 37840 940 37840 {}
C {lab_pin.sym} 940 37840 0 0 {name=l30266 lab=BL5}
N 960 37800 940 37800 {}
C {lab_pin.sym} 940 37800 0 0 {name=l30267 lab=BLB5}
N 960 37760 940 37760 {}
C {lab_pin.sym} 940 37760 0 0 {name=l30268 lab=WL189}
N 1040 37840 1060 37840 {}
C {lab_pin.sym} 1060 37840 0 0 {name=l30269 lab=VDD}
N 1040 37760 1060 37760 {}
C {lab_pin.sym} 1060 37760 0 0 {name=l30270 lab=VSS}
C {bitcell_6t.sym} 1200 37800 0 0 {name=Xr189c6}
N 1160 37840 1140 37840 {}
C {lab_pin.sym} 1140 37840 0 0 {name=l30271 lab=BL6}
N 1160 37800 1140 37800 {}
C {lab_pin.sym} 1140 37800 0 0 {name=l30272 lab=BLB6}
N 1160 37760 1140 37760 {}
C {lab_pin.sym} 1140 37760 0 0 {name=l30273 lab=WL189}
N 1240 37840 1260 37840 {}
C {lab_pin.sym} 1260 37840 0 0 {name=l30274 lab=VDD}
N 1240 37760 1260 37760 {}
C {lab_pin.sym} 1260 37760 0 0 {name=l30275 lab=VSS}
C {bitcell_6t.sym} 1400 37800 0 0 {name=Xr189c7}
N 1360 37840 1340 37840 {}
C {lab_pin.sym} 1340 37840 0 0 {name=l30276 lab=BL7}
N 1360 37800 1340 37800 {}
C {lab_pin.sym} 1340 37800 0 0 {name=l30277 lab=BLB7}
N 1360 37760 1340 37760 {}
C {lab_pin.sym} 1340 37760 0 0 {name=l30278 lab=WL189}
N 1440 37840 1460 37840 {}
C {lab_pin.sym} 1460 37840 0 0 {name=l30279 lab=VDD}
N 1440 37760 1460 37760 {}
C {lab_pin.sym} 1460 37760 0 0 {name=l30280 lab=VSS}
C {bitcell_6t.sym} 1600 37800 0 0 {name=Xr189c8}
N 1560 37840 1540 37840 {}
C {lab_pin.sym} 1540 37840 0 0 {name=l30281 lab=BL8}
N 1560 37800 1540 37800 {}
C {lab_pin.sym} 1540 37800 0 0 {name=l30282 lab=BLB8}
N 1560 37760 1540 37760 {}
C {lab_pin.sym} 1540 37760 0 0 {name=l30283 lab=WL189}
N 1640 37840 1660 37840 {}
C {lab_pin.sym} 1660 37840 0 0 {name=l30284 lab=VDD}
N 1640 37760 1660 37760 {}
C {lab_pin.sym} 1660 37760 0 0 {name=l30285 lab=VSS}
C {bitcell_6t.sym} 1800 37800 0 0 {name=Xr189c9}
N 1760 37840 1740 37840 {}
C {lab_pin.sym} 1740 37840 0 0 {name=l30286 lab=BL9}
N 1760 37800 1740 37800 {}
C {lab_pin.sym} 1740 37800 0 0 {name=l30287 lab=BLB9}
N 1760 37760 1740 37760 {}
C {lab_pin.sym} 1740 37760 0 0 {name=l30288 lab=WL189}
N 1840 37840 1860 37840 {}
C {lab_pin.sym} 1860 37840 0 0 {name=l30289 lab=VDD}
N 1840 37760 1860 37760 {}
C {lab_pin.sym} 1860 37760 0 0 {name=l30290 lab=VSS}
C {bitcell_6t.sym} 2000 37800 0 0 {name=Xr189c10}
N 1960 37840 1940 37840 {}
C {lab_pin.sym} 1940 37840 0 0 {name=l30291 lab=BL10}
N 1960 37800 1940 37800 {}
C {lab_pin.sym} 1940 37800 0 0 {name=l30292 lab=BLB10}
N 1960 37760 1940 37760 {}
C {lab_pin.sym} 1940 37760 0 0 {name=l30293 lab=WL189}
N 2040 37840 2060 37840 {}
C {lab_pin.sym} 2060 37840 0 0 {name=l30294 lab=VDD}
N 2040 37760 2060 37760 {}
C {lab_pin.sym} 2060 37760 0 0 {name=l30295 lab=VSS}
C {bitcell_6t.sym} 2200 37800 0 0 {name=Xr189c11}
N 2160 37840 2140 37840 {}
C {lab_pin.sym} 2140 37840 0 0 {name=l30296 lab=BL11}
N 2160 37800 2140 37800 {}
C {lab_pin.sym} 2140 37800 0 0 {name=l30297 lab=BLB11}
N 2160 37760 2140 37760 {}
C {lab_pin.sym} 2140 37760 0 0 {name=l30298 lab=WL189}
N 2240 37840 2260 37840 {}
C {lab_pin.sym} 2260 37840 0 0 {name=l30299 lab=VDD}
N 2240 37760 2260 37760 {}
C {lab_pin.sym} 2260 37760 0 0 {name=l30300 lab=VSS}
C {bitcell_6t.sym} 2400 37800 0 0 {name=Xr189c12}
N 2360 37840 2340 37840 {}
C {lab_pin.sym} 2340 37840 0 0 {name=l30301 lab=BL12}
N 2360 37800 2340 37800 {}
C {lab_pin.sym} 2340 37800 0 0 {name=l30302 lab=BLB12}
N 2360 37760 2340 37760 {}
C {lab_pin.sym} 2340 37760 0 0 {name=l30303 lab=WL189}
N 2440 37840 2460 37840 {}
C {lab_pin.sym} 2460 37840 0 0 {name=l30304 lab=VDD}
N 2440 37760 2460 37760 {}
C {lab_pin.sym} 2460 37760 0 0 {name=l30305 lab=VSS}
C {bitcell_6t.sym} 2600 37800 0 0 {name=Xr189c13}
N 2560 37840 2540 37840 {}
C {lab_pin.sym} 2540 37840 0 0 {name=l30306 lab=BL13}
N 2560 37800 2540 37800 {}
C {lab_pin.sym} 2540 37800 0 0 {name=l30307 lab=BLB13}
N 2560 37760 2540 37760 {}
C {lab_pin.sym} 2540 37760 0 0 {name=l30308 lab=WL189}
N 2640 37840 2660 37840 {}
C {lab_pin.sym} 2660 37840 0 0 {name=l30309 lab=VDD}
N 2640 37760 2660 37760 {}
C {lab_pin.sym} 2660 37760 0 0 {name=l30310 lab=VSS}
C {bitcell_6t.sym} 2800 37800 0 0 {name=Xr189c14}
N 2760 37840 2740 37840 {}
C {lab_pin.sym} 2740 37840 0 0 {name=l30311 lab=BL14}
N 2760 37800 2740 37800 {}
C {lab_pin.sym} 2740 37800 0 0 {name=l30312 lab=BLB14}
N 2760 37760 2740 37760 {}
C {lab_pin.sym} 2740 37760 0 0 {name=l30313 lab=WL189}
N 2840 37840 2860 37840 {}
C {lab_pin.sym} 2860 37840 0 0 {name=l30314 lab=VDD}
N 2840 37760 2860 37760 {}
C {lab_pin.sym} 2860 37760 0 0 {name=l30315 lab=VSS}
C {bitcell_6t.sym} 3000 37800 0 0 {name=Xr189c15}
N 2960 37840 2940 37840 {}
C {lab_pin.sym} 2940 37840 0 0 {name=l30316 lab=BL15}
N 2960 37800 2940 37800 {}
C {lab_pin.sym} 2940 37800 0 0 {name=l30317 lab=BLB15}
N 2960 37760 2940 37760 {}
C {lab_pin.sym} 2940 37760 0 0 {name=l30318 lab=WL189}
N 3040 37840 3060 37840 {}
C {lab_pin.sym} 3060 37840 0 0 {name=l30319 lab=VDD}
N 3040 37760 3060 37760 {}
C {lab_pin.sym} 3060 37760 0 0 {name=l30320 lab=VSS}
C {bitcell_6t.sym} 3200 37800 0 0 {name=Xr189c16}
N 3160 37840 3140 37840 {}
C {lab_pin.sym} 3140 37840 0 0 {name=l30321 lab=BL16}
N 3160 37800 3140 37800 {}
C {lab_pin.sym} 3140 37800 0 0 {name=l30322 lab=BLB16}
N 3160 37760 3140 37760 {}
C {lab_pin.sym} 3140 37760 0 0 {name=l30323 lab=WL189}
N 3240 37840 3260 37840 {}
C {lab_pin.sym} 3260 37840 0 0 {name=l30324 lab=VDD}
N 3240 37760 3260 37760 {}
C {lab_pin.sym} 3260 37760 0 0 {name=l30325 lab=VSS}
C {bitcell_6t.sym} 3400 37800 0 0 {name=Xr189c17}
N 3360 37840 3340 37840 {}
C {lab_pin.sym} 3340 37840 0 0 {name=l30326 lab=BL17}
N 3360 37800 3340 37800 {}
C {lab_pin.sym} 3340 37800 0 0 {name=l30327 lab=BLB17}
N 3360 37760 3340 37760 {}
C {lab_pin.sym} 3340 37760 0 0 {name=l30328 lab=WL189}
N 3440 37840 3460 37840 {}
C {lab_pin.sym} 3460 37840 0 0 {name=l30329 lab=VDD}
N 3440 37760 3460 37760 {}
C {lab_pin.sym} 3460 37760 0 0 {name=l30330 lab=VSS}
C {bitcell_6t.sym} 3600 37800 0 0 {name=Xr189c18}
N 3560 37840 3540 37840 {}
C {lab_pin.sym} 3540 37840 0 0 {name=l30331 lab=BL18}
N 3560 37800 3540 37800 {}
C {lab_pin.sym} 3540 37800 0 0 {name=l30332 lab=BLB18}
N 3560 37760 3540 37760 {}
C {lab_pin.sym} 3540 37760 0 0 {name=l30333 lab=WL189}
N 3640 37840 3660 37840 {}
C {lab_pin.sym} 3660 37840 0 0 {name=l30334 lab=VDD}
N 3640 37760 3660 37760 {}
C {lab_pin.sym} 3660 37760 0 0 {name=l30335 lab=VSS}
C {bitcell_6t.sym} 3800 37800 0 0 {name=Xr189c19}
N 3760 37840 3740 37840 {}
C {lab_pin.sym} 3740 37840 0 0 {name=l30336 lab=BL19}
N 3760 37800 3740 37800 {}
C {lab_pin.sym} 3740 37800 0 0 {name=l30337 lab=BLB19}
N 3760 37760 3740 37760 {}
C {lab_pin.sym} 3740 37760 0 0 {name=l30338 lab=WL189}
N 3840 37840 3860 37840 {}
C {lab_pin.sym} 3860 37840 0 0 {name=l30339 lab=VDD}
N 3840 37760 3860 37760 {}
C {lab_pin.sym} 3860 37760 0 0 {name=l30340 lab=VSS}
C {bitcell_6t.sym} 4000 37800 0 0 {name=Xr189c20}
N 3960 37840 3940 37840 {}
C {lab_pin.sym} 3940 37840 0 0 {name=l30341 lab=BL20}
N 3960 37800 3940 37800 {}
C {lab_pin.sym} 3940 37800 0 0 {name=l30342 lab=BLB20}
N 3960 37760 3940 37760 {}
C {lab_pin.sym} 3940 37760 0 0 {name=l30343 lab=WL189}
N 4040 37840 4060 37840 {}
C {lab_pin.sym} 4060 37840 0 0 {name=l30344 lab=VDD}
N 4040 37760 4060 37760 {}
C {lab_pin.sym} 4060 37760 0 0 {name=l30345 lab=VSS}
C {bitcell_6t.sym} 4200 37800 0 0 {name=Xr189c21}
N 4160 37840 4140 37840 {}
C {lab_pin.sym} 4140 37840 0 0 {name=l30346 lab=BL21}
N 4160 37800 4140 37800 {}
C {lab_pin.sym} 4140 37800 0 0 {name=l30347 lab=BLB21}
N 4160 37760 4140 37760 {}
C {lab_pin.sym} 4140 37760 0 0 {name=l30348 lab=WL189}
N 4240 37840 4260 37840 {}
C {lab_pin.sym} 4260 37840 0 0 {name=l30349 lab=VDD}
N 4240 37760 4260 37760 {}
C {lab_pin.sym} 4260 37760 0 0 {name=l30350 lab=VSS}
C {bitcell_6t.sym} 4400 37800 0 0 {name=Xr189c22}
N 4360 37840 4340 37840 {}
C {lab_pin.sym} 4340 37840 0 0 {name=l30351 lab=BL22}
N 4360 37800 4340 37800 {}
C {lab_pin.sym} 4340 37800 0 0 {name=l30352 lab=BLB22}
N 4360 37760 4340 37760 {}
C {lab_pin.sym} 4340 37760 0 0 {name=l30353 lab=WL189}
N 4440 37840 4460 37840 {}
C {lab_pin.sym} 4460 37840 0 0 {name=l30354 lab=VDD}
N 4440 37760 4460 37760 {}
C {lab_pin.sym} 4460 37760 0 0 {name=l30355 lab=VSS}
C {bitcell_6t.sym} 4600 37800 0 0 {name=Xr189c23}
N 4560 37840 4540 37840 {}
C {lab_pin.sym} 4540 37840 0 0 {name=l30356 lab=BL23}
N 4560 37800 4540 37800 {}
C {lab_pin.sym} 4540 37800 0 0 {name=l30357 lab=BLB23}
N 4560 37760 4540 37760 {}
C {lab_pin.sym} 4540 37760 0 0 {name=l30358 lab=WL189}
N 4640 37840 4660 37840 {}
C {lab_pin.sym} 4660 37840 0 0 {name=l30359 lab=VDD}
N 4640 37760 4660 37760 {}
C {lab_pin.sym} 4660 37760 0 0 {name=l30360 lab=VSS}
C {bitcell_6t.sym} 4800 37800 0 0 {name=Xr189c24}
N 4760 37840 4740 37840 {}
C {lab_pin.sym} 4740 37840 0 0 {name=l30361 lab=BL24}
N 4760 37800 4740 37800 {}
C {lab_pin.sym} 4740 37800 0 0 {name=l30362 lab=BLB24}
N 4760 37760 4740 37760 {}
C {lab_pin.sym} 4740 37760 0 0 {name=l30363 lab=WL189}
N 4840 37840 4860 37840 {}
C {lab_pin.sym} 4860 37840 0 0 {name=l30364 lab=VDD}
N 4840 37760 4860 37760 {}
C {lab_pin.sym} 4860 37760 0 0 {name=l30365 lab=VSS}
C {bitcell_6t.sym} 5000 37800 0 0 {name=Xr189c25}
N 4960 37840 4940 37840 {}
C {lab_pin.sym} 4940 37840 0 0 {name=l30366 lab=BL25}
N 4960 37800 4940 37800 {}
C {lab_pin.sym} 4940 37800 0 0 {name=l30367 lab=BLB25}
N 4960 37760 4940 37760 {}
C {lab_pin.sym} 4940 37760 0 0 {name=l30368 lab=WL189}
N 5040 37840 5060 37840 {}
C {lab_pin.sym} 5060 37840 0 0 {name=l30369 lab=VDD}
N 5040 37760 5060 37760 {}
C {lab_pin.sym} 5060 37760 0 0 {name=l30370 lab=VSS}
C {bitcell_6t.sym} 5200 37800 0 0 {name=Xr189c26}
N 5160 37840 5140 37840 {}
C {lab_pin.sym} 5140 37840 0 0 {name=l30371 lab=BL26}
N 5160 37800 5140 37800 {}
C {lab_pin.sym} 5140 37800 0 0 {name=l30372 lab=BLB26}
N 5160 37760 5140 37760 {}
C {lab_pin.sym} 5140 37760 0 0 {name=l30373 lab=WL189}
N 5240 37840 5260 37840 {}
C {lab_pin.sym} 5260 37840 0 0 {name=l30374 lab=VDD}
N 5240 37760 5260 37760 {}
C {lab_pin.sym} 5260 37760 0 0 {name=l30375 lab=VSS}
C {bitcell_6t.sym} 5400 37800 0 0 {name=Xr189c27}
N 5360 37840 5340 37840 {}
C {lab_pin.sym} 5340 37840 0 0 {name=l30376 lab=BL27}
N 5360 37800 5340 37800 {}
C {lab_pin.sym} 5340 37800 0 0 {name=l30377 lab=BLB27}
N 5360 37760 5340 37760 {}
C {lab_pin.sym} 5340 37760 0 0 {name=l30378 lab=WL189}
N 5440 37840 5460 37840 {}
C {lab_pin.sym} 5460 37840 0 0 {name=l30379 lab=VDD}
N 5440 37760 5460 37760 {}
C {lab_pin.sym} 5460 37760 0 0 {name=l30380 lab=VSS}
C {bitcell_6t.sym} 5600 37800 0 0 {name=Xr189c28}
N 5560 37840 5540 37840 {}
C {lab_pin.sym} 5540 37840 0 0 {name=l30381 lab=BL28}
N 5560 37800 5540 37800 {}
C {lab_pin.sym} 5540 37800 0 0 {name=l30382 lab=BLB28}
N 5560 37760 5540 37760 {}
C {lab_pin.sym} 5540 37760 0 0 {name=l30383 lab=WL189}
N 5640 37840 5660 37840 {}
C {lab_pin.sym} 5660 37840 0 0 {name=l30384 lab=VDD}
N 5640 37760 5660 37760 {}
C {lab_pin.sym} 5660 37760 0 0 {name=l30385 lab=VSS}
C {bitcell_6t.sym} 5800 37800 0 0 {name=Xr189c29}
N 5760 37840 5740 37840 {}
C {lab_pin.sym} 5740 37840 0 0 {name=l30386 lab=BL29}
N 5760 37800 5740 37800 {}
C {lab_pin.sym} 5740 37800 0 0 {name=l30387 lab=BLB29}
N 5760 37760 5740 37760 {}
C {lab_pin.sym} 5740 37760 0 0 {name=l30388 lab=WL189}
N 5840 37840 5860 37840 {}
C {lab_pin.sym} 5860 37840 0 0 {name=l30389 lab=VDD}
N 5840 37760 5860 37760 {}
C {lab_pin.sym} 5860 37760 0 0 {name=l30390 lab=VSS}
C {bitcell_6t.sym} 6000 37800 0 0 {name=Xr189c30}
N 5960 37840 5940 37840 {}
C {lab_pin.sym} 5940 37840 0 0 {name=l30391 lab=BL30}
N 5960 37800 5940 37800 {}
C {lab_pin.sym} 5940 37800 0 0 {name=l30392 lab=BLB30}
N 5960 37760 5940 37760 {}
C {lab_pin.sym} 5940 37760 0 0 {name=l30393 lab=WL189}
N 6040 37840 6060 37840 {}
C {lab_pin.sym} 6060 37840 0 0 {name=l30394 lab=VDD}
N 6040 37760 6060 37760 {}
C {lab_pin.sym} 6060 37760 0 0 {name=l30395 lab=VSS}
C {bitcell_6t.sym} 6200 37800 0 0 {name=Xr189c31}
N 6160 37840 6140 37840 {}
C {lab_pin.sym} 6140 37840 0 0 {name=l30396 lab=BL31}
N 6160 37800 6140 37800 {}
C {lab_pin.sym} 6140 37800 0 0 {name=l30397 lab=BLB31}
N 6160 37760 6140 37760 {}
C {lab_pin.sym} 6140 37760 0 0 {name=l30398 lab=WL189}
N 6240 37840 6260 37840 {}
C {lab_pin.sym} 6260 37840 0 0 {name=l30399 lab=VDD}
N 6240 37760 6260 37760 {}
C {lab_pin.sym} 6260 37760 0 0 {name=l30400 lab=VSS}
C {bitcell_6t.sym} 0 38000 0 0 {name=Xr190c0}
N -40 38040 -60 38040 {}
C {lab_pin.sym} -60 38040 0 0 {name=l30401 lab=BL0}
N -40 38000 -60 38000 {}
C {lab_pin.sym} -60 38000 0 0 {name=l30402 lab=BLB0}
N -40 37960 -60 37960 {}
C {lab_pin.sym} -60 37960 0 0 {name=l30403 lab=WL190}
N 40 38040 60 38040 {}
C {lab_pin.sym} 60 38040 0 0 {name=l30404 lab=VDD}
N 40 37960 60 37960 {}
C {lab_pin.sym} 60 37960 0 0 {name=l30405 lab=VSS}
C {bitcell_6t.sym} 200 38000 0 0 {name=Xr190c1}
N 160 38040 140 38040 {}
C {lab_pin.sym} 140 38040 0 0 {name=l30406 lab=BL1}
N 160 38000 140 38000 {}
C {lab_pin.sym} 140 38000 0 0 {name=l30407 lab=BLB1}
N 160 37960 140 37960 {}
C {lab_pin.sym} 140 37960 0 0 {name=l30408 lab=WL190}
N 240 38040 260 38040 {}
C {lab_pin.sym} 260 38040 0 0 {name=l30409 lab=VDD}
N 240 37960 260 37960 {}
C {lab_pin.sym} 260 37960 0 0 {name=l30410 lab=VSS}
C {bitcell_6t.sym} 400 38000 0 0 {name=Xr190c2}
N 360 38040 340 38040 {}
C {lab_pin.sym} 340 38040 0 0 {name=l30411 lab=BL2}
N 360 38000 340 38000 {}
C {lab_pin.sym} 340 38000 0 0 {name=l30412 lab=BLB2}
N 360 37960 340 37960 {}
C {lab_pin.sym} 340 37960 0 0 {name=l30413 lab=WL190}
N 440 38040 460 38040 {}
C {lab_pin.sym} 460 38040 0 0 {name=l30414 lab=VDD}
N 440 37960 460 37960 {}
C {lab_pin.sym} 460 37960 0 0 {name=l30415 lab=VSS}
C {bitcell_6t.sym} 600 38000 0 0 {name=Xr190c3}
N 560 38040 540 38040 {}
C {lab_pin.sym} 540 38040 0 0 {name=l30416 lab=BL3}
N 560 38000 540 38000 {}
C {lab_pin.sym} 540 38000 0 0 {name=l30417 lab=BLB3}
N 560 37960 540 37960 {}
C {lab_pin.sym} 540 37960 0 0 {name=l30418 lab=WL190}
N 640 38040 660 38040 {}
C {lab_pin.sym} 660 38040 0 0 {name=l30419 lab=VDD}
N 640 37960 660 37960 {}
C {lab_pin.sym} 660 37960 0 0 {name=l30420 lab=VSS}
C {bitcell_6t.sym} 800 38000 0 0 {name=Xr190c4}
N 760 38040 740 38040 {}
C {lab_pin.sym} 740 38040 0 0 {name=l30421 lab=BL4}
N 760 38000 740 38000 {}
C {lab_pin.sym} 740 38000 0 0 {name=l30422 lab=BLB4}
N 760 37960 740 37960 {}
C {lab_pin.sym} 740 37960 0 0 {name=l30423 lab=WL190}
N 840 38040 860 38040 {}
C {lab_pin.sym} 860 38040 0 0 {name=l30424 lab=VDD}
N 840 37960 860 37960 {}
C {lab_pin.sym} 860 37960 0 0 {name=l30425 lab=VSS}
C {bitcell_6t.sym} 1000 38000 0 0 {name=Xr190c5}
N 960 38040 940 38040 {}
C {lab_pin.sym} 940 38040 0 0 {name=l30426 lab=BL5}
N 960 38000 940 38000 {}
C {lab_pin.sym} 940 38000 0 0 {name=l30427 lab=BLB5}
N 960 37960 940 37960 {}
C {lab_pin.sym} 940 37960 0 0 {name=l30428 lab=WL190}
N 1040 38040 1060 38040 {}
C {lab_pin.sym} 1060 38040 0 0 {name=l30429 lab=VDD}
N 1040 37960 1060 37960 {}
C {lab_pin.sym} 1060 37960 0 0 {name=l30430 lab=VSS}
C {bitcell_6t.sym} 1200 38000 0 0 {name=Xr190c6}
N 1160 38040 1140 38040 {}
C {lab_pin.sym} 1140 38040 0 0 {name=l30431 lab=BL6}
N 1160 38000 1140 38000 {}
C {lab_pin.sym} 1140 38000 0 0 {name=l30432 lab=BLB6}
N 1160 37960 1140 37960 {}
C {lab_pin.sym} 1140 37960 0 0 {name=l30433 lab=WL190}
N 1240 38040 1260 38040 {}
C {lab_pin.sym} 1260 38040 0 0 {name=l30434 lab=VDD}
N 1240 37960 1260 37960 {}
C {lab_pin.sym} 1260 37960 0 0 {name=l30435 lab=VSS}
C {bitcell_6t.sym} 1400 38000 0 0 {name=Xr190c7}
N 1360 38040 1340 38040 {}
C {lab_pin.sym} 1340 38040 0 0 {name=l30436 lab=BL7}
N 1360 38000 1340 38000 {}
C {lab_pin.sym} 1340 38000 0 0 {name=l30437 lab=BLB7}
N 1360 37960 1340 37960 {}
C {lab_pin.sym} 1340 37960 0 0 {name=l30438 lab=WL190}
N 1440 38040 1460 38040 {}
C {lab_pin.sym} 1460 38040 0 0 {name=l30439 lab=VDD}
N 1440 37960 1460 37960 {}
C {lab_pin.sym} 1460 37960 0 0 {name=l30440 lab=VSS}
C {bitcell_6t.sym} 1600 38000 0 0 {name=Xr190c8}
N 1560 38040 1540 38040 {}
C {lab_pin.sym} 1540 38040 0 0 {name=l30441 lab=BL8}
N 1560 38000 1540 38000 {}
C {lab_pin.sym} 1540 38000 0 0 {name=l30442 lab=BLB8}
N 1560 37960 1540 37960 {}
C {lab_pin.sym} 1540 37960 0 0 {name=l30443 lab=WL190}
N 1640 38040 1660 38040 {}
C {lab_pin.sym} 1660 38040 0 0 {name=l30444 lab=VDD}
N 1640 37960 1660 37960 {}
C {lab_pin.sym} 1660 37960 0 0 {name=l30445 lab=VSS}
C {bitcell_6t.sym} 1800 38000 0 0 {name=Xr190c9}
N 1760 38040 1740 38040 {}
C {lab_pin.sym} 1740 38040 0 0 {name=l30446 lab=BL9}
N 1760 38000 1740 38000 {}
C {lab_pin.sym} 1740 38000 0 0 {name=l30447 lab=BLB9}
N 1760 37960 1740 37960 {}
C {lab_pin.sym} 1740 37960 0 0 {name=l30448 lab=WL190}
N 1840 38040 1860 38040 {}
C {lab_pin.sym} 1860 38040 0 0 {name=l30449 lab=VDD}
N 1840 37960 1860 37960 {}
C {lab_pin.sym} 1860 37960 0 0 {name=l30450 lab=VSS}
C {bitcell_6t.sym} 2000 38000 0 0 {name=Xr190c10}
N 1960 38040 1940 38040 {}
C {lab_pin.sym} 1940 38040 0 0 {name=l30451 lab=BL10}
N 1960 38000 1940 38000 {}
C {lab_pin.sym} 1940 38000 0 0 {name=l30452 lab=BLB10}
N 1960 37960 1940 37960 {}
C {lab_pin.sym} 1940 37960 0 0 {name=l30453 lab=WL190}
N 2040 38040 2060 38040 {}
C {lab_pin.sym} 2060 38040 0 0 {name=l30454 lab=VDD}
N 2040 37960 2060 37960 {}
C {lab_pin.sym} 2060 37960 0 0 {name=l30455 lab=VSS}
C {bitcell_6t.sym} 2200 38000 0 0 {name=Xr190c11}
N 2160 38040 2140 38040 {}
C {lab_pin.sym} 2140 38040 0 0 {name=l30456 lab=BL11}
N 2160 38000 2140 38000 {}
C {lab_pin.sym} 2140 38000 0 0 {name=l30457 lab=BLB11}
N 2160 37960 2140 37960 {}
C {lab_pin.sym} 2140 37960 0 0 {name=l30458 lab=WL190}
N 2240 38040 2260 38040 {}
C {lab_pin.sym} 2260 38040 0 0 {name=l30459 lab=VDD}
N 2240 37960 2260 37960 {}
C {lab_pin.sym} 2260 37960 0 0 {name=l30460 lab=VSS}
C {bitcell_6t.sym} 2400 38000 0 0 {name=Xr190c12}
N 2360 38040 2340 38040 {}
C {lab_pin.sym} 2340 38040 0 0 {name=l30461 lab=BL12}
N 2360 38000 2340 38000 {}
C {lab_pin.sym} 2340 38000 0 0 {name=l30462 lab=BLB12}
N 2360 37960 2340 37960 {}
C {lab_pin.sym} 2340 37960 0 0 {name=l30463 lab=WL190}
N 2440 38040 2460 38040 {}
C {lab_pin.sym} 2460 38040 0 0 {name=l30464 lab=VDD}
N 2440 37960 2460 37960 {}
C {lab_pin.sym} 2460 37960 0 0 {name=l30465 lab=VSS}
C {bitcell_6t.sym} 2600 38000 0 0 {name=Xr190c13}
N 2560 38040 2540 38040 {}
C {lab_pin.sym} 2540 38040 0 0 {name=l30466 lab=BL13}
N 2560 38000 2540 38000 {}
C {lab_pin.sym} 2540 38000 0 0 {name=l30467 lab=BLB13}
N 2560 37960 2540 37960 {}
C {lab_pin.sym} 2540 37960 0 0 {name=l30468 lab=WL190}
N 2640 38040 2660 38040 {}
C {lab_pin.sym} 2660 38040 0 0 {name=l30469 lab=VDD}
N 2640 37960 2660 37960 {}
C {lab_pin.sym} 2660 37960 0 0 {name=l30470 lab=VSS}
C {bitcell_6t.sym} 2800 38000 0 0 {name=Xr190c14}
N 2760 38040 2740 38040 {}
C {lab_pin.sym} 2740 38040 0 0 {name=l30471 lab=BL14}
N 2760 38000 2740 38000 {}
C {lab_pin.sym} 2740 38000 0 0 {name=l30472 lab=BLB14}
N 2760 37960 2740 37960 {}
C {lab_pin.sym} 2740 37960 0 0 {name=l30473 lab=WL190}
N 2840 38040 2860 38040 {}
C {lab_pin.sym} 2860 38040 0 0 {name=l30474 lab=VDD}
N 2840 37960 2860 37960 {}
C {lab_pin.sym} 2860 37960 0 0 {name=l30475 lab=VSS}
C {bitcell_6t.sym} 3000 38000 0 0 {name=Xr190c15}
N 2960 38040 2940 38040 {}
C {lab_pin.sym} 2940 38040 0 0 {name=l30476 lab=BL15}
N 2960 38000 2940 38000 {}
C {lab_pin.sym} 2940 38000 0 0 {name=l30477 lab=BLB15}
N 2960 37960 2940 37960 {}
C {lab_pin.sym} 2940 37960 0 0 {name=l30478 lab=WL190}
N 3040 38040 3060 38040 {}
C {lab_pin.sym} 3060 38040 0 0 {name=l30479 lab=VDD}
N 3040 37960 3060 37960 {}
C {lab_pin.sym} 3060 37960 0 0 {name=l30480 lab=VSS}
C {bitcell_6t.sym} 3200 38000 0 0 {name=Xr190c16}
N 3160 38040 3140 38040 {}
C {lab_pin.sym} 3140 38040 0 0 {name=l30481 lab=BL16}
N 3160 38000 3140 38000 {}
C {lab_pin.sym} 3140 38000 0 0 {name=l30482 lab=BLB16}
N 3160 37960 3140 37960 {}
C {lab_pin.sym} 3140 37960 0 0 {name=l30483 lab=WL190}
N 3240 38040 3260 38040 {}
C {lab_pin.sym} 3260 38040 0 0 {name=l30484 lab=VDD}
N 3240 37960 3260 37960 {}
C {lab_pin.sym} 3260 37960 0 0 {name=l30485 lab=VSS}
C {bitcell_6t.sym} 3400 38000 0 0 {name=Xr190c17}
N 3360 38040 3340 38040 {}
C {lab_pin.sym} 3340 38040 0 0 {name=l30486 lab=BL17}
N 3360 38000 3340 38000 {}
C {lab_pin.sym} 3340 38000 0 0 {name=l30487 lab=BLB17}
N 3360 37960 3340 37960 {}
C {lab_pin.sym} 3340 37960 0 0 {name=l30488 lab=WL190}
N 3440 38040 3460 38040 {}
C {lab_pin.sym} 3460 38040 0 0 {name=l30489 lab=VDD}
N 3440 37960 3460 37960 {}
C {lab_pin.sym} 3460 37960 0 0 {name=l30490 lab=VSS}
C {bitcell_6t.sym} 3600 38000 0 0 {name=Xr190c18}
N 3560 38040 3540 38040 {}
C {lab_pin.sym} 3540 38040 0 0 {name=l30491 lab=BL18}
N 3560 38000 3540 38000 {}
C {lab_pin.sym} 3540 38000 0 0 {name=l30492 lab=BLB18}
N 3560 37960 3540 37960 {}
C {lab_pin.sym} 3540 37960 0 0 {name=l30493 lab=WL190}
N 3640 38040 3660 38040 {}
C {lab_pin.sym} 3660 38040 0 0 {name=l30494 lab=VDD}
N 3640 37960 3660 37960 {}
C {lab_pin.sym} 3660 37960 0 0 {name=l30495 lab=VSS}
C {bitcell_6t.sym} 3800 38000 0 0 {name=Xr190c19}
N 3760 38040 3740 38040 {}
C {lab_pin.sym} 3740 38040 0 0 {name=l30496 lab=BL19}
N 3760 38000 3740 38000 {}
C {lab_pin.sym} 3740 38000 0 0 {name=l30497 lab=BLB19}
N 3760 37960 3740 37960 {}
C {lab_pin.sym} 3740 37960 0 0 {name=l30498 lab=WL190}
N 3840 38040 3860 38040 {}
C {lab_pin.sym} 3860 38040 0 0 {name=l30499 lab=VDD}
N 3840 37960 3860 37960 {}
C {lab_pin.sym} 3860 37960 0 0 {name=l30500 lab=VSS}
C {bitcell_6t.sym} 4000 38000 0 0 {name=Xr190c20}
N 3960 38040 3940 38040 {}
C {lab_pin.sym} 3940 38040 0 0 {name=l30501 lab=BL20}
N 3960 38000 3940 38000 {}
C {lab_pin.sym} 3940 38000 0 0 {name=l30502 lab=BLB20}
N 3960 37960 3940 37960 {}
C {lab_pin.sym} 3940 37960 0 0 {name=l30503 lab=WL190}
N 4040 38040 4060 38040 {}
C {lab_pin.sym} 4060 38040 0 0 {name=l30504 lab=VDD}
N 4040 37960 4060 37960 {}
C {lab_pin.sym} 4060 37960 0 0 {name=l30505 lab=VSS}
C {bitcell_6t.sym} 4200 38000 0 0 {name=Xr190c21}
N 4160 38040 4140 38040 {}
C {lab_pin.sym} 4140 38040 0 0 {name=l30506 lab=BL21}
N 4160 38000 4140 38000 {}
C {lab_pin.sym} 4140 38000 0 0 {name=l30507 lab=BLB21}
N 4160 37960 4140 37960 {}
C {lab_pin.sym} 4140 37960 0 0 {name=l30508 lab=WL190}
N 4240 38040 4260 38040 {}
C {lab_pin.sym} 4260 38040 0 0 {name=l30509 lab=VDD}
N 4240 37960 4260 37960 {}
C {lab_pin.sym} 4260 37960 0 0 {name=l30510 lab=VSS}
C {bitcell_6t.sym} 4400 38000 0 0 {name=Xr190c22}
N 4360 38040 4340 38040 {}
C {lab_pin.sym} 4340 38040 0 0 {name=l30511 lab=BL22}
N 4360 38000 4340 38000 {}
C {lab_pin.sym} 4340 38000 0 0 {name=l30512 lab=BLB22}
N 4360 37960 4340 37960 {}
C {lab_pin.sym} 4340 37960 0 0 {name=l30513 lab=WL190}
N 4440 38040 4460 38040 {}
C {lab_pin.sym} 4460 38040 0 0 {name=l30514 lab=VDD}
N 4440 37960 4460 37960 {}
C {lab_pin.sym} 4460 37960 0 0 {name=l30515 lab=VSS}
C {bitcell_6t.sym} 4600 38000 0 0 {name=Xr190c23}
N 4560 38040 4540 38040 {}
C {lab_pin.sym} 4540 38040 0 0 {name=l30516 lab=BL23}
N 4560 38000 4540 38000 {}
C {lab_pin.sym} 4540 38000 0 0 {name=l30517 lab=BLB23}
N 4560 37960 4540 37960 {}
C {lab_pin.sym} 4540 37960 0 0 {name=l30518 lab=WL190}
N 4640 38040 4660 38040 {}
C {lab_pin.sym} 4660 38040 0 0 {name=l30519 lab=VDD}
N 4640 37960 4660 37960 {}
C {lab_pin.sym} 4660 37960 0 0 {name=l30520 lab=VSS}
C {bitcell_6t.sym} 4800 38000 0 0 {name=Xr190c24}
N 4760 38040 4740 38040 {}
C {lab_pin.sym} 4740 38040 0 0 {name=l30521 lab=BL24}
N 4760 38000 4740 38000 {}
C {lab_pin.sym} 4740 38000 0 0 {name=l30522 lab=BLB24}
N 4760 37960 4740 37960 {}
C {lab_pin.sym} 4740 37960 0 0 {name=l30523 lab=WL190}
N 4840 38040 4860 38040 {}
C {lab_pin.sym} 4860 38040 0 0 {name=l30524 lab=VDD}
N 4840 37960 4860 37960 {}
C {lab_pin.sym} 4860 37960 0 0 {name=l30525 lab=VSS}
C {bitcell_6t.sym} 5000 38000 0 0 {name=Xr190c25}
N 4960 38040 4940 38040 {}
C {lab_pin.sym} 4940 38040 0 0 {name=l30526 lab=BL25}
N 4960 38000 4940 38000 {}
C {lab_pin.sym} 4940 38000 0 0 {name=l30527 lab=BLB25}
N 4960 37960 4940 37960 {}
C {lab_pin.sym} 4940 37960 0 0 {name=l30528 lab=WL190}
N 5040 38040 5060 38040 {}
C {lab_pin.sym} 5060 38040 0 0 {name=l30529 lab=VDD}
N 5040 37960 5060 37960 {}
C {lab_pin.sym} 5060 37960 0 0 {name=l30530 lab=VSS}
C {bitcell_6t.sym} 5200 38000 0 0 {name=Xr190c26}
N 5160 38040 5140 38040 {}
C {lab_pin.sym} 5140 38040 0 0 {name=l30531 lab=BL26}
N 5160 38000 5140 38000 {}
C {lab_pin.sym} 5140 38000 0 0 {name=l30532 lab=BLB26}
N 5160 37960 5140 37960 {}
C {lab_pin.sym} 5140 37960 0 0 {name=l30533 lab=WL190}
N 5240 38040 5260 38040 {}
C {lab_pin.sym} 5260 38040 0 0 {name=l30534 lab=VDD}
N 5240 37960 5260 37960 {}
C {lab_pin.sym} 5260 37960 0 0 {name=l30535 lab=VSS}
C {bitcell_6t.sym} 5400 38000 0 0 {name=Xr190c27}
N 5360 38040 5340 38040 {}
C {lab_pin.sym} 5340 38040 0 0 {name=l30536 lab=BL27}
N 5360 38000 5340 38000 {}
C {lab_pin.sym} 5340 38000 0 0 {name=l30537 lab=BLB27}
N 5360 37960 5340 37960 {}
C {lab_pin.sym} 5340 37960 0 0 {name=l30538 lab=WL190}
N 5440 38040 5460 38040 {}
C {lab_pin.sym} 5460 38040 0 0 {name=l30539 lab=VDD}
N 5440 37960 5460 37960 {}
C {lab_pin.sym} 5460 37960 0 0 {name=l30540 lab=VSS}
C {bitcell_6t.sym} 5600 38000 0 0 {name=Xr190c28}
N 5560 38040 5540 38040 {}
C {lab_pin.sym} 5540 38040 0 0 {name=l30541 lab=BL28}
N 5560 38000 5540 38000 {}
C {lab_pin.sym} 5540 38000 0 0 {name=l30542 lab=BLB28}
N 5560 37960 5540 37960 {}
C {lab_pin.sym} 5540 37960 0 0 {name=l30543 lab=WL190}
N 5640 38040 5660 38040 {}
C {lab_pin.sym} 5660 38040 0 0 {name=l30544 lab=VDD}
N 5640 37960 5660 37960 {}
C {lab_pin.sym} 5660 37960 0 0 {name=l30545 lab=VSS}
C {bitcell_6t.sym} 5800 38000 0 0 {name=Xr190c29}
N 5760 38040 5740 38040 {}
C {lab_pin.sym} 5740 38040 0 0 {name=l30546 lab=BL29}
N 5760 38000 5740 38000 {}
C {lab_pin.sym} 5740 38000 0 0 {name=l30547 lab=BLB29}
N 5760 37960 5740 37960 {}
C {lab_pin.sym} 5740 37960 0 0 {name=l30548 lab=WL190}
N 5840 38040 5860 38040 {}
C {lab_pin.sym} 5860 38040 0 0 {name=l30549 lab=VDD}
N 5840 37960 5860 37960 {}
C {lab_pin.sym} 5860 37960 0 0 {name=l30550 lab=VSS}
C {bitcell_6t.sym} 6000 38000 0 0 {name=Xr190c30}
N 5960 38040 5940 38040 {}
C {lab_pin.sym} 5940 38040 0 0 {name=l30551 lab=BL30}
N 5960 38000 5940 38000 {}
C {lab_pin.sym} 5940 38000 0 0 {name=l30552 lab=BLB30}
N 5960 37960 5940 37960 {}
C {lab_pin.sym} 5940 37960 0 0 {name=l30553 lab=WL190}
N 6040 38040 6060 38040 {}
C {lab_pin.sym} 6060 38040 0 0 {name=l30554 lab=VDD}
N 6040 37960 6060 37960 {}
C {lab_pin.sym} 6060 37960 0 0 {name=l30555 lab=VSS}
C {bitcell_6t.sym} 6200 38000 0 0 {name=Xr190c31}
N 6160 38040 6140 38040 {}
C {lab_pin.sym} 6140 38040 0 0 {name=l30556 lab=BL31}
N 6160 38000 6140 38000 {}
C {lab_pin.sym} 6140 38000 0 0 {name=l30557 lab=BLB31}
N 6160 37960 6140 37960 {}
C {lab_pin.sym} 6140 37960 0 0 {name=l30558 lab=WL190}
N 6240 38040 6260 38040 {}
C {lab_pin.sym} 6260 38040 0 0 {name=l30559 lab=VDD}
N 6240 37960 6260 37960 {}
C {lab_pin.sym} 6260 37960 0 0 {name=l30560 lab=VSS}
C {bitcell_6t.sym} 0 38200 0 0 {name=Xr191c0}
N -40 38240 -60 38240 {}
C {lab_pin.sym} -60 38240 0 0 {name=l30561 lab=BL0}
N -40 38200 -60 38200 {}
C {lab_pin.sym} -60 38200 0 0 {name=l30562 lab=BLB0}
N -40 38160 -60 38160 {}
C {lab_pin.sym} -60 38160 0 0 {name=l30563 lab=WL191}
N 40 38240 60 38240 {}
C {lab_pin.sym} 60 38240 0 0 {name=l30564 lab=VDD}
N 40 38160 60 38160 {}
C {lab_pin.sym} 60 38160 0 0 {name=l30565 lab=VSS}
C {bitcell_6t.sym} 200 38200 0 0 {name=Xr191c1}
N 160 38240 140 38240 {}
C {lab_pin.sym} 140 38240 0 0 {name=l30566 lab=BL1}
N 160 38200 140 38200 {}
C {lab_pin.sym} 140 38200 0 0 {name=l30567 lab=BLB1}
N 160 38160 140 38160 {}
C {lab_pin.sym} 140 38160 0 0 {name=l30568 lab=WL191}
N 240 38240 260 38240 {}
C {lab_pin.sym} 260 38240 0 0 {name=l30569 lab=VDD}
N 240 38160 260 38160 {}
C {lab_pin.sym} 260 38160 0 0 {name=l30570 lab=VSS}
C {bitcell_6t.sym} 400 38200 0 0 {name=Xr191c2}
N 360 38240 340 38240 {}
C {lab_pin.sym} 340 38240 0 0 {name=l30571 lab=BL2}
N 360 38200 340 38200 {}
C {lab_pin.sym} 340 38200 0 0 {name=l30572 lab=BLB2}
N 360 38160 340 38160 {}
C {lab_pin.sym} 340 38160 0 0 {name=l30573 lab=WL191}
N 440 38240 460 38240 {}
C {lab_pin.sym} 460 38240 0 0 {name=l30574 lab=VDD}
N 440 38160 460 38160 {}
C {lab_pin.sym} 460 38160 0 0 {name=l30575 lab=VSS}
C {bitcell_6t.sym} 600 38200 0 0 {name=Xr191c3}
N 560 38240 540 38240 {}
C {lab_pin.sym} 540 38240 0 0 {name=l30576 lab=BL3}
N 560 38200 540 38200 {}
C {lab_pin.sym} 540 38200 0 0 {name=l30577 lab=BLB3}
N 560 38160 540 38160 {}
C {lab_pin.sym} 540 38160 0 0 {name=l30578 lab=WL191}
N 640 38240 660 38240 {}
C {lab_pin.sym} 660 38240 0 0 {name=l30579 lab=VDD}
N 640 38160 660 38160 {}
C {lab_pin.sym} 660 38160 0 0 {name=l30580 lab=VSS}
C {bitcell_6t.sym} 800 38200 0 0 {name=Xr191c4}
N 760 38240 740 38240 {}
C {lab_pin.sym} 740 38240 0 0 {name=l30581 lab=BL4}
N 760 38200 740 38200 {}
C {lab_pin.sym} 740 38200 0 0 {name=l30582 lab=BLB4}
N 760 38160 740 38160 {}
C {lab_pin.sym} 740 38160 0 0 {name=l30583 lab=WL191}
N 840 38240 860 38240 {}
C {lab_pin.sym} 860 38240 0 0 {name=l30584 lab=VDD}
N 840 38160 860 38160 {}
C {lab_pin.sym} 860 38160 0 0 {name=l30585 lab=VSS}
C {bitcell_6t.sym} 1000 38200 0 0 {name=Xr191c5}
N 960 38240 940 38240 {}
C {lab_pin.sym} 940 38240 0 0 {name=l30586 lab=BL5}
N 960 38200 940 38200 {}
C {lab_pin.sym} 940 38200 0 0 {name=l30587 lab=BLB5}
N 960 38160 940 38160 {}
C {lab_pin.sym} 940 38160 0 0 {name=l30588 lab=WL191}
N 1040 38240 1060 38240 {}
C {lab_pin.sym} 1060 38240 0 0 {name=l30589 lab=VDD}
N 1040 38160 1060 38160 {}
C {lab_pin.sym} 1060 38160 0 0 {name=l30590 lab=VSS}
C {bitcell_6t.sym} 1200 38200 0 0 {name=Xr191c6}
N 1160 38240 1140 38240 {}
C {lab_pin.sym} 1140 38240 0 0 {name=l30591 lab=BL6}
N 1160 38200 1140 38200 {}
C {lab_pin.sym} 1140 38200 0 0 {name=l30592 lab=BLB6}
N 1160 38160 1140 38160 {}
C {lab_pin.sym} 1140 38160 0 0 {name=l30593 lab=WL191}
N 1240 38240 1260 38240 {}
C {lab_pin.sym} 1260 38240 0 0 {name=l30594 lab=VDD}
N 1240 38160 1260 38160 {}
C {lab_pin.sym} 1260 38160 0 0 {name=l30595 lab=VSS}
C {bitcell_6t.sym} 1400 38200 0 0 {name=Xr191c7}
N 1360 38240 1340 38240 {}
C {lab_pin.sym} 1340 38240 0 0 {name=l30596 lab=BL7}
N 1360 38200 1340 38200 {}
C {lab_pin.sym} 1340 38200 0 0 {name=l30597 lab=BLB7}
N 1360 38160 1340 38160 {}
C {lab_pin.sym} 1340 38160 0 0 {name=l30598 lab=WL191}
N 1440 38240 1460 38240 {}
C {lab_pin.sym} 1460 38240 0 0 {name=l30599 lab=VDD}
N 1440 38160 1460 38160 {}
C {lab_pin.sym} 1460 38160 0 0 {name=l30600 lab=VSS}
C {bitcell_6t.sym} 1600 38200 0 0 {name=Xr191c8}
N 1560 38240 1540 38240 {}
C {lab_pin.sym} 1540 38240 0 0 {name=l30601 lab=BL8}
N 1560 38200 1540 38200 {}
C {lab_pin.sym} 1540 38200 0 0 {name=l30602 lab=BLB8}
N 1560 38160 1540 38160 {}
C {lab_pin.sym} 1540 38160 0 0 {name=l30603 lab=WL191}
N 1640 38240 1660 38240 {}
C {lab_pin.sym} 1660 38240 0 0 {name=l30604 lab=VDD}
N 1640 38160 1660 38160 {}
C {lab_pin.sym} 1660 38160 0 0 {name=l30605 lab=VSS}
C {bitcell_6t.sym} 1800 38200 0 0 {name=Xr191c9}
N 1760 38240 1740 38240 {}
C {lab_pin.sym} 1740 38240 0 0 {name=l30606 lab=BL9}
N 1760 38200 1740 38200 {}
C {lab_pin.sym} 1740 38200 0 0 {name=l30607 lab=BLB9}
N 1760 38160 1740 38160 {}
C {lab_pin.sym} 1740 38160 0 0 {name=l30608 lab=WL191}
N 1840 38240 1860 38240 {}
C {lab_pin.sym} 1860 38240 0 0 {name=l30609 lab=VDD}
N 1840 38160 1860 38160 {}
C {lab_pin.sym} 1860 38160 0 0 {name=l30610 lab=VSS}
C {bitcell_6t.sym} 2000 38200 0 0 {name=Xr191c10}
N 1960 38240 1940 38240 {}
C {lab_pin.sym} 1940 38240 0 0 {name=l30611 lab=BL10}
N 1960 38200 1940 38200 {}
C {lab_pin.sym} 1940 38200 0 0 {name=l30612 lab=BLB10}
N 1960 38160 1940 38160 {}
C {lab_pin.sym} 1940 38160 0 0 {name=l30613 lab=WL191}
N 2040 38240 2060 38240 {}
C {lab_pin.sym} 2060 38240 0 0 {name=l30614 lab=VDD}
N 2040 38160 2060 38160 {}
C {lab_pin.sym} 2060 38160 0 0 {name=l30615 lab=VSS}
C {bitcell_6t.sym} 2200 38200 0 0 {name=Xr191c11}
N 2160 38240 2140 38240 {}
C {lab_pin.sym} 2140 38240 0 0 {name=l30616 lab=BL11}
N 2160 38200 2140 38200 {}
C {lab_pin.sym} 2140 38200 0 0 {name=l30617 lab=BLB11}
N 2160 38160 2140 38160 {}
C {lab_pin.sym} 2140 38160 0 0 {name=l30618 lab=WL191}
N 2240 38240 2260 38240 {}
C {lab_pin.sym} 2260 38240 0 0 {name=l30619 lab=VDD}
N 2240 38160 2260 38160 {}
C {lab_pin.sym} 2260 38160 0 0 {name=l30620 lab=VSS}
C {bitcell_6t.sym} 2400 38200 0 0 {name=Xr191c12}
N 2360 38240 2340 38240 {}
C {lab_pin.sym} 2340 38240 0 0 {name=l30621 lab=BL12}
N 2360 38200 2340 38200 {}
C {lab_pin.sym} 2340 38200 0 0 {name=l30622 lab=BLB12}
N 2360 38160 2340 38160 {}
C {lab_pin.sym} 2340 38160 0 0 {name=l30623 lab=WL191}
N 2440 38240 2460 38240 {}
C {lab_pin.sym} 2460 38240 0 0 {name=l30624 lab=VDD}
N 2440 38160 2460 38160 {}
C {lab_pin.sym} 2460 38160 0 0 {name=l30625 lab=VSS}
C {bitcell_6t.sym} 2600 38200 0 0 {name=Xr191c13}
N 2560 38240 2540 38240 {}
C {lab_pin.sym} 2540 38240 0 0 {name=l30626 lab=BL13}
N 2560 38200 2540 38200 {}
C {lab_pin.sym} 2540 38200 0 0 {name=l30627 lab=BLB13}
N 2560 38160 2540 38160 {}
C {lab_pin.sym} 2540 38160 0 0 {name=l30628 lab=WL191}
N 2640 38240 2660 38240 {}
C {lab_pin.sym} 2660 38240 0 0 {name=l30629 lab=VDD}
N 2640 38160 2660 38160 {}
C {lab_pin.sym} 2660 38160 0 0 {name=l30630 lab=VSS}
C {bitcell_6t.sym} 2800 38200 0 0 {name=Xr191c14}
N 2760 38240 2740 38240 {}
C {lab_pin.sym} 2740 38240 0 0 {name=l30631 lab=BL14}
N 2760 38200 2740 38200 {}
C {lab_pin.sym} 2740 38200 0 0 {name=l30632 lab=BLB14}
N 2760 38160 2740 38160 {}
C {lab_pin.sym} 2740 38160 0 0 {name=l30633 lab=WL191}
N 2840 38240 2860 38240 {}
C {lab_pin.sym} 2860 38240 0 0 {name=l30634 lab=VDD}
N 2840 38160 2860 38160 {}
C {lab_pin.sym} 2860 38160 0 0 {name=l30635 lab=VSS}
C {bitcell_6t.sym} 3000 38200 0 0 {name=Xr191c15}
N 2960 38240 2940 38240 {}
C {lab_pin.sym} 2940 38240 0 0 {name=l30636 lab=BL15}
N 2960 38200 2940 38200 {}
C {lab_pin.sym} 2940 38200 0 0 {name=l30637 lab=BLB15}
N 2960 38160 2940 38160 {}
C {lab_pin.sym} 2940 38160 0 0 {name=l30638 lab=WL191}
N 3040 38240 3060 38240 {}
C {lab_pin.sym} 3060 38240 0 0 {name=l30639 lab=VDD}
N 3040 38160 3060 38160 {}
C {lab_pin.sym} 3060 38160 0 0 {name=l30640 lab=VSS}
C {bitcell_6t.sym} 3200 38200 0 0 {name=Xr191c16}
N 3160 38240 3140 38240 {}
C {lab_pin.sym} 3140 38240 0 0 {name=l30641 lab=BL16}
N 3160 38200 3140 38200 {}
C {lab_pin.sym} 3140 38200 0 0 {name=l30642 lab=BLB16}
N 3160 38160 3140 38160 {}
C {lab_pin.sym} 3140 38160 0 0 {name=l30643 lab=WL191}
N 3240 38240 3260 38240 {}
C {lab_pin.sym} 3260 38240 0 0 {name=l30644 lab=VDD}
N 3240 38160 3260 38160 {}
C {lab_pin.sym} 3260 38160 0 0 {name=l30645 lab=VSS}
C {bitcell_6t.sym} 3400 38200 0 0 {name=Xr191c17}
N 3360 38240 3340 38240 {}
C {lab_pin.sym} 3340 38240 0 0 {name=l30646 lab=BL17}
N 3360 38200 3340 38200 {}
C {lab_pin.sym} 3340 38200 0 0 {name=l30647 lab=BLB17}
N 3360 38160 3340 38160 {}
C {lab_pin.sym} 3340 38160 0 0 {name=l30648 lab=WL191}
N 3440 38240 3460 38240 {}
C {lab_pin.sym} 3460 38240 0 0 {name=l30649 lab=VDD}
N 3440 38160 3460 38160 {}
C {lab_pin.sym} 3460 38160 0 0 {name=l30650 lab=VSS}
C {bitcell_6t.sym} 3600 38200 0 0 {name=Xr191c18}
N 3560 38240 3540 38240 {}
C {lab_pin.sym} 3540 38240 0 0 {name=l30651 lab=BL18}
N 3560 38200 3540 38200 {}
C {lab_pin.sym} 3540 38200 0 0 {name=l30652 lab=BLB18}
N 3560 38160 3540 38160 {}
C {lab_pin.sym} 3540 38160 0 0 {name=l30653 lab=WL191}
N 3640 38240 3660 38240 {}
C {lab_pin.sym} 3660 38240 0 0 {name=l30654 lab=VDD}
N 3640 38160 3660 38160 {}
C {lab_pin.sym} 3660 38160 0 0 {name=l30655 lab=VSS}
C {bitcell_6t.sym} 3800 38200 0 0 {name=Xr191c19}
N 3760 38240 3740 38240 {}
C {lab_pin.sym} 3740 38240 0 0 {name=l30656 lab=BL19}
N 3760 38200 3740 38200 {}
C {lab_pin.sym} 3740 38200 0 0 {name=l30657 lab=BLB19}
N 3760 38160 3740 38160 {}
C {lab_pin.sym} 3740 38160 0 0 {name=l30658 lab=WL191}
N 3840 38240 3860 38240 {}
C {lab_pin.sym} 3860 38240 0 0 {name=l30659 lab=VDD}
N 3840 38160 3860 38160 {}
C {lab_pin.sym} 3860 38160 0 0 {name=l30660 lab=VSS}
C {bitcell_6t.sym} 4000 38200 0 0 {name=Xr191c20}
N 3960 38240 3940 38240 {}
C {lab_pin.sym} 3940 38240 0 0 {name=l30661 lab=BL20}
N 3960 38200 3940 38200 {}
C {lab_pin.sym} 3940 38200 0 0 {name=l30662 lab=BLB20}
N 3960 38160 3940 38160 {}
C {lab_pin.sym} 3940 38160 0 0 {name=l30663 lab=WL191}
N 4040 38240 4060 38240 {}
C {lab_pin.sym} 4060 38240 0 0 {name=l30664 lab=VDD}
N 4040 38160 4060 38160 {}
C {lab_pin.sym} 4060 38160 0 0 {name=l30665 lab=VSS}
C {bitcell_6t.sym} 4200 38200 0 0 {name=Xr191c21}
N 4160 38240 4140 38240 {}
C {lab_pin.sym} 4140 38240 0 0 {name=l30666 lab=BL21}
N 4160 38200 4140 38200 {}
C {lab_pin.sym} 4140 38200 0 0 {name=l30667 lab=BLB21}
N 4160 38160 4140 38160 {}
C {lab_pin.sym} 4140 38160 0 0 {name=l30668 lab=WL191}
N 4240 38240 4260 38240 {}
C {lab_pin.sym} 4260 38240 0 0 {name=l30669 lab=VDD}
N 4240 38160 4260 38160 {}
C {lab_pin.sym} 4260 38160 0 0 {name=l30670 lab=VSS}
C {bitcell_6t.sym} 4400 38200 0 0 {name=Xr191c22}
N 4360 38240 4340 38240 {}
C {lab_pin.sym} 4340 38240 0 0 {name=l30671 lab=BL22}
N 4360 38200 4340 38200 {}
C {lab_pin.sym} 4340 38200 0 0 {name=l30672 lab=BLB22}
N 4360 38160 4340 38160 {}
C {lab_pin.sym} 4340 38160 0 0 {name=l30673 lab=WL191}
N 4440 38240 4460 38240 {}
C {lab_pin.sym} 4460 38240 0 0 {name=l30674 lab=VDD}
N 4440 38160 4460 38160 {}
C {lab_pin.sym} 4460 38160 0 0 {name=l30675 lab=VSS}
C {bitcell_6t.sym} 4600 38200 0 0 {name=Xr191c23}
N 4560 38240 4540 38240 {}
C {lab_pin.sym} 4540 38240 0 0 {name=l30676 lab=BL23}
N 4560 38200 4540 38200 {}
C {lab_pin.sym} 4540 38200 0 0 {name=l30677 lab=BLB23}
N 4560 38160 4540 38160 {}
C {lab_pin.sym} 4540 38160 0 0 {name=l30678 lab=WL191}
N 4640 38240 4660 38240 {}
C {lab_pin.sym} 4660 38240 0 0 {name=l30679 lab=VDD}
N 4640 38160 4660 38160 {}
C {lab_pin.sym} 4660 38160 0 0 {name=l30680 lab=VSS}
C {bitcell_6t.sym} 4800 38200 0 0 {name=Xr191c24}
N 4760 38240 4740 38240 {}
C {lab_pin.sym} 4740 38240 0 0 {name=l30681 lab=BL24}
N 4760 38200 4740 38200 {}
C {lab_pin.sym} 4740 38200 0 0 {name=l30682 lab=BLB24}
N 4760 38160 4740 38160 {}
C {lab_pin.sym} 4740 38160 0 0 {name=l30683 lab=WL191}
N 4840 38240 4860 38240 {}
C {lab_pin.sym} 4860 38240 0 0 {name=l30684 lab=VDD}
N 4840 38160 4860 38160 {}
C {lab_pin.sym} 4860 38160 0 0 {name=l30685 lab=VSS}
C {bitcell_6t.sym} 5000 38200 0 0 {name=Xr191c25}
N 4960 38240 4940 38240 {}
C {lab_pin.sym} 4940 38240 0 0 {name=l30686 lab=BL25}
N 4960 38200 4940 38200 {}
C {lab_pin.sym} 4940 38200 0 0 {name=l30687 lab=BLB25}
N 4960 38160 4940 38160 {}
C {lab_pin.sym} 4940 38160 0 0 {name=l30688 lab=WL191}
N 5040 38240 5060 38240 {}
C {lab_pin.sym} 5060 38240 0 0 {name=l30689 lab=VDD}
N 5040 38160 5060 38160 {}
C {lab_pin.sym} 5060 38160 0 0 {name=l30690 lab=VSS}
C {bitcell_6t.sym} 5200 38200 0 0 {name=Xr191c26}
N 5160 38240 5140 38240 {}
C {lab_pin.sym} 5140 38240 0 0 {name=l30691 lab=BL26}
N 5160 38200 5140 38200 {}
C {lab_pin.sym} 5140 38200 0 0 {name=l30692 lab=BLB26}
N 5160 38160 5140 38160 {}
C {lab_pin.sym} 5140 38160 0 0 {name=l30693 lab=WL191}
N 5240 38240 5260 38240 {}
C {lab_pin.sym} 5260 38240 0 0 {name=l30694 lab=VDD}
N 5240 38160 5260 38160 {}
C {lab_pin.sym} 5260 38160 0 0 {name=l30695 lab=VSS}
C {bitcell_6t.sym} 5400 38200 0 0 {name=Xr191c27}
N 5360 38240 5340 38240 {}
C {lab_pin.sym} 5340 38240 0 0 {name=l30696 lab=BL27}
N 5360 38200 5340 38200 {}
C {lab_pin.sym} 5340 38200 0 0 {name=l30697 lab=BLB27}
N 5360 38160 5340 38160 {}
C {lab_pin.sym} 5340 38160 0 0 {name=l30698 lab=WL191}
N 5440 38240 5460 38240 {}
C {lab_pin.sym} 5460 38240 0 0 {name=l30699 lab=VDD}
N 5440 38160 5460 38160 {}
C {lab_pin.sym} 5460 38160 0 0 {name=l30700 lab=VSS}
C {bitcell_6t.sym} 5600 38200 0 0 {name=Xr191c28}
N 5560 38240 5540 38240 {}
C {lab_pin.sym} 5540 38240 0 0 {name=l30701 lab=BL28}
N 5560 38200 5540 38200 {}
C {lab_pin.sym} 5540 38200 0 0 {name=l30702 lab=BLB28}
N 5560 38160 5540 38160 {}
C {lab_pin.sym} 5540 38160 0 0 {name=l30703 lab=WL191}
N 5640 38240 5660 38240 {}
C {lab_pin.sym} 5660 38240 0 0 {name=l30704 lab=VDD}
N 5640 38160 5660 38160 {}
C {lab_pin.sym} 5660 38160 0 0 {name=l30705 lab=VSS}
C {bitcell_6t.sym} 5800 38200 0 0 {name=Xr191c29}
N 5760 38240 5740 38240 {}
C {lab_pin.sym} 5740 38240 0 0 {name=l30706 lab=BL29}
N 5760 38200 5740 38200 {}
C {lab_pin.sym} 5740 38200 0 0 {name=l30707 lab=BLB29}
N 5760 38160 5740 38160 {}
C {lab_pin.sym} 5740 38160 0 0 {name=l30708 lab=WL191}
N 5840 38240 5860 38240 {}
C {lab_pin.sym} 5860 38240 0 0 {name=l30709 lab=VDD}
N 5840 38160 5860 38160 {}
C {lab_pin.sym} 5860 38160 0 0 {name=l30710 lab=VSS}
C {bitcell_6t.sym} 6000 38200 0 0 {name=Xr191c30}
N 5960 38240 5940 38240 {}
C {lab_pin.sym} 5940 38240 0 0 {name=l30711 lab=BL30}
N 5960 38200 5940 38200 {}
C {lab_pin.sym} 5940 38200 0 0 {name=l30712 lab=BLB30}
N 5960 38160 5940 38160 {}
C {lab_pin.sym} 5940 38160 0 0 {name=l30713 lab=WL191}
N 6040 38240 6060 38240 {}
C {lab_pin.sym} 6060 38240 0 0 {name=l30714 lab=VDD}
N 6040 38160 6060 38160 {}
C {lab_pin.sym} 6060 38160 0 0 {name=l30715 lab=VSS}
C {bitcell_6t.sym} 6200 38200 0 0 {name=Xr191c31}
N 6160 38240 6140 38240 {}
C {lab_pin.sym} 6140 38240 0 0 {name=l30716 lab=BL31}
N 6160 38200 6140 38200 {}
C {lab_pin.sym} 6140 38200 0 0 {name=l30717 lab=BLB31}
N 6160 38160 6140 38160 {}
C {lab_pin.sym} 6140 38160 0 0 {name=l30718 lab=WL191}
N 6240 38240 6260 38240 {}
C {lab_pin.sym} 6260 38240 0 0 {name=l30719 lab=VDD}
N 6240 38160 6260 38160 {}
C {lab_pin.sym} 6260 38160 0 0 {name=l30720 lab=VSS}
C {bitcell_6t.sym} 0 38400 0 0 {name=Xr192c0}
N -40 38440 -60 38440 {}
C {lab_pin.sym} -60 38440 0 0 {name=l30721 lab=BL0}
N -40 38400 -60 38400 {}
C {lab_pin.sym} -60 38400 0 0 {name=l30722 lab=BLB0}
N -40 38360 -60 38360 {}
C {lab_pin.sym} -60 38360 0 0 {name=l30723 lab=WL192}
N 40 38440 60 38440 {}
C {lab_pin.sym} 60 38440 0 0 {name=l30724 lab=VDD}
N 40 38360 60 38360 {}
C {lab_pin.sym} 60 38360 0 0 {name=l30725 lab=VSS}
C {bitcell_6t.sym} 200 38400 0 0 {name=Xr192c1}
N 160 38440 140 38440 {}
C {lab_pin.sym} 140 38440 0 0 {name=l30726 lab=BL1}
N 160 38400 140 38400 {}
C {lab_pin.sym} 140 38400 0 0 {name=l30727 lab=BLB1}
N 160 38360 140 38360 {}
C {lab_pin.sym} 140 38360 0 0 {name=l30728 lab=WL192}
N 240 38440 260 38440 {}
C {lab_pin.sym} 260 38440 0 0 {name=l30729 lab=VDD}
N 240 38360 260 38360 {}
C {lab_pin.sym} 260 38360 0 0 {name=l30730 lab=VSS}
C {bitcell_6t.sym} 400 38400 0 0 {name=Xr192c2}
N 360 38440 340 38440 {}
C {lab_pin.sym} 340 38440 0 0 {name=l30731 lab=BL2}
N 360 38400 340 38400 {}
C {lab_pin.sym} 340 38400 0 0 {name=l30732 lab=BLB2}
N 360 38360 340 38360 {}
C {lab_pin.sym} 340 38360 0 0 {name=l30733 lab=WL192}
N 440 38440 460 38440 {}
C {lab_pin.sym} 460 38440 0 0 {name=l30734 lab=VDD}
N 440 38360 460 38360 {}
C {lab_pin.sym} 460 38360 0 0 {name=l30735 lab=VSS}
C {bitcell_6t.sym} 600 38400 0 0 {name=Xr192c3}
N 560 38440 540 38440 {}
C {lab_pin.sym} 540 38440 0 0 {name=l30736 lab=BL3}
N 560 38400 540 38400 {}
C {lab_pin.sym} 540 38400 0 0 {name=l30737 lab=BLB3}
N 560 38360 540 38360 {}
C {lab_pin.sym} 540 38360 0 0 {name=l30738 lab=WL192}
N 640 38440 660 38440 {}
C {lab_pin.sym} 660 38440 0 0 {name=l30739 lab=VDD}
N 640 38360 660 38360 {}
C {lab_pin.sym} 660 38360 0 0 {name=l30740 lab=VSS}
C {bitcell_6t.sym} 800 38400 0 0 {name=Xr192c4}
N 760 38440 740 38440 {}
C {lab_pin.sym} 740 38440 0 0 {name=l30741 lab=BL4}
N 760 38400 740 38400 {}
C {lab_pin.sym} 740 38400 0 0 {name=l30742 lab=BLB4}
N 760 38360 740 38360 {}
C {lab_pin.sym} 740 38360 0 0 {name=l30743 lab=WL192}
N 840 38440 860 38440 {}
C {lab_pin.sym} 860 38440 0 0 {name=l30744 lab=VDD}
N 840 38360 860 38360 {}
C {lab_pin.sym} 860 38360 0 0 {name=l30745 lab=VSS}
C {bitcell_6t.sym} 1000 38400 0 0 {name=Xr192c5}
N 960 38440 940 38440 {}
C {lab_pin.sym} 940 38440 0 0 {name=l30746 lab=BL5}
N 960 38400 940 38400 {}
C {lab_pin.sym} 940 38400 0 0 {name=l30747 lab=BLB5}
N 960 38360 940 38360 {}
C {lab_pin.sym} 940 38360 0 0 {name=l30748 lab=WL192}
N 1040 38440 1060 38440 {}
C {lab_pin.sym} 1060 38440 0 0 {name=l30749 lab=VDD}
N 1040 38360 1060 38360 {}
C {lab_pin.sym} 1060 38360 0 0 {name=l30750 lab=VSS}
C {bitcell_6t.sym} 1200 38400 0 0 {name=Xr192c6}
N 1160 38440 1140 38440 {}
C {lab_pin.sym} 1140 38440 0 0 {name=l30751 lab=BL6}
N 1160 38400 1140 38400 {}
C {lab_pin.sym} 1140 38400 0 0 {name=l30752 lab=BLB6}
N 1160 38360 1140 38360 {}
C {lab_pin.sym} 1140 38360 0 0 {name=l30753 lab=WL192}
N 1240 38440 1260 38440 {}
C {lab_pin.sym} 1260 38440 0 0 {name=l30754 lab=VDD}
N 1240 38360 1260 38360 {}
C {lab_pin.sym} 1260 38360 0 0 {name=l30755 lab=VSS}
C {bitcell_6t.sym} 1400 38400 0 0 {name=Xr192c7}
N 1360 38440 1340 38440 {}
C {lab_pin.sym} 1340 38440 0 0 {name=l30756 lab=BL7}
N 1360 38400 1340 38400 {}
C {lab_pin.sym} 1340 38400 0 0 {name=l30757 lab=BLB7}
N 1360 38360 1340 38360 {}
C {lab_pin.sym} 1340 38360 0 0 {name=l30758 lab=WL192}
N 1440 38440 1460 38440 {}
C {lab_pin.sym} 1460 38440 0 0 {name=l30759 lab=VDD}
N 1440 38360 1460 38360 {}
C {lab_pin.sym} 1460 38360 0 0 {name=l30760 lab=VSS}
C {bitcell_6t.sym} 1600 38400 0 0 {name=Xr192c8}
N 1560 38440 1540 38440 {}
C {lab_pin.sym} 1540 38440 0 0 {name=l30761 lab=BL8}
N 1560 38400 1540 38400 {}
C {lab_pin.sym} 1540 38400 0 0 {name=l30762 lab=BLB8}
N 1560 38360 1540 38360 {}
C {lab_pin.sym} 1540 38360 0 0 {name=l30763 lab=WL192}
N 1640 38440 1660 38440 {}
C {lab_pin.sym} 1660 38440 0 0 {name=l30764 lab=VDD}
N 1640 38360 1660 38360 {}
C {lab_pin.sym} 1660 38360 0 0 {name=l30765 lab=VSS}
C {bitcell_6t.sym} 1800 38400 0 0 {name=Xr192c9}
N 1760 38440 1740 38440 {}
C {lab_pin.sym} 1740 38440 0 0 {name=l30766 lab=BL9}
N 1760 38400 1740 38400 {}
C {lab_pin.sym} 1740 38400 0 0 {name=l30767 lab=BLB9}
N 1760 38360 1740 38360 {}
C {lab_pin.sym} 1740 38360 0 0 {name=l30768 lab=WL192}
N 1840 38440 1860 38440 {}
C {lab_pin.sym} 1860 38440 0 0 {name=l30769 lab=VDD}
N 1840 38360 1860 38360 {}
C {lab_pin.sym} 1860 38360 0 0 {name=l30770 lab=VSS}
C {bitcell_6t.sym} 2000 38400 0 0 {name=Xr192c10}
N 1960 38440 1940 38440 {}
C {lab_pin.sym} 1940 38440 0 0 {name=l30771 lab=BL10}
N 1960 38400 1940 38400 {}
C {lab_pin.sym} 1940 38400 0 0 {name=l30772 lab=BLB10}
N 1960 38360 1940 38360 {}
C {lab_pin.sym} 1940 38360 0 0 {name=l30773 lab=WL192}
N 2040 38440 2060 38440 {}
C {lab_pin.sym} 2060 38440 0 0 {name=l30774 lab=VDD}
N 2040 38360 2060 38360 {}
C {lab_pin.sym} 2060 38360 0 0 {name=l30775 lab=VSS}
C {bitcell_6t.sym} 2200 38400 0 0 {name=Xr192c11}
N 2160 38440 2140 38440 {}
C {lab_pin.sym} 2140 38440 0 0 {name=l30776 lab=BL11}
N 2160 38400 2140 38400 {}
C {lab_pin.sym} 2140 38400 0 0 {name=l30777 lab=BLB11}
N 2160 38360 2140 38360 {}
C {lab_pin.sym} 2140 38360 0 0 {name=l30778 lab=WL192}
N 2240 38440 2260 38440 {}
C {lab_pin.sym} 2260 38440 0 0 {name=l30779 lab=VDD}
N 2240 38360 2260 38360 {}
C {lab_pin.sym} 2260 38360 0 0 {name=l30780 lab=VSS}
C {bitcell_6t.sym} 2400 38400 0 0 {name=Xr192c12}
N 2360 38440 2340 38440 {}
C {lab_pin.sym} 2340 38440 0 0 {name=l30781 lab=BL12}
N 2360 38400 2340 38400 {}
C {lab_pin.sym} 2340 38400 0 0 {name=l30782 lab=BLB12}
N 2360 38360 2340 38360 {}
C {lab_pin.sym} 2340 38360 0 0 {name=l30783 lab=WL192}
N 2440 38440 2460 38440 {}
C {lab_pin.sym} 2460 38440 0 0 {name=l30784 lab=VDD}
N 2440 38360 2460 38360 {}
C {lab_pin.sym} 2460 38360 0 0 {name=l30785 lab=VSS}
C {bitcell_6t.sym} 2600 38400 0 0 {name=Xr192c13}
N 2560 38440 2540 38440 {}
C {lab_pin.sym} 2540 38440 0 0 {name=l30786 lab=BL13}
N 2560 38400 2540 38400 {}
C {lab_pin.sym} 2540 38400 0 0 {name=l30787 lab=BLB13}
N 2560 38360 2540 38360 {}
C {lab_pin.sym} 2540 38360 0 0 {name=l30788 lab=WL192}
N 2640 38440 2660 38440 {}
C {lab_pin.sym} 2660 38440 0 0 {name=l30789 lab=VDD}
N 2640 38360 2660 38360 {}
C {lab_pin.sym} 2660 38360 0 0 {name=l30790 lab=VSS}
C {bitcell_6t.sym} 2800 38400 0 0 {name=Xr192c14}
N 2760 38440 2740 38440 {}
C {lab_pin.sym} 2740 38440 0 0 {name=l30791 lab=BL14}
N 2760 38400 2740 38400 {}
C {lab_pin.sym} 2740 38400 0 0 {name=l30792 lab=BLB14}
N 2760 38360 2740 38360 {}
C {lab_pin.sym} 2740 38360 0 0 {name=l30793 lab=WL192}
N 2840 38440 2860 38440 {}
C {lab_pin.sym} 2860 38440 0 0 {name=l30794 lab=VDD}
N 2840 38360 2860 38360 {}
C {lab_pin.sym} 2860 38360 0 0 {name=l30795 lab=VSS}
C {bitcell_6t.sym} 3000 38400 0 0 {name=Xr192c15}
N 2960 38440 2940 38440 {}
C {lab_pin.sym} 2940 38440 0 0 {name=l30796 lab=BL15}
N 2960 38400 2940 38400 {}
C {lab_pin.sym} 2940 38400 0 0 {name=l30797 lab=BLB15}
N 2960 38360 2940 38360 {}
C {lab_pin.sym} 2940 38360 0 0 {name=l30798 lab=WL192}
N 3040 38440 3060 38440 {}
C {lab_pin.sym} 3060 38440 0 0 {name=l30799 lab=VDD}
N 3040 38360 3060 38360 {}
C {lab_pin.sym} 3060 38360 0 0 {name=l30800 lab=VSS}
C {bitcell_6t.sym} 3200 38400 0 0 {name=Xr192c16}
N 3160 38440 3140 38440 {}
C {lab_pin.sym} 3140 38440 0 0 {name=l30801 lab=BL16}
N 3160 38400 3140 38400 {}
C {lab_pin.sym} 3140 38400 0 0 {name=l30802 lab=BLB16}
N 3160 38360 3140 38360 {}
C {lab_pin.sym} 3140 38360 0 0 {name=l30803 lab=WL192}
N 3240 38440 3260 38440 {}
C {lab_pin.sym} 3260 38440 0 0 {name=l30804 lab=VDD}
N 3240 38360 3260 38360 {}
C {lab_pin.sym} 3260 38360 0 0 {name=l30805 lab=VSS}
C {bitcell_6t.sym} 3400 38400 0 0 {name=Xr192c17}
N 3360 38440 3340 38440 {}
C {lab_pin.sym} 3340 38440 0 0 {name=l30806 lab=BL17}
N 3360 38400 3340 38400 {}
C {lab_pin.sym} 3340 38400 0 0 {name=l30807 lab=BLB17}
N 3360 38360 3340 38360 {}
C {lab_pin.sym} 3340 38360 0 0 {name=l30808 lab=WL192}
N 3440 38440 3460 38440 {}
C {lab_pin.sym} 3460 38440 0 0 {name=l30809 lab=VDD}
N 3440 38360 3460 38360 {}
C {lab_pin.sym} 3460 38360 0 0 {name=l30810 lab=VSS}
C {bitcell_6t.sym} 3600 38400 0 0 {name=Xr192c18}
N 3560 38440 3540 38440 {}
C {lab_pin.sym} 3540 38440 0 0 {name=l30811 lab=BL18}
N 3560 38400 3540 38400 {}
C {lab_pin.sym} 3540 38400 0 0 {name=l30812 lab=BLB18}
N 3560 38360 3540 38360 {}
C {lab_pin.sym} 3540 38360 0 0 {name=l30813 lab=WL192}
N 3640 38440 3660 38440 {}
C {lab_pin.sym} 3660 38440 0 0 {name=l30814 lab=VDD}
N 3640 38360 3660 38360 {}
C {lab_pin.sym} 3660 38360 0 0 {name=l30815 lab=VSS}
C {bitcell_6t.sym} 3800 38400 0 0 {name=Xr192c19}
N 3760 38440 3740 38440 {}
C {lab_pin.sym} 3740 38440 0 0 {name=l30816 lab=BL19}
N 3760 38400 3740 38400 {}
C {lab_pin.sym} 3740 38400 0 0 {name=l30817 lab=BLB19}
N 3760 38360 3740 38360 {}
C {lab_pin.sym} 3740 38360 0 0 {name=l30818 lab=WL192}
N 3840 38440 3860 38440 {}
C {lab_pin.sym} 3860 38440 0 0 {name=l30819 lab=VDD}
N 3840 38360 3860 38360 {}
C {lab_pin.sym} 3860 38360 0 0 {name=l30820 lab=VSS}
C {bitcell_6t.sym} 4000 38400 0 0 {name=Xr192c20}
N 3960 38440 3940 38440 {}
C {lab_pin.sym} 3940 38440 0 0 {name=l30821 lab=BL20}
N 3960 38400 3940 38400 {}
C {lab_pin.sym} 3940 38400 0 0 {name=l30822 lab=BLB20}
N 3960 38360 3940 38360 {}
C {lab_pin.sym} 3940 38360 0 0 {name=l30823 lab=WL192}
N 4040 38440 4060 38440 {}
C {lab_pin.sym} 4060 38440 0 0 {name=l30824 lab=VDD}
N 4040 38360 4060 38360 {}
C {lab_pin.sym} 4060 38360 0 0 {name=l30825 lab=VSS}
C {bitcell_6t.sym} 4200 38400 0 0 {name=Xr192c21}
N 4160 38440 4140 38440 {}
C {lab_pin.sym} 4140 38440 0 0 {name=l30826 lab=BL21}
N 4160 38400 4140 38400 {}
C {lab_pin.sym} 4140 38400 0 0 {name=l30827 lab=BLB21}
N 4160 38360 4140 38360 {}
C {lab_pin.sym} 4140 38360 0 0 {name=l30828 lab=WL192}
N 4240 38440 4260 38440 {}
C {lab_pin.sym} 4260 38440 0 0 {name=l30829 lab=VDD}
N 4240 38360 4260 38360 {}
C {lab_pin.sym} 4260 38360 0 0 {name=l30830 lab=VSS}
C {bitcell_6t.sym} 4400 38400 0 0 {name=Xr192c22}
N 4360 38440 4340 38440 {}
C {lab_pin.sym} 4340 38440 0 0 {name=l30831 lab=BL22}
N 4360 38400 4340 38400 {}
C {lab_pin.sym} 4340 38400 0 0 {name=l30832 lab=BLB22}
N 4360 38360 4340 38360 {}
C {lab_pin.sym} 4340 38360 0 0 {name=l30833 lab=WL192}
N 4440 38440 4460 38440 {}
C {lab_pin.sym} 4460 38440 0 0 {name=l30834 lab=VDD}
N 4440 38360 4460 38360 {}
C {lab_pin.sym} 4460 38360 0 0 {name=l30835 lab=VSS}
C {bitcell_6t.sym} 4600 38400 0 0 {name=Xr192c23}
N 4560 38440 4540 38440 {}
C {lab_pin.sym} 4540 38440 0 0 {name=l30836 lab=BL23}
N 4560 38400 4540 38400 {}
C {lab_pin.sym} 4540 38400 0 0 {name=l30837 lab=BLB23}
N 4560 38360 4540 38360 {}
C {lab_pin.sym} 4540 38360 0 0 {name=l30838 lab=WL192}
N 4640 38440 4660 38440 {}
C {lab_pin.sym} 4660 38440 0 0 {name=l30839 lab=VDD}
N 4640 38360 4660 38360 {}
C {lab_pin.sym} 4660 38360 0 0 {name=l30840 lab=VSS}
C {bitcell_6t.sym} 4800 38400 0 0 {name=Xr192c24}
N 4760 38440 4740 38440 {}
C {lab_pin.sym} 4740 38440 0 0 {name=l30841 lab=BL24}
N 4760 38400 4740 38400 {}
C {lab_pin.sym} 4740 38400 0 0 {name=l30842 lab=BLB24}
N 4760 38360 4740 38360 {}
C {lab_pin.sym} 4740 38360 0 0 {name=l30843 lab=WL192}
N 4840 38440 4860 38440 {}
C {lab_pin.sym} 4860 38440 0 0 {name=l30844 lab=VDD}
N 4840 38360 4860 38360 {}
C {lab_pin.sym} 4860 38360 0 0 {name=l30845 lab=VSS}
C {bitcell_6t.sym} 5000 38400 0 0 {name=Xr192c25}
N 4960 38440 4940 38440 {}
C {lab_pin.sym} 4940 38440 0 0 {name=l30846 lab=BL25}
N 4960 38400 4940 38400 {}
C {lab_pin.sym} 4940 38400 0 0 {name=l30847 lab=BLB25}
N 4960 38360 4940 38360 {}
C {lab_pin.sym} 4940 38360 0 0 {name=l30848 lab=WL192}
N 5040 38440 5060 38440 {}
C {lab_pin.sym} 5060 38440 0 0 {name=l30849 lab=VDD}
N 5040 38360 5060 38360 {}
C {lab_pin.sym} 5060 38360 0 0 {name=l30850 lab=VSS}
C {bitcell_6t.sym} 5200 38400 0 0 {name=Xr192c26}
N 5160 38440 5140 38440 {}
C {lab_pin.sym} 5140 38440 0 0 {name=l30851 lab=BL26}
N 5160 38400 5140 38400 {}
C {lab_pin.sym} 5140 38400 0 0 {name=l30852 lab=BLB26}
N 5160 38360 5140 38360 {}
C {lab_pin.sym} 5140 38360 0 0 {name=l30853 lab=WL192}
N 5240 38440 5260 38440 {}
C {lab_pin.sym} 5260 38440 0 0 {name=l30854 lab=VDD}
N 5240 38360 5260 38360 {}
C {lab_pin.sym} 5260 38360 0 0 {name=l30855 lab=VSS}
C {bitcell_6t.sym} 5400 38400 0 0 {name=Xr192c27}
N 5360 38440 5340 38440 {}
C {lab_pin.sym} 5340 38440 0 0 {name=l30856 lab=BL27}
N 5360 38400 5340 38400 {}
C {lab_pin.sym} 5340 38400 0 0 {name=l30857 lab=BLB27}
N 5360 38360 5340 38360 {}
C {lab_pin.sym} 5340 38360 0 0 {name=l30858 lab=WL192}
N 5440 38440 5460 38440 {}
C {lab_pin.sym} 5460 38440 0 0 {name=l30859 lab=VDD}
N 5440 38360 5460 38360 {}
C {lab_pin.sym} 5460 38360 0 0 {name=l30860 lab=VSS}
C {bitcell_6t.sym} 5600 38400 0 0 {name=Xr192c28}
N 5560 38440 5540 38440 {}
C {lab_pin.sym} 5540 38440 0 0 {name=l30861 lab=BL28}
N 5560 38400 5540 38400 {}
C {lab_pin.sym} 5540 38400 0 0 {name=l30862 lab=BLB28}
N 5560 38360 5540 38360 {}
C {lab_pin.sym} 5540 38360 0 0 {name=l30863 lab=WL192}
N 5640 38440 5660 38440 {}
C {lab_pin.sym} 5660 38440 0 0 {name=l30864 lab=VDD}
N 5640 38360 5660 38360 {}
C {lab_pin.sym} 5660 38360 0 0 {name=l30865 lab=VSS}
C {bitcell_6t.sym} 5800 38400 0 0 {name=Xr192c29}
N 5760 38440 5740 38440 {}
C {lab_pin.sym} 5740 38440 0 0 {name=l30866 lab=BL29}
N 5760 38400 5740 38400 {}
C {lab_pin.sym} 5740 38400 0 0 {name=l30867 lab=BLB29}
N 5760 38360 5740 38360 {}
C {lab_pin.sym} 5740 38360 0 0 {name=l30868 lab=WL192}
N 5840 38440 5860 38440 {}
C {lab_pin.sym} 5860 38440 0 0 {name=l30869 lab=VDD}
N 5840 38360 5860 38360 {}
C {lab_pin.sym} 5860 38360 0 0 {name=l30870 lab=VSS}
C {bitcell_6t.sym} 6000 38400 0 0 {name=Xr192c30}
N 5960 38440 5940 38440 {}
C {lab_pin.sym} 5940 38440 0 0 {name=l30871 lab=BL30}
N 5960 38400 5940 38400 {}
C {lab_pin.sym} 5940 38400 0 0 {name=l30872 lab=BLB30}
N 5960 38360 5940 38360 {}
C {lab_pin.sym} 5940 38360 0 0 {name=l30873 lab=WL192}
N 6040 38440 6060 38440 {}
C {lab_pin.sym} 6060 38440 0 0 {name=l30874 lab=VDD}
N 6040 38360 6060 38360 {}
C {lab_pin.sym} 6060 38360 0 0 {name=l30875 lab=VSS}
C {bitcell_6t.sym} 6200 38400 0 0 {name=Xr192c31}
N 6160 38440 6140 38440 {}
C {lab_pin.sym} 6140 38440 0 0 {name=l30876 lab=BL31}
N 6160 38400 6140 38400 {}
C {lab_pin.sym} 6140 38400 0 0 {name=l30877 lab=BLB31}
N 6160 38360 6140 38360 {}
C {lab_pin.sym} 6140 38360 0 0 {name=l30878 lab=WL192}
N 6240 38440 6260 38440 {}
C {lab_pin.sym} 6260 38440 0 0 {name=l30879 lab=VDD}
N 6240 38360 6260 38360 {}
C {lab_pin.sym} 6260 38360 0 0 {name=l30880 lab=VSS}
C {bitcell_6t.sym} 0 38600 0 0 {name=Xr193c0}
N -40 38640 -60 38640 {}
C {lab_pin.sym} -60 38640 0 0 {name=l30881 lab=BL0}
N -40 38600 -60 38600 {}
C {lab_pin.sym} -60 38600 0 0 {name=l30882 lab=BLB0}
N -40 38560 -60 38560 {}
C {lab_pin.sym} -60 38560 0 0 {name=l30883 lab=WL193}
N 40 38640 60 38640 {}
C {lab_pin.sym} 60 38640 0 0 {name=l30884 lab=VDD}
N 40 38560 60 38560 {}
C {lab_pin.sym} 60 38560 0 0 {name=l30885 lab=VSS}
C {bitcell_6t.sym} 200 38600 0 0 {name=Xr193c1}
N 160 38640 140 38640 {}
C {lab_pin.sym} 140 38640 0 0 {name=l30886 lab=BL1}
N 160 38600 140 38600 {}
C {lab_pin.sym} 140 38600 0 0 {name=l30887 lab=BLB1}
N 160 38560 140 38560 {}
C {lab_pin.sym} 140 38560 0 0 {name=l30888 lab=WL193}
N 240 38640 260 38640 {}
C {lab_pin.sym} 260 38640 0 0 {name=l30889 lab=VDD}
N 240 38560 260 38560 {}
C {lab_pin.sym} 260 38560 0 0 {name=l30890 lab=VSS}
C {bitcell_6t.sym} 400 38600 0 0 {name=Xr193c2}
N 360 38640 340 38640 {}
C {lab_pin.sym} 340 38640 0 0 {name=l30891 lab=BL2}
N 360 38600 340 38600 {}
C {lab_pin.sym} 340 38600 0 0 {name=l30892 lab=BLB2}
N 360 38560 340 38560 {}
C {lab_pin.sym} 340 38560 0 0 {name=l30893 lab=WL193}
N 440 38640 460 38640 {}
C {lab_pin.sym} 460 38640 0 0 {name=l30894 lab=VDD}
N 440 38560 460 38560 {}
C {lab_pin.sym} 460 38560 0 0 {name=l30895 lab=VSS}
C {bitcell_6t.sym} 600 38600 0 0 {name=Xr193c3}
N 560 38640 540 38640 {}
C {lab_pin.sym} 540 38640 0 0 {name=l30896 lab=BL3}
N 560 38600 540 38600 {}
C {lab_pin.sym} 540 38600 0 0 {name=l30897 lab=BLB3}
N 560 38560 540 38560 {}
C {lab_pin.sym} 540 38560 0 0 {name=l30898 lab=WL193}
N 640 38640 660 38640 {}
C {lab_pin.sym} 660 38640 0 0 {name=l30899 lab=VDD}
N 640 38560 660 38560 {}
C {lab_pin.sym} 660 38560 0 0 {name=l30900 lab=VSS}
C {bitcell_6t.sym} 800 38600 0 0 {name=Xr193c4}
N 760 38640 740 38640 {}
C {lab_pin.sym} 740 38640 0 0 {name=l30901 lab=BL4}
N 760 38600 740 38600 {}
C {lab_pin.sym} 740 38600 0 0 {name=l30902 lab=BLB4}
N 760 38560 740 38560 {}
C {lab_pin.sym} 740 38560 0 0 {name=l30903 lab=WL193}
N 840 38640 860 38640 {}
C {lab_pin.sym} 860 38640 0 0 {name=l30904 lab=VDD}
N 840 38560 860 38560 {}
C {lab_pin.sym} 860 38560 0 0 {name=l30905 lab=VSS}
C {bitcell_6t.sym} 1000 38600 0 0 {name=Xr193c5}
N 960 38640 940 38640 {}
C {lab_pin.sym} 940 38640 0 0 {name=l30906 lab=BL5}
N 960 38600 940 38600 {}
C {lab_pin.sym} 940 38600 0 0 {name=l30907 lab=BLB5}
N 960 38560 940 38560 {}
C {lab_pin.sym} 940 38560 0 0 {name=l30908 lab=WL193}
N 1040 38640 1060 38640 {}
C {lab_pin.sym} 1060 38640 0 0 {name=l30909 lab=VDD}
N 1040 38560 1060 38560 {}
C {lab_pin.sym} 1060 38560 0 0 {name=l30910 lab=VSS}
C {bitcell_6t.sym} 1200 38600 0 0 {name=Xr193c6}
N 1160 38640 1140 38640 {}
C {lab_pin.sym} 1140 38640 0 0 {name=l30911 lab=BL6}
N 1160 38600 1140 38600 {}
C {lab_pin.sym} 1140 38600 0 0 {name=l30912 lab=BLB6}
N 1160 38560 1140 38560 {}
C {lab_pin.sym} 1140 38560 0 0 {name=l30913 lab=WL193}
N 1240 38640 1260 38640 {}
C {lab_pin.sym} 1260 38640 0 0 {name=l30914 lab=VDD}
N 1240 38560 1260 38560 {}
C {lab_pin.sym} 1260 38560 0 0 {name=l30915 lab=VSS}
C {bitcell_6t.sym} 1400 38600 0 0 {name=Xr193c7}
N 1360 38640 1340 38640 {}
C {lab_pin.sym} 1340 38640 0 0 {name=l30916 lab=BL7}
N 1360 38600 1340 38600 {}
C {lab_pin.sym} 1340 38600 0 0 {name=l30917 lab=BLB7}
N 1360 38560 1340 38560 {}
C {lab_pin.sym} 1340 38560 0 0 {name=l30918 lab=WL193}
N 1440 38640 1460 38640 {}
C {lab_pin.sym} 1460 38640 0 0 {name=l30919 lab=VDD}
N 1440 38560 1460 38560 {}
C {lab_pin.sym} 1460 38560 0 0 {name=l30920 lab=VSS}
C {bitcell_6t.sym} 1600 38600 0 0 {name=Xr193c8}
N 1560 38640 1540 38640 {}
C {lab_pin.sym} 1540 38640 0 0 {name=l30921 lab=BL8}
N 1560 38600 1540 38600 {}
C {lab_pin.sym} 1540 38600 0 0 {name=l30922 lab=BLB8}
N 1560 38560 1540 38560 {}
C {lab_pin.sym} 1540 38560 0 0 {name=l30923 lab=WL193}
N 1640 38640 1660 38640 {}
C {lab_pin.sym} 1660 38640 0 0 {name=l30924 lab=VDD}
N 1640 38560 1660 38560 {}
C {lab_pin.sym} 1660 38560 0 0 {name=l30925 lab=VSS}
C {bitcell_6t.sym} 1800 38600 0 0 {name=Xr193c9}
N 1760 38640 1740 38640 {}
C {lab_pin.sym} 1740 38640 0 0 {name=l30926 lab=BL9}
N 1760 38600 1740 38600 {}
C {lab_pin.sym} 1740 38600 0 0 {name=l30927 lab=BLB9}
N 1760 38560 1740 38560 {}
C {lab_pin.sym} 1740 38560 0 0 {name=l30928 lab=WL193}
N 1840 38640 1860 38640 {}
C {lab_pin.sym} 1860 38640 0 0 {name=l30929 lab=VDD}
N 1840 38560 1860 38560 {}
C {lab_pin.sym} 1860 38560 0 0 {name=l30930 lab=VSS}
C {bitcell_6t.sym} 2000 38600 0 0 {name=Xr193c10}
N 1960 38640 1940 38640 {}
C {lab_pin.sym} 1940 38640 0 0 {name=l30931 lab=BL10}
N 1960 38600 1940 38600 {}
C {lab_pin.sym} 1940 38600 0 0 {name=l30932 lab=BLB10}
N 1960 38560 1940 38560 {}
C {lab_pin.sym} 1940 38560 0 0 {name=l30933 lab=WL193}
N 2040 38640 2060 38640 {}
C {lab_pin.sym} 2060 38640 0 0 {name=l30934 lab=VDD}
N 2040 38560 2060 38560 {}
C {lab_pin.sym} 2060 38560 0 0 {name=l30935 lab=VSS}
C {bitcell_6t.sym} 2200 38600 0 0 {name=Xr193c11}
N 2160 38640 2140 38640 {}
C {lab_pin.sym} 2140 38640 0 0 {name=l30936 lab=BL11}
N 2160 38600 2140 38600 {}
C {lab_pin.sym} 2140 38600 0 0 {name=l30937 lab=BLB11}
N 2160 38560 2140 38560 {}
C {lab_pin.sym} 2140 38560 0 0 {name=l30938 lab=WL193}
N 2240 38640 2260 38640 {}
C {lab_pin.sym} 2260 38640 0 0 {name=l30939 lab=VDD}
N 2240 38560 2260 38560 {}
C {lab_pin.sym} 2260 38560 0 0 {name=l30940 lab=VSS}
C {bitcell_6t.sym} 2400 38600 0 0 {name=Xr193c12}
N 2360 38640 2340 38640 {}
C {lab_pin.sym} 2340 38640 0 0 {name=l30941 lab=BL12}
N 2360 38600 2340 38600 {}
C {lab_pin.sym} 2340 38600 0 0 {name=l30942 lab=BLB12}
N 2360 38560 2340 38560 {}
C {lab_pin.sym} 2340 38560 0 0 {name=l30943 lab=WL193}
N 2440 38640 2460 38640 {}
C {lab_pin.sym} 2460 38640 0 0 {name=l30944 lab=VDD}
N 2440 38560 2460 38560 {}
C {lab_pin.sym} 2460 38560 0 0 {name=l30945 lab=VSS}
C {bitcell_6t.sym} 2600 38600 0 0 {name=Xr193c13}
N 2560 38640 2540 38640 {}
C {lab_pin.sym} 2540 38640 0 0 {name=l30946 lab=BL13}
N 2560 38600 2540 38600 {}
C {lab_pin.sym} 2540 38600 0 0 {name=l30947 lab=BLB13}
N 2560 38560 2540 38560 {}
C {lab_pin.sym} 2540 38560 0 0 {name=l30948 lab=WL193}
N 2640 38640 2660 38640 {}
C {lab_pin.sym} 2660 38640 0 0 {name=l30949 lab=VDD}
N 2640 38560 2660 38560 {}
C {lab_pin.sym} 2660 38560 0 0 {name=l30950 lab=VSS}
C {bitcell_6t.sym} 2800 38600 0 0 {name=Xr193c14}
N 2760 38640 2740 38640 {}
C {lab_pin.sym} 2740 38640 0 0 {name=l30951 lab=BL14}
N 2760 38600 2740 38600 {}
C {lab_pin.sym} 2740 38600 0 0 {name=l30952 lab=BLB14}
N 2760 38560 2740 38560 {}
C {lab_pin.sym} 2740 38560 0 0 {name=l30953 lab=WL193}
N 2840 38640 2860 38640 {}
C {lab_pin.sym} 2860 38640 0 0 {name=l30954 lab=VDD}
N 2840 38560 2860 38560 {}
C {lab_pin.sym} 2860 38560 0 0 {name=l30955 lab=VSS}
C {bitcell_6t.sym} 3000 38600 0 0 {name=Xr193c15}
N 2960 38640 2940 38640 {}
C {lab_pin.sym} 2940 38640 0 0 {name=l30956 lab=BL15}
N 2960 38600 2940 38600 {}
C {lab_pin.sym} 2940 38600 0 0 {name=l30957 lab=BLB15}
N 2960 38560 2940 38560 {}
C {lab_pin.sym} 2940 38560 0 0 {name=l30958 lab=WL193}
N 3040 38640 3060 38640 {}
C {lab_pin.sym} 3060 38640 0 0 {name=l30959 lab=VDD}
N 3040 38560 3060 38560 {}
C {lab_pin.sym} 3060 38560 0 0 {name=l30960 lab=VSS}
C {bitcell_6t.sym} 3200 38600 0 0 {name=Xr193c16}
N 3160 38640 3140 38640 {}
C {lab_pin.sym} 3140 38640 0 0 {name=l30961 lab=BL16}
N 3160 38600 3140 38600 {}
C {lab_pin.sym} 3140 38600 0 0 {name=l30962 lab=BLB16}
N 3160 38560 3140 38560 {}
C {lab_pin.sym} 3140 38560 0 0 {name=l30963 lab=WL193}
N 3240 38640 3260 38640 {}
C {lab_pin.sym} 3260 38640 0 0 {name=l30964 lab=VDD}
N 3240 38560 3260 38560 {}
C {lab_pin.sym} 3260 38560 0 0 {name=l30965 lab=VSS}
C {bitcell_6t.sym} 3400 38600 0 0 {name=Xr193c17}
N 3360 38640 3340 38640 {}
C {lab_pin.sym} 3340 38640 0 0 {name=l30966 lab=BL17}
N 3360 38600 3340 38600 {}
C {lab_pin.sym} 3340 38600 0 0 {name=l30967 lab=BLB17}
N 3360 38560 3340 38560 {}
C {lab_pin.sym} 3340 38560 0 0 {name=l30968 lab=WL193}
N 3440 38640 3460 38640 {}
C {lab_pin.sym} 3460 38640 0 0 {name=l30969 lab=VDD}
N 3440 38560 3460 38560 {}
C {lab_pin.sym} 3460 38560 0 0 {name=l30970 lab=VSS}
C {bitcell_6t.sym} 3600 38600 0 0 {name=Xr193c18}
N 3560 38640 3540 38640 {}
C {lab_pin.sym} 3540 38640 0 0 {name=l30971 lab=BL18}
N 3560 38600 3540 38600 {}
C {lab_pin.sym} 3540 38600 0 0 {name=l30972 lab=BLB18}
N 3560 38560 3540 38560 {}
C {lab_pin.sym} 3540 38560 0 0 {name=l30973 lab=WL193}
N 3640 38640 3660 38640 {}
C {lab_pin.sym} 3660 38640 0 0 {name=l30974 lab=VDD}
N 3640 38560 3660 38560 {}
C {lab_pin.sym} 3660 38560 0 0 {name=l30975 lab=VSS}
C {bitcell_6t.sym} 3800 38600 0 0 {name=Xr193c19}
N 3760 38640 3740 38640 {}
C {lab_pin.sym} 3740 38640 0 0 {name=l30976 lab=BL19}
N 3760 38600 3740 38600 {}
C {lab_pin.sym} 3740 38600 0 0 {name=l30977 lab=BLB19}
N 3760 38560 3740 38560 {}
C {lab_pin.sym} 3740 38560 0 0 {name=l30978 lab=WL193}
N 3840 38640 3860 38640 {}
C {lab_pin.sym} 3860 38640 0 0 {name=l30979 lab=VDD}
N 3840 38560 3860 38560 {}
C {lab_pin.sym} 3860 38560 0 0 {name=l30980 lab=VSS}
C {bitcell_6t.sym} 4000 38600 0 0 {name=Xr193c20}
N 3960 38640 3940 38640 {}
C {lab_pin.sym} 3940 38640 0 0 {name=l30981 lab=BL20}
N 3960 38600 3940 38600 {}
C {lab_pin.sym} 3940 38600 0 0 {name=l30982 lab=BLB20}
N 3960 38560 3940 38560 {}
C {lab_pin.sym} 3940 38560 0 0 {name=l30983 lab=WL193}
N 4040 38640 4060 38640 {}
C {lab_pin.sym} 4060 38640 0 0 {name=l30984 lab=VDD}
N 4040 38560 4060 38560 {}
C {lab_pin.sym} 4060 38560 0 0 {name=l30985 lab=VSS}
C {bitcell_6t.sym} 4200 38600 0 0 {name=Xr193c21}
N 4160 38640 4140 38640 {}
C {lab_pin.sym} 4140 38640 0 0 {name=l30986 lab=BL21}
N 4160 38600 4140 38600 {}
C {lab_pin.sym} 4140 38600 0 0 {name=l30987 lab=BLB21}
N 4160 38560 4140 38560 {}
C {lab_pin.sym} 4140 38560 0 0 {name=l30988 lab=WL193}
N 4240 38640 4260 38640 {}
C {lab_pin.sym} 4260 38640 0 0 {name=l30989 lab=VDD}
N 4240 38560 4260 38560 {}
C {lab_pin.sym} 4260 38560 0 0 {name=l30990 lab=VSS}
C {bitcell_6t.sym} 4400 38600 0 0 {name=Xr193c22}
N 4360 38640 4340 38640 {}
C {lab_pin.sym} 4340 38640 0 0 {name=l30991 lab=BL22}
N 4360 38600 4340 38600 {}
C {lab_pin.sym} 4340 38600 0 0 {name=l30992 lab=BLB22}
N 4360 38560 4340 38560 {}
C {lab_pin.sym} 4340 38560 0 0 {name=l30993 lab=WL193}
N 4440 38640 4460 38640 {}
C {lab_pin.sym} 4460 38640 0 0 {name=l30994 lab=VDD}
N 4440 38560 4460 38560 {}
C {lab_pin.sym} 4460 38560 0 0 {name=l30995 lab=VSS}
C {bitcell_6t.sym} 4600 38600 0 0 {name=Xr193c23}
N 4560 38640 4540 38640 {}
C {lab_pin.sym} 4540 38640 0 0 {name=l30996 lab=BL23}
N 4560 38600 4540 38600 {}
C {lab_pin.sym} 4540 38600 0 0 {name=l30997 lab=BLB23}
N 4560 38560 4540 38560 {}
C {lab_pin.sym} 4540 38560 0 0 {name=l30998 lab=WL193}
N 4640 38640 4660 38640 {}
C {lab_pin.sym} 4660 38640 0 0 {name=l30999 lab=VDD}
N 4640 38560 4660 38560 {}
C {lab_pin.sym} 4660 38560 0 0 {name=l31000 lab=VSS}
C {bitcell_6t.sym} 4800 38600 0 0 {name=Xr193c24}
N 4760 38640 4740 38640 {}
C {lab_pin.sym} 4740 38640 0 0 {name=l31001 lab=BL24}
N 4760 38600 4740 38600 {}
C {lab_pin.sym} 4740 38600 0 0 {name=l31002 lab=BLB24}
N 4760 38560 4740 38560 {}
C {lab_pin.sym} 4740 38560 0 0 {name=l31003 lab=WL193}
N 4840 38640 4860 38640 {}
C {lab_pin.sym} 4860 38640 0 0 {name=l31004 lab=VDD}
N 4840 38560 4860 38560 {}
C {lab_pin.sym} 4860 38560 0 0 {name=l31005 lab=VSS}
C {bitcell_6t.sym} 5000 38600 0 0 {name=Xr193c25}
N 4960 38640 4940 38640 {}
C {lab_pin.sym} 4940 38640 0 0 {name=l31006 lab=BL25}
N 4960 38600 4940 38600 {}
C {lab_pin.sym} 4940 38600 0 0 {name=l31007 lab=BLB25}
N 4960 38560 4940 38560 {}
C {lab_pin.sym} 4940 38560 0 0 {name=l31008 lab=WL193}
N 5040 38640 5060 38640 {}
C {lab_pin.sym} 5060 38640 0 0 {name=l31009 lab=VDD}
N 5040 38560 5060 38560 {}
C {lab_pin.sym} 5060 38560 0 0 {name=l31010 lab=VSS}
C {bitcell_6t.sym} 5200 38600 0 0 {name=Xr193c26}
N 5160 38640 5140 38640 {}
C {lab_pin.sym} 5140 38640 0 0 {name=l31011 lab=BL26}
N 5160 38600 5140 38600 {}
C {lab_pin.sym} 5140 38600 0 0 {name=l31012 lab=BLB26}
N 5160 38560 5140 38560 {}
C {lab_pin.sym} 5140 38560 0 0 {name=l31013 lab=WL193}
N 5240 38640 5260 38640 {}
C {lab_pin.sym} 5260 38640 0 0 {name=l31014 lab=VDD}
N 5240 38560 5260 38560 {}
C {lab_pin.sym} 5260 38560 0 0 {name=l31015 lab=VSS}
C {bitcell_6t.sym} 5400 38600 0 0 {name=Xr193c27}
N 5360 38640 5340 38640 {}
C {lab_pin.sym} 5340 38640 0 0 {name=l31016 lab=BL27}
N 5360 38600 5340 38600 {}
C {lab_pin.sym} 5340 38600 0 0 {name=l31017 lab=BLB27}
N 5360 38560 5340 38560 {}
C {lab_pin.sym} 5340 38560 0 0 {name=l31018 lab=WL193}
N 5440 38640 5460 38640 {}
C {lab_pin.sym} 5460 38640 0 0 {name=l31019 lab=VDD}
N 5440 38560 5460 38560 {}
C {lab_pin.sym} 5460 38560 0 0 {name=l31020 lab=VSS}
C {bitcell_6t.sym} 5600 38600 0 0 {name=Xr193c28}
N 5560 38640 5540 38640 {}
C {lab_pin.sym} 5540 38640 0 0 {name=l31021 lab=BL28}
N 5560 38600 5540 38600 {}
C {lab_pin.sym} 5540 38600 0 0 {name=l31022 lab=BLB28}
N 5560 38560 5540 38560 {}
C {lab_pin.sym} 5540 38560 0 0 {name=l31023 lab=WL193}
N 5640 38640 5660 38640 {}
C {lab_pin.sym} 5660 38640 0 0 {name=l31024 lab=VDD}
N 5640 38560 5660 38560 {}
C {lab_pin.sym} 5660 38560 0 0 {name=l31025 lab=VSS}
C {bitcell_6t.sym} 5800 38600 0 0 {name=Xr193c29}
N 5760 38640 5740 38640 {}
C {lab_pin.sym} 5740 38640 0 0 {name=l31026 lab=BL29}
N 5760 38600 5740 38600 {}
C {lab_pin.sym} 5740 38600 0 0 {name=l31027 lab=BLB29}
N 5760 38560 5740 38560 {}
C {lab_pin.sym} 5740 38560 0 0 {name=l31028 lab=WL193}
N 5840 38640 5860 38640 {}
C {lab_pin.sym} 5860 38640 0 0 {name=l31029 lab=VDD}
N 5840 38560 5860 38560 {}
C {lab_pin.sym} 5860 38560 0 0 {name=l31030 lab=VSS}
C {bitcell_6t.sym} 6000 38600 0 0 {name=Xr193c30}
N 5960 38640 5940 38640 {}
C {lab_pin.sym} 5940 38640 0 0 {name=l31031 lab=BL30}
N 5960 38600 5940 38600 {}
C {lab_pin.sym} 5940 38600 0 0 {name=l31032 lab=BLB30}
N 5960 38560 5940 38560 {}
C {lab_pin.sym} 5940 38560 0 0 {name=l31033 lab=WL193}
N 6040 38640 6060 38640 {}
C {lab_pin.sym} 6060 38640 0 0 {name=l31034 lab=VDD}
N 6040 38560 6060 38560 {}
C {lab_pin.sym} 6060 38560 0 0 {name=l31035 lab=VSS}
C {bitcell_6t.sym} 6200 38600 0 0 {name=Xr193c31}
N 6160 38640 6140 38640 {}
C {lab_pin.sym} 6140 38640 0 0 {name=l31036 lab=BL31}
N 6160 38600 6140 38600 {}
C {lab_pin.sym} 6140 38600 0 0 {name=l31037 lab=BLB31}
N 6160 38560 6140 38560 {}
C {lab_pin.sym} 6140 38560 0 0 {name=l31038 lab=WL193}
N 6240 38640 6260 38640 {}
C {lab_pin.sym} 6260 38640 0 0 {name=l31039 lab=VDD}
N 6240 38560 6260 38560 {}
C {lab_pin.sym} 6260 38560 0 0 {name=l31040 lab=VSS}
C {bitcell_6t.sym} 0 38800 0 0 {name=Xr194c0}
N -40 38840 -60 38840 {}
C {lab_pin.sym} -60 38840 0 0 {name=l31041 lab=BL0}
N -40 38800 -60 38800 {}
C {lab_pin.sym} -60 38800 0 0 {name=l31042 lab=BLB0}
N -40 38760 -60 38760 {}
C {lab_pin.sym} -60 38760 0 0 {name=l31043 lab=WL194}
N 40 38840 60 38840 {}
C {lab_pin.sym} 60 38840 0 0 {name=l31044 lab=VDD}
N 40 38760 60 38760 {}
C {lab_pin.sym} 60 38760 0 0 {name=l31045 lab=VSS}
C {bitcell_6t.sym} 200 38800 0 0 {name=Xr194c1}
N 160 38840 140 38840 {}
C {lab_pin.sym} 140 38840 0 0 {name=l31046 lab=BL1}
N 160 38800 140 38800 {}
C {lab_pin.sym} 140 38800 0 0 {name=l31047 lab=BLB1}
N 160 38760 140 38760 {}
C {lab_pin.sym} 140 38760 0 0 {name=l31048 lab=WL194}
N 240 38840 260 38840 {}
C {lab_pin.sym} 260 38840 0 0 {name=l31049 lab=VDD}
N 240 38760 260 38760 {}
C {lab_pin.sym} 260 38760 0 0 {name=l31050 lab=VSS}
C {bitcell_6t.sym} 400 38800 0 0 {name=Xr194c2}
N 360 38840 340 38840 {}
C {lab_pin.sym} 340 38840 0 0 {name=l31051 lab=BL2}
N 360 38800 340 38800 {}
C {lab_pin.sym} 340 38800 0 0 {name=l31052 lab=BLB2}
N 360 38760 340 38760 {}
C {lab_pin.sym} 340 38760 0 0 {name=l31053 lab=WL194}
N 440 38840 460 38840 {}
C {lab_pin.sym} 460 38840 0 0 {name=l31054 lab=VDD}
N 440 38760 460 38760 {}
C {lab_pin.sym} 460 38760 0 0 {name=l31055 lab=VSS}
C {bitcell_6t.sym} 600 38800 0 0 {name=Xr194c3}
N 560 38840 540 38840 {}
C {lab_pin.sym} 540 38840 0 0 {name=l31056 lab=BL3}
N 560 38800 540 38800 {}
C {lab_pin.sym} 540 38800 0 0 {name=l31057 lab=BLB3}
N 560 38760 540 38760 {}
C {lab_pin.sym} 540 38760 0 0 {name=l31058 lab=WL194}
N 640 38840 660 38840 {}
C {lab_pin.sym} 660 38840 0 0 {name=l31059 lab=VDD}
N 640 38760 660 38760 {}
C {lab_pin.sym} 660 38760 0 0 {name=l31060 lab=VSS}
C {bitcell_6t.sym} 800 38800 0 0 {name=Xr194c4}
N 760 38840 740 38840 {}
C {lab_pin.sym} 740 38840 0 0 {name=l31061 lab=BL4}
N 760 38800 740 38800 {}
C {lab_pin.sym} 740 38800 0 0 {name=l31062 lab=BLB4}
N 760 38760 740 38760 {}
C {lab_pin.sym} 740 38760 0 0 {name=l31063 lab=WL194}
N 840 38840 860 38840 {}
C {lab_pin.sym} 860 38840 0 0 {name=l31064 lab=VDD}
N 840 38760 860 38760 {}
C {lab_pin.sym} 860 38760 0 0 {name=l31065 lab=VSS}
C {bitcell_6t.sym} 1000 38800 0 0 {name=Xr194c5}
N 960 38840 940 38840 {}
C {lab_pin.sym} 940 38840 0 0 {name=l31066 lab=BL5}
N 960 38800 940 38800 {}
C {lab_pin.sym} 940 38800 0 0 {name=l31067 lab=BLB5}
N 960 38760 940 38760 {}
C {lab_pin.sym} 940 38760 0 0 {name=l31068 lab=WL194}
N 1040 38840 1060 38840 {}
C {lab_pin.sym} 1060 38840 0 0 {name=l31069 lab=VDD}
N 1040 38760 1060 38760 {}
C {lab_pin.sym} 1060 38760 0 0 {name=l31070 lab=VSS}
C {bitcell_6t.sym} 1200 38800 0 0 {name=Xr194c6}
N 1160 38840 1140 38840 {}
C {lab_pin.sym} 1140 38840 0 0 {name=l31071 lab=BL6}
N 1160 38800 1140 38800 {}
C {lab_pin.sym} 1140 38800 0 0 {name=l31072 lab=BLB6}
N 1160 38760 1140 38760 {}
C {lab_pin.sym} 1140 38760 0 0 {name=l31073 lab=WL194}
N 1240 38840 1260 38840 {}
C {lab_pin.sym} 1260 38840 0 0 {name=l31074 lab=VDD}
N 1240 38760 1260 38760 {}
C {lab_pin.sym} 1260 38760 0 0 {name=l31075 lab=VSS}
C {bitcell_6t.sym} 1400 38800 0 0 {name=Xr194c7}
N 1360 38840 1340 38840 {}
C {lab_pin.sym} 1340 38840 0 0 {name=l31076 lab=BL7}
N 1360 38800 1340 38800 {}
C {lab_pin.sym} 1340 38800 0 0 {name=l31077 lab=BLB7}
N 1360 38760 1340 38760 {}
C {lab_pin.sym} 1340 38760 0 0 {name=l31078 lab=WL194}
N 1440 38840 1460 38840 {}
C {lab_pin.sym} 1460 38840 0 0 {name=l31079 lab=VDD}
N 1440 38760 1460 38760 {}
C {lab_pin.sym} 1460 38760 0 0 {name=l31080 lab=VSS}
C {bitcell_6t.sym} 1600 38800 0 0 {name=Xr194c8}
N 1560 38840 1540 38840 {}
C {lab_pin.sym} 1540 38840 0 0 {name=l31081 lab=BL8}
N 1560 38800 1540 38800 {}
C {lab_pin.sym} 1540 38800 0 0 {name=l31082 lab=BLB8}
N 1560 38760 1540 38760 {}
C {lab_pin.sym} 1540 38760 0 0 {name=l31083 lab=WL194}
N 1640 38840 1660 38840 {}
C {lab_pin.sym} 1660 38840 0 0 {name=l31084 lab=VDD}
N 1640 38760 1660 38760 {}
C {lab_pin.sym} 1660 38760 0 0 {name=l31085 lab=VSS}
C {bitcell_6t.sym} 1800 38800 0 0 {name=Xr194c9}
N 1760 38840 1740 38840 {}
C {lab_pin.sym} 1740 38840 0 0 {name=l31086 lab=BL9}
N 1760 38800 1740 38800 {}
C {lab_pin.sym} 1740 38800 0 0 {name=l31087 lab=BLB9}
N 1760 38760 1740 38760 {}
C {lab_pin.sym} 1740 38760 0 0 {name=l31088 lab=WL194}
N 1840 38840 1860 38840 {}
C {lab_pin.sym} 1860 38840 0 0 {name=l31089 lab=VDD}
N 1840 38760 1860 38760 {}
C {lab_pin.sym} 1860 38760 0 0 {name=l31090 lab=VSS}
C {bitcell_6t.sym} 2000 38800 0 0 {name=Xr194c10}
N 1960 38840 1940 38840 {}
C {lab_pin.sym} 1940 38840 0 0 {name=l31091 lab=BL10}
N 1960 38800 1940 38800 {}
C {lab_pin.sym} 1940 38800 0 0 {name=l31092 lab=BLB10}
N 1960 38760 1940 38760 {}
C {lab_pin.sym} 1940 38760 0 0 {name=l31093 lab=WL194}
N 2040 38840 2060 38840 {}
C {lab_pin.sym} 2060 38840 0 0 {name=l31094 lab=VDD}
N 2040 38760 2060 38760 {}
C {lab_pin.sym} 2060 38760 0 0 {name=l31095 lab=VSS}
C {bitcell_6t.sym} 2200 38800 0 0 {name=Xr194c11}
N 2160 38840 2140 38840 {}
C {lab_pin.sym} 2140 38840 0 0 {name=l31096 lab=BL11}
N 2160 38800 2140 38800 {}
C {lab_pin.sym} 2140 38800 0 0 {name=l31097 lab=BLB11}
N 2160 38760 2140 38760 {}
C {lab_pin.sym} 2140 38760 0 0 {name=l31098 lab=WL194}
N 2240 38840 2260 38840 {}
C {lab_pin.sym} 2260 38840 0 0 {name=l31099 lab=VDD}
N 2240 38760 2260 38760 {}
C {lab_pin.sym} 2260 38760 0 0 {name=l31100 lab=VSS}
C {bitcell_6t.sym} 2400 38800 0 0 {name=Xr194c12}
N 2360 38840 2340 38840 {}
C {lab_pin.sym} 2340 38840 0 0 {name=l31101 lab=BL12}
N 2360 38800 2340 38800 {}
C {lab_pin.sym} 2340 38800 0 0 {name=l31102 lab=BLB12}
N 2360 38760 2340 38760 {}
C {lab_pin.sym} 2340 38760 0 0 {name=l31103 lab=WL194}
N 2440 38840 2460 38840 {}
C {lab_pin.sym} 2460 38840 0 0 {name=l31104 lab=VDD}
N 2440 38760 2460 38760 {}
C {lab_pin.sym} 2460 38760 0 0 {name=l31105 lab=VSS}
C {bitcell_6t.sym} 2600 38800 0 0 {name=Xr194c13}
N 2560 38840 2540 38840 {}
C {lab_pin.sym} 2540 38840 0 0 {name=l31106 lab=BL13}
N 2560 38800 2540 38800 {}
C {lab_pin.sym} 2540 38800 0 0 {name=l31107 lab=BLB13}
N 2560 38760 2540 38760 {}
C {lab_pin.sym} 2540 38760 0 0 {name=l31108 lab=WL194}
N 2640 38840 2660 38840 {}
C {lab_pin.sym} 2660 38840 0 0 {name=l31109 lab=VDD}
N 2640 38760 2660 38760 {}
C {lab_pin.sym} 2660 38760 0 0 {name=l31110 lab=VSS}
C {bitcell_6t.sym} 2800 38800 0 0 {name=Xr194c14}
N 2760 38840 2740 38840 {}
C {lab_pin.sym} 2740 38840 0 0 {name=l31111 lab=BL14}
N 2760 38800 2740 38800 {}
C {lab_pin.sym} 2740 38800 0 0 {name=l31112 lab=BLB14}
N 2760 38760 2740 38760 {}
C {lab_pin.sym} 2740 38760 0 0 {name=l31113 lab=WL194}
N 2840 38840 2860 38840 {}
C {lab_pin.sym} 2860 38840 0 0 {name=l31114 lab=VDD}
N 2840 38760 2860 38760 {}
C {lab_pin.sym} 2860 38760 0 0 {name=l31115 lab=VSS}
C {bitcell_6t.sym} 3000 38800 0 0 {name=Xr194c15}
N 2960 38840 2940 38840 {}
C {lab_pin.sym} 2940 38840 0 0 {name=l31116 lab=BL15}
N 2960 38800 2940 38800 {}
C {lab_pin.sym} 2940 38800 0 0 {name=l31117 lab=BLB15}
N 2960 38760 2940 38760 {}
C {lab_pin.sym} 2940 38760 0 0 {name=l31118 lab=WL194}
N 3040 38840 3060 38840 {}
C {lab_pin.sym} 3060 38840 0 0 {name=l31119 lab=VDD}
N 3040 38760 3060 38760 {}
C {lab_pin.sym} 3060 38760 0 0 {name=l31120 lab=VSS}
C {bitcell_6t.sym} 3200 38800 0 0 {name=Xr194c16}
N 3160 38840 3140 38840 {}
C {lab_pin.sym} 3140 38840 0 0 {name=l31121 lab=BL16}
N 3160 38800 3140 38800 {}
C {lab_pin.sym} 3140 38800 0 0 {name=l31122 lab=BLB16}
N 3160 38760 3140 38760 {}
C {lab_pin.sym} 3140 38760 0 0 {name=l31123 lab=WL194}
N 3240 38840 3260 38840 {}
C {lab_pin.sym} 3260 38840 0 0 {name=l31124 lab=VDD}
N 3240 38760 3260 38760 {}
C {lab_pin.sym} 3260 38760 0 0 {name=l31125 lab=VSS}
C {bitcell_6t.sym} 3400 38800 0 0 {name=Xr194c17}
N 3360 38840 3340 38840 {}
C {lab_pin.sym} 3340 38840 0 0 {name=l31126 lab=BL17}
N 3360 38800 3340 38800 {}
C {lab_pin.sym} 3340 38800 0 0 {name=l31127 lab=BLB17}
N 3360 38760 3340 38760 {}
C {lab_pin.sym} 3340 38760 0 0 {name=l31128 lab=WL194}
N 3440 38840 3460 38840 {}
C {lab_pin.sym} 3460 38840 0 0 {name=l31129 lab=VDD}
N 3440 38760 3460 38760 {}
C {lab_pin.sym} 3460 38760 0 0 {name=l31130 lab=VSS}
C {bitcell_6t.sym} 3600 38800 0 0 {name=Xr194c18}
N 3560 38840 3540 38840 {}
C {lab_pin.sym} 3540 38840 0 0 {name=l31131 lab=BL18}
N 3560 38800 3540 38800 {}
C {lab_pin.sym} 3540 38800 0 0 {name=l31132 lab=BLB18}
N 3560 38760 3540 38760 {}
C {lab_pin.sym} 3540 38760 0 0 {name=l31133 lab=WL194}
N 3640 38840 3660 38840 {}
C {lab_pin.sym} 3660 38840 0 0 {name=l31134 lab=VDD}
N 3640 38760 3660 38760 {}
C {lab_pin.sym} 3660 38760 0 0 {name=l31135 lab=VSS}
C {bitcell_6t.sym} 3800 38800 0 0 {name=Xr194c19}
N 3760 38840 3740 38840 {}
C {lab_pin.sym} 3740 38840 0 0 {name=l31136 lab=BL19}
N 3760 38800 3740 38800 {}
C {lab_pin.sym} 3740 38800 0 0 {name=l31137 lab=BLB19}
N 3760 38760 3740 38760 {}
C {lab_pin.sym} 3740 38760 0 0 {name=l31138 lab=WL194}
N 3840 38840 3860 38840 {}
C {lab_pin.sym} 3860 38840 0 0 {name=l31139 lab=VDD}
N 3840 38760 3860 38760 {}
C {lab_pin.sym} 3860 38760 0 0 {name=l31140 lab=VSS}
C {bitcell_6t.sym} 4000 38800 0 0 {name=Xr194c20}
N 3960 38840 3940 38840 {}
C {lab_pin.sym} 3940 38840 0 0 {name=l31141 lab=BL20}
N 3960 38800 3940 38800 {}
C {lab_pin.sym} 3940 38800 0 0 {name=l31142 lab=BLB20}
N 3960 38760 3940 38760 {}
C {lab_pin.sym} 3940 38760 0 0 {name=l31143 lab=WL194}
N 4040 38840 4060 38840 {}
C {lab_pin.sym} 4060 38840 0 0 {name=l31144 lab=VDD}
N 4040 38760 4060 38760 {}
C {lab_pin.sym} 4060 38760 0 0 {name=l31145 lab=VSS}
C {bitcell_6t.sym} 4200 38800 0 0 {name=Xr194c21}
N 4160 38840 4140 38840 {}
C {lab_pin.sym} 4140 38840 0 0 {name=l31146 lab=BL21}
N 4160 38800 4140 38800 {}
C {lab_pin.sym} 4140 38800 0 0 {name=l31147 lab=BLB21}
N 4160 38760 4140 38760 {}
C {lab_pin.sym} 4140 38760 0 0 {name=l31148 lab=WL194}
N 4240 38840 4260 38840 {}
C {lab_pin.sym} 4260 38840 0 0 {name=l31149 lab=VDD}
N 4240 38760 4260 38760 {}
C {lab_pin.sym} 4260 38760 0 0 {name=l31150 lab=VSS}
C {bitcell_6t.sym} 4400 38800 0 0 {name=Xr194c22}
N 4360 38840 4340 38840 {}
C {lab_pin.sym} 4340 38840 0 0 {name=l31151 lab=BL22}
N 4360 38800 4340 38800 {}
C {lab_pin.sym} 4340 38800 0 0 {name=l31152 lab=BLB22}
N 4360 38760 4340 38760 {}
C {lab_pin.sym} 4340 38760 0 0 {name=l31153 lab=WL194}
N 4440 38840 4460 38840 {}
C {lab_pin.sym} 4460 38840 0 0 {name=l31154 lab=VDD}
N 4440 38760 4460 38760 {}
C {lab_pin.sym} 4460 38760 0 0 {name=l31155 lab=VSS}
C {bitcell_6t.sym} 4600 38800 0 0 {name=Xr194c23}
N 4560 38840 4540 38840 {}
C {lab_pin.sym} 4540 38840 0 0 {name=l31156 lab=BL23}
N 4560 38800 4540 38800 {}
C {lab_pin.sym} 4540 38800 0 0 {name=l31157 lab=BLB23}
N 4560 38760 4540 38760 {}
C {lab_pin.sym} 4540 38760 0 0 {name=l31158 lab=WL194}
N 4640 38840 4660 38840 {}
C {lab_pin.sym} 4660 38840 0 0 {name=l31159 lab=VDD}
N 4640 38760 4660 38760 {}
C {lab_pin.sym} 4660 38760 0 0 {name=l31160 lab=VSS}
C {bitcell_6t.sym} 4800 38800 0 0 {name=Xr194c24}
N 4760 38840 4740 38840 {}
C {lab_pin.sym} 4740 38840 0 0 {name=l31161 lab=BL24}
N 4760 38800 4740 38800 {}
C {lab_pin.sym} 4740 38800 0 0 {name=l31162 lab=BLB24}
N 4760 38760 4740 38760 {}
C {lab_pin.sym} 4740 38760 0 0 {name=l31163 lab=WL194}
N 4840 38840 4860 38840 {}
C {lab_pin.sym} 4860 38840 0 0 {name=l31164 lab=VDD}
N 4840 38760 4860 38760 {}
C {lab_pin.sym} 4860 38760 0 0 {name=l31165 lab=VSS}
C {bitcell_6t.sym} 5000 38800 0 0 {name=Xr194c25}
N 4960 38840 4940 38840 {}
C {lab_pin.sym} 4940 38840 0 0 {name=l31166 lab=BL25}
N 4960 38800 4940 38800 {}
C {lab_pin.sym} 4940 38800 0 0 {name=l31167 lab=BLB25}
N 4960 38760 4940 38760 {}
C {lab_pin.sym} 4940 38760 0 0 {name=l31168 lab=WL194}
N 5040 38840 5060 38840 {}
C {lab_pin.sym} 5060 38840 0 0 {name=l31169 lab=VDD}
N 5040 38760 5060 38760 {}
C {lab_pin.sym} 5060 38760 0 0 {name=l31170 lab=VSS}
C {bitcell_6t.sym} 5200 38800 0 0 {name=Xr194c26}
N 5160 38840 5140 38840 {}
C {lab_pin.sym} 5140 38840 0 0 {name=l31171 lab=BL26}
N 5160 38800 5140 38800 {}
C {lab_pin.sym} 5140 38800 0 0 {name=l31172 lab=BLB26}
N 5160 38760 5140 38760 {}
C {lab_pin.sym} 5140 38760 0 0 {name=l31173 lab=WL194}
N 5240 38840 5260 38840 {}
C {lab_pin.sym} 5260 38840 0 0 {name=l31174 lab=VDD}
N 5240 38760 5260 38760 {}
C {lab_pin.sym} 5260 38760 0 0 {name=l31175 lab=VSS}
C {bitcell_6t.sym} 5400 38800 0 0 {name=Xr194c27}
N 5360 38840 5340 38840 {}
C {lab_pin.sym} 5340 38840 0 0 {name=l31176 lab=BL27}
N 5360 38800 5340 38800 {}
C {lab_pin.sym} 5340 38800 0 0 {name=l31177 lab=BLB27}
N 5360 38760 5340 38760 {}
C {lab_pin.sym} 5340 38760 0 0 {name=l31178 lab=WL194}
N 5440 38840 5460 38840 {}
C {lab_pin.sym} 5460 38840 0 0 {name=l31179 lab=VDD}
N 5440 38760 5460 38760 {}
C {lab_pin.sym} 5460 38760 0 0 {name=l31180 lab=VSS}
C {bitcell_6t.sym} 5600 38800 0 0 {name=Xr194c28}
N 5560 38840 5540 38840 {}
C {lab_pin.sym} 5540 38840 0 0 {name=l31181 lab=BL28}
N 5560 38800 5540 38800 {}
C {lab_pin.sym} 5540 38800 0 0 {name=l31182 lab=BLB28}
N 5560 38760 5540 38760 {}
C {lab_pin.sym} 5540 38760 0 0 {name=l31183 lab=WL194}
N 5640 38840 5660 38840 {}
C {lab_pin.sym} 5660 38840 0 0 {name=l31184 lab=VDD}
N 5640 38760 5660 38760 {}
C {lab_pin.sym} 5660 38760 0 0 {name=l31185 lab=VSS}
C {bitcell_6t.sym} 5800 38800 0 0 {name=Xr194c29}
N 5760 38840 5740 38840 {}
C {lab_pin.sym} 5740 38840 0 0 {name=l31186 lab=BL29}
N 5760 38800 5740 38800 {}
C {lab_pin.sym} 5740 38800 0 0 {name=l31187 lab=BLB29}
N 5760 38760 5740 38760 {}
C {lab_pin.sym} 5740 38760 0 0 {name=l31188 lab=WL194}
N 5840 38840 5860 38840 {}
C {lab_pin.sym} 5860 38840 0 0 {name=l31189 lab=VDD}
N 5840 38760 5860 38760 {}
C {lab_pin.sym} 5860 38760 0 0 {name=l31190 lab=VSS}
C {bitcell_6t.sym} 6000 38800 0 0 {name=Xr194c30}
N 5960 38840 5940 38840 {}
C {lab_pin.sym} 5940 38840 0 0 {name=l31191 lab=BL30}
N 5960 38800 5940 38800 {}
C {lab_pin.sym} 5940 38800 0 0 {name=l31192 lab=BLB30}
N 5960 38760 5940 38760 {}
C {lab_pin.sym} 5940 38760 0 0 {name=l31193 lab=WL194}
N 6040 38840 6060 38840 {}
C {lab_pin.sym} 6060 38840 0 0 {name=l31194 lab=VDD}
N 6040 38760 6060 38760 {}
C {lab_pin.sym} 6060 38760 0 0 {name=l31195 lab=VSS}
C {bitcell_6t.sym} 6200 38800 0 0 {name=Xr194c31}
N 6160 38840 6140 38840 {}
C {lab_pin.sym} 6140 38840 0 0 {name=l31196 lab=BL31}
N 6160 38800 6140 38800 {}
C {lab_pin.sym} 6140 38800 0 0 {name=l31197 lab=BLB31}
N 6160 38760 6140 38760 {}
C {lab_pin.sym} 6140 38760 0 0 {name=l31198 lab=WL194}
N 6240 38840 6260 38840 {}
C {lab_pin.sym} 6260 38840 0 0 {name=l31199 lab=VDD}
N 6240 38760 6260 38760 {}
C {lab_pin.sym} 6260 38760 0 0 {name=l31200 lab=VSS}
C {bitcell_6t.sym} 0 39000 0 0 {name=Xr195c0}
N -40 39040 -60 39040 {}
C {lab_pin.sym} -60 39040 0 0 {name=l31201 lab=BL0}
N -40 39000 -60 39000 {}
C {lab_pin.sym} -60 39000 0 0 {name=l31202 lab=BLB0}
N -40 38960 -60 38960 {}
C {lab_pin.sym} -60 38960 0 0 {name=l31203 lab=WL195}
N 40 39040 60 39040 {}
C {lab_pin.sym} 60 39040 0 0 {name=l31204 lab=VDD}
N 40 38960 60 38960 {}
C {lab_pin.sym} 60 38960 0 0 {name=l31205 lab=VSS}
C {bitcell_6t.sym} 200 39000 0 0 {name=Xr195c1}
N 160 39040 140 39040 {}
C {lab_pin.sym} 140 39040 0 0 {name=l31206 lab=BL1}
N 160 39000 140 39000 {}
C {lab_pin.sym} 140 39000 0 0 {name=l31207 lab=BLB1}
N 160 38960 140 38960 {}
C {lab_pin.sym} 140 38960 0 0 {name=l31208 lab=WL195}
N 240 39040 260 39040 {}
C {lab_pin.sym} 260 39040 0 0 {name=l31209 lab=VDD}
N 240 38960 260 38960 {}
C {lab_pin.sym} 260 38960 0 0 {name=l31210 lab=VSS}
C {bitcell_6t.sym} 400 39000 0 0 {name=Xr195c2}
N 360 39040 340 39040 {}
C {lab_pin.sym} 340 39040 0 0 {name=l31211 lab=BL2}
N 360 39000 340 39000 {}
C {lab_pin.sym} 340 39000 0 0 {name=l31212 lab=BLB2}
N 360 38960 340 38960 {}
C {lab_pin.sym} 340 38960 0 0 {name=l31213 lab=WL195}
N 440 39040 460 39040 {}
C {lab_pin.sym} 460 39040 0 0 {name=l31214 lab=VDD}
N 440 38960 460 38960 {}
C {lab_pin.sym} 460 38960 0 0 {name=l31215 lab=VSS}
C {bitcell_6t.sym} 600 39000 0 0 {name=Xr195c3}
N 560 39040 540 39040 {}
C {lab_pin.sym} 540 39040 0 0 {name=l31216 lab=BL3}
N 560 39000 540 39000 {}
C {lab_pin.sym} 540 39000 0 0 {name=l31217 lab=BLB3}
N 560 38960 540 38960 {}
C {lab_pin.sym} 540 38960 0 0 {name=l31218 lab=WL195}
N 640 39040 660 39040 {}
C {lab_pin.sym} 660 39040 0 0 {name=l31219 lab=VDD}
N 640 38960 660 38960 {}
C {lab_pin.sym} 660 38960 0 0 {name=l31220 lab=VSS}
C {bitcell_6t.sym} 800 39000 0 0 {name=Xr195c4}
N 760 39040 740 39040 {}
C {lab_pin.sym} 740 39040 0 0 {name=l31221 lab=BL4}
N 760 39000 740 39000 {}
C {lab_pin.sym} 740 39000 0 0 {name=l31222 lab=BLB4}
N 760 38960 740 38960 {}
C {lab_pin.sym} 740 38960 0 0 {name=l31223 lab=WL195}
N 840 39040 860 39040 {}
C {lab_pin.sym} 860 39040 0 0 {name=l31224 lab=VDD}
N 840 38960 860 38960 {}
C {lab_pin.sym} 860 38960 0 0 {name=l31225 lab=VSS}
C {bitcell_6t.sym} 1000 39000 0 0 {name=Xr195c5}
N 960 39040 940 39040 {}
C {lab_pin.sym} 940 39040 0 0 {name=l31226 lab=BL5}
N 960 39000 940 39000 {}
C {lab_pin.sym} 940 39000 0 0 {name=l31227 lab=BLB5}
N 960 38960 940 38960 {}
C {lab_pin.sym} 940 38960 0 0 {name=l31228 lab=WL195}
N 1040 39040 1060 39040 {}
C {lab_pin.sym} 1060 39040 0 0 {name=l31229 lab=VDD}
N 1040 38960 1060 38960 {}
C {lab_pin.sym} 1060 38960 0 0 {name=l31230 lab=VSS}
C {bitcell_6t.sym} 1200 39000 0 0 {name=Xr195c6}
N 1160 39040 1140 39040 {}
C {lab_pin.sym} 1140 39040 0 0 {name=l31231 lab=BL6}
N 1160 39000 1140 39000 {}
C {lab_pin.sym} 1140 39000 0 0 {name=l31232 lab=BLB6}
N 1160 38960 1140 38960 {}
C {lab_pin.sym} 1140 38960 0 0 {name=l31233 lab=WL195}
N 1240 39040 1260 39040 {}
C {lab_pin.sym} 1260 39040 0 0 {name=l31234 lab=VDD}
N 1240 38960 1260 38960 {}
C {lab_pin.sym} 1260 38960 0 0 {name=l31235 lab=VSS}
C {bitcell_6t.sym} 1400 39000 0 0 {name=Xr195c7}
N 1360 39040 1340 39040 {}
C {lab_pin.sym} 1340 39040 0 0 {name=l31236 lab=BL7}
N 1360 39000 1340 39000 {}
C {lab_pin.sym} 1340 39000 0 0 {name=l31237 lab=BLB7}
N 1360 38960 1340 38960 {}
C {lab_pin.sym} 1340 38960 0 0 {name=l31238 lab=WL195}
N 1440 39040 1460 39040 {}
C {lab_pin.sym} 1460 39040 0 0 {name=l31239 lab=VDD}
N 1440 38960 1460 38960 {}
C {lab_pin.sym} 1460 38960 0 0 {name=l31240 lab=VSS}
C {bitcell_6t.sym} 1600 39000 0 0 {name=Xr195c8}
N 1560 39040 1540 39040 {}
C {lab_pin.sym} 1540 39040 0 0 {name=l31241 lab=BL8}
N 1560 39000 1540 39000 {}
C {lab_pin.sym} 1540 39000 0 0 {name=l31242 lab=BLB8}
N 1560 38960 1540 38960 {}
C {lab_pin.sym} 1540 38960 0 0 {name=l31243 lab=WL195}
N 1640 39040 1660 39040 {}
C {lab_pin.sym} 1660 39040 0 0 {name=l31244 lab=VDD}
N 1640 38960 1660 38960 {}
C {lab_pin.sym} 1660 38960 0 0 {name=l31245 lab=VSS}
C {bitcell_6t.sym} 1800 39000 0 0 {name=Xr195c9}
N 1760 39040 1740 39040 {}
C {lab_pin.sym} 1740 39040 0 0 {name=l31246 lab=BL9}
N 1760 39000 1740 39000 {}
C {lab_pin.sym} 1740 39000 0 0 {name=l31247 lab=BLB9}
N 1760 38960 1740 38960 {}
C {lab_pin.sym} 1740 38960 0 0 {name=l31248 lab=WL195}
N 1840 39040 1860 39040 {}
C {lab_pin.sym} 1860 39040 0 0 {name=l31249 lab=VDD}
N 1840 38960 1860 38960 {}
C {lab_pin.sym} 1860 38960 0 0 {name=l31250 lab=VSS}
C {bitcell_6t.sym} 2000 39000 0 0 {name=Xr195c10}
N 1960 39040 1940 39040 {}
C {lab_pin.sym} 1940 39040 0 0 {name=l31251 lab=BL10}
N 1960 39000 1940 39000 {}
C {lab_pin.sym} 1940 39000 0 0 {name=l31252 lab=BLB10}
N 1960 38960 1940 38960 {}
C {lab_pin.sym} 1940 38960 0 0 {name=l31253 lab=WL195}
N 2040 39040 2060 39040 {}
C {lab_pin.sym} 2060 39040 0 0 {name=l31254 lab=VDD}
N 2040 38960 2060 38960 {}
C {lab_pin.sym} 2060 38960 0 0 {name=l31255 lab=VSS}
C {bitcell_6t.sym} 2200 39000 0 0 {name=Xr195c11}
N 2160 39040 2140 39040 {}
C {lab_pin.sym} 2140 39040 0 0 {name=l31256 lab=BL11}
N 2160 39000 2140 39000 {}
C {lab_pin.sym} 2140 39000 0 0 {name=l31257 lab=BLB11}
N 2160 38960 2140 38960 {}
C {lab_pin.sym} 2140 38960 0 0 {name=l31258 lab=WL195}
N 2240 39040 2260 39040 {}
C {lab_pin.sym} 2260 39040 0 0 {name=l31259 lab=VDD}
N 2240 38960 2260 38960 {}
C {lab_pin.sym} 2260 38960 0 0 {name=l31260 lab=VSS}
C {bitcell_6t.sym} 2400 39000 0 0 {name=Xr195c12}
N 2360 39040 2340 39040 {}
C {lab_pin.sym} 2340 39040 0 0 {name=l31261 lab=BL12}
N 2360 39000 2340 39000 {}
C {lab_pin.sym} 2340 39000 0 0 {name=l31262 lab=BLB12}
N 2360 38960 2340 38960 {}
C {lab_pin.sym} 2340 38960 0 0 {name=l31263 lab=WL195}
N 2440 39040 2460 39040 {}
C {lab_pin.sym} 2460 39040 0 0 {name=l31264 lab=VDD}
N 2440 38960 2460 38960 {}
C {lab_pin.sym} 2460 38960 0 0 {name=l31265 lab=VSS}
C {bitcell_6t.sym} 2600 39000 0 0 {name=Xr195c13}
N 2560 39040 2540 39040 {}
C {lab_pin.sym} 2540 39040 0 0 {name=l31266 lab=BL13}
N 2560 39000 2540 39000 {}
C {lab_pin.sym} 2540 39000 0 0 {name=l31267 lab=BLB13}
N 2560 38960 2540 38960 {}
C {lab_pin.sym} 2540 38960 0 0 {name=l31268 lab=WL195}
N 2640 39040 2660 39040 {}
C {lab_pin.sym} 2660 39040 0 0 {name=l31269 lab=VDD}
N 2640 38960 2660 38960 {}
C {lab_pin.sym} 2660 38960 0 0 {name=l31270 lab=VSS}
C {bitcell_6t.sym} 2800 39000 0 0 {name=Xr195c14}
N 2760 39040 2740 39040 {}
C {lab_pin.sym} 2740 39040 0 0 {name=l31271 lab=BL14}
N 2760 39000 2740 39000 {}
C {lab_pin.sym} 2740 39000 0 0 {name=l31272 lab=BLB14}
N 2760 38960 2740 38960 {}
C {lab_pin.sym} 2740 38960 0 0 {name=l31273 lab=WL195}
N 2840 39040 2860 39040 {}
C {lab_pin.sym} 2860 39040 0 0 {name=l31274 lab=VDD}
N 2840 38960 2860 38960 {}
C {lab_pin.sym} 2860 38960 0 0 {name=l31275 lab=VSS}
C {bitcell_6t.sym} 3000 39000 0 0 {name=Xr195c15}
N 2960 39040 2940 39040 {}
C {lab_pin.sym} 2940 39040 0 0 {name=l31276 lab=BL15}
N 2960 39000 2940 39000 {}
C {lab_pin.sym} 2940 39000 0 0 {name=l31277 lab=BLB15}
N 2960 38960 2940 38960 {}
C {lab_pin.sym} 2940 38960 0 0 {name=l31278 lab=WL195}
N 3040 39040 3060 39040 {}
C {lab_pin.sym} 3060 39040 0 0 {name=l31279 lab=VDD}
N 3040 38960 3060 38960 {}
C {lab_pin.sym} 3060 38960 0 0 {name=l31280 lab=VSS}
C {bitcell_6t.sym} 3200 39000 0 0 {name=Xr195c16}
N 3160 39040 3140 39040 {}
C {lab_pin.sym} 3140 39040 0 0 {name=l31281 lab=BL16}
N 3160 39000 3140 39000 {}
C {lab_pin.sym} 3140 39000 0 0 {name=l31282 lab=BLB16}
N 3160 38960 3140 38960 {}
C {lab_pin.sym} 3140 38960 0 0 {name=l31283 lab=WL195}
N 3240 39040 3260 39040 {}
C {lab_pin.sym} 3260 39040 0 0 {name=l31284 lab=VDD}
N 3240 38960 3260 38960 {}
C {lab_pin.sym} 3260 38960 0 0 {name=l31285 lab=VSS}
C {bitcell_6t.sym} 3400 39000 0 0 {name=Xr195c17}
N 3360 39040 3340 39040 {}
C {lab_pin.sym} 3340 39040 0 0 {name=l31286 lab=BL17}
N 3360 39000 3340 39000 {}
C {lab_pin.sym} 3340 39000 0 0 {name=l31287 lab=BLB17}
N 3360 38960 3340 38960 {}
C {lab_pin.sym} 3340 38960 0 0 {name=l31288 lab=WL195}
N 3440 39040 3460 39040 {}
C {lab_pin.sym} 3460 39040 0 0 {name=l31289 lab=VDD}
N 3440 38960 3460 38960 {}
C {lab_pin.sym} 3460 38960 0 0 {name=l31290 lab=VSS}
C {bitcell_6t.sym} 3600 39000 0 0 {name=Xr195c18}
N 3560 39040 3540 39040 {}
C {lab_pin.sym} 3540 39040 0 0 {name=l31291 lab=BL18}
N 3560 39000 3540 39000 {}
C {lab_pin.sym} 3540 39000 0 0 {name=l31292 lab=BLB18}
N 3560 38960 3540 38960 {}
C {lab_pin.sym} 3540 38960 0 0 {name=l31293 lab=WL195}
N 3640 39040 3660 39040 {}
C {lab_pin.sym} 3660 39040 0 0 {name=l31294 lab=VDD}
N 3640 38960 3660 38960 {}
C {lab_pin.sym} 3660 38960 0 0 {name=l31295 lab=VSS}
C {bitcell_6t.sym} 3800 39000 0 0 {name=Xr195c19}
N 3760 39040 3740 39040 {}
C {lab_pin.sym} 3740 39040 0 0 {name=l31296 lab=BL19}
N 3760 39000 3740 39000 {}
C {lab_pin.sym} 3740 39000 0 0 {name=l31297 lab=BLB19}
N 3760 38960 3740 38960 {}
C {lab_pin.sym} 3740 38960 0 0 {name=l31298 lab=WL195}
N 3840 39040 3860 39040 {}
C {lab_pin.sym} 3860 39040 0 0 {name=l31299 lab=VDD}
N 3840 38960 3860 38960 {}
C {lab_pin.sym} 3860 38960 0 0 {name=l31300 lab=VSS}
C {bitcell_6t.sym} 4000 39000 0 0 {name=Xr195c20}
N 3960 39040 3940 39040 {}
C {lab_pin.sym} 3940 39040 0 0 {name=l31301 lab=BL20}
N 3960 39000 3940 39000 {}
C {lab_pin.sym} 3940 39000 0 0 {name=l31302 lab=BLB20}
N 3960 38960 3940 38960 {}
C {lab_pin.sym} 3940 38960 0 0 {name=l31303 lab=WL195}
N 4040 39040 4060 39040 {}
C {lab_pin.sym} 4060 39040 0 0 {name=l31304 lab=VDD}
N 4040 38960 4060 38960 {}
C {lab_pin.sym} 4060 38960 0 0 {name=l31305 lab=VSS}
C {bitcell_6t.sym} 4200 39000 0 0 {name=Xr195c21}
N 4160 39040 4140 39040 {}
C {lab_pin.sym} 4140 39040 0 0 {name=l31306 lab=BL21}
N 4160 39000 4140 39000 {}
C {lab_pin.sym} 4140 39000 0 0 {name=l31307 lab=BLB21}
N 4160 38960 4140 38960 {}
C {lab_pin.sym} 4140 38960 0 0 {name=l31308 lab=WL195}
N 4240 39040 4260 39040 {}
C {lab_pin.sym} 4260 39040 0 0 {name=l31309 lab=VDD}
N 4240 38960 4260 38960 {}
C {lab_pin.sym} 4260 38960 0 0 {name=l31310 lab=VSS}
C {bitcell_6t.sym} 4400 39000 0 0 {name=Xr195c22}
N 4360 39040 4340 39040 {}
C {lab_pin.sym} 4340 39040 0 0 {name=l31311 lab=BL22}
N 4360 39000 4340 39000 {}
C {lab_pin.sym} 4340 39000 0 0 {name=l31312 lab=BLB22}
N 4360 38960 4340 38960 {}
C {lab_pin.sym} 4340 38960 0 0 {name=l31313 lab=WL195}
N 4440 39040 4460 39040 {}
C {lab_pin.sym} 4460 39040 0 0 {name=l31314 lab=VDD}
N 4440 38960 4460 38960 {}
C {lab_pin.sym} 4460 38960 0 0 {name=l31315 lab=VSS}
C {bitcell_6t.sym} 4600 39000 0 0 {name=Xr195c23}
N 4560 39040 4540 39040 {}
C {lab_pin.sym} 4540 39040 0 0 {name=l31316 lab=BL23}
N 4560 39000 4540 39000 {}
C {lab_pin.sym} 4540 39000 0 0 {name=l31317 lab=BLB23}
N 4560 38960 4540 38960 {}
C {lab_pin.sym} 4540 38960 0 0 {name=l31318 lab=WL195}
N 4640 39040 4660 39040 {}
C {lab_pin.sym} 4660 39040 0 0 {name=l31319 lab=VDD}
N 4640 38960 4660 38960 {}
C {lab_pin.sym} 4660 38960 0 0 {name=l31320 lab=VSS}
C {bitcell_6t.sym} 4800 39000 0 0 {name=Xr195c24}
N 4760 39040 4740 39040 {}
C {lab_pin.sym} 4740 39040 0 0 {name=l31321 lab=BL24}
N 4760 39000 4740 39000 {}
C {lab_pin.sym} 4740 39000 0 0 {name=l31322 lab=BLB24}
N 4760 38960 4740 38960 {}
C {lab_pin.sym} 4740 38960 0 0 {name=l31323 lab=WL195}
N 4840 39040 4860 39040 {}
C {lab_pin.sym} 4860 39040 0 0 {name=l31324 lab=VDD}
N 4840 38960 4860 38960 {}
C {lab_pin.sym} 4860 38960 0 0 {name=l31325 lab=VSS}
C {bitcell_6t.sym} 5000 39000 0 0 {name=Xr195c25}
N 4960 39040 4940 39040 {}
C {lab_pin.sym} 4940 39040 0 0 {name=l31326 lab=BL25}
N 4960 39000 4940 39000 {}
C {lab_pin.sym} 4940 39000 0 0 {name=l31327 lab=BLB25}
N 4960 38960 4940 38960 {}
C {lab_pin.sym} 4940 38960 0 0 {name=l31328 lab=WL195}
N 5040 39040 5060 39040 {}
C {lab_pin.sym} 5060 39040 0 0 {name=l31329 lab=VDD}
N 5040 38960 5060 38960 {}
C {lab_pin.sym} 5060 38960 0 0 {name=l31330 lab=VSS}
C {bitcell_6t.sym} 5200 39000 0 0 {name=Xr195c26}
N 5160 39040 5140 39040 {}
C {lab_pin.sym} 5140 39040 0 0 {name=l31331 lab=BL26}
N 5160 39000 5140 39000 {}
C {lab_pin.sym} 5140 39000 0 0 {name=l31332 lab=BLB26}
N 5160 38960 5140 38960 {}
C {lab_pin.sym} 5140 38960 0 0 {name=l31333 lab=WL195}
N 5240 39040 5260 39040 {}
C {lab_pin.sym} 5260 39040 0 0 {name=l31334 lab=VDD}
N 5240 38960 5260 38960 {}
C {lab_pin.sym} 5260 38960 0 0 {name=l31335 lab=VSS}
C {bitcell_6t.sym} 5400 39000 0 0 {name=Xr195c27}
N 5360 39040 5340 39040 {}
C {lab_pin.sym} 5340 39040 0 0 {name=l31336 lab=BL27}
N 5360 39000 5340 39000 {}
C {lab_pin.sym} 5340 39000 0 0 {name=l31337 lab=BLB27}
N 5360 38960 5340 38960 {}
C {lab_pin.sym} 5340 38960 0 0 {name=l31338 lab=WL195}
N 5440 39040 5460 39040 {}
C {lab_pin.sym} 5460 39040 0 0 {name=l31339 lab=VDD}
N 5440 38960 5460 38960 {}
C {lab_pin.sym} 5460 38960 0 0 {name=l31340 lab=VSS}
C {bitcell_6t.sym} 5600 39000 0 0 {name=Xr195c28}
N 5560 39040 5540 39040 {}
C {lab_pin.sym} 5540 39040 0 0 {name=l31341 lab=BL28}
N 5560 39000 5540 39000 {}
C {lab_pin.sym} 5540 39000 0 0 {name=l31342 lab=BLB28}
N 5560 38960 5540 38960 {}
C {lab_pin.sym} 5540 38960 0 0 {name=l31343 lab=WL195}
N 5640 39040 5660 39040 {}
C {lab_pin.sym} 5660 39040 0 0 {name=l31344 lab=VDD}
N 5640 38960 5660 38960 {}
C {lab_pin.sym} 5660 38960 0 0 {name=l31345 lab=VSS}
C {bitcell_6t.sym} 5800 39000 0 0 {name=Xr195c29}
N 5760 39040 5740 39040 {}
C {lab_pin.sym} 5740 39040 0 0 {name=l31346 lab=BL29}
N 5760 39000 5740 39000 {}
C {lab_pin.sym} 5740 39000 0 0 {name=l31347 lab=BLB29}
N 5760 38960 5740 38960 {}
C {lab_pin.sym} 5740 38960 0 0 {name=l31348 lab=WL195}
N 5840 39040 5860 39040 {}
C {lab_pin.sym} 5860 39040 0 0 {name=l31349 lab=VDD}
N 5840 38960 5860 38960 {}
C {lab_pin.sym} 5860 38960 0 0 {name=l31350 lab=VSS}
C {bitcell_6t.sym} 6000 39000 0 0 {name=Xr195c30}
N 5960 39040 5940 39040 {}
C {lab_pin.sym} 5940 39040 0 0 {name=l31351 lab=BL30}
N 5960 39000 5940 39000 {}
C {lab_pin.sym} 5940 39000 0 0 {name=l31352 lab=BLB30}
N 5960 38960 5940 38960 {}
C {lab_pin.sym} 5940 38960 0 0 {name=l31353 lab=WL195}
N 6040 39040 6060 39040 {}
C {lab_pin.sym} 6060 39040 0 0 {name=l31354 lab=VDD}
N 6040 38960 6060 38960 {}
C {lab_pin.sym} 6060 38960 0 0 {name=l31355 lab=VSS}
C {bitcell_6t.sym} 6200 39000 0 0 {name=Xr195c31}
N 6160 39040 6140 39040 {}
C {lab_pin.sym} 6140 39040 0 0 {name=l31356 lab=BL31}
N 6160 39000 6140 39000 {}
C {lab_pin.sym} 6140 39000 0 0 {name=l31357 lab=BLB31}
N 6160 38960 6140 38960 {}
C {lab_pin.sym} 6140 38960 0 0 {name=l31358 lab=WL195}
N 6240 39040 6260 39040 {}
C {lab_pin.sym} 6260 39040 0 0 {name=l31359 lab=VDD}
N 6240 38960 6260 38960 {}
C {lab_pin.sym} 6260 38960 0 0 {name=l31360 lab=VSS}
C {bitcell_6t.sym} 0 39200 0 0 {name=Xr196c0}
N -40 39240 -60 39240 {}
C {lab_pin.sym} -60 39240 0 0 {name=l31361 lab=BL0}
N -40 39200 -60 39200 {}
C {lab_pin.sym} -60 39200 0 0 {name=l31362 lab=BLB0}
N -40 39160 -60 39160 {}
C {lab_pin.sym} -60 39160 0 0 {name=l31363 lab=WL196}
N 40 39240 60 39240 {}
C {lab_pin.sym} 60 39240 0 0 {name=l31364 lab=VDD}
N 40 39160 60 39160 {}
C {lab_pin.sym} 60 39160 0 0 {name=l31365 lab=VSS}
C {bitcell_6t.sym} 200 39200 0 0 {name=Xr196c1}
N 160 39240 140 39240 {}
C {lab_pin.sym} 140 39240 0 0 {name=l31366 lab=BL1}
N 160 39200 140 39200 {}
C {lab_pin.sym} 140 39200 0 0 {name=l31367 lab=BLB1}
N 160 39160 140 39160 {}
C {lab_pin.sym} 140 39160 0 0 {name=l31368 lab=WL196}
N 240 39240 260 39240 {}
C {lab_pin.sym} 260 39240 0 0 {name=l31369 lab=VDD}
N 240 39160 260 39160 {}
C {lab_pin.sym} 260 39160 0 0 {name=l31370 lab=VSS}
C {bitcell_6t.sym} 400 39200 0 0 {name=Xr196c2}
N 360 39240 340 39240 {}
C {lab_pin.sym} 340 39240 0 0 {name=l31371 lab=BL2}
N 360 39200 340 39200 {}
C {lab_pin.sym} 340 39200 0 0 {name=l31372 lab=BLB2}
N 360 39160 340 39160 {}
C {lab_pin.sym} 340 39160 0 0 {name=l31373 lab=WL196}
N 440 39240 460 39240 {}
C {lab_pin.sym} 460 39240 0 0 {name=l31374 lab=VDD}
N 440 39160 460 39160 {}
C {lab_pin.sym} 460 39160 0 0 {name=l31375 lab=VSS}
C {bitcell_6t.sym} 600 39200 0 0 {name=Xr196c3}
N 560 39240 540 39240 {}
C {lab_pin.sym} 540 39240 0 0 {name=l31376 lab=BL3}
N 560 39200 540 39200 {}
C {lab_pin.sym} 540 39200 0 0 {name=l31377 lab=BLB3}
N 560 39160 540 39160 {}
C {lab_pin.sym} 540 39160 0 0 {name=l31378 lab=WL196}
N 640 39240 660 39240 {}
C {lab_pin.sym} 660 39240 0 0 {name=l31379 lab=VDD}
N 640 39160 660 39160 {}
C {lab_pin.sym} 660 39160 0 0 {name=l31380 lab=VSS}
C {bitcell_6t.sym} 800 39200 0 0 {name=Xr196c4}
N 760 39240 740 39240 {}
C {lab_pin.sym} 740 39240 0 0 {name=l31381 lab=BL4}
N 760 39200 740 39200 {}
C {lab_pin.sym} 740 39200 0 0 {name=l31382 lab=BLB4}
N 760 39160 740 39160 {}
C {lab_pin.sym} 740 39160 0 0 {name=l31383 lab=WL196}
N 840 39240 860 39240 {}
C {lab_pin.sym} 860 39240 0 0 {name=l31384 lab=VDD}
N 840 39160 860 39160 {}
C {lab_pin.sym} 860 39160 0 0 {name=l31385 lab=VSS}
C {bitcell_6t.sym} 1000 39200 0 0 {name=Xr196c5}
N 960 39240 940 39240 {}
C {lab_pin.sym} 940 39240 0 0 {name=l31386 lab=BL5}
N 960 39200 940 39200 {}
C {lab_pin.sym} 940 39200 0 0 {name=l31387 lab=BLB5}
N 960 39160 940 39160 {}
C {lab_pin.sym} 940 39160 0 0 {name=l31388 lab=WL196}
N 1040 39240 1060 39240 {}
C {lab_pin.sym} 1060 39240 0 0 {name=l31389 lab=VDD}
N 1040 39160 1060 39160 {}
C {lab_pin.sym} 1060 39160 0 0 {name=l31390 lab=VSS}
C {bitcell_6t.sym} 1200 39200 0 0 {name=Xr196c6}
N 1160 39240 1140 39240 {}
C {lab_pin.sym} 1140 39240 0 0 {name=l31391 lab=BL6}
N 1160 39200 1140 39200 {}
C {lab_pin.sym} 1140 39200 0 0 {name=l31392 lab=BLB6}
N 1160 39160 1140 39160 {}
C {lab_pin.sym} 1140 39160 0 0 {name=l31393 lab=WL196}
N 1240 39240 1260 39240 {}
C {lab_pin.sym} 1260 39240 0 0 {name=l31394 lab=VDD}
N 1240 39160 1260 39160 {}
C {lab_pin.sym} 1260 39160 0 0 {name=l31395 lab=VSS}
C {bitcell_6t.sym} 1400 39200 0 0 {name=Xr196c7}
N 1360 39240 1340 39240 {}
C {lab_pin.sym} 1340 39240 0 0 {name=l31396 lab=BL7}
N 1360 39200 1340 39200 {}
C {lab_pin.sym} 1340 39200 0 0 {name=l31397 lab=BLB7}
N 1360 39160 1340 39160 {}
C {lab_pin.sym} 1340 39160 0 0 {name=l31398 lab=WL196}
N 1440 39240 1460 39240 {}
C {lab_pin.sym} 1460 39240 0 0 {name=l31399 lab=VDD}
N 1440 39160 1460 39160 {}
C {lab_pin.sym} 1460 39160 0 0 {name=l31400 lab=VSS}
C {bitcell_6t.sym} 1600 39200 0 0 {name=Xr196c8}
N 1560 39240 1540 39240 {}
C {lab_pin.sym} 1540 39240 0 0 {name=l31401 lab=BL8}
N 1560 39200 1540 39200 {}
C {lab_pin.sym} 1540 39200 0 0 {name=l31402 lab=BLB8}
N 1560 39160 1540 39160 {}
C {lab_pin.sym} 1540 39160 0 0 {name=l31403 lab=WL196}
N 1640 39240 1660 39240 {}
C {lab_pin.sym} 1660 39240 0 0 {name=l31404 lab=VDD}
N 1640 39160 1660 39160 {}
C {lab_pin.sym} 1660 39160 0 0 {name=l31405 lab=VSS}
C {bitcell_6t.sym} 1800 39200 0 0 {name=Xr196c9}
N 1760 39240 1740 39240 {}
C {lab_pin.sym} 1740 39240 0 0 {name=l31406 lab=BL9}
N 1760 39200 1740 39200 {}
C {lab_pin.sym} 1740 39200 0 0 {name=l31407 lab=BLB9}
N 1760 39160 1740 39160 {}
C {lab_pin.sym} 1740 39160 0 0 {name=l31408 lab=WL196}
N 1840 39240 1860 39240 {}
C {lab_pin.sym} 1860 39240 0 0 {name=l31409 lab=VDD}
N 1840 39160 1860 39160 {}
C {lab_pin.sym} 1860 39160 0 0 {name=l31410 lab=VSS}
C {bitcell_6t.sym} 2000 39200 0 0 {name=Xr196c10}
N 1960 39240 1940 39240 {}
C {lab_pin.sym} 1940 39240 0 0 {name=l31411 lab=BL10}
N 1960 39200 1940 39200 {}
C {lab_pin.sym} 1940 39200 0 0 {name=l31412 lab=BLB10}
N 1960 39160 1940 39160 {}
C {lab_pin.sym} 1940 39160 0 0 {name=l31413 lab=WL196}
N 2040 39240 2060 39240 {}
C {lab_pin.sym} 2060 39240 0 0 {name=l31414 lab=VDD}
N 2040 39160 2060 39160 {}
C {lab_pin.sym} 2060 39160 0 0 {name=l31415 lab=VSS}
C {bitcell_6t.sym} 2200 39200 0 0 {name=Xr196c11}
N 2160 39240 2140 39240 {}
C {lab_pin.sym} 2140 39240 0 0 {name=l31416 lab=BL11}
N 2160 39200 2140 39200 {}
C {lab_pin.sym} 2140 39200 0 0 {name=l31417 lab=BLB11}
N 2160 39160 2140 39160 {}
C {lab_pin.sym} 2140 39160 0 0 {name=l31418 lab=WL196}
N 2240 39240 2260 39240 {}
C {lab_pin.sym} 2260 39240 0 0 {name=l31419 lab=VDD}
N 2240 39160 2260 39160 {}
C {lab_pin.sym} 2260 39160 0 0 {name=l31420 lab=VSS}
C {bitcell_6t.sym} 2400 39200 0 0 {name=Xr196c12}
N 2360 39240 2340 39240 {}
C {lab_pin.sym} 2340 39240 0 0 {name=l31421 lab=BL12}
N 2360 39200 2340 39200 {}
C {lab_pin.sym} 2340 39200 0 0 {name=l31422 lab=BLB12}
N 2360 39160 2340 39160 {}
C {lab_pin.sym} 2340 39160 0 0 {name=l31423 lab=WL196}
N 2440 39240 2460 39240 {}
C {lab_pin.sym} 2460 39240 0 0 {name=l31424 lab=VDD}
N 2440 39160 2460 39160 {}
C {lab_pin.sym} 2460 39160 0 0 {name=l31425 lab=VSS}
C {bitcell_6t.sym} 2600 39200 0 0 {name=Xr196c13}
N 2560 39240 2540 39240 {}
C {lab_pin.sym} 2540 39240 0 0 {name=l31426 lab=BL13}
N 2560 39200 2540 39200 {}
C {lab_pin.sym} 2540 39200 0 0 {name=l31427 lab=BLB13}
N 2560 39160 2540 39160 {}
C {lab_pin.sym} 2540 39160 0 0 {name=l31428 lab=WL196}
N 2640 39240 2660 39240 {}
C {lab_pin.sym} 2660 39240 0 0 {name=l31429 lab=VDD}
N 2640 39160 2660 39160 {}
C {lab_pin.sym} 2660 39160 0 0 {name=l31430 lab=VSS}
C {bitcell_6t.sym} 2800 39200 0 0 {name=Xr196c14}
N 2760 39240 2740 39240 {}
C {lab_pin.sym} 2740 39240 0 0 {name=l31431 lab=BL14}
N 2760 39200 2740 39200 {}
C {lab_pin.sym} 2740 39200 0 0 {name=l31432 lab=BLB14}
N 2760 39160 2740 39160 {}
C {lab_pin.sym} 2740 39160 0 0 {name=l31433 lab=WL196}
N 2840 39240 2860 39240 {}
C {lab_pin.sym} 2860 39240 0 0 {name=l31434 lab=VDD}
N 2840 39160 2860 39160 {}
C {lab_pin.sym} 2860 39160 0 0 {name=l31435 lab=VSS}
C {bitcell_6t.sym} 3000 39200 0 0 {name=Xr196c15}
N 2960 39240 2940 39240 {}
C {lab_pin.sym} 2940 39240 0 0 {name=l31436 lab=BL15}
N 2960 39200 2940 39200 {}
C {lab_pin.sym} 2940 39200 0 0 {name=l31437 lab=BLB15}
N 2960 39160 2940 39160 {}
C {lab_pin.sym} 2940 39160 0 0 {name=l31438 lab=WL196}
N 3040 39240 3060 39240 {}
C {lab_pin.sym} 3060 39240 0 0 {name=l31439 lab=VDD}
N 3040 39160 3060 39160 {}
C {lab_pin.sym} 3060 39160 0 0 {name=l31440 lab=VSS}
C {bitcell_6t.sym} 3200 39200 0 0 {name=Xr196c16}
N 3160 39240 3140 39240 {}
C {lab_pin.sym} 3140 39240 0 0 {name=l31441 lab=BL16}
N 3160 39200 3140 39200 {}
C {lab_pin.sym} 3140 39200 0 0 {name=l31442 lab=BLB16}
N 3160 39160 3140 39160 {}
C {lab_pin.sym} 3140 39160 0 0 {name=l31443 lab=WL196}
N 3240 39240 3260 39240 {}
C {lab_pin.sym} 3260 39240 0 0 {name=l31444 lab=VDD}
N 3240 39160 3260 39160 {}
C {lab_pin.sym} 3260 39160 0 0 {name=l31445 lab=VSS}
C {bitcell_6t.sym} 3400 39200 0 0 {name=Xr196c17}
N 3360 39240 3340 39240 {}
C {lab_pin.sym} 3340 39240 0 0 {name=l31446 lab=BL17}
N 3360 39200 3340 39200 {}
C {lab_pin.sym} 3340 39200 0 0 {name=l31447 lab=BLB17}
N 3360 39160 3340 39160 {}
C {lab_pin.sym} 3340 39160 0 0 {name=l31448 lab=WL196}
N 3440 39240 3460 39240 {}
C {lab_pin.sym} 3460 39240 0 0 {name=l31449 lab=VDD}
N 3440 39160 3460 39160 {}
C {lab_pin.sym} 3460 39160 0 0 {name=l31450 lab=VSS}
C {bitcell_6t.sym} 3600 39200 0 0 {name=Xr196c18}
N 3560 39240 3540 39240 {}
C {lab_pin.sym} 3540 39240 0 0 {name=l31451 lab=BL18}
N 3560 39200 3540 39200 {}
C {lab_pin.sym} 3540 39200 0 0 {name=l31452 lab=BLB18}
N 3560 39160 3540 39160 {}
C {lab_pin.sym} 3540 39160 0 0 {name=l31453 lab=WL196}
N 3640 39240 3660 39240 {}
C {lab_pin.sym} 3660 39240 0 0 {name=l31454 lab=VDD}
N 3640 39160 3660 39160 {}
C {lab_pin.sym} 3660 39160 0 0 {name=l31455 lab=VSS}
C {bitcell_6t.sym} 3800 39200 0 0 {name=Xr196c19}
N 3760 39240 3740 39240 {}
C {lab_pin.sym} 3740 39240 0 0 {name=l31456 lab=BL19}
N 3760 39200 3740 39200 {}
C {lab_pin.sym} 3740 39200 0 0 {name=l31457 lab=BLB19}
N 3760 39160 3740 39160 {}
C {lab_pin.sym} 3740 39160 0 0 {name=l31458 lab=WL196}
N 3840 39240 3860 39240 {}
C {lab_pin.sym} 3860 39240 0 0 {name=l31459 lab=VDD}
N 3840 39160 3860 39160 {}
C {lab_pin.sym} 3860 39160 0 0 {name=l31460 lab=VSS}
C {bitcell_6t.sym} 4000 39200 0 0 {name=Xr196c20}
N 3960 39240 3940 39240 {}
C {lab_pin.sym} 3940 39240 0 0 {name=l31461 lab=BL20}
N 3960 39200 3940 39200 {}
C {lab_pin.sym} 3940 39200 0 0 {name=l31462 lab=BLB20}
N 3960 39160 3940 39160 {}
C {lab_pin.sym} 3940 39160 0 0 {name=l31463 lab=WL196}
N 4040 39240 4060 39240 {}
C {lab_pin.sym} 4060 39240 0 0 {name=l31464 lab=VDD}
N 4040 39160 4060 39160 {}
C {lab_pin.sym} 4060 39160 0 0 {name=l31465 lab=VSS}
C {bitcell_6t.sym} 4200 39200 0 0 {name=Xr196c21}
N 4160 39240 4140 39240 {}
C {lab_pin.sym} 4140 39240 0 0 {name=l31466 lab=BL21}
N 4160 39200 4140 39200 {}
C {lab_pin.sym} 4140 39200 0 0 {name=l31467 lab=BLB21}
N 4160 39160 4140 39160 {}
C {lab_pin.sym} 4140 39160 0 0 {name=l31468 lab=WL196}
N 4240 39240 4260 39240 {}
C {lab_pin.sym} 4260 39240 0 0 {name=l31469 lab=VDD}
N 4240 39160 4260 39160 {}
C {lab_pin.sym} 4260 39160 0 0 {name=l31470 lab=VSS}
C {bitcell_6t.sym} 4400 39200 0 0 {name=Xr196c22}
N 4360 39240 4340 39240 {}
C {lab_pin.sym} 4340 39240 0 0 {name=l31471 lab=BL22}
N 4360 39200 4340 39200 {}
C {lab_pin.sym} 4340 39200 0 0 {name=l31472 lab=BLB22}
N 4360 39160 4340 39160 {}
C {lab_pin.sym} 4340 39160 0 0 {name=l31473 lab=WL196}
N 4440 39240 4460 39240 {}
C {lab_pin.sym} 4460 39240 0 0 {name=l31474 lab=VDD}
N 4440 39160 4460 39160 {}
C {lab_pin.sym} 4460 39160 0 0 {name=l31475 lab=VSS}
C {bitcell_6t.sym} 4600 39200 0 0 {name=Xr196c23}
N 4560 39240 4540 39240 {}
C {lab_pin.sym} 4540 39240 0 0 {name=l31476 lab=BL23}
N 4560 39200 4540 39200 {}
C {lab_pin.sym} 4540 39200 0 0 {name=l31477 lab=BLB23}
N 4560 39160 4540 39160 {}
C {lab_pin.sym} 4540 39160 0 0 {name=l31478 lab=WL196}
N 4640 39240 4660 39240 {}
C {lab_pin.sym} 4660 39240 0 0 {name=l31479 lab=VDD}
N 4640 39160 4660 39160 {}
C {lab_pin.sym} 4660 39160 0 0 {name=l31480 lab=VSS}
C {bitcell_6t.sym} 4800 39200 0 0 {name=Xr196c24}
N 4760 39240 4740 39240 {}
C {lab_pin.sym} 4740 39240 0 0 {name=l31481 lab=BL24}
N 4760 39200 4740 39200 {}
C {lab_pin.sym} 4740 39200 0 0 {name=l31482 lab=BLB24}
N 4760 39160 4740 39160 {}
C {lab_pin.sym} 4740 39160 0 0 {name=l31483 lab=WL196}
N 4840 39240 4860 39240 {}
C {lab_pin.sym} 4860 39240 0 0 {name=l31484 lab=VDD}
N 4840 39160 4860 39160 {}
C {lab_pin.sym} 4860 39160 0 0 {name=l31485 lab=VSS}
C {bitcell_6t.sym} 5000 39200 0 0 {name=Xr196c25}
N 4960 39240 4940 39240 {}
C {lab_pin.sym} 4940 39240 0 0 {name=l31486 lab=BL25}
N 4960 39200 4940 39200 {}
C {lab_pin.sym} 4940 39200 0 0 {name=l31487 lab=BLB25}
N 4960 39160 4940 39160 {}
C {lab_pin.sym} 4940 39160 0 0 {name=l31488 lab=WL196}
N 5040 39240 5060 39240 {}
C {lab_pin.sym} 5060 39240 0 0 {name=l31489 lab=VDD}
N 5040 39160 5060 39160 {}
C {lab_pin.sym} 5060 39160 0 0 {name=l31490 lab=VSS}
C {bitcell_6t.sym} 5200 39200 0 0 {name=Xr196c26}
N 5160 39240 5140 39240 {}
C {lab_pin.sym} 5140 39240 0 0 {name=l31491 lab=BL26}
N 5160 39200 5140 39200 {}
C {lab_pin.sym} 5140 39200 0 0 {name=l31492 lab=BLB26}
N 5160 39160 5140 39160 {}
C {lab_pin.sym} 5140 39160 0 0 {name=l31493 lab=WL196}
N 5240 39240 5260 39240 {}
C {lab_pin.sym} 5260 39240 0 0 {name=l31494 lab=VDD}
N 5240 39160 5260 39160 {}
C {lab_pin.sym} 5260 39160 0 0 {name=l31495 lab=VSS}
C {bitcell_6t.sym} 5400 39200 0 0 {name=Xr196c27}
N 5360 39240 5340 39240 {}
C {lab_pin.sym} 5340 39240 0 0 {name=l31496 lab=BL27}
N 5360 39200 5340 39200 {}
C {lab_pin.sym} 5340 39200 0 0 {name=l31497 lab=BLB27}
N 5360 39160 5340 39160 {}
C {lab_pin.sym} 5340 39160 0 0 {name=l31498 lab=WL196}
N 5440 39240 5460 39240 {}
C {lab_pin.sym} 5460 39240 0 0 {name=l31499 lab=VDD}
N 5440 39160 5460 39160 {}
C {lab_pin.sym} 5460 39160 0 0 {name=l31500 lab=VSS}
C {bitcell_6t.sym} 5600 39200 0 0 {name=Xr196c28}
N 5560 39240 5540 39240 {}
C {lab_pin.sym} 5540 39240 0 0 {name=l31501 lab=BL28}
N 5560 39200 5540 39200 {}
C {lab_pin.sym} 5540 39200 0 0 {name=l31502 lab=BLB28}
N 5560 39160 5540 39160 {}
C {lab_pin.sym} 5540 39160 0 0 {name=l31503 lab=WL196}
N 5640 39240 5660 39240 {}
C {lab_pin.sym} 5660 39240 0 0 {name=l31504 lab=VDD}
N 5640 39160 5660 39160 {}
C {lab_pin.sym} 5660 39160 0 0 {name=l31505 lab=VSS}
C {bitcell_6t.sym} 5800 39200 0 0 {name=Xr196c29}
N 5760 39240 5740 39240 {}
C {lab_pin.sym} 5740 39240 0 0 {name=l31506 lab=BL29}
N 5760 39200 5740 39200 {}
C {lab_pin.sym} 5740 39200 0 0 {name=l31507 lab=BLB29}
N 5760 39160 5740 39160 {}
C {lab_pin.sym} 5740 39160 0 0 {name=l31508 lab=WL196}
N 5840 39240 5860 39240 {}
C {lab_pin.sym} 5860 39240 0 0 {name=l31509 lab=VDD}
N 5840 39160 5860 39160 {}
C {lab_pin.sym} 5860 39160 0 0 {name=l31510 lab=VSS}
C {bitcell_6t.sym} 6000 39200 0 0 {name=Xr196c30}
N 5960 39240 5940 39240 {}
C {lab_pin.sym} 5940 39240 0 0 {name=l31511 lab=BL30}
N 5960 39200 5940 39200 {}
C {lab_pin.sym} 5940 39200 0 0 {name=l31512 lab=BLB30}
N 5960 39160 5940 39160 {}
C {lab_pin.sym} 5940 39160 0 0 {name=l31513 lab=WL196}
N 6040 39240 6060 39240 {}
C {lab_pin.sym} 6060 39240 0 0 {name=l31514 lab=VDD}
N 6040 39160 6060 39160 {}
C {lab_pin.sym} 6060 39160 0 0 {name=l31515 lab=VSS}
C {bitcell_6t.sym} 6200 39200 0 0 {name=Xr196c31}
N 6160 39240 6140 39240 {}
C {lab_pin.sym} 6140 39240 0 0 {name=l31516 lab=BL31}
N 6160 39200 6140 39200 {}
C {lab_pin.sym} 6140 39200 0 0 {name=l31517 lab=BLB31}
N 6160 39160 6140 39160 {}
C {lab_pin.sym} 6140 39160 0 0 {name=l31518 lab=WL196}
N 6240 39240 6260 39240 {}
C {lab_pin.sym} 6260 39240 0 0 {name=l31519 lab=VDD}
N 6240 39160 6260 39160 {}
C {lab_pin.sym} 6260 39160 0 0 {name=l31520 lab=VSS}
C {bitcell_6t.sym} 0 39400 0 0 {name=Xr197c0}
N -40 39440 -60 39440 {}
C {lab_pin.sym} -60 39440 0 0 {name=l31521 lab=BL0}
N -40 39400 -60 39400 {}
C {lab_pin.sym} -60 39400 0 0 {name=l31522 lab=BLB0}
N -40 39360 -60 39360 {}
C {lab_pin.sym} -60 39360 0 0 {name=l31523 lab=WL197}
N 40 39440 60 39440 {}
C {lab_pin.sym} 60 39440 0 0 {name=l31524 lab=VDD}
N 40 39360 60 39360 {}
C {lab_pin.sym} 60 39360 0 0 {name=l31525 lab=VSS}
C {bitcell_6t.sym} 200 39400 0 0 {name=Xr197c1}
N 160 39440 140 39440 {}
C {lab_pin.sym} 140 39440 0 0 {name=l31526 lab=BL1}
N 160 39400 140 39400 {}
C {lab_pin.sym} 140 39400 0 0 {name=l31527 lab=BLB1}
N 160 39360 140 39360 {}
C {lab_pin.sym} 140 39360 0 0 {name=l31528 lab=WL197}
N 240 39440 260 39440 {}
C {lab_pin.sym} 260 39440 0 0 {name=l31529 lab=VDD}
N 240 39360 260 39360 {}
C {lab_pin.sym} 260 39360 0 0 {name=l31530 lab=VSS}
C {bitcell_6t.sym} 400 39400 0 0 {name=Xr197c2}
N 360 39440 340 39440 {}
C {lab_pin.sym} 340 39440 0 0 {name=l31531 lab=BL2}
N 360 39400 340 39400 {}
C {lab_pin.sym} 340 39400 0 0 {name=l31532 lab=BLB2}
N 360 39360 340 39360 {}
C {lab_pin.sym} 340 39360 0 0 {name=l31533 lab=WL197}
N 440 39440 460 39440 {}
C {lab_pin.sym} 460 39440 0 0 {name=l31534 lab=VDD}
N 440 39360 460 39360 {}
C {lab_pin.sym} 460 39360 0 0 {name=l31535 lab=VSS}
C {bitcell_6t.sym} 600 39400 0 0 {name=Xr197c3}
N 560 39440 540 39440 {}
C {lab_pin.sym} 540 39440 0 0 {name=l31536 lab=BL3}
N 560 39400 540 39400 {}
C {lab_pin.sym} 540 39400 0 0 {name=l31537 lab=BLB3}
N 560 39360 540 39360 {}
C {lab_pin.sym} 540 39360 0 0 {name=l31538 lab=WL197}
N 640 39440 660 39440 {}
C {lab_pin.sym} 660 39440 0 0 {name=l31539 lab=VDD}
N 640 39360 660 39360 {}
C {lab_pin.sym} 660 39360 0 0 {name=l31540 lab=VSS}
C {bitcell_6t.sym} 800 39400 0 0 {name=Xr197c4}
N 760 39440 740 39440 {}
C {lab_pin.sym} 740 39440 0 0 {name=l31541 lab=BL4}
N 760 39400 740 39400 {}
C {lab_pin.sym} 740 39400 0 0 {name=l31542 lab=BLB4}
N 760 39360 740 39360 {}
C {lab_pin.sym} 740 39360 0 0 {name=l31543 lab=WL197}
N 840 39440 860 39440 {}
C {lab_pin.sym} 860 39440 0 0 {name=l31544 lab=VDD}
N 840 39360 860 39360 {}
C {lab_pin.sym} 860 39360 0 0 {name=l31545 lab=VSS}
