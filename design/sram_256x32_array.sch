C {lab_pin.sym} 5460 44840 0 0 {name=l35979 lab=VDD}
N 5440 44760 5460 44760 {}
C {lab_pin.sym} 5460 44760 0 0 {name=l35980 lab=VSS}
C {bitcell_6t.sym} 5600 44800 0 0 {name=Xr224c28}
N 5560 44840 5540 44840 {}
C {lab_pin.sym} 5540 44840 0 0 {name=l35981 lab=BL28}
N 5560 44800 5540 44800 {}
C {lab_pin.sym} 5540 44800 0 0 {name=l35982 lab=BLB28}
N 5560 44760 5540 44760 {}
C {lab_pin.sym} 5540 44760 0 0 {name=l35983 lab=WL224}
N 5640 44840 5660 44840 {}
C {lab_pin.sym} 5660 44840 0 0 {name=l35984 lab=VDD}
N 5640 44760 5660 44760 {}
C {lab_pin.sym} 5660 44760 0 0 {name=l35985 lab=VSS}
C {bitcell_6t.sym} 5800 44800 0 0 {name=Xr224c29}
N 5760 44840 5740 44840 {}
C {lab_pin.sym} 5740 44840 0 0 {name=l35986 lab=BL29}
N 5760 44800 5740 44800 {}
C {lab_pin.sym} 5740 44800 0 0 {name=l35987 lab=BLB29}
N 5760 44760 5740 44760 {}
C {lab_pin.sym} 5740 44760 0 0 {name=l35988 lab=WL224}
N 5840 44840 5860 44840 {}
C {lab_pin.sym} 5860 44840 0 0 {name=l35989 lab=VDD}
N 5840 44760 5860 44760 {}
C {lab_pin.sym} 5860 44760 0 0 {name=l35990 lab=VSS}
C {bitcell_6t.sym} 6000 44800 0 0 {name=Xr224c30}
N 5960 44840 5940 44840 {}
C {lab_pin.sym} 5940 44840 0 0 {name=l35991 lab=BL30}
N 5960 44800 5940 44800 {}
C {lab_pin.sym} 5940 44800 0 0 {name=l35992 lab=BLB30}
N 5960 44760 5940 44760 {}
C {lab_pin.sym} 5940 44760 0 0 {name=l35993 lab=WL224}
N 6040 44840 6060 44840 {}
C {lab_pin.sym} 6060 44840 0 0 {name=l35994 lab=VDD}
N 6040 44760 6060 44760 {}
C {lab_pin.sym} 6060 44760 0 0 {name=l35995 lab=VSS}
C {bitcell_6t.sym} 6200 44800 0 0 {name=Xr224c31}
N 6160 44840 6140 44840 {}
C {lab_pin.sym} 6140 44840 0 0 {name=l35996 lab=BL31}
N 6160 44800 6140 44800 {}
C {lab_pin.sym} 6140 44800 0 0 {name=l35997 lab=BLB31}
N 6160 44760 6140 44760 {}
C {lab_pin.sym} 6140 44760 0 0 {name=l35998 lab=WL224}
N 6240 44840 6260 44840 {}
C {lab_pin.sym} 6260 44840 0 0 {name=l35999 lab=VDD}
N 6240 44760 6260 44760 {}
C {lab_pin.sym} 6260 44760 0 0 {name=l36000 lab=VSS}
C {bitcell_6t.sym} 0 45000 0 0 {name=Xr225c0}
N -40 45040 -60 45040 {}
C {lab_pin.sym} -60 45040 0 0 {name=l36001 lab=BL0}
N -40 45000 -60 45000 {}
C {lab_pin.sym} -60 45000 0 0 {name=l36002 lab=BLB0}
N -40 44960 -60 44960 {}
C {lab_pin.sym} -60 44960 0 0 {name=l36003 lab=WL225}
N 40 45040 60 45040 {}
C {lab_pin.sym} 60 45040 0 0 {name=l36004 lab=VDD}
N 40 44960 60 44960 {}
C {lab_pin.sym} 60 44960 0 0 {name=l36005 lab=VSS}
C {bitcell_6t.sym} 200 45000 0 0 {name=Xr225c1}
N 160 45040 140 45040 {}
C {lab_pin.sym} 140 45040 0 0 {name=l36006 lab=BL1}
N 160 45000 140 45000 {}
C {lab_pin.sym} 140 45000 0 0 {name=l36007 lab=BLB1}
N 160 44960 140 44960 {}
C {lab_pin.sym} 140 44960 0 0 {name=l36008 lab=WL225}
N 240 45040 260 45040 {}
C {lab_pin.sym} 260 45040 0 0 {name=l36009 lab=VDD}
N 240 44960 260 44960 {}
C {lab_pin.sym} 260 44960 0 0 {name=l36010 lab=VSS}
C {bitcell_6t.sym} 400 45000 0 0 {name=Xr225c2}
N 360 45040 340 45040 {}
C {lab_pin.sym} 340 45040 0 0 {name=l36011 lab=BL2}
N 360 45000 340 45000 {}
C {lab_pin.sym} 340 45000 0 0 {name=l36012 lab=BLB2}
N 360 44960 340 44960 {}
C {lab_pin.sym} 340 44960 0 0 {name=l36013 lab=WL225}
N 440 45040 460 45040 {}
C {lab_pin.sym} 460 45040 0 0 {name=l36014 lab=VDD}
N 440 44960 460 44960 {}
C {lab_pin.sym} 460 44960 0 0 {name=l36015 lab=VSS}
C {bitcell_6t.sym} 600 45000 0 0 {name=Xr225c3}
N 560 45040 540 45040 {}
C {lab_pin.sym} 540 45040 0 0 {name=l36016 lab=BL3}
N 560 45000 540 45000 {}
C {lab_pin.sym} 540 45000 0 0 {name=l36017 lab=BLB3}
N 560 44960 540 44960 {}
C {lab_pin.sym} 540 44960 0 0 {name=l36018 lab=WL225}
N 640 45040 660 45040 {}
C {lab_pin.sym} 660 45040 0 0 {name=l36019 lab=VDD}
N 640 44960 660 44960 {}
C {lab_pin.sym} 660 44960 0 0 {name=l36020 lab=VSS}
C {bitcell_6t.sym} 800 45000 0 0 {name=Xr225c4}
N 760 45040 740 45040 {}
C {lab_pin.sym} 740 45040 0 0 {name=l36021 lab=BL4}
N 760 45000 740 45000 {}
C {lab_pin.sym} 740 45000 0 0 {name=l36022 lab=BLB4}
N 760 44960 740 44960 {}
C {lab_pin.sym} 740 44960 0 0 {name=l36023 lab=WL225}
N 840 45040 860 45040 {}
C {lab_pin.sym} 860 45040 0 0 {name=l36024 lab=VDD}
N 840 44960 860 44960 {}
C {lab_pin.sym} 860 44960 0 0 {name=l36025 lab=VSS}
C {bitcell_6t.sym} 1000 45000 0 0 {name=Xr225c5}
N 960 45040 940 45040 {}
C {lab_pin.sym} 940 45040 0 0 {name=l36026 lab=BL5}
N 960 45000 940 45000 {}
C {lab_pin.sym} 940 45000 0 0 {name=l36027 lab=BLB5}
N 960 44960 940 44960 {}
C {lab_pin.sym} 940 44960 0 0 {name=l36028 lab=WL225}
N 1040 45040 1060 45040 {}
C {lab_pin.sym} 1060 45040 0 0 {name=l36029 lab=VDD}
N 1040 44960 1060 44960 {}
C {lab_pin.sym} 1060 44960 0 0 {name=l36030 lab=VSS}
C {bitcell_6t.sym} 1200 45000 0 0 {name=Xr225c6}
N 1160 45040 1140 45040 {}
C {lab_pin.sym} 1140 45040 0 0 {name=l36031 lab=BL6}
N 1160 45000 1140 45000 {}
C {lab_pin.sym} 1140 45000 0 0 {name=l36032 lab=BLB6}
N 1160 44960 1140 44960 {}
C {lab_pin.sym} 1140 44960 0 0 {name=l36033 lab=WL225}
N 1240 45040 1260 45040 {}
C {lab_pin.sym} 1260 45040 0 0 {name=l36034 lab=VDD}
N 1240 44960 1260 44960 {}
C {lab_pin.sym} 1260 44960 0 0 {name=l36035 lab=VSS}
C {bitcell_6t.sym} 1400 45000 0 0 {name=Xr225c7}
N 1360 45040 1340 45040 {}
C {lab_pin.sym} 1340 45040 0 0 {name=l36036 lab=BL7}
N 1360 45000 1340 45000 {}
C {lab_pin.sym} 1340 45000 0 0 {name=l36037 lab=BLB7}
N 1360 44960 1340 44960 {}
C {lab_pin.sym} 1340 44960 0 0 {name=l36038 lab=WL225}
N 1440 45040 1460 45040 {}
C {lab_pin.sym} 1460 45040 0 0 {name=l36039 lab=VDD}
N 1440 44960 1460 44960 {}
C {lab_pin.sym} 1460 44960 0 0 {name=l36040 lab=VSS}
C {bitcell_6t.sym} 1600 45000 0 0 {name=Xr225c8}
N 1560 45040 1540 45040 {}
C {lab_pin.sym} 1540 45040 0 0 {name=l36041 lab=BL8}
N 1560 45000 1540 45000 {}
C {lab_pin.sym} 1540 45000 0 0 {name=l36042 lab=BLB8}
N 1560 44960 1540 44960 {}
C {lab_pin.sym} 1540 44960 0 0 {name=l36043 lab=WL225}
N 1640 45040 1660 45040 {}
C {lab_pin.sym} 1660 45040 0 0 {name=l36044 lab=VDD}
N 1640 44960 1660 44960 {}
C {lab_pin.sym} 1660 44960 0 0 {name=l36045 lab=VSS}
C {bitcell_6t.sym} 1800 45000 0 0 {name=Xr225c9}
N 1760 45040 1740 45040 {}
C {lab_pin.sym} 1740 45040 0 0 {name=l36046 lab=BL9}
N 1760 45000 1740 45000 {}
C {lab_pin.sym} 1740 45000 0 0 {name=l36047 lab=BLB9}
N 1760 44960 1740 44960 {}
C {lab_pin.sym} 1740 44960 0 0 {name=l36048 lab=WL225}
N 1840 45040 1860 45040 {}
C {lab_pin.sym} 1860 45040 0 0 {name=l36049 lab=VDD}
N 1840 44960 1860 44960 {}
C {lab_pin.sym} 1860 44960 0 0 {name=l36050 lab=VSS}
C {bitcell_6t.sym} 2000 45000 0 0 {name=Xr225c10}
N 1960 45040 1940 45040 {}
C {lab_pin.sym} 1940 45040 0 0 {name=l36051 lab=BL10}
N 1960 45000 1940 45000 {}
C {lab_pin.sym} 1940 45000 0 0 {name=l36052 lab=BLB10}
N 1960 44960 1940 44960 {}
C {lab_pin.sym} 1940 44960 0 0 {name=l36053 lab=WL225}
N 2040 45040 2060 45040 {}
C {lab_pin.sym} 2060 45040 0 0 {name=l36054 lab=VDD}
N 2040 44960 2060 44960 {}
C {lab_pin.sym} 2060 44960 0 0 {name=l36055 lab=VSS}
C {bitcell_6t.sym} 2200 45000 0 0 {name=Xr225c11}
N 2160 45040 2140 45040 {}
C {lab_pin.sym} 2140 45040 0 0 {name=l36056 lab=BL11}
N 2160 45000 2140 45000 {}
C {lab_pin.sym} 2140 45000 0 0 {name=l36057 lab=BLB11}
N 2160 44960 2140 44960 {}
C {lab_pin.sym} 2140 44960 0 0 {name=l36058 lab=WL225}
N 2240 45040 2260 45040 {}
C {lab_pin.sym} 2260 45040 0 0 {name=l36059 lab=VDD}
N 2240 44960 2260 44960 {}
C {lab_pin.sym} 2260 44960 0 0 {name=l36060 lab=VSS}
C {bitcell_6t.sym} 2400 45000 0 0 {name=Xr225c12}
N 2360 45040 2340 45040 {}
C {lab_pin.sym} 2340 45040 0 0 {name=l36061 lab=BL12}
N 2360 45000 2340 45000 {}
C {lab_pin.sym} 2340 45000 0 0 {name=l36062 lab=BLB12}
N 2360 44960 2340 44960 {}
C {lab_pin.sym} 2340 44960 0 0 {name=l36063 lab=WL225}
N 2440 45040 2460 45040 {}
C {lab_pin.sym} 2460 45040 0 0 {name=l36064 lab=VDD}
N 2440 44960 2460 44960 {}
C {lab_pin.sym} 2460 44960 0 0 {name=l36065 lab=VSS}
C {bitcell_6t.sym} 2600 45000 0 0 {name=Xr225c13}
N 2560 45040 2540 45040 {}
C {lab_pin.sym} 2540 45040 0 0 {name=l36066 lab=BL13}
N 2560 45000 2540 45000 {}
C {lab_pin.sym} 2540 45000 0 0 {name=l36067 lab=BLB13}
N 2560 44960 2540 44960 {}
C {lab_pin.sym} 2540 44960 0 0 {name=l36068 lab=WL225}
N 2640 45040 2660 45040 {}
C {lab_pin.sym} 2660 45040 0 0 {name=l36069 lab=VDD}
N 2640 44960 2660 44960 {}
C {lab_pin.sym} 2660 44960 0 0 {name=l36070 lab=VSS}
C {bitcell_6t.sym} 2800 45000 0 0 {name=Xr225c14}
N 2760 45040 2740 45040 {}
C {lab_pin.sym} 2740 45040 0 0 {name=l36071 lab=BL14}
N 2760 45000 2740 45000 {}
C {lab_pin.sym} 2740 45000 0 0 {name=l36072 lab=BLB14}
N 2760 44960 2740 44960 {}
C {lab_pin.sym} 2740 44960 0 0 {name=l36073 lab=WL225}
N 2840 45040 2860 45040 {}
C {lab_pin.sym} 2860 45040 0 0 {name=l36074 lab=VDD}
N 2840 44960 2860 44960 {}
C {lab_pin.sym} 2860 44960 0 0 {name=l36075 lab=VSS}
C {bitcell_6t.sym} 3000 45000 0 0 {name=Xr225c15}
N 2960 45040 2940 45040 {}
C {lab_pin.sym} 2940 45040 0 0 {name=l36076 lab=BL15}
N 2960 45000 2940 45000 {}
C {lab_pin.sym} 2940 45000 0 0 {name=l36077 lab=BLB15}
N 2960 44960 2940 44960 {}
C {lab_pin.sym} 2940 44960 0 0 {name=l36078 lab=WL225}
N 3040 45040 3060 45040 {}
C {lab_pin.sym} 3060 45040 0 0 {name=l36079 lab=VDD}
N 3040 44960 3060 44960 {}
C {lab_pin.sym} 3060 44960 0 0 {name=l36080 lab=VSS}
C {bitcell_6t.sym} 3200 45000 0 0 {name=Xr225c16}
N 3160 45040 3140 45040 {}
C {lab_pin.sym} 3140 45040 0 0 {name=l36081 lab=BL16}
N 3160 45000 3140 45000 {}
C {lab_pin.sym} 3140 45000 0 0 {name=l36082 lab=BLB16}
N 3160 44960 3140 44960 {}
C {lab_pin.sym} 3140 44960 0 0 {name=l36083 lab=WL225}
N 3240 45040 3260 45040 {}
C {lab_pin.sym} 3260 45040 0 0 {name=l36084 lab=VDD}
N 3240 44960 3260 44960 {}
C {lab_pin.sym} 3260 44960 0 0 {name=l36085 lab=VSS}
C {bitcell_6t.sym} 3400 45000 0 0 {name=Xr225c17}
N 3360 45040 3340 45040 {}
C {lab_pin.sym} 3340 45040 0 0 {name=l36086 lab=BL17}
N 3360 45000 3340 45000 {}
C {lab_pin.sym} 3340 45000 0 0 {name=l36087 lab=BLB17}
N 3360 44960 3340 44960 {}
C {lab_pin.sym} 3340 44960 0 0 {name=l36088 lab=WL225}
N 3440 45040 3460 45040 {}
C {lab_pin.sym} 3460 45040 0 0 {name=l36089 lab=VDD}
N 3440 44960 3460 44960 {}
C {lab_pin.sym} 3460 44960 0 0 {name=l36090 lab=VSS}
C {bitcell_6t.sym} 3600 45000 0 0 {name=Xr225c18}
N 3560 45040 3540 45040 {}
C {lab_pin.sym} 3540 45040 0 0 {name=l36091 lab=BL18}
N 3560 45000 3540 45000 {}
C {lab_pin.sym} 3540 45000 0 0 {name=l36092 lab=BLB18}
N 3560 44960 3540 44960 {}
C {lab_pin.sym} 3540 44960 0 0 {name=l36093 lab=WL225}
N 3640 45040 3660 45040 {}
C {lab_pin.sym} 3660 45040 0 0 {name=l36094 lab=VDD}
N 3640 44960 3660 44960 {}
C {lab_pin.sym} 3660 44960 0 0 {name=l36095 lab=VSS}
C {bitcell_6t.sym} 3800 45000 0 0 {name=Xr225c19}
N 3760 45040 3740 45040 {}
C {lab_pin.sym} 3740 45040 0 0 {name=l36096 lab=BL19}
N 3760 45000 3740 45000 {}
C {lab_pin.sym} 3740 45000 0 0 {name=l36097 lab=BLB19}
N 3760 44960 3740 44960 {}
C {lab_pin.sym} 3740 44960 0 0 {name=l36098 lab=WL225}
N 3840 45040 3860 45040 {}
C {lab_pin.sym} 3860 45040 0 0 {name=l36099 lab=VDD}
N 3840 44960 3860 44960 {}
C {lab_pin.sym} 3860 44960 0 0 {name=l36100 lab=VSS}
C {bitcell_6t.sym} 4000 45000 0 0 {name=Xr225c20}
N 3960 45040 3940 45040 {}
C {lab_pin.sym} 3940 45040 0 0 {name=l36101 lab=BL20}
N 3960 45000 3940 45000 {}
C {lab_pin.sym} 3940 45000 0 0 {name=l36102 lab=BLB20}
N 3960 44960 3940 44960 {}
C {lab_pin.sym} 3940 44960 0 0 {name=l36103 lab=WL225}
N 4040 45040 4060 45040 {}
C {lab_pin.sym} 4060 45040 0 0 {name=l36104 lab=VDD}
N 4040 44960 4060 44960 {}
C {lab_pin.sym} 4060 44960 0 0 {name=l36105 lab=VSS}
C {bitcell_6t.sym} 4200 45000 0 0 {name=Xr225c21}
N 4160 45040 4140 45040 {}
C {lab_pin.sym} 4140 45040 0 0 {name=l36106 lab=BL21}
N 4160 45000 4140 45000 {}
C {lab_pin.sym} 4140 45000 0 0 {name=l36107 lab=BLB21}
N 4160 44960 4140 44960 {}
C {lab_pin.sym} 4140 44960 0 0 {name=l36108 lab=WL225}
N 4240 45040 4260 45040 {}
C {lab_pin.sym} 4260 45040 0 0 {name=l36109 lab=VDD}
N 4240 44960 4260 44960 {}
C {lab_pin.sym} 4260 44960 0 0 {name=l36110 lab=VSS}
C {bitcell_6t.sym} 4400 45000 0 0 {name=Xr225c22}
N 4360 45040 4340 45040 {}
C {lab_pin.sym} 4340 45040 0 0 {name=l36111 lab=BL22}
N 4360 45000 4340 45000 {}
C {lab_pin.sym} 4340 45000 0 0 {name=l36112 lab=BLB22}
N 4360 44960 4340 44960 {}
C {lab_pin.sym} 4340 44960 0 0 {name=l36113 lab=WL225}
N 4440 45040 4460 45040 {}
C {lab_pin.sym} 4460 45040 0 0 {name=l36114 lab=VDD}
N 4440 44960 4460 44960 {}
C {lab_pin.sym} 4460 44960 0 0 {name=l36115 lab=VSS}
C {bitcell_6t.sym} 4600 45000 0 0 {name=Xr225c23}
N 4560 45040 4540 45040 {}
C {lab_pin.sym} 4540 45040 0 0 {name=l36116 lab=BL23}
N 4560 45000 4540 45000 {}
C {lab_pin.sym} 4540 45000 0 0 {name=l36117 lab=BLB23}
N 4560 44960 4540 44960 {}
C {lab_pin.sym} 4540 44960 0 0 {name=l36118 lab=WL225}
N 4640 45040 4660 45040 {}
C {lab_pin.sym} 4660 45040 0 0 {name=l36119 lab=VDD}
N 4640 44960 4660 44960 {}
C {lab_pin.sym} 4660 44960 0 0 {name=l36120 lab=VSS}
C {bitcell_6t.sym} 4800 45000 0 0 {name=Xr225c24}
N 4760 45040 4740 45040 {}
C {lab_pin.sym} 4740 45040 0 0 {name=l36121 lab=BL24}
N 4760 45000 4740 45000 {}
C {lab_pin.sym} 4740 45000 0 0 {name=l36122 lab=BLB24}
N 4760 44960 4740 44960 {}
C {lab_pin.sym} 4740 44960 0 0 {name=l36123 lab=WL225}
N 4840 45040 4860 45040 {}
C {lab_pin.sym} 4860 45040 0 0 {name=l36124 lab=VDD}
N 4840 44960 4860 44960 {}
C {lab_pin.sym} 4860 44960 0 0 {name=l36125 lab=VSS}
C {bitcell_6t.sym} 5000 45000 0 0 {name=Xr225c25}
N 4960 45040 4940 45040 {}
C {lab_pin.sym} 4940 45040 0 0 {name=l36126 lab=BL25}
N 4960 45000 4940 45000 {}
C {lab_pin.sym} 4940 45000 0 0 {name=l36127 lab=BLB25}
N 4960 44960 4940 44960 {}
C {lab_pin.sym} 4940 44960 0 0 {name=l36128 lab=WL225}
N 5040 45040 5060 45040 {}
C {lab_pin.sym} 5060 45040 0 0 {name=l36129 lab=VDD}
N 5040 44960 5060 44960 {}
C {lab_pin.sym} 5060 44960 0 0 {name=l36130 lab=VSS}
C {bitcell_6t.sym} 5200 45000 0 0 {name=Xr225c26}
N 5160 45040 5140 45040 {}
C {lab_pin.sym} 5140 45040 0 0 {name=l36131 lab=BL26}
N 5160 45000 5140 45000 {}
C {lab_pin.sym} 5140 45000 0 0 {name=l36132 lab=BLB26}
N 5160 44960 5140 44960 {}
C {lab_pin.sym} 5140 44960 0 0 {name=l36133 lab=WL225}
N 5240 45040 5260 45040 {}
C {lab_pin.sym} 5260 45040 0 0 {name=l36134 lab=VDD}
N 5240 44960 5260 44960 {}
C {lab_pin.sym} 5260 44960 0 0 {name=l36135 lab=VSS}
C {bitcell_6t.sym} 5400 45000 0 0 {name=Xr225c27}
N 5360 45040 5340 45040 {}
C {lab_pin.sym} 5340 45040 0 0 {name=l36136 lab=BL27}
N 5360 45000 5340 45000 {}
C {lab_pin.sym} 5340 45000 0 0 {name=l36137 lab=BLB27}
N 5360 44960 5340 44960 {}
C {lab_pin.sym} 5340 44960 0 0 {name=l36138 lab=WL225}
N 5440 45040 5460 45040 {}
C {lab_pin.sym} 5460 45040 0 0 {name=l36139 lab=VDD}
N 5440 44960 5460 44960 {}
C {lab_pin.sym} 5460 44960 0 0 {name=l36140 lab=VSS}
C {bitcell_6t.sym} 5600 45000 0 0 {name=Xr225c28}
N 5560 45040 5540 45040 {}
C {lab_pin.sym} 5540 45040 0 0 {name=l36141 lab=BL28}
N 5560 45000 5540 45000 {}
C {lab_pin.sym} 5540 45000 0 0 {name=l36142 lab=BLB28}
N 5560 44960 5540 44960 {}
C {lab_pin.sym} 5540 44960 0 0 {name=l36143 lab=WL225}
N 5640 45040 5660 45040 {}
C {lab_pin.sym} 5660 45040 0 0 {name=l36144 lab=VDD}
N 5640 44960 5660 44960 {}
C {lab_pin.sym} 5660 44960 0 0 {name=l36145 lab=VSS}
C {bitcell_6t.sym} 5800 45000 0 0 {name=Xr225c29}
N 5760 45040 5740 45040 {}
C {lab_pin.sym} 5740 45040 0 0 {name=l36146 lab=BL29}
N 5760 45000 5740 45000 {}
C {lab_pin.sym} 5740 45000 0 0 {name=l36147 lab=BLB29}
N 5760 44960 5740 44960 {}
C {lab_pin.sym} 5740 44960 0 0 {name=l36148 lab=WL225}
N 5840 45040 5860 45040 {}
C {lab_pin.sym} 5860 45040 0 0 {name=l36149 lab=VDD}
N 5840 44960 5860 44960 {}
C {lab_pin.sym} 5860 44960 0 0 {name=l36150 lab=VSS}
C {bitcell_6t.sym} 6000 45000 0 0 {name=Xr225c30}
N 5960 45040 5940 45040 {}
C {lab_pin.sym} 5940 45040 0 0 {name=l36151 lab=BL30}
N 5960 45000 5940 45000 {}
C {lab_pin.sym} 5940 45000 0 0 {name=l36152 lab=BLB30}
N 5960 44960 5940 44960 {}
C {lab_pin.sym} 5940 44960 0 0 {name=l36153 lab=WL225}
N 6040 45040 6060 45040 {}
C {lab_pin.sym} 6060 45040 0 0 {name=l36154 lab=VDD}
N 6040 44960 6060 44960 {}
C {lab_pin.sym} 6060 44960 0 0 {name=l36155 lab=VSS}
C {bitcell_6t.sym} 6200 45000 0 0 {name=Xr225c31}
N 6160 45040 6140 45040 {}
C {lab_pin.sym} 6140 45040 0 0 {name=l36156 lab=BL31}
N 6160 45000 6140 45000 {}
C {lab_pin.sym} 6140 45000 0 0 {name=l36157 lab=BLB31}
N 6160 44960 6140 44960 {}
C {lab_pin.sym} 6140 44960 0 0 {name=l36158 lab=WL225}
N 6240 45040 6260 45040 {}
C {lab_pin.sym} 6260 45040 0 0 {name=l36159 lab=VDD}
N 6240 44960 6260 44960 {}
C {lab_pin.sym} 6260 44960 0 0 {name=l36160 lab=VSS}
C {bitcell_6t.sym} 0 45200 0 0 {name=Xr226c0}
N -40 45240 -60 45240 {}
C {lab_pin.sym} -60 45240 0 0 {name=l36161 lab=BL0}
N -40 45200 -60 45200 {}
C {lab_pin.sym} -60 45200 0 0 {name=l36162 lab=BLB0}
N -40 45160 -60 45160 {}
C {lab_pin.sym} -60 45160 0 0 {name=l36163 lab=WL226}
N 40 45240 60 45240 {}
C {lab_pin.sym} 60 45240 0 0 {name=l36164 lab=VDD}
N 40 45160 60 45160 {}
C {lab_pin.sym} 60 45160 0 0 {name=l36165 lab=VSS}
C {bitcell_6t.sym} 200 45200 0 0 {name=Xr226c1}
N 160 45240 140 45240 {}
C {lab_pin.sym} 140 45240 0 0 {name=l36166 lab=BL1}
N 160 45200 140 45200 {}
C {lab_pin.sym} 140 45200 0 0 {name=l36167 lab=BLB1}
N 160 45160 140 45160 {}
C {lab_pin.sym} 140 45160 0 0 {name=l36168 lab=WL226}
N 240 45240 260 45240 {}
C {lab_pin.sym} 260 45240 0 0 {name=l36169 lab=VDD}
N 240 45160 260 45160 {}
C {lab_pin.sym} 260 45160 0 0 {name=l36170 lab=VSS}
C {bitcell_6t.sym} 400 45200 0 0 {name=Xr226c2}
N 360 45240 340 45240 {}
C {lab_pin.sym} 340 45240 0 0 {name=l36171 lab=BL2}
N 360 45200 340 45200 {}
C {lab_pin.sym} 340 45200 0 0 {name=l36172 lab=BLB2}
N 360 45160 340 45160 {}
C {lab_pin.sym} 340 45160 0 0 {name=l36173 lab=WL226}
N 440 45240 460 45240 {}
C {lab_pin.sym} 460 45240 0 0 {name=l36174 lab=VDD}
N 440 45160 460 45160 {}
C {lab_pin.sym} 460 45160 0 0 {name=l36175 lab=VSS}
C {bitcell_6t.sym} 600 45200 0 0 {name=Xr226c3}
N 560 45240 540 45240 {}
C {lab_pin.sym} 540 45240 0 0 {name=l36176 lab=BL3}
N 560 45200 540 45200 {}
C {lab_pin.sym} 540 45200 0 0 {name=l36177 lab=BLB3}
N 560 45160 540 45160 {}
C {lab_pin.sym} 540 45160 0 0 {name=l36178 lab=WL226}
N 640 45240 660 45240 {}
C {lab_pin.sym} 660 45240 0 0 {name=l36179 lab=VDD}
N 640 45160 660 45160 {}
C {lab_pin.sym} 660 45160 0 0 {name=l36180 lab=VSS}
C {bitcell_6t.sym} 800 45200 0 0 {name=Xr226c4}
N 760 45240 740 45240 {}
C {lab_pin.sym} 740 45240 0 0 {name=l36181 lab=BL4}
N 760 45200 740 45200 {}
C {lab_pin.sym} 740 45200 0 0 {name=l36182 lab=BLB4}
N 760 45160 740 45160 {}
C {lab_pin.sym} 740 45160 0 0 {name=l36183 lab=WL226}
N 840 45240 860 45240 {}
C {lab_pin.sym} 860 45240 0 0 {name=l36184 lab=VDD}
N 840 45160 860 45160 {}
C {lab_pin.sym} 860 45160 0 0 {name=l36185 lab=VSS}
C {bitcell_6t.sym} 1000 45200 0 0 {name=Xr226c5}
N 960 45240 940 45240 {}
C {lab_pin.sym} 940 45240 0 0 {name=l36186 lab=BL5}
N 960 45200 940 45200 {}
C {lab_pin.sym} 940 45200 0 0 {name=l36187 lab=BLB5}
N 960 45160 940 45160 {}
C {lab_pin.sym} 940 45160 0 0 {name=l36188 lab=WL226}
N 1040 45240 1060 45240 {}
C {lab_pin.sym} 1060 45240 0 0 {name=l36189 lab=VDD}
N 1040 45160 1060 45160 {}
C {lab_pin.sym} 1060 45160 0 0 {name=l36190 lab=VSS}
C {bitcell_6t.sym} 1200 45200 0 0 {name=Xr226c6}
N 1160 45240 1140 45240 {}
C {lab_pin.sym} 1140 45240 0 0 {name=l36191 lab=BL6}
N 1160 45200 1140 45200 {}
C {lab_pin.sym} 1140 45200 0 0 {name=l36192 lab=BLB6}
N 1160 45160 1140 45160 {}
C {lab_pin.sym} 1140 45160 0 0 {name=l36193 lab=WL226}
N 1240 45240 1260 45240 {}
C {lab_pin.sym} 1260 45240 0 0 {name=l36194 lab=VDD}
N 1240 45160 1260 45160 {}
C {lab_pin.sym} 1260 45160 0 0 {name=l36195 lab=VSS}
C {bitcell_6t.sym} 1400 45200 0 0 {name=Xr226c7}
N 1360 45240 1340 45240 {}
C {lab_pin.sym} 1340 45240 0 0 {name=l36196 lab=BL7}
N 1360 45200 1340 45200 {}
C {lab_pin.sym} 1340 45200 0 0 {name=l36197 lab=BLB7}
N 1360 45160 1340 45160 {}
C {lab_pin.sym} 1340 45160 0 0 {name=l36198 lab=WL226}
N 1440 45240 1460 45240 {}
C {lab_pin.sym} 1460 45240 0 0 {name=l36199 lab=VDD}
N 1440 45160 1460 45160 {}
C {lab_pin.sym} 1460 45160 0 0 {name=l36200 lab=VSS}
C {bitcell_6t.sym} 1600 45200 0 0 {name=Xr226c8}
N 1560 45240 1540 45240 {}
C {lab_pin.sym} 1540 45240 0 0 {name=l36201 lab=BL8}
N 1560 45200 1540 45200 {}
C {lab_pin.sym} 1540 45200 0 0 {name=l36202 lab=BLB8}
N 1560 45160 1540 45160 {}
C {lab_pin.sym} 1540 45160 0 0 {name=l36203 lab=WL226}
N 1640 45240 1660 45240 {}
C {lab_pin.sym} 1660 45240 0 0 {name=l36204 lab=VDD}
N 1640 45160 1660 45160 {}
C {lab_pin.sym} 1660 45160 0 0 {name=l36205 lab=VSS}
C {bitcell_6t.sym} 1800 45200 0 0 {name=Xr226c9}
N 1760 45240 1740 45240 {}
C {lab_pin.sym} 1740 45240 0 0 {name=l36206 lab=BL9}
N 1760 45200 1740 45200 {}
C {lab_pin.sym} 1740 45200 0 0 {name=l36207 lab=BLB9}
N 1760 45160 1740 45160 {}
C {lab_pin.sym} 1740 45160 0 0 {name=l36208 lab=WL226}
N 1840 45240 1860 45240 {}
C {lab_pin.sym} 1860 45240 0 0 {name=l36209 lab=VDD}
N 1840 45160 1860 45160 {}
C {lab_pin.sym} 1860 45160 0 0 {name=l36210 lab=VSS}
C {bitcell_6t.sym} 2000 45200 0 0 {name=Xr226c10}
N 1960 45240 1940 45240 {}
C {lab_pin.sym} 1940 45240 0 0 {name=l36211 lab=BL10}
N 1960 45200 1940 45200 {}
C {lab_pin.sym} 1940 45200 0 0 {name=l36212 lab=BLB10}
N 1960 45160 1940 45160 {}
C {lab_pin.sym} 1940 45160 0 0 {name=l36213 lab=WL226}
N 2040 45240 2060 45240 {}
C {lab_pin.sym} 2060 45240 0 0 {name=l36214 lab=VDD}
N 2040 45160 2060 45160 {}
C {lab_pin.sym} 2060 45160 0 0 {name=l36215 lab=VSS}
C {bitcell_6t.sym} 2200 45200 0 0 {name=Xr226c11}
N 2160 45240 2140 45240 {}
C {lab_pin.sym} 2140 45240 0 0 {name=l36216 lab=BL11}
N 2160 45200 2140 45200 {}
C {lab_pin.sym} 2140 45200 0 0 {name=l36217 lab=BLB11}
N 2160 45160 2140 45160 {}
C {lab_pin.sym} 2140 45160 0 0 {name=l36218 lab=WL226}
N 2240 45240 2260 45240 {}
C {lab_pin.sym} 2260 45240 0 0 {name=l36219 lab=VDD}
N 2240 45160 2260 45160 {}
C {lab_pin.sym} 2260 45160 0 0 {name=l36220 lab=VSS}
C {bitcell_6t.sym} 2400 45200 0 0 {name=Xr226c12}
N 2360 45240 2340 45240 {}
C {lab_pin.sym} 2340 45240 0 0 {name=l36221 lab=BL12}
N 2360 45200 2340 45200 {}
C {lab_pin.sym} 2340 45200 0 0 {name=l36222 lab=BLB12}
N 2360 45160 2340 45160 {}
C {lab_pin.sym} 2340 45160 0 0 {name=l36223 lab=WL226}
N 2440 45240 2460 45240 {}
C {lab_pin.sym} 2460 45240 0 0 {name=l36224 lab=VDD}
N 2440 45160 2460 45160 {}
C {lab_pin.sym} 2460 45160 0 0 {name=l36225 lab=VSS}
C {bitcell_6t.sym} 2600 45200 0 0 {name=Xr226c13}
N 2560 45240 2540 45240 {}
C {lab_pin.sym} 2540 45240 0 0 {name=l36226 lab=BL13}
N 2560 45200 2540 45200 {}
C {lab_pin.sym} 2540 45200 0 0 {name=l36227 lab=BLB13}
N 2560 45160 2540 45160 {}
C {lab_pin.sym} 2540 45160 0 0 {name=l36228 lab=WL226}
N 2640 45240 2660 45240 {}
C {lab_pin.sym} 2660 45240 0 0 {name=l36229 lab=VDD}
N 2640 45160 2660 45160 {}
C {lab_pin.sym} 2660 45160 0 0 {name=l36230 lab=VSS}
C {bitcell_6t.sym} 2800 45200 0 0 {name=Xr226c14}
N 2760 45240 2740 45240 {}
C {lab_pin.sym} 2740 45240 0 0 {name=l36231 lab=BL14}
N 2760 45200 2740 45200 {}
C {lab_pin.sym} 2740 45200 0 0 {name=l36232 lab=BLB14}
N 2760 45160 2740 45160 {}
C {lab_pin.sym} 2740 45160 0 0 {name=l36233 lab=WL226}
N 2840 45240 2860 45240 {}
C {lab_pin.sym} 2860 45240 0 0 {name=l36234 lab=VDD}
N 2840 45160 2860 45160 {}
C {lab_pin.sym} 2860 45160 0 0 {name=l36235 lab=VSS}
C {bitcell_6t.sym} 3000 45200 0 0 {name=Xr226c15}
N 2960 45240 2940 45240 {}
C {lab_pin.sym} 2940 45240 0 0 {name=l36236 lab=BL15}
N 2960 45200 2940 45200 {}
C {lab_pin.sym} 2940 45200 0 0 {name=l36237 lab=BLB15}
N 2960 45160 2940 45160 {}
C {lab_pin.sym} 2940 45160 0 0 {name=l36238 lab=WL226}
N 3040 45240 3060 45240 {}
C {lab_pin.sym} 3060 45240 0 0 {name=l36239 lab=VDD}
N 3040 45160 3060 45160 {}
C {lab_pin.sym} 3060 45160 0 0 {name=l36240 lab=VSS}
C {bitcell_6t.sym} 3200 45200 0 0 {name=Xr226c16}
N 3160 45240 3140 45240 {}
C {lab_pin.sym} 3140 45240 0 0 {name=l36241 lab=BL16}
N 3160 45200 3140 45200 {}
C {lab_pin.sym} 3140 45200 0 0 {name=l36242 lab=BLB16}
N 3160 45160 3140 45160 {}
C {lab_pin.sym} 3140 45160 0 0 {name=l36243 lab=WL226}
N 3240 45240 3260 45240 {}
C {lab_pin.sym} 3260 45240 0 0 {name=l36244 lab=VDD}
N 3240 45160 3260 45160 {}
C {lab_pin.sym} 3260 45160 0 0 {name=l36245 lab=VSS}
C {bitcell_6t.sym} 3400 45200 0 0 {name=Xr226c17}
N 3360 45240 3340 45240 {}
C {lab_pin.sym} 3340 45240 0 0 {name=l36246 lab=BL17}
N 3360 45200 3340 45200 {}
C {lab_pin.sym} 3340 45200 0 0 {name=l36247 lab=BLB17}
N 3360 45160 3340 45160 {}
C {lab_pin.sym} 3340 45160 0 0 {name=l36248 lab=WL226}
N 3440 45240 3460 45240 {}
C {lab_pin.sym} 3460 45240 0 0 {name=l36249 lab=VDD}
N 3440 45160 3460 45160 {}
C {lab_pin.sym} 3460 45160 0 0 {name=l36250 lab=VSS}
C {bitcell_6t.sym} 3600 45200 0 0 {name=Xr226c18}
N 3560 45240 3540 45240 {}
C {lab_pin.sym} 3540 45240 0 0 {name=l36251 lab=BL18}
N 3560 45200 3540 45200 {}
C {lab_pin.sym} 3540 45200 0 0 {name=l36252 lab=BLB18}
N 3560 45160 3540 45160 {}
C {lab_pin.sym} 3540 45160 0 0 {name=l36253 lab=WL226}
N 3640 45240 3660 45240 {}
C {lab_pin.sym} 3660 45240 0 0 {name=l36254 lab=VDD}
N 3640 45160 3660 45160 {}
C {lab_pin.sym} 3660 45160 0 0 {name=l36255 lab=VSS}
C {bitcell_6t.sym} 3800 45200 0 0 {name=Xr226c19}
N 3760 45240 3740 45240 {}
C {lab_pin.sym} 3740 45240 0 0 {name=l36256 lab=BL19}
N 3760 45200 3740 45200 {}
C {lab_pin.sym} 3740 45200 0 0 {name=l36257 lab=BLB19}
N 3760 45160 3740 45160 {}
C {lab_pin.sym} 3740 45160 0 0 {name=l36258 lab=WL226}
N 3840 45240 3860 45240 {}
C {lab_pin.sym} 3860 45240 0 0 {name=l36259 lab=VDD}
N 3840 45160 3860 45160 {}
C {lab_pin.sym} 3860 45160 0 0 {name=l36260 lab=VSS}
C {bitcell_6t.sym} 4000 45200 0 0 {name=Xr226c20}
N 3960 45240 3940 45240 {}
C {lab_pin.sym} 3940 45240 0 0 {name=l36261 lab=BL20}
N 3960 45200 3940 45200 {}
C {lab_pin.sym} 3940 45200 0 0 {name=l36262 lab=BLB20}
N 3960 45160 3940 45160 {}
C {lab_pin.sym} 3940 45160 0 0 {name=l36263 lab=WL226}
N 4040 45240 4060 45240 {}
C {lab_pin.sym} 4060 45240 0 0 {name=l36264 lab=VDD}
N 4040 45160 4060 45160 {}
C {lab_pin.sym} 4060 45160 0 0 {name=l36265 lab=VSS}
C {bitcell_6t.sym} 4200 45200 0 0 {name=Xr226c21}
N 4160 45240 4140 45240 {}
C {lab_pin.sym} 4140 45240 0 0 {name=l36266 lab=BL21}
N 4160 45200 4140 45200 {}
C {lab_pin.sym} 4140 45200 0 0 {name=l36267 lab=BLB21}
N 4160 45160 4140 45160 {}
C {lab_pin.sym} 4140 45160 0 0 {name=l36268 lab=WL226}
N 4240 45240 4260 45240 {}
C {lab_pin.sym} 4260 45240 0 0 {name=l36269 lab=VDD}
N 4240 45160 4260 45160 {}
C {lab_pin.sym} 4260 45160 0 0 {name=l36270 lab=VSS}
C {bitcell_6t.sym} 4400 45200 0 0 {name=Xr226c22}
N 4360 45240 4340 45240 {}
C {lab_pin.sym} 4340 45240 0 0 {name=l36271 lab=BL22}
N 4360 45200 4340 45200 {}
C {lab_pin.sym} 4340 45200 0 0 {name=l36272 lab=BLB22}
N 4360 45160 4340 45160 {}
C {lab_pin.sym} 4340 45160 0 0 {name=l36273 lab=WL226}
N 4440 45240 4460 45240 {}
C {lab_pin.sym} 4460 45240 0 0 {name=l36274 lab=VDD}
N 4440 45160 4460 45160 {}
C {lab_pin.sym} 4460 45160 0 0 {name=l36275 lab=VSS}
C {bitcell_6t.sym} 4600 45200 0 0 {name=Xr226c23}
N 4560 45240 4540 45240 {}
C {lab_pin.sym} 4540 45240 0 0 {name=l36276 lab=BL23}
N 4560 45200 4540 45200 {}
C {lab_pin.sym} 4540 45200 0 0 {name=l36277 lab=BLB23}
N 4560 45160 4540 45160 {}
C {lab_pin.sym} 4540 45160 0 0 {name=l36278 lab=WL226}
N 4640 45240 4660 45240 {}
C {lab_pin.sym} 4660 45240 0 0 {name=l36279 lab=VDD}
N 4640 45160 4660 45160 {}
C {lab_pin.sym} 4660 45160 0 0 {name=l36280 lab=VSS}
C {bitcell_6t.sym} 4800 45200 0 0 {name=Xr226c24}
N 4760 45240 4740 45240 {}
C {lab_pin.sym} 4740 45240 0 0 {name=l36281 lab=BL24}
N 4760 45200 4740 45200 {}
C {lab_pin.sym} 4740 45200 0 0 {name=l36282 lab=BLB24}
N 4760 45160 4740 45160 {}
C {lab_pin.sym} 4740 45160 0 0 {name=l36283 lab=WL226}
N 4840 45240 4860 45240 {}
C {lab_pin.sym} 4860 45240 0 0 {name=l36284 lab=VDD}
N 4840 45160 4860 45160 {}
C {lab_pin.sym} 4860 45160 0 0 {name=l36285 lab=VSS}
C {bitcell_6t.sym} 5000 45200 0 0 {name=Xr226c25}
N 4960 45240 4940 45240 {}
C {lab_pin.sym} 4940 45240 0 0 {name=l36286 lab=BL25}
N 4960 45200 4940 45200 {}
C {lab_pin.sym} 4940 45200 0 0 {name=l36287 lab=BLB25}
N 4960 45160 4940 45160 {}
C {lab_pin.sym} 4940 45160 0 0 {name=l36288 lab=WL226}
N 5040 45240 5060 45240 {}
C {lab_pin.sym} 5060 45240 0 0 {name=l36289 lab=VDD}
N 5040 45160 5060 45160 {}
C {lab_pin.sym} 5060 45160 0 0 {name=l36290 lab=VSS}
C {bitcell_6t.sym} 5200 45200 0 0 {name=Xr226c26}
N 5160 45240 5140 45240 {}
C {lab_pin.sym} 5140 45240 0 0 {name=l36291 lab=BL26}
N 5160 45200 5140 45200 {}
C {lab_pin.sym} 5140 45200 0 0 {name=l36292 lab=BLB26}
N 5160 45160 5140 45160 {}
C {lab_pin.sym} 5140 45160 0 0 {name=l36293 lab=WL226}
N 5240 45240 5260 45240 {}
C {lab_pin.sym} 5260 45240 0 0 {name=l36294 lab=VDD}
N 5240 45160 5260 45160 {}
C {lab_pin.sym} 5260 45160 0 0 {name=l36295 lab=VSS}
C {bitcell_6t.sym} 5400 45200 0 0 {name=Xr226c27}
N 5360 45240 5340 45240 {}
C {lab_pin.sym} 5340 45240 0 0 {name=l36296 lab=BL27}
N 5360 45200 5340 45200 {}
C {lab_pin.sym} 5340 45200 0 0 {name=l36297 lab=BLB27}
N 5360 45160 5340 45160 {}
C {lab_pin.sym} 5340 45160 0 0 {name=l36298 lab=WL226}
N 5440 45240 5460 45240 {}
C {lab_pin.sym} 5460 45240 0 0 {name=l36299 lab=VDD}
N 5440 45160 5460 45160 {}
C {lab_pin.sym} 5460 45160 0 0 {name=l36300 lab=VSS}
C {bitcell_6t.sym} 5600 45200 0 0 {name=Xr226c28}
N 5560 45240 5540 45240 {}
C {lab_pin.sym} 5540 45240 0 0 {name=l36301 lab=BL28}
N 5560 45200 5540 45200 {}
C {lab_pin.sym} 5540 45200 0 0 {name=l36302 lab=BLB28}
N 5560 45160 5540 45160 {}
C {lab_pin.sym} 5540 45160 0 0 {name=l36303 lab=WL226}
N 5640 45240 5660 45240 {}
C {lab_pin.sym} 5660 45240 0 0 {name=l36304 lab=VDD}
N 5640 45160 5660 45160 {}
C {lab_pin.sym} 5660 45160 0 0 {name=l36305 lab=VSS}
C {bitcell_6t.sym} 5800 45200 0 0 {name=Xr226c29}
N 5760 45240 5740 45240 {}
C {lab_pin.sym} 5740 45240 0 0 {name=l36306 lab=BL29}
N 5760 45200 5740 45200 {}
C {lab_pin.sym} 5740 45200 0 0 {name=l36307 lab=BLB29}
N 5760 45160 5740 45160 {}
C {lab_pin.sym} 5740 45160 0 0 {name=l36308 lab=WL226}
N 5840 45240 5860 45240 {}
C {lab_pin.sym} 5860 45240 0 0 {name=l36309 lab=VDD}
N 5840 45160 5860 45160 {}
C {lab_pin.sym} 5860 45160 0 0 {name=l36310 lab=VSS}
C {bitcell_6t.sym} 6000 45200 0 0 {name=Xr226c30}
N 5960 45240 5940 45240 {}
C {lab_pin.sym} 5940 45240 0 0 {name=l36311 lab=BL30}
N 5960 45200 5940 45200 {}
C {lab_pin.sym} 5940 45200 0 0 {name=l36312 lab=BLB30}
N 5960 45160 5940 45160 {}
C {lab_pin.sym} 5940 45160 0 0 {name=l36313 lab=WL226}
N 6040 45240 6060 45240 {}
C {lab_pin.sym} 6060 45240 0 0 {name=l36314 lab=VDD}
N 6040 45160 6060 45160 {}
C {lab_pin.sym} 6060 45160 0 0 {name=l36315 lab=VSS}
C {bitcell_6t.sym} 6200 45200 0 0 {name=Xr226c31}
N 6160 45240 6140 45240 {}
C {lab_pin.sym} 6140 45240 0 0 {name=l36316 lab=BL31}
N 6160 45200 6140 45200 {}
C {lab_pin.sym} 6140 45200 0 0 {name=l36317 lab=BLB31}
N 6160 45160 6140 45160 {}
C {lab_pin.sym} 6140 45160 0 0 {name=l36318 lab=WL226}
N 6240 45240 6260 45240 {}
C {lab_pin.sym} 6260 45240 0 0 {name=l36319 lab=VDD}
N 6240 45160 6260 45160 {}
C {lab_pin.sym} 6260 45160 0 0 {name=l36320 lab=VSS}
C {bitcell_6t.sym} 0 45400 0 0 {name=Xr227c0}
N -40 45440 -60 45440 {}
C {lab_pin.sym} -60 45440 0 0 {name=l36321 lab=BL0}
N -40 45400 -60 45400 {}
C {lab_pin.sym} -60 45400 0 0 {name=l36322 lab=BLB0}
N -40 45360 -60 45360 {}
C {lab_pin.sym} -60 45360 0 0 {name=l36323 lab=WL227}
N 40 45440 60 45440 {}
C {lab_pin.sym} 60 45440 0 0 {name=l36324 lab=VDD}
N 40 45360 60 45360 {}
C {lab_pin.sym} 60 45360 0 0 {name=l36325 lab=VSS}
C {bitcell_6t.sym} 200 45400 0 0 {name=Xr227c1}
N 160 45440 140 45440 {}
C {lab_pin.sym} 140 45440 0 0 {name=l36326 lab=BL1}
N 160 45400 140 45400 {}
C {lab_pin.sym} 140 45400 0 0 {name=l36327 lab=BLB1}
N 160 45360 140 45360 {}
C {lab_pin.sym} 140 45360 0 0 {name=l36328 lab=WL227}
N 240 45440 260 45440 {}
C {lab_pin.sym} 260 45440 0 0 {name=l36329 lab=VDD}
N 240 45360 260 45360 {}
C {lab_pin.sym} 260 45360 0 0 {name=l36330 lab=VSS}
C {bitcell_6t.sym} 400 45400 0 0 {name=Xr227c2}
N 360 45440 340 45440 {}
C {lab_pin.sym} 340 45440 0 0 {name=l36331 lab=BL2}
N 360 45400 340 45400 {}
C {lab_pin.sym} 340 45400 0 0 {name=l36332 lab=BLB2}
N 360 45360 340 45360 {}
C {lab_pin.sym} 340 45360 0 0 {name=l36333 lab=WL227}
N 440 45440 460 45440 {}
C {lab_pin.sym} 460 45440 0 0 {name=l36334 lab=VDD}
N 440 45360 460 45360 {}
C {lab_pin.sym} 460 45360 0 0 {name=l36335 lab=VSS}
C {bitcell_6t.sym} 600 45400 0 0 {name=Xr227c3}
N 560 45440 540 45440 {}
C {lab_pin.sym} 540 45440 0 0 {name=l36336 lab=BL3}
N 560 45400 540 45400 {}
C {lab_pin.sym} 540 45400 0 0 {name=l36337 lab=BLB3}
N 560 45360 540 45360 {}
C {lab_pin.sym} 540 45360 0 0 {name=l36338 lab=WL227}
N 640 45440 660 45440 {}
C {lab_pin.sym} 660 45440 0 0 {name=l36339 lab=VDD}
N 640 45360 660 45360 {}
C {lab_pin.sym} 660 45360 0 0 {name=l36340 lab=VSS}
C {bitcell_6t.sym} 800 45400 0 0 {name=Xr227c4}
N 760 45440 740 45440 {}
C {lab_pin.sym} 740 45440 0 0 {name=l36341 lab=BL4}
N 760 45400 740 45400 {}
C {lab_pin.sym} 740 45400 0 0 {name=l36342 lab=BLB4}
N 760 45360 740 45360 {}
C {lab_pin.sym} 740 45360 0 0 {name=l36343 lab=WL227}
N 840 45440 860 45440 {}
C {lab_pin.sym} 860 45440 0 0 {name=l36344 lab=VDD}
N 840 45360 860 45360 {}
C {lab_pin.sym} 860 45360 0 0 {name=l36345 lab=VSS}
C {bitcell_6t.sym} 1000 45400 0 0 {name=Xr227c5}
N 960 45440 940 45440 {}
C {lab_pin.sym} 940 45440 0 0 {name=l36346 lab=BL5}
N 960 45400 940 45400 {}
C {lab_pin.sym} 940 45400 0 0 {name=l36347 lab=BLB5}
N 960 45360 940 45360 {}
C {lab_pin.sym} 940 45360 0 0 {name=l36348 lab=WL227}
N 1040 45440 1060 45440 {}
C {lab_pin.sym} 1060 45440 0 0 {name=l36349 lab=VDD}
N 1040 45360 1060 45360 {}
C {lab_pin.sym} 1060 45360 0 0 {name=l36350 lab=VSS}
C {bitcell_6t.sym} 1200 45400 0 0 {name=Xr227c6}
N 1160 45440 1140 45440 {}
C {lab_pin.sym} 1140 45440 0 0 {name=l36351 lab=BL6}
N 1160 45400 1140 45400 {}
C {lab_pin.sym} 1140 45400 0 0 {name=l36352 lab=BLB6}
N 1160 45360 1140 45360 {}
C {lab_pin.sym} 1140 45360 0 0 {name=l36353 lab=WL227}
N 1240 45440 1260 45440 {}
C {lab_pin.sym} 1260 45440 0 0 {name=l36354 lab=VDD}
N 1240 45360 1260 45360 {}
C {lab_pin.sym} 1260 45360 0 0 {name=l36355 lab=VSS}
C {bitcell_6t.sym} 1400 45400 0 0 {name=Xr227c7}
N 1360 45440 1340 45440 {}
C {lab_pin.sym} 1340 45440 0 0 {name=l36356 lab=BL7}
N 1360 45400 1340 45400 {}
C {lab_pin.sym} 1340 45400 0 0 {name=l36357 lab=BLB7}
N 1360 45360 1340 45360 {}
C {lab_pin.sym} 1340 45360 0 0 {name=l36358 lab=WL227}
N 1440 45440 1460 45440 {}
C {lab_pin.sym} 1460 45440 0 0 {name=l36359 lab=VDD}
N 1440 45360 1460 45360 {}
C {lab_pin.sym} 1460 45360 0 0 {name=l36360 lab=VSS}
C {bitcell_6t.sym} 1600 45400 0 0 {name=Xr227c8}
N 1560 45440 1540 45440 {}
C {lab_pin.sym} 1540 45440 0 0 {name=l36361 lab=BL8}
N 1560 45400 1540 45400 {}
C {lab_pin.sym} 1540 45400 0 0 {name=l36362 lab=BLB8}
N 1560 45360 1540 45360 {}
C {lab_pin.sym} 1540 45360 0 0 {name=l36363 lab=WL227}
N 1640 45440 1660 45440 {}
C {lab_pin.sym} 1660 45440 0 0 {name=l36364 lab=VDD}
N 1640 45360 1660 45360 {}
C {lab_pin.sym} 1660 45360 0 0 {name=l36365 lab=VSS}
C {bitcell_6t.sym} 1800 45400 0 0 {name=Xr227c9}
N 1760 45440 1740 45440 {}
C {lab_pin.sym} 1740 45440 0 0 {name=l36366 lab=BL9}
N 1760 45400 1740 45400 {}
C {lab_pin.sym} 1740 45400 0 0 {name=l36367 lab=BLB9}
N 1760 45360 1740 45360 {}
C {lab_pin.sym} 1740 45360 0 0 {name=l36368 lab=WL227}
N 1840 45440 1860 45440 {}
C {lab_pin.sym} 1860 45440 0 0 {name=l36369 lab=VDD}
N 1840 45360 1860 45360 {}
C {lab_pin.sym} 1860 45360 0 0 {name=l36370 lab=VSS}
C {bitcell_6t.sym} 2000 45400 0 0 {name=Xr227c10}
N 1960 45440 1940 45440 {}
C {lab_pin.sym} 1940 45440 0 0 {name=l36371 lab=BL10}
N 1960 45400 1940 45400 {}
C {lab_pin.sym} 1940 45400 0 0 {name=l36372 lab=BLB10}
N 1960 45360 1940 45360 {}
C {lab_pin.sym} 1940 45360 0 0 {name=l36373 lab=WL227}
N 2040 45440 2060 45440 {}
C {lab_pin.sym} 2060 45440 0 0 {name=l36374 lab=VDD}
N 2040 45360 2060 45360 {}
C {lab_pin.sym} 2060 45360 0 0 {name=l36375 lab=VSS}
C {bitcell_6t.sym} 2200 45400 0 0 {name=Xr227c11}
N 2160 45440 2140 45440 {}
C {lab_pin.sym} 2140 45440 0 0 {name=l36376 lab=BL11}
N 2160 45400 2140 45400 {}
C {lab_pin.sym} 2140 45400 0 0 {name=l36377 lab=BLB11}
N 2160 45360 2140 45360 {}
C {lab_pin.sym} 2140 45360 0 0 {name=l36378 lab=WL227}
N 2240 45440 2260 45440 {}
C {lab_pin.sym} 2260 45440 0 0 {name=l36379 lab=VDD}
N 2240 45360 2260 45360 {}
C {lab_pin.sym} 2260 45360 0 0 {name=l36380 lab=VSS}
C {bitcell_6t.sym} 2400 45400 0 0 {name=Xr227c12}
N 2360 45440 2340 45440 {}
C {lab_pin.sym} 2340 45440 0 0 {name=l36381 lab=BL12}
N 2360 45400 2340 45400 {}
C {lab_pin.sym} 2340 45400 0 0 {name=l36382 lab=BLB12}
N 2360 45360 2340 45360 {}
C {lab_pin.sym} 2340 45360 0 0 {name=l36383 lab=WL227}
N 2440 45440 2460 45440 {}
C {lab_pin.sym} 2460 45440 0 0 {name=l36384 lab=VDD}
N 2440 45360 2460 45360 {}
C {lab_pin.sym} 2460 45360 0 0 {name=l36385 lab=VSS}
C {bitcell_6t.sym} 2600 45400 0 0 {name=Xr227c13}
N 2560 45440 2540 45440 {}
C {lab_pin.sym} 2540 45440 0 0 {name=l36386 lab=BL13}
N 2560 45400 2540 45400 {}
C {lab_pin.sym} 2540 45400 0 0 {name=l36387 lab=BLB13}
N 2560 45360 2540 45360 {}
C {lab_pin.sym} 2540 45360 0 0 {name=l36388 lab=WL227}
N 2640 45440 2660 45440 {}
C {lab_pin.sym} 2660 45440 0 0 {name=l36389 lab=VDD}
N 2640 45360 2660 45360 {}
C {lab_pin.sym} 2660 45360 0 0 {name=l36390 lab=VSS}
C {bitcell_6t.sym} 2800 45400 0 0 {name=Xr227c14}
N 2760 45440 2740 45440 {}
C {lab_pin.sym} 2740 45440 0 0 {name=l36391 lab=BL14}
N 2760 45400 2740 45400 {}
C {lab_pin.sym} 2740 45400 0 0 {name=l36392 lab=BLB14}
N 2760 45360 2740 45360 {}
C {lab_pin.sym} 2740 45360 0 0 {name=l36393 lab=WL227}
N 2840 45440 2860 45440 {}
C {lab_pin.sym} 2860 45440 0 0 {name=l36394 lab=VDD}
N 2840 45360 2860 45360 {}
C {lab_pin.sym} 2860 45360 0 0 {name=l36395 lab=VSS}
C {bitcell_6t.sym} 3000 45400 0 0 {name=Xr227c15}
N 2960 45440 2940 45440 {}
C {lab_pin.sym} 2940 45440 0 0 {name=l36396 lab=BL15}
N 2960 45400 2940 45400 {}
C {lab_pin.sym} 2940 45400 0 0 {name=l36397 lab=BLB15}
N 2960 45360 2940 45360 {}
C {lab_pin.sym} 2940 45360 0 0 {name=l36398 lab=WL227}
N 3040 45440 3060 45440 {}
C {lab_pin.sym} 3060 45440 0 0 {name=l36399 lab=VDD}
N 3040 45360 3060 45360 {}
C {lab_pin.sym} 3060 45360 0 0 {name=l36400 lab=VSS}
C {bitcell_6t.sym} 3200 45400 0 0 {name=Xr227c16}
N 3160 45440 3140 45440 {}
C {lab_pin.sym} 3140 45440 0 0 {name=l36401 lab=BL16}
N 3160 45400 3140 45400 {}
C {lab_pin.sym} 3140 45400 0 0 {name=l36402 lab=BLB16}
N 3160 45360 3140 45360 {}
C {lab_pin.sym} 3140 45360 0 0 {name=l36403 lab=WL227}
N 3240 45440 3260 45440 {}
C {lab_pin.sym} 3260 45440 0 0 {name=l36404 lab=VDD}
N 3240 45360 3260 45360 {}
C {lab_pin.sym} 3260 45360 0 0 {name=l36405 lab=VSS}
C {bitcell_6t.sym} 3400 45400 0 0 {name=Xr227c17}
N 3360 45440 3340 45440 {}
C {lab_pin.sym} 3340 45440 0 0 {name=l36406 lab=BL17}
N 3360 45400 3340 45400 {}
C {lab_pin.sym} 3340 45400 0 0 {name=l36407 lab=BLB17}
N 3360 45360 3340 45360 {}
C {lab_pin.sym} 3340 45360 0 0 {name=l36408 lab=WL227}
N 3440 45440 3460 45440 {}
C {lab_pin.sym} 3460 45440 0 0 {name=l36409 lab=VDD}
N 3440 45360 3460 45360 {}
C {lab_pin.sym} 3460 45360 0 0 {name=l36410 lab=VSS}
C {bitcell_6t.sym} 3600 45400 0 0 {name=Xr227c18}
N 3560 45440 3540 45440 {}
C {lab_pin.sym} 3540 45440 0 0 {name=l36411 lab=BL18}
N 3560 45400 3540 45400 {}
C {lab_pin.sym} 3540 45400 0 0 {name=l36412 lab=BLB18}
N 3560 45360 3540 45360 {}
C {lab_pin.sym} 3540 45360 0 0 {name=l36413 lab=WL227}
N 3640 45440 3660 45440 {}
C {lab_pin.sym} 3660 45440 0 0 {name=l36414 lab=VDD}
N 3640 45360 3660 45360 {}
C {lab_pin.sym} 3660 45360 0 0 {name=l36415 lab=VSS}
C {bitcell_6t.sym} 3800 45400 0 0 {name=Xr227c19}
N 3760 45440 3740 45440 {}
C {lab_pin.sym} 3740 45440 0 0 {name=l36416 lab=BL19}
N 3760 45400 3740 45400 {}
C {lab_pin.sym} 3740 45400 0 0 {name=l36417 lab=BLB19}
N 3760 45360 3740 45360 {}
C {lab_pin.sym} 3740 45360 0 0 {name=l36418 lab=WL227}
N 3840 45440 3860 45440 {}
C {lab_pin.sym} 3860 45440 0 0 {name=l36419 lab=VDD}
N 3840 45360 3860 45360 {}
C {lab_pin.sym} 3860 45360 0 0 {name=l36420 lab=VSS}
C {bitcell_6t.sym} 4000 45400 0 0 {name=Xr227c20}
N 3960 45440 3940 45440 {}
C {lab_pin.sym} 3940 45440 0 0 {name=l36421 lab=BL20}
N 3960 45400 3940 45400 {}
C {lab_pin.sym} 3940 45400 0 0 {name=l36422 lab=BLB20}
N 3960 45360 3940 45360 {}
C {lab_pin.sym} 3940 45360 0 0 {name=l36423 lab=WL227}
N 4040 45440 4060 45440 {}
C {lab_pin.sym} 4060 45440 0 0 {name=l36424 lab=VDD}
N 4040 45360 4060 45360 {}
C {lab_pin.sym} 4060 45360 0 0 {name=l36425 lab=VSS}
C {bitcell_6t.sym} 4200 45400 0 0 {name=Xr227c21}
N 4160 45440 4140 45440 {}
C {lab_pin.sym} 4140 45440 0 0 {name=l36426 lab=BL21}
N 4160 45400 4140 45400 {}
C {lab_pin.sym} 4140 45400 0 0 {name=l36427 lab=BLB21}
N 4160 45360 4140 45360 {}
C {lab_pin.sym} 4140 45360 0 0 {name=l36428 lab=WL227}
N 4240 45440 4260 45440 {}
C {lab_pin.sym} 4260 45440 0 0 {name=l36429 lab=VDD}
N 4240 45360 4260 45360 {}
C {lab_pin.sym} 4260 45360 0 0 {name=l36430 lab=VSS}
C {bitcell_6t.sym} 4400 45400 0 0 {name=Xr227c22}
N 4360 45440 4340 45440 {}
C {lab_pin.sym} 4340 45440 0 0 {name=l36431 lab=BL22}
N 4360 45400 4340 45400 {}
C {lab_pin.sym} 4340 45400 0 0 {name=l36432 lab=BLB22}
N 4360 45360 4340 45360 {}
C {lab_pin.sym} 4340 45360 0 0 {name=l36433 lab=WL227}
N 4440 45440 4460 45440 {}
C {lab_pin.sym} 4460 45440 0 0 {name=l36434 lab=VDD}
N 4440 45360 4460 45360 {}
C {lab_pin.sym} 4460 45360 0 0 {name=l36435 lab=VSS}
C {bitcell_6t.sym} 4600 45400 0 0 {name=Xr227c23}
N 4560 45440 4540 45440 {}
C {lab_pin.sym} 4540 45440 0 0 {name=l36436 lab=BL23}
N 4560 45400 4540 45400 {}
C {lab_pin.sym} 4540 45400 0 0 {name=l36437 lab=BLB23}
N 4560 45360 4540 45360 {}
C {lab_pin.sym} 4540 45360 0 0 {name=l36438 lab=WL227}
N 4640 45440 4660 45440 {}
C {lab_pin.sym} 4660 45440 0 0 {name=l36439 lab=VDD}
N 4640 45360 4660 45360 {}
C {lab_pin.sym} 4660 45360 0 0 {name=l36440 lab=VSS}
C {bitcell_6t.sym} 4800 45400 0 0 {name=Xr227c24}
N 4760 45440 4740 45440 {}
C {lab_pin.sym} 4740 45440 0 0 {name=l36441 lab=BL24}
N 4760 45400 4740 45400 {}
C {lab_pin.sym} 4740 45400 0 0 {name=l36442 lab=BLB24}
N 4760 45360 4740 45360 {}
C {lab_pin.sym} 4740 45360 0 0 {name=l36443 lab=WL227}
N 4840 45440 4860 45440 {}
C {lab_pin.sym} 4860 45440 0 0 {name=l36444 lab=VDD}
N 4840 45360 4860 45360 {}
C {lab_pin.sym} 4860 45360 0 0 {name=l36445 lab=VSS}
C {bitcell_6t.sym} 5000 45400 0 0 {name=Xr227c25}
N 4960 45440 4940 45440 {}
C {lab_pin.sym} 4940 45440 0 0 {name=l36446 lab=BL25}
N 4960 45400 4940 45400 {}
C {lab_pin.sym} 4940 45400 0 0 {name=l36447 lab=BLB25}
N 4960 45360 4940 45360 {}
C {lab_pin.sym} 4940 45360 0 0 {name=l36448 lab=WL227}
N 5040 45440 5060 45440 {}
C {lab_pin.sym} 5060 45440 0 0 {name=l36449 lab=VDD}
N 5040 45360 5060 45360 {}
C {lab_pin.sym} 5060 45360 0 0 {name=l36450 lab=VSS}
C {bitcell_6t.sym} 5200 45400 0 0 {name=Xr227c26}
N 5160 45440 5140 45440 {}
C {lab_pin.sym} 5140 45440 0 0 {name=l36451 lab=BL26}
N 5160 45400 5140 45400 {}
C {lab_pin.sym} 5140 45400 0 0 {name=l36452 lab=BLB26}
N 5160 45360 5140 45360 {}
C {lab_pin.sym} 5140 45360 0 0 {name=l36453 lab=WL227}
N 5240 45440 5260 45440 {}
C {lab_pin.sym} 5260 45440 0 0 {name=l36454 lab=VDD}
N 5240 45360 5260 45360 {}
C {lab_pin.sym} 5260 45360 0 0 {name=l36455 lab=VSS}
C {bitcell_6t.sym} 5400 45400 0 0 {name=Xr227c27}
N 5360 45440 5340 45440 {}
C {lab_pin.sym} 5340 45440 0 0 {name=l36456 lab=BL27}
N 5360 45400 5340 45400 {}
C {lab_pin.sym} 5340 45400 0 0 {name=l36457 lab=BLB27}
N 5360 45360 5340 45360 {}
C {lab_pin.sym} 5340 45360 0 0 {name=l36458 lab=WL227}
N 5440 45440 5460 45440 {}
C {lab_pin.sym} 5460 45440 0 0 {name=l36459 lab=VDD}
N 5440 45360 5460 45360 {}
C {lab_pin.sym} 5460 45360 0 0 {name=l36460 lab=VSS}
C {bitcell_6t.sym} 5600 45400 0 0 {name=Xr227c28}
N 5560 45440 5540 45440 {}
C {lab_pin.sym} 5540 45440 0 0 {name=l36461 lab=BL28}
N 5560 45400 5540 45400 {}
C {lab_pin.sym} 5540 45400 0 0 {name=l36462 lab=BLB28}
N 5560 45360 5540 45360 {}
C {lab_pin.sym} 5540 45360 0 0 {name=l36463 lab=WL227}
N 5640 45440 5660 45440 {}
C {lab_pin.sym} 5660 45440 0 0 {name=l36464 lab=VDD}
N 5640 45360 5660 45360 {}
C {lab_pin.sym} 5660 45360 0 0 {name=l36465 lab=VSS}
C {bitcell_6t.sym} 5800 45400 0 0 {name=Xr227c29}
N 5760 45440 5740 45440 {}
C {lab_pin.sym} 5740 45440 0 0 {name=l36466 lab=BL29}
N 5760 45400 5740 45400 {}
C {lab_pin.sym} 5740 45400 0 0 {name=l36467 lab=BLB29}
N 5760 45360 5740 45360 {}
C {lab_pin.sym} 5740 45360 0 0 {name=l36468 lab=WL227}
N 5840 45440 5860 45440 {}
C {lab_pin.sym} 5860 45440 0 0 {name=l36469 lab=VDD}
N 5840 45360 5860 45360 {}
C {lab_pin.sym} 5860 45360 0 0 {name=l36470 lab=VSS}
C {bitcell_6t.sym} 6000 45400 0 0 {name=Xr227c30}
N 5960 45440 5940 45440 {}
C {lab_pin.sym} 5940 45440 0 0 {name=l36471 lab=BL30}
N 5960 45400 5940 45400 {}
C {lab_pin.sym} 5940 45400 0 0 {name=l36472 lab=BLB30}
N 5960 45360 5940 45360 {}
C {lab_pin.sym} 5940 45360 0 0 {name=l36473 lab=WL227}
N 6040 45440 6060 45440 {}
C {lab_pin.sym} 6060 45440 0 0 {name=l36474 lab=VDD}
N 6040 45360 6060 45360 {}
C {lab_pin.sym} 6060 45360 0 0 {name=l36475 lab=VSS}
C {bitcell_6t.sym} 6200 45400 0 0 {name=Xr227c31}
N 6160 45440 6140 45440 {}
C {lab_pin.sym} 6140 45440 0 0 {name=l36476 lab=BL31}
N 6160 45400 6140 45400 {}
C {lab_pin.sym} 6140 45400 0 0 {name=l36477 lab=BLB31}
N 6160 45360 6140 45360 {}
C {lab_pin.sym} 6140 45360 0 0 {name=l36478 lab=WL227}
N 6240 45440 6260 45440 {}
C {lab_pin.sym} 6260 45440 0 0 {name=l36479 lab=VDD}
N 6240 45360 6260 45360 {}
C {lab_pin.sym} 6260 45360 0 0 {name=l36480 lab=VSS}
C {bitcell_6t.sym} 0 45600 0 0 {name=Xr228c0}
N -40 45640 -60 45640 {}
C {lab_pin.sym} -60 45640 0 0 {name=l36481 lab=BL0}
N -40 45600 -60 45600 {}
C {lab_pin.sym} -60 45600 0 0 {name=l36482 lab=BLB0}
N -40 45560 -60 45560 {}
C {lab_pin.sym} -60 45560 0 0 {name=l36483 lab=WL228}
N 40 45640 60 45640 {}
C {lab_pin.sym} 60 45640 0 0 {name=l36484 lab=VDD}
N 40 45560 60 45560 {}
C {lab_pin.sym} 60 45560 0 0 {name=l36485 lab=VSS}
C {bitcell_6t.sym} 200 45600 0 0 {name=Xr228c1}
N 160 45640 140 45640 {}
C {lab_pin.sym} 140 45640 0 0 {name=l36486 lab=BL1}
N 160 45600 140 45600 {}
C {lab_pin.sym} 140 45600 0 0 {name=l36487 lab=BLB1}
N 160 45560 140 45560 {}
C {lab_pin.sym} 140 45560 0 0 {name=l36488 lab=WL228}
N 240 45640 260 45640 {}
C {lab_pin.sym} 260 45640 0 0 {name=l36489 lab=VDD}
N 240 45560 260 45560 {}
C {lab_pin.sym} 260 45560 0 0 {name=l36490 lab=VSS}
C {bitcell_6t.sym} 400 45600 0 0 {name=Xr228c2}
N 360 45640 340 45640 {}
C {lab_pin.sym} 340 45640 0 0 {name=l36491 lab=BL2}
N 360 45600 340 45600 {}
C {lab_pin.sym} 340 45600 0 0 {name=l36492 lab=BLB2}
N 360 45560 340 45560 {}
C {lab_pin.sym} 340 45560 0 0 {name=l36493 lab=WL228}
N 440 45640 460 45640 {}
C {lab_pin.sym} 460 45640 0 0 {name=l36494 lab=VDD}
N 440 45560 460 45560 {}
C {lab_pin.sym} 460 45560 0 0 {name=l36495 lab=VSS}
C {bitcell_6t.sym} 600 45600 0 0 {name=Xr228c3}
N 560 45640 540 45640 {}
C {lab_pin.sym} 540 45640 0 0 {name=l36496 lab=BL3}
N 560 45600 540 45600 {}
C {lab_pin.sym} 540 45600 0 0 {name=l36497 lab=BLB3}
N 560 45560 540 45560 {}
C {lab_pin.sym} 540 45560 0 0 {name=l36498 lab=WL228}
N 640 45640 660 45640 {}
C {lab_pin.sym} 660 45640 0 0 {name=l36499 lab=VDD}
N 640 45560 660 45560 {}
C {lab_pin.sym} 660 45560 0 0 {name=l36500 lab=VSS}
C {bitcell_6t.sym} 800 45600 0 0 {name=Xr228c4}
N 760 45640 740 45640 {}
C {lab_pin.sym} 740 45640 0 0 {name=l36501 lab=BL4}
N 760 45600 740 45600 {}
C {lab_pin.sym} 740 45600 0 0 {name=l36502 lab=BLB4}
N 760 45560 740 45560 {}
C {lab_pin.sym} 740 45560 0 0 {name=l36503 lab=WL228}
N 840 45640 860 45640 {}
C {lab_pin.sym} 860 45640 0 0 {name=l36504 lab=VDD}
N 840 45560 860 45560 {}
C {lab_pin.sym} 860 45560 0 0 {name=l36505 lab=VSS}
C {bitcell_6t.sym} 1000 45600 0 0 {name=Xr228c5}
N 960 45640 940 45640 {}
C {lab_pin.sym} 940 45640 0 0 {name=l36506 lab=BL5}
N 960 45600 940 45600 {}
C {lab_pin.sym} 940 45600 0 0 {name=l36507 lab=BLB5}
N 960 45560 940 45560 {}
C {lab_pin.sym} 940 45560 0 0 {name=l36508 lab=WL228}
N 1040 45640 1060 45640 {}
C {lab_pin.sym} 1060 45640 0 0 {name=l36509 lab=VDD}
N 1040 45560 1060 45560 {}
C {lab_pin.sym} 1060 45560 0 0 {name=l36510 lab=VSS}
C {bitcell_6t.sym} 1200 45600 0 0 {name=Xr228c6}
N 1160 45640 1140 45640 {}
C {lab_pin.sym} 1140 45640 0 0 {name=l36511 lab=BL6}
N 1160 45600 1140 45600 {}
C {lab_pin.sym} 1140 45600 0 0 {name=l36512 lab=BLB6}
N 1160 45560 1140 45560 {}
C {lab_pin.sym} 1140 45560 0 0 {name=l36513 lab=WL228}
N 1240 45640 1260 45640 {}
C {lab_pin.sym} 1260 45640 0 0 {name=l36514 lab=VDD}
N 1240 45560 1260 45560 {}
C {lab_pin.sym} 1260 45560 0 0 {name=l36515 lab=VSS}
C {bitcell_6t.sym} 1400 45600 0 0 {name=Xr228c7}
N 1360 45640 1340 45640 {}
C {lab_pin.sym} 1340 45640 0 0 {name=l36516 lab=BL7}
N 1360 45600 1340 45600 {}
C {lab_pin.sym} 1340 45600 0 0 {name=l36517 lab=BLB7}
N 1360 45560 1340 45560 {}
C {lab_pin.sym} 1340 45560 0 0 {name=l36518 lab=WL228}
N 1440 45640 1460 45640 {}
C {lab_pin.sym} 1460 45640 0 0 {name=l36519 lab=VDD}
N 1440 45560 1460 45560 {}
C {lab_pin.sym} 1460 45560 0 0 {name=l36520 lab=VSS}
C {bitcell_6t.sym} 1600 45600 0 0 {name=Xr228c8}
N 1560 45640 1540 45640 {}
C {lab_pin.sym} 1540 45640 0 0 {name=l36521 lab=BL8}
N 1560 45600 1540 45600 {}
C {lab_pin.sym} 1540 45600 0 0 {name=l36522 lab=BLB8}
N 1560 45560 1540 45560 {}
C {lab_pin.sym} 1540 45560 0 0 {name=l36523 lab=WL228}
N 1640 45640 1660 45640 {}
C {lab_pin.sym} 1660 45640 0 0 {name=l36524 lab=VDD}
N 1640 45560 1660 45560 {}
C {lab_pin.sym} 1660 45560 0 0 {name=l36525 lab=VSS}
C {bitcell_6t.sym} 1800 45600 0 0 {name=Xr228c9}
N 1760 45640 1740 45640 {}
C {lab_pin.sym} 1740 45640 0 0 {name=l36526 lab=BL9}
N 1760 45600 1740 45600 {}
C {lab_pin.sym} 1740 45600 0 0 {name=l36527 lab=BLB9}
N 1760 45560 1740 45560 {}
C {lab_pin.sym} 1740 45560 0 0 {name=l36528 lab=WL228}
N 1840 45640 1860 45640 {}
C {lab_pin.sym} 1860 45640 0 0 {name=l36529 lab=VDD}
N 1840 45560 1860 45560 {}
C {lab_pin.sym} 1860 45560 0 0 {name=l36530 lab=VSS}
C {bitcell_6t.sym} 2000 45600 0 0 {name=Xr228c10}
N 1960 45640 1940 45640 {}
C {lab_pin.sym} 1940 45640 0 0 {name=l36531 lab=BL10}
N 1960 45600 1940 45600 {}
C {lab_pin.sym} 1940 45600 0 0 {name=l36532 lab=BLB10}
N 1960 45560 1940 45560 {}
C {lab_pin.sym} 1940 45560 0 0 {name=l36533 lab=WL228}
N 2040 45640 2060 45640 {}
C {lab_pin.sym} 2060 45640 0 0 {name=l36534 lab=VDD}
N 2040 45560 2060 45560 {}
C {lab_pin.sym} 2060 45560 0 0 {name=l36535 lab=VSS}
C {bitcell_6t.sym} 2200 45600 0 0 {name=Xr228c11}
N 2160 45640 2140 45640 {}
C {lab_pin.sym} 2140 45640 0 0 {name=l36536 lab=BL11}
N 2160 45600 2140 45600 {}
C {lab_pin.sym} 2140 45600 0 0 {name=l36537 lab=BLB11}
N 2160 45560 2140 45560 {}
C {lab_pin.sym} 2140 45560 0 0 {name=l36538 lab=WL228}
N 2240 45640 2260 45640 {}
C {lab_pin.sym} 2260 45640 0 0 {name=l36539 lab=VDD}
N 2240 45560 2260 45560 {}
C {lab_pin.sym} 2260 45560 0 0 {name=l36540 lab=VSS}
C {bitcell_6t.sym} 2400 45600 0 0 {name=Xr228c12}
N 2360 45640 2340 45640 {}
C {lab_pin.sym} 2340 45640 0 0 {name=l36541 lab=BL12}
N 2360 45600 2340 45600 {}
C {lab_pin.sym} 2340 45600 0 0 {name=l36542 lab=BLB12}
N 2360 45560 2340 45560 {}
C {lab_pin.sym} 2340 45560 0 0 {name=l36543 lab=WL228}
N 2440 45640 2460 45640 {}
C {lab_pin.sym} 2460 45640 0 0 {name=l36544 lab=VDD}
N 2440 45560 2460 45560 {}
C {lab_pin.sym} 2460 45560 0 0 {name=l36545 lab=VSS}
C {bitcell_6t.sym} 2600 45600 0 0 {name=Xr228c13}
N 2560 45640 2540 45640 {}
C {lab_pin.sym} 2540 45640 0 0 {name=l36546 lab=BL13}
N 2560 45600 2540 45600 {}
C {lab_pin.sym} 2540 45600 0 0 {name=l36547 lab=BLB13}
N 2560 45560 2540 45560 {}
C {lab_pin.sym} 2540 45560 0 0 {name=l36548 lab=WL228}
N 2640 45640 2660 45640 {}
C {lab_pin.sym} 2660 45640 0 0 {name=l36549 lab=VDD}
N 2640 45560 2660 45560 {}
C {lab_pin.sym} 2660 45560 0 0 {name=l36550 lab=VSS}
C {bitcell_6t.sym} 2800 45600 0 0 {name=Xr228c14}
N 2760 45640 2740 45640 {}
C {lab_pin.sym} 2740 45640 0 0 {name=l36551 lab=BL14}
N 2760 45600 2740 45600 {}
C {lab_pin.sym} 2740 45600 0 0 {name=l36552 lab=BLB14}
N 2760 45560 2740 45560 {}
C {lab_pin.sym} 2740 45560 0 0 {name=l36553 lab=WL228}
N 2840 45640 2860 45640 {}
C {lab_pin.sym} 2860 45640 0 0 {name=l36554 lab=VDD}
N 2840 45560 2860 45560 {}
C {lab_pin.sym} 2860 45560 0 0 {name=l36555 lab=VSS}
C {bitcell_6t.sym} 3000 45600 0 0 {name=Xr228c15}
N 2960 45640 2940 45640 {}
C {lab_pin.sym} 2940 45640 0 0 {name=l36556 lab=BL15}
N 2960 45600 2940 45600 {}
C {lab_pin.sym} 2940 45600 0 0 {name=l36557 lab=BLB15}
N 2960 45560 2940 45560 {}
C {lab_pin.sym} 2940 45560 0 0 {name=l36558 lab=WL228}
N 3040 45640 3060 45640 {}
C {lab_pin.sym} 3060 45640 0 0 {name=l36559 lab=VDD}
N 3040 45560 3060 45560 {}
C {lab_pin.sym} 3060 45560 0 0 {name=l36560 lab=VSS}
C {bitcell_6t.sym} 3200 45600 0 0 {name=Xr228c16}
N 3160 45640 3140 45640 {}
C {lab_pin.sym} 3140 45640 0 0 {name=l36561 lab=BL16}
N 3160 45600 3140 45600 {}
C {lab_pin.sym} 3140 45600 0 0 {name=l36562 lab=BLB16}
N 3160 45560 3140 45560 {}
C {lab_pin.sym} 3140 45560 0 0 {name=l36563 lab=WL228}
N 3240 45640 3260 45640 {}
C {lab_pin.sym} 3260 45640 0 0 {name=l36564 lab=VDD}
N 3240 45560 3260 45560 {}
C {lab_pin.sym} 3260 45560 0 0 {name=l36565 lab=VSS}
C {bitcell_6t.sym} 3400 45600 0 0 {name=Xr228c17}
N 3360 45640 3340 45640 {}
C {lab_pin.sym} 3340 45640 0 0 {name=l36566 lab=BL17}
N 3360 45600 3340 45600 {}
C {lab_pin.sym} 3340 45600 0 0 {name=l36567 lab=BLB17}
N 3360 45560 3340 45560 {}
C {lab_pin.sym} 3340 45560 0 0 {name=l36568 lab=WL228}
N 3440 45640 3460 45640 {}
C {lab_pin.sym} 3460 45640 0 0 {name=l36569 lab=VDD}
N 3440 45560 3460 45560 {}
C {lab_pin.sym} 3460 45560 0 0 {name=l36570 lab=VSS}
C {bitcell_6t.sym} 3600 45600 0 0 {name=Xr228c18}
N 3560 45640 3540 45640 {}
C {lab_pin.sym} 3540 45640 0 0 {name=l36571 lab=BL18}
N 3560 45600 3540 45600 {}
C {lab_pin.sym} 3540 45600 0 0 {name=l36572 lab=BLB18}
N 3560 45560 3540 45560 {}
C {lab_pin.sym} 3540 45560 0 0 {name=l36573 lab=WL228}
N 3640 45640 3660 45640 {}
C {lab_pin.sym} 3660 45640 0 0 {name=l36574 lab=VDD}
N 3640 45560 3660 45560 {}
C {lab_pin.sym} 3660 45560 0 0 {name=l36575 lab=VSS}
C {bitcell_6t.sym} 3800 45600 0 0 {name=Xr228c19}
N 3760 45640 3740 45640 {}
C {lab_pin.sym} 3740 45640 0 0 {name=l36576 lab=BL19}
N 3760 45600 3740 45600 {}
C {lab_pin.sym} 3740 45600 0 0 {name=l36577 lab=BLB19}
N 3760 45560 3740 45560 {}
C {lab_pin.sym} 3740 45560 0 0 {name=l36578 lab=WL228}
N 3840 45640 3860 45640 {}
C {lab_pin.sym} 3860 45640 0 0 {name=l36579 lab=VDD}
N 3840 45560 3860 45560 {}
C {lab_pin.sym} 3860 45560 0 0 {name=l36580 lab=VSS}
C {bitcell_6t.sym} 4000 45600 0 0 {name=Xr228c20}
N 3960 45640 3940 45640 {}
C {lab_pin.sym} 3940 45640 0 0 {name=l36581 lab=BL20}
N 3960 45600 3940 45600 {}
C {lab_pin.sym} 3940 45600 0 0 {name=l36582 lab=BLB20}
N 3960 45560 3940 45560 {}
C {lab_pin.sym} 3940 45560 0 0 {name=l36583 lab=WL228}
N 4040 45640 4060 45640 {}
C {lab_pin.sym} 4060 45640 0 0 {name=l36584 lab=VDD}
N 4040 45560 4060 45560 {}
C {lab_pin.sym} 4060 45560 0 0 {name=l36585 lab=VSS}
C {bitcell_6t.sym} 4200 45600 0 0 {name=Xr228c21}
N 4160 45640 4140 45640 {}
C {lab_pin.sym} 4140 45640 0 0 {name=l36586 lab=BL21}
N 4160 45600 4140 45600 {}
C {lab_pin.sym} 4140 45600 0 0 {name=l36587 lab=BLB21}
N 4160 45560 4140 45560 {}
C {lab_pin.sym} 4140 45560 0 0 {name=l36588 lab=WL228}
N 4240 45640 4260 45640 {}
C {lab_pin.sym} 4260 45640 0 0 {name=l36589 lab=VDD}
N 4240 45560 4260 45560 {}
C {lab_pin.sym} 4260 45560 0 0 {name=l36590 lab=VSS}
C {bitcell_6t.sym} 4400 45600 0 0 {name=Xr228c22}
N 4360 45640 4340 45640 {}
C {lab_pin.sym} 4340 45640 0 0 {name=l36591 lab=BL22}
N 4360 45600 4340 45600 {}
C {lab_pin.sym} 4340 45600 0 0 {name=l36592 lab=BLB22}
N 4360 45560 4340 45560 {}
C {lab_pin.sym} 4340 45560 0 0 {name=l36593 lab=WL228}
N 4440 45640 4460 45640 {}
C {lab_pin.sym} 4460 45640 0 0 {name=l36594 lab=VDD}
N 4440 45560 4460 45560 {}
C {lab_pin.sym} 4460 45560 0 0 {name=l36595 lab=VSS}
C {bitcell_6t.sym} 4600 45600 0 0 {name=Xr228c23}
N 4560 45640 4540 45640 {}
C {lab_pin.sym} 4540 45640 0 0 {name=l36596 lab=BL23}
N 4560 45600 4540 45600 {}
C {lab_pin.sym} 4540 45600 0 0 {name=l36597 lab=BLB23}
N 4560 45560 4540 45560 {}
C {lab_pin.sym} 4540 45560 0 0 {name=l36598 lab=WL228}
N 4640 45640 4660 45640 {}
C {lab_pin.sym} 4660 45640 0 0 {name=l36599 lab=VDD}
N 4640 45560 4660 45560 {}
C {lab_pin.sym} 4660 45560 0 0 {name=l36600 lab=VSS}
C {bitcell_6t.sym} 4800 45600 0 0 {name=Xr228c24}
N 4760 45640 4740 45640 {}
C {lab_pin.sym} 4740 45640 0 0 {name=l36601 lab=BL24}
N 4760 45600 4740 45600 {}
C {lab_pin.sym} 4740 45600 0 0 {name=l36602 lab=BLB24}
N 4760 45560 4740 45560 {}
C {lab_pin.sym} 4740 45560 0 0 {name=l36603 lab=WL228}
N 4840 45640 4860 45640 {}
C {lab_pin.sym} 4860 45640 0 0 {name=l36604 lab=VDD}
N 4840 45560 4860 45560 {}
C {lab_pin.sym} 4860 45560 0 0 {name=l36605 lab=VSS}
C {bitcell_6t.sym} 5000 45600 0 0 {name=Xr228c25}
N 4960 45640 4940 45640 {}
C {lab_pin.sym} 4940 45640 0 0 {name=l36606 lab=BL25}
N 4960 45600 4940 45600 {}
C {lab_pin.sym} 4940 45600 0 0 {name=l36607 lab=BLB25}
N 4960 45560 4940 45560 {}
C {lab_pin.sym} 4940 45560 0 0 {name=l36608 lab=WL228}
N 5040 45640 5060 45640 {}
C {lab_pin.sym} 5060 45640 0 0 {name=l36609 lab=VDD}
N 5040 45560 5060 45560 {}
C {lab_pin.sym} 5060 45560 0 0 {name=l36610 lab=VSS}
C {bitcell_6t.sym} 5200 45600 0 0 {name=Xr228c26}
N 5160 45640 5140 45640 {}
C {lab_pin.sym} 5140 45640 0 0 {name=l36611 lab=BL26}
N 5160 45600 5140 45600 {}
C {lab_pin.sym} 5140 45600 0 0 {name=l36612 lab=BLB26}
N 5160 45560 5140 45560 {}
C {lab_pin.sym} 5140 45560 0 0 {name=l36613 lab=WL228}
N 5240 45640 5260 45640 {}
C {lab_pin.sym} 5260 45640 0 0 {name=l36614 lab=VDD}
N 5240 45560 5260 45560 {}
C {lab_pin.sym} 5260 45560 0 0 {name=l36615 lab=VSS}
C {bitcell_6t.sym} 5400 45600 0 0 {name=Xr228c27}
N 5360 45640 5340 45640 {}
C {lab_pin.sym} 5340 45640 0 0 {name=l36616 lab=BL27}
N 5360 45600 5340 45600 {}
C {lab_pin.sym} 5340 45600 0 0 {name=l36617 lab=BLB27}
N 5360 45560 5340 45560 {}
C {lab_pin.sym} 5340 45560 0 0 {name=l36618 lab=WL228}
N 5440 45640 5460 45640 {}
C {lab_pin.sym} 5460 45640 0 0 {name=l36619 lab=VDD}
N 5440 45560 5460 45560 {}
C {lab_pin.sym} 5460 45560 0 0 {name=l36620 lab=VSS}
C {bitcell_6t.sym} 5600 45600 0 0 {name=Xr228c28}
N 5560 45640 5540 45640 {}
C {lab_pin.sym} 5540 45640 0 0 {name=l36621 lab=BL28}
N 5560 45600 5540 45600 {}
C {lab_pin.sym} 5540 45600 0 0 {name=l36622 lab=BLB28}
N 5560 45560 5540 45560 {}
C {lab_pin.sym} 5540 45560 0 0 {name=l36623 lab=WL228}
N 5640 45640 5660 45640 {}
C {lab_pin.sym} 5660 45640 0 0 {name=l36624 lab=VDD}
N 5640 45560 5660 45560 {}
C {lab_pin.sym} 5660 45560 0 0 {name=l36625 lab=VSS}
C {bitcell_6t.sym} 5800 45600 0 0 {name=Xr228c29}
N 5760 45640 5740 45640 {}
C {lab_pin.sym} 5740 45640 0 0 {name=l36626 lab=BL29}
N 5760 45600 5740 45600 {}
C {lab_pin.sym} 5740 45600 0 0 {name=l36627 lab=BLB29}
N 5760 45560 5740 45560 {}
C {lab_pin.sym} 5740 45560 0 0 {name=l36628 lab=WL228}
N 5840 45640 5860 45640 {}
C {lab_pin.sym} 5860 45640 0 0 {name=l36629 lab=VDD}
N 5840 45560 5860 45560 {}
C {lab_pin.sym} 5860 45560 0 0 {name=l36630 lab=VSS}
C {bitcell_6t.sym} 6000 45600 0 0 {name=Xr228c30}
N 5960 45640 5940 45640 {}
C {lab_pin.sym} 5940 45640 0 0 {name=l36631 lab=BL30}
N 5960 45600 5940 45600 {}
C {lab_pin.sym} 5940 45600 0 0 {name=l36632 lab=BLB30}
N 5960 45560 5940 45560 {}
C {lab_pin.sym} 5940 45560 0 0 {name=l36633 lab=WL228}
N 6040 45640 6060 45640 {}
C {lab_pin.sym} 6060 45640 0 0 {name=l36634 lab=VDD}
N 6040 45560 6060 45560 {}
C {lab_pin.sym} 6060 45560 0 0 {name=l36635 lab=VSS}
C {bitcell_6t.sym} 6200 45600 0 0 {name=Xr228c31}
N 6160 45640 6140 45640 {}
C {lab_pin.sym} 6140 45640 0 0 {name=l36636 lab=BL31}
N 6160 45600 6140 45600 {}
C {lab_pin.sym} 6140 45600 0 0 {name=l36637 lab=BLB31}
N 6160 45560 6140 45560 {}
C {lab_pin.sym} 6140 45560 0 0 {name=l36638 lab=WL228}
N 6240 45640 6260 45640 {}
C {lab_pin.sym} 6260 45640 0 0 {name=l36639 lab=VDD}
N 6240 45560 6260 45560 {}
C {lab_pin.sym} 6260 45560 0 0 {name=l36640 lab=VSS}
C {bitcell_6t.sym} 0 45800 0 0 {name=Xr229c0}
N -40 45840 -60 45840 {}
C {lab_pin.sym} -60 45840 0 0 {name=l36641 lab=BL0}
N -40 45800 -60 45800 {}
C {lab_pin.sym} -60 45800 0 0 {name=l36642 lab=BLB0}
N -40 45760 -60 45760 {}
C {lab_pin.sym} -60 45760 0 0 {name=l36643 lab=WL229}
N 40 45840 60 45840 {}
C {lab_pin.sym} 60 45840 0 0 {name=l36644 lab=VDD}
N 40 45760 60 45760 {}
C {lab_pin.sym} 60 45760 0 0 {name=l36645 lab=VSS}
C {bitcell_6t.sym} 200 45800 0 0 {name=Xr229c1}
N 160 45840 140 45840 {}
C {lab_pin.sym} 140 45840 0 0 {name=l36646 lab=BL1}
N 160 45800 140 45800 {}
C {lab_pin.sym} 140 45800 0 0 {name=l36647 lab=BLB1}
N 160 45760 140 45760 {}
C {lab_pin.sym} 140 45760 0 0 {name=l36648 lab=WL229}
N 240 45840 260 45840 {}
C {lab_pin.sym} 260 45840 0 0 {name=l36649 lab=VDD}
N 240 45760 260 45760 {}
C {lab_pin.sym} 260 45760 0 0 {name=l36650 lab=VSS}
C {bitcell_6t.sym} 400 45800 0 0 {name=Xr229c2}
N 360 45840 340 45840 {}
C {lab_pin.sym} 340 45840 0 0 {name=l36651 lab=BL2}
N 360 45800 340 45800 {}
C {lab_pin.sym} 340 45800 0 0 {name=l36652 lab=BLB2}
N 360 45760 340 45760 {}
C {lab_pin.sym} 340 45760 0 0 {name=l36653 lab=WL229}
N 440 45840 460 45840 {}
C {lab_pin.sym} 460 45840 0 0 {name=l36654 lab=VDD}
N 440 45760 460 45760 {}
C {lab_pin.sym} 460 45760 0 0 {name=l36655 lab=VSS}
C {bitcell_6t.sym} 600 45800 0 0 {name=Xr229c3}
N 560 45840 540 45840 {}
C {lab_pin.sym} 540 45840 0 0 {name=l36656 lab=BL3}
N 560 45800 540 45800 {}
C {lab_pin.sym} 540 45800 0 0 {name=l36657 lab=BLB3}
N 560 45760 540 45760 {}
C {lab_pin.sym} 540 45760 0 0 {name=l36658 lab=WL229}
N 640 45840 660 45840 {}
C {lab_pin.sym} 660 45840 0 0 {name=l36659 lab=VDD}
N 640 45760 660 45760 {}
C {lab_pin.sym} 660 45760 0 0 {name=l36660 lab=VSS}
C {bitcell_6t.sym} 800 45800 0 0 {name=Xr229c4}
N 760 45840 740 45840 {}
C {lab_pin.sym} 740 45840 0 0 {name=l36661 lab=BL4}
N 760 45800 740 45800 {}
C {lab_pin.sym} 740 45800 0 0 {name=l36662 lab=BLB4}
N 760 45760 740 45760 {}
C {lab_pin.sym} 740 45760 0 0 {name=l36663 lab=WL229}
N 840 45840 860 45840 {}
C {lab_pin.sym} 860 45840 0 0 {name=l36664 lab=VDD}
N 840 45760 860 45760 {}
C {lab_pin.sym} 860 45760 0 0 {name=l36665 lab=VSS}
C {bitcell_6t.sym} 1000 45800 0 0 {name=Xr229c5}
N 960 45840 940 45840 {}
C {lab_pin.sym} 940 45840 0 0 {name=l36666 lab=BL5}
N 960 45800 940 45800 {}
C {lab_pin.sym} 940 45800 0 0 {name=l36667 lab=BLB5}
N 960 45760 940 45760 {}
C {lab_pin.sym} 940 45760 0 0 {name=l36668 lab=WL229}
N 1040 45840 1060 45840 {}
C {lab_pin.sym} 1060 45840 0 0 {name=l36669 lab=VDD}
N 1040 45760 1060 45760 {}
C {lab_pin.sym} 1060 45760 0 0 {name=l36670 lab=VSS}
C {bitcell_6t.sym} 1200 45800 0 0 {name=Xr229c6}
N 1160 45840 1140 45840 {}
C {lab_pin.sym} 1140 45840 0 0 {name=l36671 lab=BL6}
N 1160 45800 1140 45800 {}
C {lab_pin.sym} 1140 45800 0 0 {name=l36672 lab=BLB6}
N 1160 45760 1140 45760 {}
C {lab_pin.sym} 1140 45760 0 0 {name=l36673 lab=WL229}
N 1240 45840 1260 45840 {}
C {lab_pin.sym} 1260 45840 0 0 {name=l36674 lab=VDD}
N 1240 45760 1260 45760 {}
C {lab_pin.sym} 1260 45760 0 0 {name=l36675 lab=VSS}
C {bitcell_6t.sym} 1400 45800 0 0 {name=Xr229c7}
N 1360 45840 1340 45840 {}
C {lab_pin.sym} 1340 45840 0 0 {name=l36676 lab=BL7}
N 1360 45800 1340 45800 {}
C {lab_pin.sym} 1340 45800 0 0 {name=l36677 lab=BLB7}
N 1360 45760 1340 45760 {}
C {lab_pin.sym} 1340 45760 0 0 {name=l36678 lab=WL229}
N 1440 45840 1460 45840 {}
C {lab_pin.sym} 1460 45840 0 0 {name=l36679 lab=VDD}
N 1440 45760 1460 45760 {}
C {lab_pin.sym} 1460 45760 0 0 {name=l36680 lab=VSS}
C {bitcell_6t.sym} 1600 45800 0 0 {name=Xr229c8}
N 1560 45840 1540 45840 {}
C {lab_pin.sym} 1540 45840 0 0 {name=l36681 lab=BL8}
N 1560 45800 1540 45800 {}
C {lab_pin.sym} 1540 45800 0 0 {name=l36682 lab=BLB8}
N 1560 45760 1540 45760 {}
C {lab_pin.sym} 1540 45760 0 0 {name=l36683 lab=WL229}
N 1640 45840 1660 45840 {}
C {lab_pin.sym} 1660 45840 0 0 {name=l36684 lab=VDD}
N 1640 45760 1660 45760 {}
C {lab_pin.sym} 1660 45760 0 0 {name=l36685 lab=VSS}
C {bitcell_6t.sym} 1800 45800 0 0 {name=Xr229c9}
N 1760 45840 1740 45840 {}
C {lab_pin.sym} 1740 45840 0 0 {name=l36686 lab=BL9}
N 1760 45800 1740 45800 {}
C {lab_pin.sym} 1740 45800 0 0 {name=l36687 lab=BLB9}
N 1760 45760 1740 45760 {}
C {lab_pin.sym} 1740 45760 0 0 {name=l36688 lab=WL229}
N 1840 45840 1860 45840 {}
C {lab_pin.sym} 1860 45840 0 0 {name=l36689 lab=VDD}
N 1840 45760 1860 45760 {}
C {lab_pin.sym} 1860 45760 0 0 {name=l36690 lab=VSS}
C {bitcell_6t.sym} 2000 45800 0 0 {name=Xr229c10}
N 1960 45840 1940 45840 {}
C {lab_pin.sym} 1940 45840 0 0 {name=l36691 lab=BL10}
N 1960 45800 1940 45800 {}
C {lab_pin.sym} 1940 45800 0 0 {name=l36692 lab=BLB10}
N 1960 45760 1940 45760 {}
C {lab_pin.sym} 1940 45760 0 0 {name=l36693 lab=WL229}
N 2040 45840 2060 45840 {}
C {lab_pin.sym} 2060 45840 0 0 {name=l36694 lab=VDD}
N 2040 45760 2060 45760 {}
C {lab_pin.sym} 2060 45760 0 0 {name=l36695 lab=VSS}
C {bitcell_6t.sym} 2200 45800 0 0 {name=Xr229c11}
N 2160 45840 2140 45840 {}
C {lab_pin.sym} 2140 45840 0 0 {name=l36696 lab=BL11}
N 2160 45800 2140 45800 {}
C {lab_pin.sym} 2140 45800 0 0 {name=l36697 lab=BLB11}
N 2160 45760 2140 45760 {}
C {lab_pin.sym} 2140 45760 0 0 {name=l36698 lab=WL229}
N 2240 45840 2260 45840 {}
C {lab_pin.sym} 2260 45840 0 0 {name=l36699 lab=VDD}
N 2240 45760 2260 45760 {}
C {lab_pin.sym} 2260 45760 0 0 {name=l36700 lab=VSS}
C {bitcell_6t.sym} 2400 45800 0 0 {name=Xr229c12}
N 2360 45840 2340 45840 {}
C {lab_pin.sym} 2340 45840 0 0 {name=l36701 lab=BL12}
N 2360 45800 2340 45800 {}
C {lab_pin.sym} 2340 45800 0 0 {name=l36702 lab=BLB12}
N 2360 45760 2340 45760 {}
C {lab_pin.sym} 2340 45760 0 0 {name=l36703 lab=WL229}
N 2440 45840 2460 45840 {}
C {lab_pin.sym} 2460 45840 0 0 {name=l36704 lab=VDD}
N 2440 45760 2460 45760 {}
C {lab_pin.sym} 2460 45760 0 0 {name=l36705 lab=VSS}
C {bitcell_6t.sym} 2600 45800 0 0 {name=Xr229c13}
N 2560 45840 2540 45840 {}
C {lab_pin.sym} 2540 45840 0 0 {name=l36706 lab=BL13}
N 2560 45800 2540 45800 {}
C {lab_pin.sym} 2540 45800 0 0 {name=l36707 lab=BLB13}
N 2560 45760 2540 45760 {}
C {lab_pin.sym} 2540 45760 0 0 {name=l36708 lab=WL229}
N 2640 45840 2660 45840 {}
C {lab_pin.sym} 2660 45840 0 0 {name=l36709 lab=VDD}
N 2640 45760 2660 45760 {}
C {lab_pin.sym} 2660 45760 0 0 {name=l36710 lab=VSS}
C {bitcell_6t.sym} 2800 45800 0 0 {name=Xr229c14}
N 2760 45840 2740 45840 {}
C {lab_pin.sym} 2740 45840 0 0 {name=l36711 lab=BL14}
N 2760 45800 2740 45800 {}
C {lab_pin.sym} 2740 45800 0 0 {name=l36712 lab=BLB14}
N 2760 45760 2740 45760 {}
C {lab_pin.sym} 2740 45760 0 0 {name=l36713 lab=WL229}
N 2840 45840 2860 45840 {}
C {lab_pin.sym} 2860 45840 0 0 {name=l36714 lab=VDD}
N 2840 45760 2860 45760 {}
C {lab_pin.sym} 2860 45760 0 0 {name=l36715 lab=VSS}
C {bitcell_6t.sym} 3000 45800 0 0 {name=Xr229c15}
N 2960 45840 2940 45840 {}
C {lab_pin.sym} 2940 45840 0 0 {name=l36716 lab=BL15}
N 2960 45800 2940 45800 {}
C {lab_pin.sym} 2940 45800 0 0 {name=l36717 lab=BLB15}
N 2960 45760 2940 45760 {}
C {lab_pin.sym} 2940 45760 0 0 {name=l36718 lab=WL229}
N 3040 45840 3060 45840 {}
C {lab_pin.sym} 3060 45840 0 0 {name=l36719 lab=VDD}
N 3040 45760 3060 45760 {}
C {lab_pin.sym} 3060 45760 0 0 {name=l36720 lab=VSS}
C {bitcell_6t.sym} 3200 45800 0 0 {name=Xr229c16}
N 3160 45840 3140 45840 {}
C {lab_pin.sym} 3140 45840 0 0 {name=l36721 lab=BL16}
N 3160 45800 3140 45800 {}
C {lab_pin.sym} 3140 45800 0 0 {name=l36722 lab=BLB16}
N 3160 45760 3140 45760 {}
C {lab_pin.sym} 3140 45760 0 0 {name=l36723 lab=WL229}
N 3240 45840 3260 45840 {}
C {lab_pin.sym} 3260 45840 0 0 {name=l36724 lab=VDD}
N 3240 45760 3260 45760 {}
C {lab_pin.sym} 3260 45760 0 0 {name=l36725 lab=VSS}
C {bitcell_6t.sym} 3400 45800 0 0 {name=Xr229c17}
N 3360 45840 3340 45840 {}
C {lab_pin.sym} 3340 45840 0 0 {name=l36726 lab=BL17}
N 3360 45800 3340 45800 {}
C {lab_pin.sym} 3340 45800 0 0 {name=l36727 lab=BLB17}
N 3360 45760 3340 45760 {}
C {lab_pin.sym} 3340 45760 0 0 {name=l36728 lab=WL229}
N 3440 45840 3460 45840 {}
C {lab_pin.sym} 3460 45840 0 0 {name=l36729 lab=VDD}
N 3440 45760 3460 45760 {}
C {lab_pin.sym} 3460 45760 0 0 {name=l36730 lab=VSS}
C {bitcell_6t.sym} 3600 45800 0 0 {name=Xr229c18}
N 3560 45840 3540 45840 {}
C {lab_pin.sym} 3540 45840 0 0 {name=l36731 lab=BL18}
N 3560 45800 3540 45800 {}
C {lab_pin.sym} 3540 45800 0 0 {name=l36732 lab=BLB18}
N 3560 45760 3540 45760 {}
C {lab_pin.sym} 3540 45760 0 0 {name=l36733 lab=WL229}
N 3640 45840 3660 45840 {}
C {lab_pin.sym} 3660 45840 0 0 {name=l36734 lab=VDD}
N 3640 45760 3660 45760 {}
C {lab_pin.sym} 3660 45760 0 0 {name=l36735 lab=VSS}
C {bitcell_6t.sym} 3800 45800 0 0 {name=Xr229c19}
N 3760 45840 3740 45840 {}
C {lab_pin.sym} 3740 45840 0 0 {name=l36736 lab=BL19}
N 3760 45800 3740 45800 {}
C {lab_pin.sym} 3740 45800 0 0 {name=l36737 lab=BLB19}
N 3760 45760 3740 45760 {}
C {lab_pin.sym} 3740 45760 0 0 {name=l36738 lab=WL229}
N 3840 45840 3860 45840 {}
C {lab_pin.sym} 3860 45840 0 0 {name=l36739 lab=VDD}
N 3840 45760 3860 45760 {}
C {lab_pin.sym} 3860 45760 0 0 {name=l36740 lab=VSS}
C {bitcell_6t.sym} 4000 45800 0 0 {name=Xr229c20}
N 3960 45840 3940 45840 {}
C {lab_pin.sym} 3940 45840 0 0 {name=l36741 lab=BL20}
N 3960 45800 3940 45800 {}
C {lab_pin.sym} 3940 45800 0 0 {name=l36742 lab=BLB20}
N 3960 45760 3940 45760 {}
C {lab_pin.sym} 3940 45760 0 0 {name=l36743 lab=WL229}
N 4040 45840 4060 45840 {}
C {lab_pin.sym} 4060 45840 0 0 {name=l36744 lab=VDD}
N 4040 45760 4060 45760 {}
C {lab_pin.sym} 4060 45760 0 0 {name=l36745 lab=VSS}
C {bitcell_6t.sym} 4200 45800 0 0 {name=Xr229c21}
N 4160 45840 4140 45840 {}
C {lab_pin.sym} 4140 45840 0 0 {name=l36746 lab=BL21}
N 4160 45800 4140 45800 {}
C {lab_pin.sym} 4140 45800 0 0 {name=l36747 lab=BLB21}
N 4160 45760 4140 45760 {}
C {lab_pin.sym} 4140 45760 0 0 {name=l36748 lab=WL229}
N 4240 45840 4260 45840 {}
C {lab_pin.sym} 4260 45840 0 0 {name=l36749 lab=VDD}
N 4240 45760 4260 45760 {}
C {lab_pin.sym} 4260 45760 0 0 {name=l36750 lab=VSS}
C {bitcell_6t.sym} 4400 45800 0 0 {name=Xr229c22}
N 4360 45840 4340 45840 {}
C {lab_pin.sym} 4340 45840 0 0 {name=l36751 lab=BL22}
N 4360 45800 4340 45800 {}
C {lab_pin.sym} 4340 45800 0 0 {name=l36752 lab=BLB22}
N 4360 45760 4340 45760 {}
C {lab_pin.sym} 4340 45760 0 0 {name=l36753 lab=WL229}
N 4440 45840 4460 45840 {}
C {lab_pin.sym} 4460 45840 0 0 {name=l36754 lab=VDD}
N 4440 45760 4460 45760 {}
C {lab_pin.sym} 4460 45760 0 0 {name=l36755 lab=VSS}
C {bitcell_6t.sym} 4600 45800 0 0 {name=Xr229c23}
N 4560 45840 4540 45840 {}
C {lab_pin.sym} 4540 45840 0 0 {name=l36756 lab=BL23}
N 4560 45800 4540 45800 {}
C {lab_pin.sym} 4540 45800 0 0 {name=l36757 lab=BLB23}
N 4560 45760 4540 45760 {}
C {lab_pin.sym} 4540 45760 0 0 {name=l36758 lab=WL229}
N 4640 45840 4660 45840 {}
C {lab_pin.sym} 4660 45840 0 0 {name=l36759 lab=VDD}
N 4640 45760 4660 45760 {}
C {lab_pin.sym} 4660 45760 0 0 {name=l36760 lab=VSS}
C {bitcell_6t.sym} 4800 45800 0 0 {name=Xr229c24}
N 4760 45840 4740 45840 {}
C {lab_pin.sym} 4740 45840 0 0 {name=l36761 lab=BL24}
N 4760 45800 4740 45800 {}
C {lab_pin.sym} 4740 45800 0 0 {name=l36762 lab=BLB24}
N 4760 45760 4740 45760 {}
C {lab_pin.sym} 4740 45760 0 0 {name=l36763 lab=WL229}
N 4840 45840 4860 45840 {}
C {lab_pin.sym} 4860 45840 0 0 {name=l36764 lab=VDD}
N 4840 45760 4860 45760 {}
C {lab_pin.sym} 4860 45760 0 0 {name=l36765 lab=VSS}
C {bitcell_6t.sym} 5000 45800 0 0 {name=Xr229c25}
N 4960 45840 4940 45840 {}
C {lab_pin.sym} 4940 45840 0 0 {name=l36766 lab=BL25}
N 4960 45800 4940 45800 {}
C {lab_pin.sym} 4940 45800 0 0 {name=l36767 lab=BLB25}
N 4960 45760 4940 45760 {}
C {lab_pin.sym} 4940 45760 0 0 {name=l36768 lab=WL229}
N 5040 45840 5060 45840 {}
C {lab_pin.sym} 5060 45840 0 0 {name=l36769 lab=VDD}
N 5040 45760 5060 45760 {}
C {lab_pin.sym} 5060 45760 0 0 {name=l36770 lab=VSS}
C {bitcell_6t.sym} 5200 45800 0 0 {name=Xr229c26}
N 5160 45840 5140 45840 {}
C {lab_pin.sym} 5140 45840 0 0 {name=l36771 lab=BL26}
N 5160 45800 5140 45800 {}
C {lab_pin.sym} 5140 45800 0 0 {name=l36772 lab=BLB26}
N 5160 45760 5140 45760 {}
C {lab_pin.sym} 5140 45760 0 0 {name=l36773 lab=WL229}
N 5240 45840 5260 45840 {}
C {lab_pin.sym} 5260 45840 0 0 {name=l36774 lab=VDD}
N 5240 45760 5260 45760 {}
C {lab_pin.sym} 5260 45760 0 0 {name=l36775 lab=VSS}
C {bitcell_6t.sym} 5400 45800 0 0 {name=Xr229c27}
N 5360 45840 5340 45840 {}
C {lab_pin.sym} 5340 45840 0 0 {name=l36776 lab=BL27}
N 5360 45800 5340 45800 {}
C {lab_pin.sym} 5340 45800 0 0 {name=l36777 lab=BLB27}
N 5360 45760 5340 45760 {}
C {lab_pin.sym} 5340 45760 0 0 {name=l36778 lab=WL229}
N 5440 45840 5460 45840 {}
C {lab_pin.sym} 5460 45840 0 0 {name=l36779 lab=VDD}
N 5440 45760 5460 45760 {}
C {lab_pin.sym} 5460 45760 0 0 {name=l36780 lab=VSS}
C {bitcell_6t.sym} 5600 45800 0 0 {name=Xr229c28}
N 5560 45840 5540 45840 {}
C {lab_pin.sym} 5540 45840 0 0 {name=l36781 lab=BL28}
N 5560 45800 5540 45800 {}
C {lab_pin.sym} 5540 45800 0 0 {name=l36782 lab=BLB28}
N 5560 45760 5540 45760 {}
C {lab_pin.sym} 5540 45760 0 0 {name=l36783 lab=WL229}
N 5640 45840 5660 45840 {}
C {lab_pin.sym} 5660 45840 0 0 {name=l36784 lab=VDD}
N 5640 45760 5660 45760 {}
C {lab_pin.sym} 5660 45760 0 0 {name=l36785 lab=VSS}
C {bitcell_6t.sym} 5800 45800 0 0 {name=Xr229c29}
N 5760 45840 5740 45840 {}
C {lab_pin.sym} 5740 45840 0 0 {name=l36786 lab=BL29}
N 5760 45800 5740 45800 {}
C {lab_pin.sym} 5740 45800 0 0 {name=l36787 lab=BLB29}
N 5760 45760 5740 45760 {}
C {lab_pin.sym} 5740 45760 0 0 {name=l36788 lab=WL229}
N 5840 45840 5860 45840 {}
C {lab_pin.sym} 5860 45840 0 0 {name=l36789 lab=VDD}
N 5840 45760 5860 45760 {}
C {lab_pin.sym} 5860 45760 0 0 {name=l36790 lab=VSS}
C {bitcell_6t.sym} 6000 45800 0 0 {name=Xr229c30}
N 5960 45840 5940 45840 {}
C {lab_pin.sym} 5940 45840 0 0 {name=l36791 lab=BL30}
N 5960 45800 5940 45800 {}
C {lab_pin.sym} 5940 45800 0 0 {name=l36792 lab=BLB30}
N 5960 45760 5940 45760 {}
C {lab_pin.sym} 5940 45760 0 0 {name=l36793 lab=WL229}
N 6040 45840 6060 45840 {}
C {lab_pin.sym} 6060 45840 0 0 {name=l36794 lab=VDD}
N 6040 45760 6060 45760 {}
C {lab_pin.sym} 6060 45760 0 0 {name=l36795 lab=VSS}
C {bitcell_6t.sym} 6200 45800 0 0 {name=Xr229c31}
N 6160 45840 6140 45840 {}
C {lab_pin.sym} 6140 45840 0 0 {name=l36796 lab=BL31}
N 6160 45800 6140 45800 {}
C {lab_pin.sym} 6140 45800 0 0 {name=l36797 lab=BLB31}
N 6160 45760 6140 45760 {}
C {lab_pin.sym} 6140 45760 0 0 {name=l36798 lab=WL229}
N 6240 45840 6260 45840 {}
C {lab_pin.sym} 6260 45840 0 0 {name=l36799 lab=VDD}
N 6240 45760 6260 45760 {}
C {lab_pin.sym} 6260 45760 0 0 {name=l36800 lab=VSS}
C {bitcell_6t.sym} 0 46000 0 0 {name=Xr230c0}
N -40 46040 -60 46040 {}
C {lab_pin.sym} -60 46040 0 0 {name=l36801 lab=BL0}
N -40 46000 -60 46000 {}
C {lab_pin.sym} -60 46000 0 0 {name=l36802 lab=BLB0}
N -40 45960 -60 45960 {}
C {lab_pin.sym} -60 45960 0 0 {name=l36803 lab=WL230}
N 40 46040 60 46040 {}
C {lab_pin.sym} 60 46040 0 0 {name=l36804 lab=VDD}
N 40 45960 60 45960 {}
C {lab_pin.sym} 60 45960 0 0 {name=l36805 lab=VSS}
C {bitcell_6t.sym} 200 46000 0 0 {name=Xr230c1}
N 160 46040 140 46040 {}
C {lab_pin.sym} 140 46040 0 0 {name=l36806 lab=BL1}
N 160 46000 140 46000 {}
C {lab_pin.sym} 140 46000 0 0 {name=l36807 lab=BLB1}
N 160 45960 140 45960 {}
C {lab_pin.sym} 140 45960 0 0 {name=l36808 lab=WL230}
N 240 46040 260 46040 {}
C {lab_pin.sym} 260 46040 0 0 {name=l36809 lab=VDD}
N 240 45960 260 45960 {}
C {lab_pin.sym} 260 45960 0 0 {name=l36810 lab=VSS}
C {bitcell_6t.sym} 400 46000 0 0 {name=Xr230c2}
N 360 46040 340 46040 {}
C {lab_pin.sym} 340 46040 0 0 {name=l36811 lab=BL2}
N 360 46000 340 46000 {}
C {lab_pin.sym} 340 46000 0 0 {name=l36812 lab=BLB2}
N 360 45960 340 45960 {}
C {lab_pin.sym} 340 45960 0 0 {name=l36813 lab=WL230}
N 440 46040 460 46040 {}
C {lab_pin.sym} 460 46040 0 0 {name=l36814 lab=VDD}
N 440 45960 460 45960 {}
C {lab_pin.sym} 460 45960 0 0 {name=l36815 lab=VSS}
C {bitcell_6t.sym} 600 46000 0 0 {name=Xr230c3}
N 560 46040 540 46040 {}
C {lab_pin.sym} 540 46040 0 0 {name=l36816 lab=BL3}
N 560 46000 540 46000 {}
C {lab_pin.sym} 540 46000 0 0 {name=l36817 lab=BLB3}
N 560 45960 540 45960 {}
C {lab_pin.sym} 540 45960 0 0 {name=l36818 lab=WL230}
N 640 46040 660 46040 {}
C {lab_pin.sym} 660 46040 0 0 {name=l36819 lab=VDD}
N 640 45960 660 45960 {}
C {lab_pin.sym} 660 45960 0 0 {name=l36820 lab=VSS}
C {bitcell_6t.sym} 800 46000 0 0 {name=Xr230c4}
N 760 46040 740 46040 {}
C {lab_pin.sym} 740 46040 0 0 {name=l36821 lab=BL4}
N 760 46000 740 46000 {}
C {lab_pin.sym} 740 46000 0 0 {name=l36822 lab=BLB4}
N 760 45960 740 45960 {}
C {lab_pin.sym} 740 45960 0 0 {name=l36823 lab=WL230}
N 840 46040 860 46040 {}
C {lab_pin.sym} 860 46040 0 0 {name=l36824 lab=VDD}
N 840 45960 860 45960 {}
C {lab_pin.sym} 860 45960 0 0 {name=l36825 lab=VSS}
C {bitcell_6t.sym} 1000 46000 0 0 {name=Xr230c5}
N 960 46040 940 46040 {}
C {lab_pin.sym} 940 46040 0 0 {name=l36826 lab=BL5}
N 960 46000 940 46000 {}
C {lab_pin.sym} 940 46000 0 0 {name=l36827 lab=BLB5}
N 960 45960 940 45960 {}
C {lab_pin.sym} 940 45960 0 0 {name=l36828 lab=WL230}
N 1040 46040 1060 46040 {}
C {lab_pin.sym} 1060 46040 0 0 {name=l36829 lab=VDD}
N 1040 45960 1060 45960 {}
C {lab_pin.sym} 1060 45960 0 0 {name=l36830 lab=VSS}
C {bitcell_6t.sym} 1200 46000 0 0 {name=Xr230c6}
N 1160 46040 1140 46040 {}
C {lab_pin.sym} 1140 46040 0 0 {name=l36831 lab=BL6}
N 1160 46000 1140 46000 {}
C {lab_pin.sym} 1140 46000 0 0 {name=l36832 lab=BLB6}
N 1160 45960 1140 45960 {}
C {lab_pin.sym} 1140 45960 0 0 {name=l36833 lab=WL230}
N 1240 46040 1260 46040 {}
C {lab_pin.sym} 1260 46040 0 0 {name=l36834 lab=VDD}
N 1240 45960 1260 45960 {}
C {lab_pin.sym} 1260 45960 0 0 {name=l36835 lab=VSS}
C {bitcell_6t.sym} 1400 46000 0 0 {name=Xr230c7}
N 1360 46040 1340 46040 {}
C {lab_pin.sym} 1340 46040 0 0 {name=l36836 lab=BL7}
N 1360 46000 1340 46000 {}
C {lab_pin.sym} 1340 46000 0 0 {name=l36837 lab=BLB7}
N 1360 45960 1340 45960 {}
C {lab_pin.sym} 1340 45960 0 0 {name=l36838 lab=WL230}
N 1440 46040 1460 46040 {}
C {lab_pin.sym} 1460 46040 0 0 {name=l36839 lab=VDD}
N 1440 45960 1460 45960 {}
C {lab_pin.sym} 1460 45960 0 0 {name=l36840 lab=VSS}
C {bitcell_6t.sym} 1600 46000 0 0 {name=Xr230c8}
N 1560 46040 1540 46040 {}
C {lab_pin.sym} 1540 46040 0 0 {name=l36841 lab=BL8}
N 1560 46000 1540 46000 {}
C {lab_pin.sym} 1540 46000 0 0 {name=l36842 lab=BLB8}
N 1560 45960 1540 45960 {}
C {lab_pin.sym} 1540 45960 0 0 {name=l36843 lab=WL230}
N 1640 46040 1660 46040 {}
C {lab_pin.sym} 1660 46040 0 0 {name=l36844 lab=VDD}
N 1640 45960 1660 45960 {}
C {lab_pin.sym} 1660 45960 0 0 {name=l36845 lab=VSS}
C {bitcell_6t.sym} 1800 46000 0 0 {name=Xr230c9}
N 1760 46040 1740 46040 {}
C {lab_pin.sym} 1740 46040 0 0 {name=l36846 lab=BL9}
N 1760 46000 1740 46000 {}
C {lab_pin.sym} 1740 46000 0 0 {name=l36847 lab=BLB9}
N 1760 45960 1740 45960 {}
C {lab_pin.sym} 1740 45960 0 0 {name=l36848 lab=WL230}
N 1840 46040 1860 46040 {}
C {lab_pin.sym} 1860 46040 0 0 {name=l36849 lab=VDD}
N 1840 45960 1860 45960 {}
C {lab_pin.sym} 1860 45960 0 0 {name=l36850 lab=VSS}
C {bitcell_6t.sym} 2000 46000 0 0 {name=Xr230c10}
N 1960 46040 1940 46040 {}
C {lab_pin.sym} 1940 46040 0 0 {name=l36851 lab=BL10}
N 1960 46000 1940 46000 {}
C {lab_pin.sym} 1940 46000 0 0 {name=l36852 lab=BLB10}
N 1960 45960 1940 45960 {}
C {lab_pin.sym} 1940 45960 0 0 {name=l36853 lab=WL230}
N 2040 46040 2060 46040 {}
C {lab_pin.sym} 2060 46040 0 0 {name=l36854 lab=VDD}
N 2040 45960 2060 45960 {}
C {lab_pin.sym} 2060 45960 0 0 {name=l36855 lab=VSS}
C {bitcell_6t.sym} 2200 46000 0 0 {name=Xr230c11}
N 2160 46040 2140 46040 {}
C {lab_pin.sym} 2140 46040 0 0 {name=l36856 lab=BL11}
N 2160 46000 2140 46000 {}
C {lab_pin.sym} 2140 46000 0 0 {name=l36857 lab=BLB11}
N 2160 45960 2140 45960 {}
C {lab_pin.sym} 2140 45960 0 0 {name=l36858 lab=WL230}
N 2240 46040 2260 46040 {}
C {lab_pin.sym} 2260 46040 0 0 {name=l36859 lab=VDD}
N 2240 45960 2260 45960 {}
C {lab_pin.sym} 2260 45960 0 0 {name=l36860 lab=VSS}
C {bitcell_6t.sym} 2400 46000 0 0 {name=Xr230c12}
N 2360 46040 2340 46040 {}
C {lab_pin.sym} 2340 46040 0 0 {name=l36861 lab=BL12}
N 2360 46000 2340 46000 {}
C {lab_pin.sym} 2340 46000 0 0 {name=l36862 lab=BLB12}
N 2360 45960 2340 45960 {}
C {lab_pin.sym} 2340 45960 0 0 {name=l36863 lab=WL230}
N 2440 46040 2460 46040 {}
C {lab_pin.sym} 2460 46040 0 0 {name=l36864 lab=VDD}
N 2440 45960 2460 45960 {}
C {lab_pin.sym} 2460 45960 0 0 {name=l36865 lab=VSS}
C {bitcell_6t.sym} 2600 46000 0 0 {name=Xr230c13}
N 2560 46040 2540 46040 {}
C {lab_pin.sym} 2540 46040 0 0 {name=l36866 lab=BL13}
N 2560 46000 2540 46000 {}
C {lab_pin.sym} 2540 46000 0 0 {name=l36867 lab=BLB13}
N 2560 45960 2540 45960 {}
C {lab_pin.sym} 2540 45960 0 0 {name=l36868 lab=WL230}
N 2640 46040 2660 46040 {}
C {lab_pin.sym} 2660 46040 0 0 {name=l36869 lab=VDD}
N 2640 45960 2660 45960 {}
C {lab_pin.sym} 2660 45960 0 0 {name=l36870 lab=VSS}
C {bitcell_6t.sym} 2800 46000 0 0 {name=Xr230c14}
N 2760 46040 2740 46040 {}
C {lab_pin.sym} 2740 46040 0 0 {name=l36871 lab=BL14}
N 2760 46000 2740 46000 {}
C {lab_pin.sym} 2740 46000 0 0 {name=l36872 lab=BLB14}
N 2760 45960 2740 45960 {}
C {lab_pin.sym} 2740 45960 0 0 {name=l36873 lab=WL230}
N 2840 46040 2860 46040 {}
C {lab_pin.sym} 2860 46040 0 0 {name=l36874 lab=VDD}
N 2840 45960 2860 45960 {}
C {lab_pin.sym} 2860 45960 0 0 {name=l36875 lab=VSS}
C {bitcell_6t.sym} 3000 46000 0 0 {name=Xr230c15}
N 2960 46040 2940 46040 {}
C {lab_pin.sym} 2940 46040 0 0 {name=l36876 lab=BL15}
N 2960 46000 2940 46000 {}
C {lab_pin.sym} 2940 46000 0 0 {name=l36877 lab=BLB15}
N 2960 45960 2940 45960 {}
C {lab_pin.sym} 2940 45960 0 0 {name=l36878 lab=WL230}
N 3040 46040 3060 46040 {}
C {lab_pin.sym} 3060 46040 0 0 {name=l36879 lab=VDD}
N 3040 45960 3060 45960 {}
C {lab_pin.sym} 3060 45960 0 0 {name=l36880 lab=VSS}
C {bitcell_6t.sym} 3200 46000 0 0 {name=Xr230c16}
N 3160 46040 3140 46040 {}
C {lab_pin.sym} 3140 46040 0 0 {name=l36881 lab=BL16}
N 3160 46000 3140 46000 {}
C {lab_pin.sym} 3140 46000 0 0 {name=l36882 lab=BLB16}
N 3160 45960 3140 45960 {}
C {lab_pin.sym} 3140 45960 0 0 {name=l36883 lab=WL230}
N 3240 46040 3260 46040 {}
C {lab_pin.sym} 3260 46040 0 0 {name=l36884 lab=VDD}
N 3240 45960 3260 45960 {}
C {lab_pin.sym} 3260 45960 0 0 {name=l36885 lab=VSS}
C {bitcell_6t.sym} 3400 46000 0 0 {name=Xr230c17}
N 3360 46040 3340 46040 {}
C {lab_pin.sym} 3340 46040 0 0 {name=l36886 lab=BL17}
N 3360 46000 3340 46000 {}
C {lab_pin.sym} 3340 46000 0 0 {name=l36887 lab=BLB17}
N 3360 45960 3340 45960 {}
C {lab_pin.sym} 3340 45960 0 0 {name=l36888 lab=WL230}
N 3440 46040 3460 46040 {}
C {lab_pin.sym} 3460 46040 0 0 {name=l36889 lab=VDD}
N 3440 45960 3460 45960 {}
C {lab_pin.sym} 3460 45960 0 0 {name=l36890 lab=VSS}
C {bitcell_6t.sym} 3600 46000 0 0 {name=Xr230c18}
N 3560 46040 3540 46040 {}
C {lab_pin.sym} 3540 46040 0 0 {name=l36891 lab=BL18}
N 3560 46000 3540 46000 {}
C {lab_pin.sym} 3540 46000 0 0 {name=l36892 lab=BLB18}
N 3560 45960 3540 45960 {}
C {lab_pin.sym} 3540 45960 0 0 {name=l36893 lab=WL230}
N 3640 46040 3660 46040 {}
C {lab_pin.sym} 3660 46040 0 0 {name=l36894 lab=VDD}
N 3640 45960 3660 45960 {}
C {lab_pin.sym} 3660 45960 0 0 {name=l36895 lab=VSS}
C {bitcell_6t.sym} 3800 46000 0 0 {name=Xr230c19}
N 3760 46040 3740 46040 {}
C {lab_pin.sym} 3740 46040 0 0 {name=l36896 lab=BL19}
N 3760 46000 3740 46000 {}
C {lab_pin.sym} 3740 46000 0 0 {name=l36897 lab=BLB19}
N 3760 45960 3740 45960 {}
C {lab_pin.sym} 3740 45960 0 0 {name=l36898 lab=WL230}
N 3840 46040 3860 46040 {}
C {lab_pin.sym} 3860 46040 0 0 {name=l36899 lab=VDD}
N 3840 45960 3860 45960 {}
C {lab_pin.sym} 3860 45960 0 0 {name=l36900 lab=VSS}
C {bitcell_6t.sym} 4000 46000 0 0 {name=Xr230c20}
N 3960 46040 3940 46040 {}
C {lab_pin.sym} 3940 46040 0 0 {name=l36901 lab=BL20}
N 3960 46000 3940 46000 {}
C {lab_pin.sym} 3940 46000 0 0 {name=l36902 lab=BLB20}
N 3960 45960 3940 45960 {}
C {lab_pin.sym} 3940 45960 0 0 {name=l36903 lab=WL230}
N 4040 46040 4060 46040 {}
C {lab_pin.sym} 4060 46040 0 0 {name=l36904 lab=VDD}
N 4040 45960 4060 45960 {}
C {lab_pin.sym} 4060 45960 0 0 {name=l36905 lab=VSS}
C {bitcell_6t.sym} 4200 46000 0 0 {name=Xr230c21}
N 4160 46040 4140 46040 {}
C {lab_pin.sym} 4140 46040 0 0 {name=l36906 lab=BL21}
N 4160 46000 4140 46000 {}
C {lab_pin.sym} 4140 46000 0 0 {name=l36907 lab=BLB21}
N 4160 45960 4140 45960 {}
C {lab_pin.sym} 4140 45960 0 0 {name=l36908 lab=WL230}
N 4240 46040 4260 46040 {}
C {lab_pin.sym} 4260 46040 0 0 {name=l36909 lab=VDD}
N 4240 45960 4260 45960 {}
C {lab_pin.sym} 4260 45960 0 0 {name=l36910 lab=VSS}
C {bitcell_6t.sym} 4400 46000 0 0 {name=Xr230c22}
N 4360 46040 4340 46040 {}
C {lab_pin.sym} 4340 46040 0 0 {name=l36911 lab=BL22}
N 4360 46000 4340 46000 {}
C {lab_pin.sym} 4340 46000 0 0 {name=l36912 lab=BLB22}
N 4360 45960 4340 45960 {}
C {lab_pin.sym} 4340 45960 0 0 {name=l36913 lab=WL230}
N 4440 46040 4460 46040 {}
C {lab_pin.sym} 4460 46040 0 0 {name=l36914 lab=VDD}
N 4440 45960 4460 45960 {}
C {lab_pin.sym} 4460 45960 0 0 {name=l36915 lab=VSS}
C {bitcell_6t.sym} 4600 46000 0 0 {name=Xr230c23}
N 4560 46040 4540 46040 {}
C {lab_pin.sym} 4540 46040 0 0 {name=l36916 lab=BL23}
N 4560 46000 4540 46000 {}
C {lab_pin.sym} 4540 46000 0 0 {name=l36917 lab=BLB23}
N 4560 45960 4540 45960 {}
C {lab_pin.sym} 4540 45960 0 0 {name=l36918 lab=WL230}
N 4640 46040 4660 46040 {}
C {lab_pin.sym} 4660 46040 0 0 {name=l36919 lab=VDD}
N 4640 45960 4660 45960 {}
C {lab_pin.sym} 4660 45960 0 0 {name=l36920 lab=VSS}
C {bitcell_6t.sym} 4800 46000 0 0 {name=Xr230c24}
N 4760 46040 4740 46040 {}
C {lab_pin.sym} 4740 46040 0 0 {name=l36921 lab=BL24}
N 4760 46000 4740 46000 {}
C {lab_pin.sym} 4740 46000 0 0 {name=l36922 lab=BLB24}
N 4760 45960 4740 45960 {}
C {lab_pin.sym} 4740 45960 0 0 {name=l36923 lab=WL230}
N 4840 46040 4860 46040 {}
C {lab_pin.sym} 4860 46040 0 0 {name=l36924 lab=VDD}
N 4840 45960 4860 45960 {}
C {lab_pin.sym} 4860 45960 0 0 {name=l36925 lab=VSS}
C {bitcell_6t.sym} 5000 46000 0 0 {name=Xr230c25}
N 4960 46040 4940 46040 {}
C {lab_pin.sym} 4940 46040 0 0 {name=l36926 lab=BL25}
N 4960 46000 4940 46000 {}
C {lab_pin.sym} 4940 46000 0 0 {name=l36927 lab=BLB25}
N 4960 45960 4940 45960 {}
C {lab_pin.sym} 4940 45960 0 0 {name=l36928 lab=WL230}
N 5040 46040 5060 46040 {}
C {lab_pin.sym} 5060 46040 0 0 {name=l36929 lab=VDD}
N 5040 45960 5060 45960 {}
C {lab_pin.sym} 5060 45960 0 0 {name=l36930 lab=VSS}
C {bitcell_6t.sym} 5200 46000 0 0 {name=Xr230c26}
N 5160 46040 5140 46040 {}
C {lab_pin.sym} 5140 46040 0 0 {name=l36931 lab=BL26}
N 5160 46000 5140 46000 {}
C {lab_pin.sym} 5140 46000 0 0 {name=l36932 lab=BLB26}
N 5160 45960 5140 45960 {}
C {lab_pin.sym} 5140 45960 0 0 {name=l36933 lab=WL230}
N 5240 46040 5260 46040 {}
C {lab_pin.sym} 5260 46040 0 0 {name=l36934 lab=VDD}
N 5240 45960 5260 45960 {}
C {lab_pin.sym} 5260 45960 0 0 {name=l36935 lab=VSS}
C {bitcell_6t.sym} 5400 46000 0 0 {name=Xr230c27}
N 5360 46040 5340 46040 {}
C {lab_pin.sym} 5340 46040 0 0 {name=l36936 lab=BL27}
N 5360 46000 5340 46000 {}
C {lab_pin.sym} 5340 46000 0 0 {name=l36937 lab=BLB27}
N 5360 45960 5340 45960 {}
C {lab_pin.sym} 5340 45960 0 0 {name=l36938 lab=WL230}
N 5440 46040 5460 46040 {}
C {lab_pin.sym} 5460 46040 0 0 {name=l36939 lab=VDD}
N 5440 45960 5460 45960 {}
C {lab_pin.sym} 5460 45960 0 0 {name=l36940 lab=VSS}
C {bitcell_6t.sym} 5600 46000 0 0 {name=Xr230c28}
N 5560 46040 5540 46040 {}
C {lab_pin.sym} 5540 46040 0 0 {name=l36941 lab=BL28}
N 5560 46000 5540 46000 {}
C {lab_pin.sym} 5540 46000 0 0 {name=l36942 lab=BLB28}
N 5560 45960 5540 45960 {}
C {lab_pin.sym} 5540 45960 0 0 {name=l36943 lab=WL230}
N 5640 46040 5660 46040 {}
C {lab_pin.sym} 5660 46040 0 0 {name=l36944 lab=VDD}
N 5640 45960 5660 45960 {}
C {lab_pin.sym} 5660 45960 0 0 {name=l36945 lab=VSS}
C {bitcell_6t.sym} 5800 46000 0 0 {name=Xr230c29}
N 5760 46040 5740 46040 {}
C {lab_pin.sym} 5740 46040 0 0 {name=l36946 lab=BL29}
N 5760 46000 5740 46000 {}
C {lab_pin.sym} 5740 46000 0 0 {name=l36947 lab=BLB29}
N 5760 45960 5740 45960 {}
C {lab_pin.sym} 5740 45960 0 0 {name=l36948 lab=WL230}
N 5840 46040 5860 46040 {}
C {lab_pin.sym} 5860 46040 0 0 {name=l36949 lab=VDD}
N 5840 45960 5860 45960 {}
C {lab_pin.sym} 5860 45960 0 0 {name=l36950 lab=VSS}
C {bitcell_6t.sym} 6000 46000 0 0 {name=Xr230c30}
N 5960 46040 5940 46040 {}
C {lab_pin.sym} 5940 46040 0 0 {name=l36951 lab=BL30}
N 5960 46000 5940 46000 {}
C {lab_pin.sym} 5940 46000 0 0 {name=l36952 lab=BLB30}
N 5960 45960 5940 45960 {}
C {lab_pin.sym} 5940 45960 0 0 {name=l36953 lab=WL230}
N 6040 46040 6060 46040 {}
C {lab_pin.sym} 6060 46040 0 0 {name=l36954 lab=VDD}
N 6040 45960 6060 45960 {}
C {lab_pin.sym} 6060 45960 0 0 {name=l36955 lab=VSS}
C {bitcell_6t.sym} 6200 46000 0 0 {name=Xr230c31}
N 6160 46040 6140 46040 {}
C {lab_pin.sym} 6140 46040 0 0 {name=l36956 lab=BL31}
N 6160 46000 6140 46000 {}
C {lab_pin.sym} 6140 46000 0 0 {name=l36957 lab=BLB31}
N 6160 45960 6140 45960 {}
C {lab_pin.sym} 6140 45960 0 0 {name=l36958 lab=WL230}
N 6240 46040 6260 46040 {}
C {lab_pin.sym} 6260 46040 0 0 {name=l36959 lab=VDD}
N 6240 45960 6260 45960 {}
C {lab_pin.sym} 6260 45960 0 0 {name=l36960 lab=VSS}
C {bitcell_6t.sym} 0 46200 0 0 {name=Xr231c0}
N -40 46240 -60 46240 {}
C {lab_pin.sym} -60 46240 0 0 {name=l36961 lab=BL0}
N -40 46200 -60 46200 {}
C {lab_pin.sym} -60 46200 0 0 {name=l36962 lab=BLB0}
N -40 46160 -60 46160 {}
C {lab_pin.sym} -60 46160 0 0 {name=l36963 lab=WL231}
N 40 46240 60 46240 {}
C {lab_pin.sym} 60 46240 0 0 {name=l36964 lab=VDD}
N 40 46160 60 46160 {}
C {lab_pin.sym} 60 46160 0 0 {name=l36965 lab=VSS}
C {bitcell_6t.sym} 200 46200 0 0 {name=Xr231c1}
N 160 46240 140 46240 {}
C {lab_pin.sym} 140 46240 0 0 {name=l36966 lab=BL1}
N 160 46200 140 46200 {}
C {lab_pin.sym} 140 46200 0 0 {name=l36967 lab=BLB1}
N 160 46160 140 46160 {}
C {lab_pin.sym} 140 46160 0 0 {name=l36968 lab=WL231}
N 240 46240 260 46240 {}
C {lab_pin.sym} 260 46240 0 0 {name=l36969 lab=VDD}
N 240 46160 260 46160 {}
C {lab_pin.sym} 260 46160 0 0 {name=l36970 lab=VSS}
C {bitcell_6t.sym} 400 46200 0 0 {name=Xr231c2}
N 360 46240 340 46240 {}
C {lab_pin.sym} 340 46240 0 0 {name=l36971 lab=BL2}
N 360 46200 340 46200 {}
C {lab_pin.sym} 340 46200 0 0 {name=l36972 lab=BLB2}
N 360 46160 340 46160 {}
C {lab_pin.sym} 340 46160 0 0 {name=l36973 lab=WL231}
N 440 46240 460 46240 {}
C {lab_pin.sym} 460 46240 0 0 {name=l36974 lab=VDD}
N 440 46160 460 46160 {}
C {lab_pin.sym} 460 46160 0 0 {name=l36975 lab=VSS}
C {bitcell_6t.sym} 600 46200 0 0 {name=Xr231c3}
N 560 46240 540 46240 {}
C {lab_pin.sym} 540 46240 0 0 {name=l36976 lab=BL3}
N 560 46200 540 46200 {}
C {lab_pin.sym} 540 46200 0 0 {name=l36977 lab=BLB3}
N 560 46160 540 46160 {}
C {lab_pin.sym} 540 46160 0 0 {name=l36978 lab=WL231}
N 640 46240 660 46240 {}
C {lab_pin.sym} 660 46240 0 0 {name=l36979 lab=VDD}
N 640 46160 660 46160 {}
C {lab_pin.sym} 660 46160 0 0 {name=l36980 lab=VSS}
C {bitcell_6t.sym} 800 46200 0 0 {name=Xr231c4}
N 760 46240 740 46240 {}
C {lab_pin.sym} 740 46240 0 0 {name=l36981 lab=BL4}
N 760 46200 740 46200 {}
C {lab_pin.sym} 740 46200 0 0 {name=l36982 lab=BLB4}
N 760 46160 740 46160 {}
C {lab_pin.sym} 740 46160 0 0 {name=l36983 lab=WL231}
N 840 46240 860 46240 {}
C {lab_pin.sym} 860 46240 0 0 {name=l36984 lab=VDD}
N 840 46160 860 46160 {}
C {lab_pin.sym} 860 46160 0 0 {name=l36985 lab=VSS}
C {bitcell_6t.sym} 1000 46200 0 0 {name=Xr231c5}
N 960 46240 940 46240 {}
C {lab_pin.sym} 940 46240 0 0 {name=l36986 lab=BL5}
N 960 46200 940 46200 {}
C {lab_pin.sym} 940 46200 0 0 {name=l36987 lab=BLB5}
N 960 46160 940 46160 {}
C {lab_pin.sym} 940 46160 0 0 {name=l36988 lab=WL231}
N 1040 46240 1060 46240 {}
C {lab_pin.sym} 1060 46240 0 0 {name=l36989 lab=VDD}
N 1040 46160 1060 46160 {}
C {lab_pin.sym} 1060 46160 0 0 {name=l36990 lab=VSS}
C {bitcell_6t.sym} 1200 46200 0 0 {name=Xr231c6}
N 1160 46240 1140 46240 {}
C {lab_pin.sym} 1140 46240 0 0 {name=l36991 lab=BL6}
N 1160 46200 1140 46200 {}
C {lab_pin.sym} 1140 46200 0 0 {name=l36992 lab=BLB6}
N 1160 46160 1140 46160 {}
C {lab_pin.sym} 1140 46160 0 0 {name=l36993 lab=WL231}
N 1240 46240 1260 46240 {}
C {lab_pin.sym} 1260 46240 0 0 {name=l36994 lab=VDD}
N 1240 46160 1260 46160 {}
C {lab_pin.sym} 1260 46160 0 0 {name=l36995 lab=VSS}
C {bitcell_6t.sym} 1400 46200 0 0 {name=Xr231c7}
N 1360 46240 1340 46240 {}
C {lab_pin.sym} 1340 46240 0 0 {name=l36996 lab=BL7}
N 1360 46200 1340 46200 {}
C {lab_pin.sym} 1340 46200 0 0 {name=l36997 lab=BLB7}
N 1360 46160 1340 46160 {}
C {lab_pin.sym} 1340 46160 0 0 {name=l36998 lab=WL231}
N 1440 46240 1460 46240 {}
C {lab_pin.sym} 1460 46240 0 0 {name=l36999 lab=VDD}
N 1440 46160 1460 46160 {}
C {lab_pin.sym} 1460 46160 0 0 {name=l37000 lab=VSS}
C {bitcell_6t.sym} 1600 46200 0 0 {name=Xr231c8}
N 1560 46240 1540 46240 {}
C {lab_pin.sym} 1540 46240 0 0 {name=l37001 lab=BL8}
N 1560 46200 1540 46200 {}
C {lab_pin.sym} 1540 46200 0 0 {name=l37002 lab=BLB8}
N 1560 46160 1540 46160 {}
C {lab_pin.sym} 1540 46160 0 0 {name=l37003 lab=WL231}
N 1640 46240 1660 46240 {}
C {lab_pin.sym} 1660 46240 0 0 {name=l37004 lab=VDD}
N 1640 46160 1660 46160 {}
C {lab_pin.sym} 1660 46160 0 0 {name=l37005 lab=VSS}
C {bitcell_6t.sym} 1800 46200 0 0 {name=Xr231c9}
N 1760 46240 1740 46240 {}
C {lab_pin.sym} 1740 46240 0 0 {name=l37006 lab=BL9}
N 1760 46200 1740 46200 {}
C {lab_pin.sym} 1740 46200 0 0 {name=l37007 lab=BLB9}
N 1760 46160 1740 46160 {}
C {lab_pin.sym} 1740 46160 0 0 {name=l37008 lab=WL231}
N 1840 46240 1860 46240 {}
C {lab_pin.sym} 1860 46240 0 0 {name=l37009 lab=VDD}
N 1840 46160 1860 46160 {}
C {lab_pin.sym} 1860 46160 0 0 {name=l37010 lab=VSS}
C {bitcell_6t.sym} 2000 46200 0 0 {name=Xr231c10}
N 1960 46240 1940 46240 {}
C {lab_pin.sym} 1940 46240 0 0 {name=l37011 lab=BL10}
N 1960 46200 1940 46200 {}
C {lab_pin.sym} 1940 46200 0 0 {name=l37012 lab=BLB10}
N 1960 46160 1940 46160 {}
C {lab_pin.sym} 1940 46160 0 0 {name=l37013 lab=WL231}
N 2040 46240 2060 46240 {}
C {lab_pin.sym} 2060 46240 0 0 {name=l37014 lab=VDD}
N 2040 46160 2060 46160 {}
C {lab_pin.sym} 2060 46160 0 0 {name=l37015 lab=VSS}
C {bitcell_6t.sym} 2200 46200 0 0 {name=Xr231c11}
N 2160 46240 2140 46240 {}
C {lab_pin.sym} 2140 46240 0 0 {name=l37016 lab=BL11}
N 2160 46200 2140 46200 {}
C {lab_pin.sym} 2140 46200 0 0 {name=l37017 lab=BLB11}
N 2160 46160 2140 46160 {}
C {lab_pin.sym} 2140 46160 0 0 {name=l37018 lab=WL231}
N 2240 46240 2260 46240 {}
C {lab_pin.sym} 2260 46240 0 0 {name=l37019 lab=VDD}
N 2240 46160 2260 46160 {}
C {lab_pin.sym} 2260 46160 0 0 {name=l37020 lab=VSS}
C {bitcell_6t.sym} 2400 46200 0 0 {name=Xr231c12}
N 2360 46240 2340 46240 {}
C {lab_pin.sym} 2340 46240 0 0 {name=l37021 lab=BL12}
N 2360 46200 2340 46200 {}
C {lab_pin.sym} 2340 46200 0 0 {name=l37022 lab=BLB12}
N 2360 46160 2340 46160 {}
C {lab_pin.sym} 2340 46160 0 0 {name=l37023 lab=WL231}
N 2440 46240 2460 46240 {}
C {lab_pin.sym} 2460 46240 0 0 {name=l37024 lab=VDD}
N 2440 46160 2460 46160 {}
C {lab_pin.sym} 2460 46160 0 0 {name=l37025 lab=VSS}
C {bitcell_6t.sym} 2600 46200 0 0 {name=Xr231c13}
N 2560 46240 2540 46240 {}
C {lab_pin.sym} 2540 46240 0 0 {name=l37026 lab=BL13}
N 2560 46200 2540 46200 {}
C {lab_pin.sym} 2540 46200 0 0 {name=l37027 lab=BLB13}
N 2560 46160 2540 46160 {}
C {lab_pin.sym} 2540 46160 0 0 {name=l37028 lab=WL231}
N 2640 46240 2660 46240 {}
C {lab_pin.sym} 2660 46240 0 0 {name=l37029 lab=VDD}
N 2640 46160 2660 46160 {}
C {lab_pin.sym} 2660 46160 0 0 {name=l37030 lab=VSS}
C {bitcell_6t.sym} 2800 46200 0 0 {name=Xr231c14}
N 2760 46240 2740 46240 {}
C {lab_pin.sym} 2740 46240 0 0 {name=l37031 lab=BL14}
N 2760 46200 2740 46200 {}
C {lab_pin.sym} 2740 46200 0 0 {name=l37032 lab=BLB14}
N 2760 46160 2740 46160 {}
C {lab_pin.sym} 2740 46160 0 0 {name=l37033 lab=WL231}
N 2840 46240 2860 46240 {}
C {lab_pin.sym} 2860 46240 0 0 {name=l37034 lab=VDD}
N 2840 46160 2860 46160 {}
C {lab_pin.sym} 2860 46160 0 0 {name=l37035 lab=VSS}
C {bitcell_6t.sym} 3000 46200 0 0 {name=Xr231c15}
N 2960 46240 2940 46240 {}
C {lab_pin.sym} 2940 46240 0 0 {name=l37036 lab=BL15}
N 2960 46200 2940 46200 {}
C {lab_pin.sym} 2940 46200 0 0 {name=l37037 lab=BLB15}
N 2960 46160 2940 46160 {}
C {lab_pin.sym} 2940 46160 0 0 {name=l37038 lab=WL231}
N 3040 46240 3060 46240 {}
C {lab_pin.sym} 3060 46240 0 0 {name=l37039 lab=VDD}
N 3040 46160 3060 46160 {}
C {lab_pin.sym} 3060 46160 0 0 {name=l37040 lab=VSS}
C {bitcell_6t.sym} 3200 46200 0 0 {name=Xr231c16}
N 3160 46240 3140 46240 {}
C {lab_pin.sym} 3140 46240 0 0 {name=l37041 lab=BL16}
N 3160 46200 3140 46200 {}
C {lab_pin.sym} 3140 46200 0 0 {name=l37042 lab=BLB16}
N 3160 46160 3140 46160 {}
C {lab_pin.sym} 3140 46160 0 0 {name=l37043 lab=WL231}
N 3240 46240 3260 46240 {}
C {lab_pin.sym} 3260 46240 0 0 {name=l37044 lab=VDD}
N 3240 46160 3260 46160 {}
C {lab_pin.sym} 3260 46160 0 0 {name=l37045 lab=VSS}
C {bitcell_6t.sym} 3400 46200 0 0 {name=Xr231c17}
N 3360 46240 3340 46240 {}
C {lab_pin.sym} 3340 46240 0 0 {name=l37046 lab=BL17}
N 3360 46200 3340 46200 {}
C {lab_pin.sym} 3340 46200 0 0 {name=l37047 lab=BLB17}
N 3360 46160 3340 46160 {}
C {lab_pin.sym} 3340 46160 0 0 {name=l37048 lab=WL231}
N 3440 46240 3460 46240 {}
C {lab_pin.sym} 3460 46240 0 0 {name=l37049 lab=VDD}
N 3440 46160 3460 46160 {}
C {lab_pin.sym} 3460 46160 0 0 {name=l37050 lab=VSS}
C {bitcell_6t.sym} 3600 46200 0 0 {name=Xr231c18}
N 3560 46240 3540 46240 {}
C {lab_pin.sym} 3540 46240 0 0 {name=l37051 lab=BL18}
N 3560 46200 3540 46200 {}
C {lab_pin.sym} 3540 46200 0 0 {name=l37052 lab=BLB18}
N 3560 46160 3540 46160 {}
C {lab_pin.sym} 3540 46160 0 0 {name=l37053 lab=WL231}
N 3640 46240 3660 46240 {}
C {lab_pin.sym} 3660 46240 0 0 {name=l37054 lab=VDD}
N 3640 46160 3660 46160 {}
C {lab_pin.sym} 3660 46160 0 0 {name=l37055 lab=VSS}
C {bitcell_6t.sym} 3800 46200 0 0 {name=Xr231c19}
N 3760 46240 3740 46240 {}
C {lab_pin.sym} 3740 46240 0 0 {name=l37056 lab=BL19}
N 3760 46200 3740 46200 {}
C {lab_pin.sym} 3740 46200 0 0 {name=l37057 lab=BLB19}
N 3760 46160 3740 46160 {}
C {lab_pin.sym} 3740 46160 0 0 {name=l37058 lab=WL231}
N 3840 46240 3860 46240 {}
C {lab_pin.sym} 3860 46240 0 0 {name=l37059 lab=VDD}
N 3840 46160 3860 46160 {}
C {lab_pin.sym} 3860 46160 0 0 {name=l37060 lab=VSS}
C {bitcell_6t.sym} 4000 46200 0 0 {name=Xr231c20}
N 3960 46240 3940 46240 {}
C {lab_pin.sym} 3940 46240 0 0 {name=l37061 lab=BL20}
N 3960 46200 3940 46200 {}
C {lab_pin.sym} 3940 46200 0 0 {name=l37062 lab=BLB20}
N 3960 46160 3940 46160 {}
C {lab_pin.sym} 3940 46160 0 0 {name=l37063 lab=WL231}
N 4040 46240 4060 46240 {}
C {lab_pin.sym} 4060 46240 0 0 {name=l37064 lab=VDD}
N 4040 46160 4060 46160 {}
C {lab_pin.sym} 4060 46160 0 0 {name=l37065 lab=VSS}
C {bitcell_6t.sym} 4200 46200 0 0 {name=Xr231c21}
N 4160 46240 4140 46240 {}
C {lab_pin.sym} 4140 46240 0 0 {name=l37066 lab=BL21}
N 4160 46200 4140 46200 {}
C {lab_pin.sym} 4140 46200 0 0 {name=l37067 lab=BLB21}
N 4160 46160 4140 46160 {}
C {lab_pin.sym} 4140 46160 0 0 {name=l37068 lab=WL231}
N 4240 46240 4260 46240 {}
C {lab_pin.sym} 4260 46240 0 0 {name=l37069 lab=VDD}
N 4240 46160 4260 46160 {}
C {lab_pin.sym} 4260 46160 0 0 {name=l37070 lab=VSS}
C {bitcell_6t.sym} 4400 46200 0 0 {name=Xr231c22}
N 4360 46240 4340 46240 {}
C {lab_pin.sym} 4340 46240 0 0 {name=l37071 lab=BL22}
N 4360 46200 4340 46200 {}
C {lab_pin.sym} 4340 46200 0 0 {name=l37072 lab=BLB22}
N 4360 46160 4340 46160 {}
C {lab_pin.sym} 4340 46160 0 0 {name=l37073 lab=WL231}
N 4440 46240 4460 46240 {}
C {lab_pin.sym} 4460 46240 0 0 {name=l37074 lab=VDD}
N 4440 46160 4460 46160 {}
C {lab_pin.sym} 4460 46160 0 0 {name=l37075 lab=VSS}
C {bitcell_6t.sym} 4600 46200 0 0 {name=Xr231c23}
N 4560 46240 4540 46240 {}
C {lab_pin.sym} 4540 46240 0 0 {name=l37076 lab=BL23}
N 4560 46200 4540 46200 {}
C {lab_pin.sym} 4540 46200 0 0 {name=l37077 lab=BLB23}
N 4560 46160 4540 46160 {}
C {lab_pin.sym} 4540 46160 0 0 {name=l37078 lab=WL231}
N 4640 46240 4660 46240 {}
C {lab_pin.sym} 4660 46240 0 0 {name=l37079 lab=VDD}
N 4640 46160 4660 46160 {}
C {lab_pin.sym} 4660 46160 0 0 {name=l37080 lab=VSS}
C {bitcell_6t.sym} 4800 46200 0 0 {name=Xr231c24}
N 4760 46240 4740 46240 {}
C {lab_pin.sym} 4740 46240 0 0 {name=l37081 lab=BL24}
N 4760 46200 4740 46200 {}
C {lab_pin.sym} 4740 46200 0 0 {name=l37082 lab=BLB24}
N 4760 46160 4740 46160 {}
C {lab_pin.sym} 4740 46160 0 0 {name=l37083 lab=WL231}
N 4840 46240 4860 46240 {}
C {lab_pin.sym} 4860 46240 0 0 {name=l37084 lab=VDD}
N 4840 46160 4860 46160 {}
C {lab_pin.sym} 4860 46160 0 0 {name=l37085 lab=VSS}
C {bitcell_6t.sym} 5000 46200 0 0 {name=Xr231c25}
N 4960 46240 4940 46240 {}
C {lab_pin.sym} 4940 46240 0 0 {name=l37086 lab=BL25}
N 4960 46200 4940 46200 {}
C {lab_pin.sym} 4940 46200 0 0 {name=l37087 lab=BLB25}
N 4960 46160 4940 46160 {}
C {lab_pin.sym} 4940 46160 0 0 {name=l37088 lab=WL231}
N 5040 46240 5060 46240 {}
C {lab_pin.sym} 5060 46240 0 0 {name=l37089 lab=VDD}
N 5040 46160 5060 46160 {}
C {lab_pin.sym} 5060 46160 0 0 {name=l37090 lab=VSS}
C {bitcell_6t.sym} 5200 46200 0 0 {name=Xr231c26}
N 5160 46240 5140 46240 {}
C {lab_pin.sym} 5140 46240 0 0 {name=l37091 lab=BL26}
N 5160 46200 5140 46200 {}
C {lab_pin.sym} 5140 46200 0 0 {name=l37092 lab=BLB26}
N 5160 46160 5140 46160 {}
C {lab_pin.sym} 5140 46160 0 0 {name=l37093 lab=WL231}
N 5240 46240 5260 46240 {}
C {lab_pin.sym} 5260 46240 0 0 {name=l37094 lab=VDD}
N 5240 46160 5260 46160 {}
C {lab_pin.sym} 5260 46160 0 0 {name=l37095 lab=VSS}
C {bitcell_6t.sym} 5400 46200 0 0 {name=Xr231c27}
N 5360 46240 5340 46240 {}
C {lab_pin.sym} 5340 46240 0 0 {name=l37096 lab=BL27}
N 5360 46200 5340 46200 {}
C {lab_pin.sym} 5340 46200 0 0 {name=l37097 lab=BLB27}
N 5360 46160 5340 46160 {}
C {lab_pin.sym} 5340 46160 0 0 {name=l37098 lab=WL231}
N 5440 46240 5460 46240 {}
C {lab_pin.sym} 5460 46240 0 0 {name=l37099 lab=VDD}
N 5440 46160 5460 46160 {}
C {lab_pin.sym} 5460 46160 0 0 {name=l37100 lab=VSS}
C {bitcell_6t.sym} 5600 46200 0 0 {name=Xr231c28}
N 5560 46240 5540 46240 {}
C {lab_pin.sym} 5540 46240 0 0 {name=l37101 lab=BL28}
N 5560 46200 5540 46200 {}
C {lab_pin.sym} 5540 46200 0 0 {name=l37102 lab=BLB28}
N 5560 46160 5540 46160 {}
C {lab_pin.sym} 5540 46160 0 0 {name=l37103 lab=WL231}
N 5640 46240 5660 46240 {}
C {lab_pin.sym} 5660 46240 0 0 {name=l37104 lab=VDD}
N 5640 46160 5660 46160 {}
C {lab_pin.sym} 5660 46160 0 0 {name=l37105 lab=VSS}
C {bitcell_6t.sym} 5800 46200 0 0 {name=Xr231c29}
N 5760 46240 5740 46240 {}
C {lab_pin.sym} 5740 46240 0 0 {name=l37106 lab=BL29}
N 5760 46200 5740 46200 {}
C {lab_pin.sym} 5740 46200 0 0 {name=l37107 lab=BLB29}
N 5760 46160 5740 46160 {}
C {lab_pin.sym} 5740 46160 0 0 {name=l37108 lab=WL231}
N 5840 46240 5860 46240 {}
C {lab_pin.sym} 5860 46240 0 0 {name=l37109 lab=VDD}
N 5840 46160 5860 46160 {}
C {lab_pin.sym} 5860 46160 0 0 {name=l37110 lab=VSS}
C {bitcell_6t.sym} 6000 46200 0 0 {name=Xr231c30}
N 5960 46240 5940 46240 {}
C {lab_pin.sym} 5940 46240 0 0 {name=l37111 lab=BL30}
N 5960 46200 5940 46200 {}
C {lab_pin.sym} 5940 46200 0 0 {name=l37112 lab=BLB30}
N 5960 46160 5940 46160 {}
C {lab_pin.sym} 5940 46160 0 0 {name=l37113 lab=WL231}
N 6040 46240 6060 46240 {}
C {lab_pin.sym} 6060 46240 0 0 {name=l37114 lab=VDD}
N 6040 46160 6060 46160 {}
C {lab_pin.sym} 6060 46160 0 0 {name=l37115 lab=VSS}
C {bitcell_6t.sym} 6200 46200 0 0 {name=Xr231c31}
N 6160 46240 6140 46240 {}
C {lab_pin.sym} 6140 46240 0 0 {name=l37116 lab=BL31}
N 6160 46200 6140 46200 {}
C {lab_pin.sym} 6140 46200 0 0 {name=l37117 lab=BLB31}
N 6160 46160 6140 46160 {}
C {lab_pin.sym} 6140 46160 0 0 {name=l37118 lab=WL231}
N 6240 46240 6260 46240 {}
C {lab_pin.sym} 6260 46240 0 0 {name=l37119 lab=VDD}
N 6240 46160 6260 46160 {}
C {lab_pin.sym} 6260 46160 0 0 {name=l37120 lab=VSS}
C {bitcell_6t.sym} 0 46400 0 0 {name=Xr232c0}
N -40 46440 -60 46440 {}
C {lab_pin.sym} -60 46440 0 0 {name=l37121 lab=BL0}
N -40 46400 -60 46400 {}
C {lab_pin.sym} -60 46400 0 0 {name=l37122 lab=BLB0}
N -40 46360 -60 46360 {}
C {lab_pin.sym} -60 46360 0 0 {name=l37123 lab=WL232}
N 40 46440 60 46440 {}
C {lab_pin.sym} 60 46440 0 0 {name=l37124 lab=VDD}
N 40 46360 60 46360 {}
C {lab_pin.sym} 60 46360 0 0 {name=l37125 lab=VSS}
C {bitcell_6t.sym} 200 46400 0 0 {name=Xr232c1}
N 160 46440 140 46440 {}
C {lab_pin.sym} 140 46440 0 0 {name=l37126 lab=BL1}
N 160 46400 140 46400 {}
C {lab_pin.sym} 140 46400 0 0 {name=l37127 lab=BLB1}
N 160 46360 140 46360 {}
C {lab_pin.sym} 140 46360 0 0 {name=l37128 lab=WL232}
N 240 46440 260 46440 {}
C {lab_pin.sym} 260 46440 0 0 {name=l37129 lab=VDD}
N 240 46360 260 46360 {}
C {lab_pin.sym} 260 46360 0 0 {name=l37130 lab=VSS}
C {bitcell_6t.sym} 400 46400 0 0 {name=Xr232c2}
N 360 46440 340 46440 {}
C {lab_pin.sym} 340 46440 0 0 {name=l37131 lab=BL2}
N 360 46400 340 46400 {}
C {lab_pin.sym} 340 46400 0 0 {name=l37132 lab=BLB2}
N 360 46360 340 46360 {}
C {lab_pin.sym} 340 46360 0 0 {name=l37133 lab=WL232}
N 440 46440 460 46440 {}
C {lab_pin.sym} 460 46440 0 0 {name=l37134 lab=VDD}
N 440 46360 460 46360 {}
C {lab_pin.sym} 460 46360 0 0 {name=l37135 lab=VSS}
C {bitcell_6t.sym} 600 46400 0 0 {name=Xr232c3}
N 560 46440 540 46440 {}
C {lab_pin.sym} 540 46440 0 0 {name=l37136 lab=BL3}
N 560 46400 540 46400 {}
C {lab_pin.sym} 540 46400 0 0 {name=l37137 lab=BLB3}
N 560 46360 540 46360 {}
C {lab_pin.sym} 540 46360 0 0 {name=l37138 lab=WL232}
N 640 46440 660 46440 {}
C {lab_pin.sym} 660 46440 0 0 {name=l37139 lab=VDD}
N 640 46360 660 46360 {}
C {lab_pin.sym} 660 46360 0 0 {name=l37140 lab=VSS}
C {bitcell_6t.sym} 800 46400 0 0 {name=Xr232c4}
N 760 46440 740 46440 {}
C {lab_pin.sym} 740 46440 0 0 {name=l37141 lab=BL4}
N 760 46400 740 46400 {}
C {lab_pin.sym} 740 46400 0 0 {name=l37142 lab=BLB4}
N 760 46360 740 46360 {}
C {lab_pin.sym} 740 46360 0 0 {name=l37143 lab=WL232}
N 840 46440 860 46440 {}
C {lab_pin.sym} 860 46440 0 0 {name=l37144 lab=VDD}
N 840 46360 860 46360 {}
C {lab_pin.sym} 860 46360 0 0 {name=l37145 lab=VSS}
C {bitcell_6t.sym} 1000 46400 0 0 {name=Xr232c5}
N 960 46440 940 46440 {}
C {lab_pin.sym} 940 46440 0 0 {name=l37146 lab=BL5}
N 960 46400 940 46400 {}
C {lab_pin.sym} 940 46400 0 0 {name=l37147 lab=BLB5}
N 960 46360 940 46360 {}
C {lab_pin.sym} 940 46360 0 0 {name=l37148 lab=WL232}
N 1040 46440 1060 46440 {}
C {lab_pin.sym} 1060 46440 0 0 {name=l37149 lab=VDD}
N 1040 46360 1060 46360 {}
C {lab_pin.sym} 1060 46360 0 0 {name=l37150 lab=VSS}
C {bitcell_6t.sym} 1200 46400 0 0 {name=Xr232c6}
N 1160 46440 1140 46440 {}
C {lab_pin.sym} 1140 46440 0 0 {name=l37151 lab=BL6}
N 1160 46400 1140 46400 {}
C {lab_pin.sym} 1140 46400 0 0 {name=l37152 lab=BLB6}
N 1160 46360 1140 46360 {}
C {lab_pin.sym} 1140 46360 0 0 {name=l37153 lab=WL232}
N 1240 46440 1260 46440 {}
C {lab_pin.sym} 1260 46440 0 0 {name=l37154 lab=VDD}
N 1240 46360 1260 46360 {}
C {lab_pin.sym} 1260 46360 0 0 {name=l37155 lab=VSS}
C {bitcell_6t.sym} 1400 46400 0 0 {name=Xr232c7}
N 1360 46440 1340 46440 {}
C {lab_pin.sym} 1340 46440 0 0 {name=l37156 lab=BL7}
N 1360 46400 1340 46400 {}
C {lab_pin.sym} 1340 46400 0 0 {name=l37157 lab=BLB7}
N 1360 46360 1340 46360 {}
C {lab_pin.sym} 1340 46360 0 0 {name=l37158 lab=WL232}
N 1440 46440 1460 46440 {}
C {lab_pin.sym} 1460 46440 0 0 {name=l37159 lab=VDD}
N 1440 46360 1460 46360 {}
C {lab_pin.sym} 1460 46360 0 0 {name=l37160 lab=VSS}
C {bitcell_6t.sym} 1600 46400 0 0 {name=Xr232c8}
N 1560 46440 1540 46440 {}
C {lab_pin.sym} 1540 46440 0 0 {name=l37161 lab=BL8}
N 1560 46400 1540 46400 {}
C {lab_pin.sym} 1540 46400 0 0 {name=l37162 lab=BLB8}
N 1560 46360 1540 46360 {}
C {lab_pin.sym} 1540 46360 0 0 {name=l37163 lab=WL232}
N 1640 46440 1660 46440 {}
C {lab_pin.sym} 1660 46440 0 0 {name=l37164 lab=VDD}
N 1640 46360 1660 46360 {}
C {lab_pin.sym} 1660 46360 0 0 {name=l37165 lab=VSS}
C {bitcell_6t.sym} 1800 46400 0 0 {name=Xr232c9}
N 1760 46440 1740 46440 {}
C {lab_pin.sym} 1740 46440 0 0 {name=l37166 lab=BL9}
N 1760 46400 1740 46400 {}
C {lab_pin.sym} 1740 46400 0 0 {name=l37167 lab=BLB9}
N 1760 46360 1740 46360 {}
C {lab_pin.sym} 1740 46360 0 0 {name=l37168 lab=WL232}
N 1840 46440 1860 46440 {}
C {lab_pin.sym} 1860 46440 0 0 {name=l37169 lab=VDD}
N 1840 46360 1860 46360 {}
C {lab_pin.sym} 1860 46360 0 0 {name=l37170 lab=VSS}
C {bitcell_6t.sym} 2000 46400 0 0 {name=Xr232c10}
N 1960 46440 1940 46440 {}
C {lab_pin.sym} 1940 46440 0 0 {name=l37171 lab=BL10}
N 1960 46400 1940 46400 {}
C {lab_pin.sym} 1940 46400 0 0 {name=l37172 lab=BLB10}
N 1960 46360 1940 46360 {}
C {lab_pin.sym} 1940 46360 0 0 {name=l37173 lab=WL232}
N 2040 46440 2060 46440 {}
C {lab_pin.sym} 2060 46440 0 0 {name=l37174 lab=VDD}
N 2040 46360 2060 46360 {}
C {lab_pin.sym} 2060 46360 0 0 {name=l37175 lab=VSS}
C {bitcell_6t.sym} 2200 46400 0 0 {name=Xr232c11}
N 2160 46440 2140 46440 {}
C {lab_pin.sym} 2140 46440 0 0 {name=l37176 lab=BL11}
N 2160 46400 2140 46400 {}
C {lab_pin.sym} 2140 46400 0 0 {name=l37177 lab=BLB11}
N 2160 46360 2140 46360 {}
C {lab_pin.sym} 2140 46360 0 0 {name=l37178 lab=WL232}
N 2240 46440 2260 46440 {}
C {lab_pin.sym} 2260 46440 0 0 {name=l37179 lab=VDD}
N 2240 46360 2260 46360 {}
C {lab_pin.sym} 2260 46360 0 0 {name=l37180 lab=VSS}
C {bitcell_6t.sym} 2400 46400 0 0 {name=Xr232c12}
N 2360 46440 2340 46440 {}
C {lab_pin.sym} 2340 46440 0 0 {name=l37181 lab=BL12}
N 2360 46400 2340 46400 {}
C {lab_pin.sym} 2340 46400 0 0 {name=l37182 lab=BLB12}
N 2360 46360 2340 46360 {}
C {lab_pin.sym} 2340 46360 0 0 {name=l37183 lab=WL232}
N 2440 46440 2460 46440 {}
C {lab_pin.sym} 2460 46440 0 0 {name=l37184 lab=VDD}
N 2440 46360 2460 46360 {}
C {lab_pin.sym} 2460 46360 0 0 {name=l37185 lab=VSS}
C {bitcell_6t.sym} 2600 46400 0 0 {name=Xr232c13}
N 2560 46440 2540 46440 {}
C {lab_pin.sym} 2540 46440 0 0 {name=l37186 lab=BL13}
N 2560 46400 2540 46400 {}
C {lab_pin.sym} 2540 46400 0 0 {name=l37187 lab=BLB13}
N 2560 46360 2540 46360 {}
C {lab_pin.sym} 2540 46360 0 0 {name=l37188 lab=WL232}
N 2640 46440 2660 46440 {}
C {lab_pin.sym} 2660 46440 0 0 {name=l37189 lab=VDD}
N 2640 46360 2660 46360 {}
C {lab_pin.sym} 2660 46360 0 0 {name=l37190 lab=VSS}
C {bitcell_6t.sym} 2800 46400 0 0 {name=Xr232c14}
N 2760 46440 2740 46440 {}
C {lab_pin.sym} 2740 46440 0 0 {name=l37191 lab=BL14}
N 2760 46400 2740 46400 {}
C {lab_pin.sym} 2740 46400 0 0 {name=l37192 lab=BLB14}
N 2760 46360 2740 46360 {}
C {lab_pin.sym} 2740 46360 0 0 {name=l37193 lab=WL232}
N 2840 46440 2860 46440 {}
C {lab_pin.sym} 2860 46440 0 0 {name=l37194 lab=VDD}
N 2840 46360 2860 46360 {}
C {lab_pin.sym} 2860 46360 0 0 {name=l37195 lab=VSS}
C {bitcell_6t.sym} 3000 46400 0 0 {name=Xr232c15}
N 2960 46440 2940 46440 {}
C {lab_pin.sym} 2940 46440 0 0 {name=l37196 lab=BL15}
N 2960 46400 2940 46400 {}
C {lab_pin.sym} 2940 46400 0 0 {name=l37197 lab=BLB15}
N 2960 46360 2940 46360 {}
C {lab_pin.sym} 2940 46360 0 0 {name=l37198 lab=WL232}
N 3040 46440 3060 46440 {}
C {lab_pin.sym} 3060 46440 0 0 {name=l37199 lab=VDD}
N 3040 46360 3060 46360 {}
C {lab_pin.sym} 3060 46360 0 0 {name=l37200 lab=VSS}
C {bitcell_6t.sym} 3200 46400 0 0 {name=Xr232c16}
N 3160 46440 3140 46440 {}
C {lab_pin.sym} 3140 46440 0 0 {name=l37201 lab=BL16}
N 3160 46400 3140 46400 {}
C {lab_pin.sym} 3140 46400 0 0 {name=l37202 lab=BLB16}
N 3160 46360 3140 46360 {}
C {lab_pin.sym} 3140 46360 0 0 {name=l37203 lab=WL232}
N 3240 46440 3260 46440 {}
C {lab_pin.sym} 3260 46440 0 0 {name=l37204 lab=VDD}
N 3240 46360 3260 46360 {}
C {lab_pin.sym} 3260 46360 0 0 {name=l37205 lab=VSS}
C {bitcell_6t.sym} 3400 46400 0 0 {name=Xr232c17}
N 3360 46440 3340 46440 {}
C {lab_pin.sym} 3340 46440 0 0 {name=l37206 lab=BL17}
N 3360 46400 3340 46400 {}
C {lab_pin.sym} 3340 46400 0 0 {name=l37207 lab=BLB17}
N 3360 46360 3340 46360 {}
C {lab_pin.sym} 3340 46360 0 0 {name=l37208 lab=WL232}
N 3440 46440 3460 46440 {}
C {lab_pin.sym} 3460 46440 0 0 {name=l37209 lab=VDD}
N 3440 46360 3460 46360 {}
C {lab_pin.sym} 3460 46360 0 0 {name=l37210 lab=VSS}
C {bitcell_6t.sym} 3600 46400 0 0 {name=Xr232c18}
N 3560 46440 3540 46440 {}
C {lab_pin.sym} 3540 46440 0 0 {name=l37211 lab=BL18}
N 3560 46400 3540 46400 {}
C {lab_pin.sym} 3540 46400 0 0 {name=l37212 lab=BLB18}
N 3560 46360 3540 46360 {}
C {lab_pin.sym} 3540 46360 0 0 {name=l37213 lab=WL232}
N 3640 46440 3660 46440 {}
C {lab_pin.sym} 3660 46440 0 0 {name=l37214 lab=VDD}
N 3640 46360 3660 46360 {}
C {lab_pin.sym} 3660 46360 0 0 {name=l37215 lab=VSS}
C {bitcell_6t.sym} 3800 46400 0 0 {name=Xr232c19}
N 3760 46440 3740 46440 {}
C {lab_pin.sym} 3740 46440 0 0 {name=l37216 lab=BL19}
N 3760 46400 3740 46400 {}
C {lab_pin.sym} 3740 46400 0 0 {name=l37217 lab=BLB19}
N 3760 46360 3740 46360 {}
C {lab_pin.sym} 3740 46360 0 0 {name=l37218 lab=WL232}
N 3840 46440 3860 46440 {}
C {lab_pin.sym} 3860 46440 0 0 {name=l37219 lab=VDD}
N 3840 46360 3860 46360 {}
C {lab_pin.sym} 3860 46360 0 0 {name=l37220 lab=VSS}
C {bitcell_6t.sym} 4000 46400 0 0 {name=Xr232c20}
N 3960 46440 3940 46440 {}
C {lab_pin.sym} 3940 46440 0 0 {name=l37221 lab=BL20}
N 3960 46400 3940 46400 {}
C {lab_pin.sym} 3940 46400 0 0 {name=l37222 lab=BLB20}
N 3960 46360 3940 46360 {}
C {lab_pin.sym} 3940 46360 0 0 {name=l37223 lab=WL232}
N 4040 46440 4060 46440 {}
C {lab_pin.sym} 4060 46440 0 0 {name=l37224 lab=VDD}
N 4040 46360 4060 46360 {}
C {lab_pin.sym} 4060 46360 0 0 {name=l37225 lab=VSS}
C {bitcell_6t.sym} 4200 46400 0 0 {name=Xr232c21}
N 4160 46440 4140 46440 {}
C {lab_pin.sym} 4140 46440 0 0 {name=l37226 lab=BL21}
N 4160 46400 4140 46400 {}
C {lab_pin.sym} 4140 46400 0 0 {name=l37227 lab=BLB21}
N 4160 46360 4140 46360 {}
C {lab_pin.sym} 4140 46360 0 0 {name=l37228 lab=WL232}
N 4240 46440 4260 46440 {}
C {lab_pin.sym} 4260 46440 0 0 {name=l37229 lab=VDD}
N 4240 46360 4260 46360 {}
C {lab_pin.sym} 4260 46360 0 0 {name=l37230 lab=VSS}
C {bitcell_6t.sym} 4400 46400 0 0 {name=Xr232c22}
N 4360 46440 4340 46440 {}
C {lab_pin.sym} 4340 46440 0 0 {name=l37231 lab=BL22}
N 4360 46400 4340 46400 {}
C {lab_pin.sym} 4340 46400 0 0 {name=l37232 lab=BLB22}
N 4360 46360 4340 46360 {}
C {lab_pin.sym} 4340 46360 0 0 {name=l37233 lab=WL232}
N 4440 46440 4460 46440 {}
C {lab_pin.sym} 4460 46440 0 0 {name=l37234 lab=VDD}
N 4440 46360 4460 46360 {}
C {lab_pin.sym} 4460 46360 0 0 {name=l37235 lab=VSS}
C {bitcell_6t.sym} 4600 46400 0 0 {name=Xr232c23}
N 4560 46440 4540 46440 {}
C {lab_pin.sym} 4540 46440 0 0 {name=l37236 lab=BL23}
N 4560 46400 4540 46400 {}
C {lab_pin.sym} 4540 46400 0 0 {name=l37237 lab=BLB23}
N 4560 46360 4540 46360 {}
C {lab_pin.sym} 4540 46360 0 0 {name=l37238 lab=WL232}
N 4640 46440 4660 46440 {}
C {lab_pin.sym} 4660 46440 0 0 {name=l37239 lab=VDD}
N 4640 46360 4660 46360 {}
C {lab_pin.sym} 4660 46360 0 0 {name=l37240 lab=VSS}
C {bitcell_6t.sym} 4800 46400 0 0 {name=Xr232c24}
N 4760 46440 4740 46440 {}
C {lab_pin.sym} 4740 46440 0 0 {name=l37241 lab=BL24}
N 4760 46400 4740 46400 {}
C {lab_pin.sym} 4740 46400 0 0 {name=l37242 lab=BLB24}
N 4760 46360 4740 46360 {}
C {lab_pin.sym} 4740 46360 0 0 {name=l37243 lab=WL232}
N 4840 46440 4860 46440 {}
C {lab_pin.sym} 4860 46440 0 0 {name=l37244 lab=VDD}
N 4840 46360 4860 46360 {}
C {lab_pin.sym} 4860 46360 0 0 {name=l37245 lab=VSS}
C {bitcell_6t.sym} 5000 46400 0 0 {name=Xr232c25}
N 4960 46440 4940 46440 {}
C {lab_pin.sym} 4940 46440 0 0 {name=l37246 lab=BL25}
N 4960 46400 4940 46400 {}
C {lab_pin.sym} 4940 46400 0 0 {name=l37247 lab=BLB25}
N 4960 46360 4940 46360 {}
C {lab_pin.sym} 4940 46360 0 0 {name=l37248 lab=WL232}
N 5040 46440 5060 46440 {}
C {lab_pin.sym} 5060 46440 0 0 {name=l37249 lab=VDD}
N 5040 46360 5060 46360 {}
C {lab_pin.sym} 5060 46360 0 0 {name=l37250 lab=VSS}
C {bitcell_6t.sym} 5200 46400 0 0 {name=Xr232c26}
N 5160 46440 5140 46440 {}
C {lab_pin.sym} 5140 46440 0 0 {name=l37251 lab=BL26}
N 5160 46400 5140 46400 {}
C {lab_pin.sym} 5140 46400 0 0 {name=l37252 lab=BLB26}
N 5160 46360 5140 46360 {}
C {lab_pin.sym} 5140 46360 0 0 {name=l37253 lab=WL232}
N 5240 46440 5260 46440 {}
C {lab_pin.sym} 5260 46440 0 0 {name=l37254 lab=VDD}
N 5240 46360 5260 46360 {}
C {lab_pin.sym} 5260 46360 0 0 {name=l37255 lab=VSS}
C {bitcell_6t.sym} 5400 46400 0 0 {name=Xr232c27}
N 5360 46440 5340 46440 {}
C {lab_pin.sym} 5340 46440 0 0 {name=l37256 lab=BL27}
N 5360 46400 5340 46400 {}
C {lab_pin.sym} 5340 46400 0 0 {name=l37257 lab=BLB27}
N 5360 46360 5340 46360 {}
C {lab_pin.sym} 5340 46360 0 0 {name=l37258 lab=WL232}
N 5440 46440 5460 46440 {}
C {lab_pin.sym} 5460 46440 0 0 {name=l37259 lab=VDD}
N 5440 46360 5460 46360 {}
C {lab_pin.sym} 5460 46360 0 0 {name=l37260 lab=VSS}
C {bitcell_6t.sym} 5600 46400 0 0 {name=Xr232c28}
N 5560 46440 5540 46440 {}
C {lab_pin.sym} 5540 46440 0 0 {name=l37261 lab=BL28}
N 5560 46400 5540 46400 {}
C {lab_pin.sym} 5540 46400 0 0 {name=l37262 lab=BLB28}
N 5560 46360 5540 46360 {}
C {lab_pin.sym} 5540 46360 0 0 {name=l37263 lab=WL232}
N 5640 46440 5660 46440 {}
C {lab_pin.sym} 5660 46440 0 0 {name=l37264 lab=VDD}
N 5640 46360 5660 46360 {}
C {lab_pin.sym} 5660 46360 0 0 {name=l37265 lab=VSS}
C {bitcell_6t.sym} 5800 46400 0 0 {name=Xr232c29}
N 5760 46440 5740 46440 {}
C {lab_pin.sym} 5740 46440 0 0 {name=l37266 lab=BL29}
N 5760 46400 5740 46400 {}
C {lab_pin.sym} 5740 46400 0 0 {name=l37267 lab=BLB29}
N 5760 46360 5740 46360 {}
C {lab_pin.sym} 5740 46360 0 0 {name=l37268 lab=WL232}
N 5840 46440 5860 46440 {}
C {lab_pin.sym} 5860 46440 0 0 {name=l37269 lab=VDD}
N 5840 46360 5860 46360 {}
C {lab_pin.sym} 5860 46360 0 0 {name=l37270 lab=VSS}
C {bitcell_6t.sym} 6000 46400 0 0 {name=Xr232c30}
N 5960 46440 5940 46440 {}
C {lab_pin.sym} 5940 46440 0 0 {name=l37271 lab=BL30}
N 5960 46400 5940 46400 {}
C {lab_pin.sym} 5940 46400 0 0 {name=l37272 lab=BLB30}
N 5960 46360 5940 46360 {}
C {lab_pin.sym} 5940 46360 0 0 {name=l37273 lab=WL232}
N 6040 46440 6060 46440 {}
C {lab_pin.sym} 6060 46440 0 0 {name=l37274 lab=VDD}
N 6040 46360 6060 46360 {}
C {lab_pin.sym} 6060 46360 0 0 {name=l37275 lab=VSS}
C {bitcell_6t.sym} 6200 46400 0 0 {name=Xr232c31}
N 6160 46440 6140 46440 {}
C {lab_pin.sym} 6140 46440 0 0 {name=l37276 lab=BL31}
N 6160 46400 6140 46400 {}
C {lab_pin.sym} 6140 46400 0 0 {name=l37277 lab=BLB31}
N 6160 46360 6140 46360 {}
C {lab_pin.sym} 6140 46360 0 0 {name=l37278 lab=WL232}
N 6240 46440 6260 46440 {}
C {lab_pin.sym} 6260 46440 0 0 {name=l37279 lab=VDD}
N 6240 46360 6260 46360 {}
C {lab_pin.sym} 6260 46360 0 0 {name=l37280 lab=VSS}
C {bitcell_6t.sym} 0 46600 0 0 {name=Xr233c0}
N -40 46640 -60 46640 {}
C {lab_pin.sym} -60 46640 0 0 {name=l37281 lab=BL0}
N -40 46600 -60 46600 {}
C {lab_pin.sym} -60 46600 0 0 {name=l37282 lab=BLB0}
N -40 46560 -60 46560 {}
C {lab_pin.sym} -60 46560 0 0 {name=l37283 lab=WL233}
N 40 46640 60 46640 {}
C {lab_pin.sym} 60 46640 0 0 {name=l37284 lab=VDD}
N 40 46560 60 46560 {}
C {lab_pin.sym} 60 46560 0 0 {name=l37285 lab=VSS}
C {bitcell_6t.sym} 200 46600 0 0 {name=Xr233c1}
N 160 46640 140 46640 {}
C {lab_pin.sym} 140 46640 0 0 {name=l37286 lab=BL1}
N 160 46600 140 46600 {}
C {lab_pin.sym} 140 46600 0 0 {name=l37287 lab=BLB1}
N 160 46560 140 46560 {}
C {lab_pin.sym} 140 46560 0 0 {name=l37288 lab=WL233}
N 240 46640 260 46640 {}
C {lab_pin.sym} 260 46640 0 0 {name=l37289 lab=VDD}
N 240 46560 260 46560 {}
C {lab_pin.sym} 260 46560 0 0 {name=l37290 lab=VSS}
C {bitcell_6t.sym} 400 46600 0 0 {name=Xr233c2}
N 360 46640 340 46640 {}
C {lab_pin.sym} 340 46640 0 0 {name=l37291 lab=BL2}
N 360 46600 340 46600 {}
C {lab_pin.sym} 340 46600 0 0 {name=l37292 lab=BLB2}
N 360 46560 340 46560 {}
C {lab_pin.sym} 340 46560 0 0 {name=l37293 lab=WL233}
N 440 46640 460 46640 {}
C {lab_pin.sym} 460 46640 0 0 {name=l37294 lab=VDD}
N 440 46560 460 46560 {}
C {lab_pin.sym} 460 46560 0 0 {name=l37295 lab=VSS}
C {bitcell_6t.sym} 600 46600 0 0 {name=Xr233c3}
N 560 46640 540 46640 {}
C {lab_pin.sym} 540 46640 0 0 {name=l37296 lab=BL3}
N 560 46600 540 46600 {}
C {lab_pin.sym} 540 46600 0 0 {name=l37297 lab=BLB3}
N 560 46560 540 46560 {}
C {lab_pin.sym} 540 46560 0 0 {name=l37298 lab=WL233}
N 640 46640 660 46640 {}
C {lab_pin.sym} 660 46640 0 0 {name=l37299 lab=VDD}
N 640 46560 660 46560 {}
C {lab_pin.sym} 660 46560 0 0 {name=l37300 lab=VSS}
C {bitcell_6t.sym} 800 46600 0 0 {name=Xr233c4}
N 760 46640 740 46640 {}
C {lab_pin.sym} 740 46640 0 0 {name=l37301 lab=BL4}
N 760 46600 740 46600 {}
C {lab_pin.sym} 740 46600 0 0 {name=l37302 lab=BLB4}
N 760 46560 740 46560 {}
C {lab_pin.sym} 740 46560 0 0 {name=l37303 lab=WL233}
N 840 46640 860 46640 {}
C {lab_pin.sym} 860 46640 0 0 {name=l37304 lab=VDD}
N 840 46560 860 46560 {}
C {lab_pin.sym} 860 46560 0 0 {name=l37305 lab=VSS}
C {bitcell_6t.sym} 1000 46600 0 0 {name=Xr233c5}
N 960 46640 940 46640 {}
C {lab_pin.sym} 940 46640 0 0 {name=l37306 lab=BL5}
N 960 46600 940 46600 {}
C {lab_pin.sym} 940 46600 0 0 {name=l37307 lab=BLB5}
N 960 46560 940 46560 {}
C {lab_pin.sym} 940 46560 0 0 {name=l37308 lab=WL233}
N 1040 46640 1060 46640 {}
C {lab_pin.sym} 1060 46640 0 0 {name=l37309 lab=VDD}
N 1040 46560 1060 46560 {}
C {lab_pin.sym} 1060 46560 0 0 {name=l37310 lab=VSS}
C {bitcell_6t.sym} 1200 46600 0 0 {name=Xr233c6}
N 1160 46640 1140 46640 {}
C {lab_pin.sym} 1140 46640 0 0 {name=l37311 lab=BL6}
N 1160 46600 1140 46600 {}
C {lab_pin.sym} 1140 46600 0 0 {name=l37312 lab=BLB6}
N 1160 46560 1140 46560 {}
C {lab_pin.sym} 1140 46560 0 0 {name=l37313 lab=WL233}
N 1240 46640 1260 46640 {}
C {lab_pin.sym} 1260 46640 0 0 {name=l37314 lab=VDD}
N 1240 46560 1260 46560 {}
C {lab_pin.sym} 1260 46560 0 0 {name=l37315 lab=VSS}
C {bitcell_6t.sym} 1400 46600 0 0 {name=Xr233c7}
N 1360 46640 1340 46640 {}
C {lab_pin.sym} 1340 46640 0 0 {name=l37316 lab=BL7}
N 1360 46600 1340 46600 {}
C {lab_pin.sym} 1340 46600 0 0 {name=l37317 lab=BLB7}
N 1360 46560 1340 46560 {}
C {lab_pin.sym} 1340 46560 0 0 {name=l37318 lab=WL233}
N 1440 46640 1460 46640 {}
C {lab_pin.sym} 1460 46640 0 0 {name=l37319 lab=VDD}
N 1440 46560 1460 46560 {}
C {lab_pin.sym} 1460 46560 0 0 {name=l37320 lab=VSS}
C {bitcell_6t.sym} 1600 46600 0 0 {name=Xr233c8}
N 1560 46640 1540 46640 {}
C {lab_pin.sym} 1540 46640 0 0 {name=l37321 lab=BL8}
N 1560 46600 1540 46600 {}
C {lab_pin.sym} 1540 46600 0 0 {name=l37322 lab=BLB8}
N 1560 46560 1540 46560 {}
C {lab_pin.sym} 1540 46560 0 0 {name=l37323 lab=WL233}
N 1640 46640 1660 46640 {}
C {lab_pin.sym} 1660 46640 0 0 {name=l37324 lab=VDD}
N 1640 46560 1660 46560 {}
C {lab_pin.sym} 1660 46560 0 0 {name=l37325 lab=VSS}
C {bitcell_6t.sym} 1800 46600 0 0 {name=Xr233c9}
N 1760 46640 1740 46640 {}
C {lab_pin.sym} 1740 46640 0 0 {name=l37326 lab=BL9}
N 1760 46600 1740 46600 {}
C {lab_pin.sym} 1740 46600 0 0 {name=l37327 lab=BLB9}
N 1760 46560 1740 46560 {}
C {lab_pin.sym} 1740 46560 0 0 {name=l37328 lab=WL233}
N 1840 46640 1860 46640 {}
C {lab_pin.sym} 1860 46640 0 0 {name=l37329 lab=VDD}
N 1840 46560 1860 46560 {}
C {lab_pin.sym} 1860 46560 0 0 {name=l37330 lab=VSS}
C {bitcell_6t.sym} 2000 46600 0 0 {name=Xr233c10}
N 1960 46640 1940 46640 {}
C {lab_pin.sym} 1940 46640 0 0 {name=l37331 lab=BL10}
N 1960 46600 1940 46600 {}
C {lab_pin.sym} 1940 46600 0 0 {name=l37332 lab=BLB10}
N 1960 46560 1940 46560 {}
C {lab_pin.sym} 1940 46560 0 0 {name=l37333 lab=WL233}
N 2040 46640 2060 46640 {}
C {lab_pin.sym} 2060 46640 0 0 {name=l37334 lab=VDD}
N 2040 46560 2060 46560 {}
C {lab_pin.sym} 2060 46560 0 0 {name=l37335 lab=VSS}
C {bitcell_6t.sym} 2200 46600 0 0 {name=Xr233c11}
N 2160 46640 2140 46640 {}
C {lab_pin.sym} 2140 46640 0 0 {name=l37336 lab=BL11}
N 2160 46600 2140 46600 {}
C {lab_pin.sym} 2140 46600 0 0 {name=l37337 lab=BLB11}
N 2160 46560 2140 46560 {}
C {lab_pin.sym} 2140 46560 0 0 {name=l37338 lab=WL233}
N 2240 46640 2260 46640 {}
C {lab_pin.sym} 2260 46640 0 0 {name=l37339 lab=VDD}
N 2240 46560 2260 46560 {}
C {lab_pin.sym} 2260 46560 0 0 {name=l37340 lab=VSS}
C {bitcell_6t.sym} 2400 46600 0 0 {name=Xr233c12}
N 2360 46640 2340 46640 {}
C {lab_pin.sym} 2340 46640 0 0 {name=l37341 lab=BL12}
N 2360 46600 2340 46600 {}
C {lab_pin.sym} 2340 46600 0 0 {name=l37342 lab=BLB12}
N 2360 46560 2340 46560 {}
C {lab_pin.sym} 2340 46560 0 0 {name=l37343 lab=WL233}
N 2440 46640 2460 46640 {}
C {lab_pin.sym} 2460 46640 0 0 {name=l37344 lab=VDD}
N 2440 46560 2460 46560 {}
C {lab_pin.sym} 2460 46560 0 0 {name=l37345 lab=VSS}
C {bitcell_6t.sym} 2600 46600 0 0 {name=Xr233c13}
N 2560 46640 2540 46640 {}
C {lab_pin.sym} 2540 46640 0 0 {name=l37346 lab=BL13}
N 2560 46600 2540 46600 {}
C {lab_pin.sym} 2540 46600 0 0 {name=l37347 lab=BLB13}
N 2560 46560 2540 46560 {}
C {lab_pin.sym} 2540 46560 0 0 {name=l37348 lab=WL233}
N 2640 46640 2660 46640 {}
C {lab_pin.sym} 2660 46640 0 0 {name=l37349 lab=VDD}
N 2640 46560 2660 46560 {}
C {lab_pin.sym} 2660 46560 0 0 {name=l37350 lab=VSS}
C {bitcell_6t.sym} 2800 46600 0 0 {name=Xr233c14}
N 2760 46640 2740 46640 {}
C {lab_pin.sym} 2740 46640 0 0 {name=l37351 lab=BL14}
N 2760 46600 2740 46600 {}
C {lab_pin.sym} 2740 46600 0 0 {name=l37352 lab=BLB14}
N 2760 46560 2740 46560 {}
C {lab_pin.sym} 2740 46560 0 0 {name=l37353 lab=WL233}
N 2840 46640 2860 46640 {}
C {lab_pin.sym} 2860 46640 0 0 {name=l37354 lab=VDD}
N 2840 46560 2860 46560 {}
C {lab_pin.sym} 2860 46560 0 0 {name=l37355 lab=VSS}
C {bitcell_6t.sym} 3000 46600 0 0 {name=Xr233c15}
N 2960 46640 2940 46640 {}
C {lab_pin.sym} 2940 46640 0 0 {name=l37356 lab=BL15}
N 2960 46600 2940 46600 {}
C {lab_pin.sym} 2940 46600 0 0 {name=l37357 lab=BLB15}
N 2960 46560 2940 46560 {}
C {lab_pin.sym} 2940 46560 0 0 {name=l37358 lab=WL233}
N 3040 46640 3060 46640 {}
C {lab_pin.sym} 3060 46640 0 0 {name=l37359 lab=VDD}
N 3040 46560 3060 46560 {}
C {lab_pin.sym} 3060 46560 0 0 {name=l37360 lab=VSS}
C {bitcell_6t.sym} 3200 46600 0 0 {name=Xr233c16}
N 3160 46640 3140 46640 {}
C {lab_pin.sym} 3140 46640 0 0 {name=l37361 lab=BL16}
N 3160 46600 3140 46600 {}
C {lab_pin.sym} 3140 46600 0 0 {name=l37362 lab=BLB16}
N 3160 46560 3140 46560 {}
C {lab_pin.sym} 3140 46560 0 0 {name=l37363 lab=WL233}
N 3240 46640 3260 46640 {}
C {lab_pin.sym} 3260 46640 0 0 {name=l37364 lab=VDD}
N 3240 46560 3260 46560 {}
C {lab_pin.sym} 3260 46560 0 0 {name=l37365 lab=VSS}
C {bitcell_6t.sym} 3400 46600 0 0 {name=Xr233c17}
N 3360 46640 3340 46640 {}
C {lab_pin.sym} 3340 46640 0 0 {name=l37366 lab=BL17}
N 3360 46600 3340 46600 {}
C {lab_pin.sym} 3340 46600 0 0 {name=l37367 lab=BLB17}
N 3360 46560 3340 46560 {}
C {lab_pin.sym} 3340 46560 0 0 {name=l37368 lab=WL233}
N 3440 46640 3460 46640 {}
C {lab_pin.sym} 3460 46640 0 0 {name=l37369 lab=VDD}
N 3440 46560 3460 46560 {}
C {lab_pin.sym} 3460 46560 0 0 {name=l37370 lab=VSS}
C {bitcell_6t.sym} 3600 46600 0 0 {name=Xr233c18}
N 3560 46640 3540 46640 {}
C {lab_pin.sym} 3540 46640 0 0 {name=l37371 lab=BL18}
N 3560 46600 3540 46600 {}
C {lab_pin.sym} 3540 46600 0 0 {name=l37372 lab=BLB18}
N 3560 46560 3540 46560 {}
C {lab_pin.sym} 3540 46560 0 0 {name=l37373 lab=WL233}
N 3640 46640 3660 46640 {}
C {lab_pin.sym} 3660 46640 0 0 {name=l37374 lab=VDD}
N 3640 46560 3660 46560 {}
C {lab_pin.sym} 3660 46560 0 0 {name=l37375 lab=VSS}
C {bitcell_6t.sym} 3800 46600 0 0 {name=Xr233c19}
N 3760 46640 3740 46640 {}
C {lab_pin.sym} 3740 46640 0 0 {name=l37376 lab=BL19}
N 3760 46600 3740 46600 {}
C {lab_pin.sym} 3740 46600 0 0 {name=l37377 lab=BLB19}
N 3760 46560 3740 46560 {}
C {lab_pin.sym} 3740 46560 0 0 {name=l37378 lab=WL233}
N 3840 46640 3860 46640 {}
C {lab_pin.sym} 3860 46640 0 0 {name=l37379 lab=VDD}
N 3840 46560 3860 46560 {}
C {lab_pin.sym} 3860 46560 0 0 {name=l37380 lab=VSS}
C {bitcell_6t.sym} 4000 46600 0 0 {name=Xr233c20}
N 3960 46640 3940 46640 {}
C {lab_pin.sym} 3940 46640 0 0 {name=l37381 lab=BL20}
N 3960 46600 3940 46600 {}
C {lab_pin.sym} 3940 46600 0 0 {name=l37382 lab=BLB20}
N 3960 46560 3940 46560 {}
C {lab_pin.sym} 3940 46560 0 0 {name=l37383 lab=WL233}
N 4040 46640 4060 46640 {}
C {lab_pin.sym} 4060 46640 0 0 {name=l37384 lab=VDD}
N 4040 46560 4060 46560 {}
C {lab_pin.sym} 4060 46560 0 0 {name=l37385 lab=VSS}
C {bitcell_6t.sym} 4200 46600 0 0 {name=Xr233c21}
N 4160 46640 4140 46640 {}
C {lab_pin.sym} 4140 46640 0 0 {name=l37386 lab=BL21}
N 4160 46600 4140 46600 {}
C {lab_pin.sym} 4140 46600 0 0 {name=l37387 lab=BLB21}
N 4160 46560 4140 46560 {}
C {lab_pin.sym} 4140 46560 0 0 {name=l37388 lab=WL233}
N 4240 46640 4260 46640 {}
C {lab_pin.sym} 4260 46640 0 0 {name=l37389 lab=VDD}
N 4240 46560 4260 46560 {}
C {lab_pin.sym} 4260 46560 0 0 {name=l37390 lab=VSS}
C {bitcell_6t.sym} 4400 46600 0 0 {name=Xr233c22}
N 4360 46640 4340 46640 {}
C {lab_pin.sym} 4340 46640 0 0 {name=l37391 lab=BL22}
N 4360 46600 4340 46600 {}
C {lab_pin.sym} 4340 46600 0 0 {name=l37392 lab=BLB22}
N 4360 46560 4340 46560 {}
C {lab_pin.sym} 4340 46560 0 0 {name=l37393 lab=WL233}
N 4440 46640 4460 46640 {}
C {lab_pin.sym} 4460 46640 0 0 {name=l37394 lab=VDD}
N 4440 46560 4460 46560 {}
C {lab_pin.sym} 4460 46560 0 0 {name=l37395 lab=VSS}
C {bitcell_6t.sym} 4600 46600 0 0 {name=Xr233c23}
N 4560 46640 4540 46640 {}
C {lab_pin.sym} 4540 46640 0 0 {name=l37396 lab=BL23}
N 4560 46600 4540 46600 {}
C {lab_pin.sym} 4540 46600 0 0 {name=l37397 lab=BLB23}
N 4560 46560 4540 46560 {}
C {lab_pin.sym} 4540 46560 0 0 {name=l37398 lab=WL233}
N 4640 46640 4660 46640 {}
C {lab_pin.sym} 4660 46640 0 0 {name=l37399 lab=VDD}
N 4640 46560 4660 46560 {}
C {lab_pin.sym} 4660 46560 0 0 {name=l37400 lab=VSS}
C {bitcell_6t.sym} 4800 46600 0 0 {name=Xr233c24}
N 4760 46640 4740 46640 {}
C {lab_pin.sym} 4740 46640 0 0 {name=l37401 lab=BL24}
N 4760 46600 4740 46600 {}
C {lab_pin.sym} 4740 46600 0 0 {name=l37402 lab=BLB24}
N 4760 46560 4740 46560 {}
C {lab_pin.sym} 4740 46560 0 0 {name=l37403 lab=WL233}
N 4840 46640 4860 46640 {}
C {lab_pin.sym} 4860 46640 0 0 {name=l37404 lab=VDD}
N 4840 46560 4860 46560 {}
C {lab_pin.sym} 4860 46560 0 0 {name=l37405 lab=VSS}
C {bitcell_6t.sym} 5000 46600 0 0 {name=Xr233c25}
N 4960 46640 4940 46640 {}
C {lab_pin.sym} 4940 46640 0 0 {name=l37406 lab=BL25}
N 4960 46600 4940 46600 {}
C {lab_pin.sym} 4940 46600 0 0 {name=l37407 lab=BLB25}
N 4960 46560 4940 46560 {}
C {lab_pin.sym} 4940 46560 0 0 {name=l37408 lab=WL233}
N 5040 46640 5060 46640 {}
C {lab_pin.sym} 5060 46640 0 0 {name=l37409 lab=VDD}
N 5040 46560 5060 46560 {}
C {lab_pin.sym} 5060 46560 0 0 {name=l37410 lab=VSS}
C {bitcell_6t.sym} 5200 46600 0 0 {name=Xr233c26}
N 5160 46640 5140 46640 {}
C {lab_pin.sym} 5140 46640 0 0 {name=l37411 lab=BL26}
N 5160 46600 5140 46600 {}
C {lab_pin.sym} 5140 46600 0 0 {name=l37412 lab=BLB26}
N 5160 46560 5140 46560 {}
C {lab_pin.sym} 5140 46560 0 0 {name=l37413 lab=WL233}
N 5240 46640 5260 46640 {}
C {lab_pin.sym} 5260 46640 0 0 {name=l37414 lab=VDD}
N 5240 46560 5260 46560 {}
C {lab_pin.sym} 5260 46560 0 0 {name=l37415 lab=VSS}
C {bitcell_6t.sym} 5400 46600 0 0 {name=Xr233c27}
N 5360 46640 5340 46640 {}
C {lab_pin.sym} 5340 46640 0 0 {name=l37416 lab=BL27}
N 5360 46600 5340 46600 {}
C {lab_pin.sym} 5340 46600 0 0 {name=l37417 lab=BLB27}
N 5360 46560 5340 46560 {}
C {lab_pin.sym} 5340 46560 0 0 {name=l37418 lab=WL233}
N 5440 46640 5460 46640 {}
C {lab_pin.sym} 5460 46640 0 0 {name=l37419 lab=VDD}
N 5440 46560 5460 46560 {}
C {lab_pin.sym} 5460 46560 0 0 {name=l37420 lab=VSS}
C {bitcell_6t.sym} 5600 46600 0 0 {name=Xr233c28}
N 5560 46640 5540 46640 {}
C {lab_pin.sym} 5540 46640 0 0 {name=l37421 lab=BL28}
N 5560 46600 5540 46600 {}
C {lab_pin.sym} 5540 46600 0 0 {name=l37422 lab=BLB28}
N 5560 46560 5540 46560 {}
C {lab_pin.sym} 5540 46560 0 0 {name=l37423 lab=WL233}
N 5640 46640 5660 46640 {}
C {lab_pin.sym} 5660 46640 0 0 {name=l37424 lab=VDD}
N 5640 46560 5660 46560 {}
C {lab_pin.sym} 5660 46560 0 0 {name=l37425 lab=VSS}
C {bitcell_6t.sym} 5800 46600 0 0 {name=Xr233c29}
N 5760 46640 5740 46640 {}
C {lab_pin.sym} 5740 46640 0 0 {name=l37426 lab=BL29}
N 5760 46600 5740 46600 {}
C {lab_pin.sym} 5740 46600 0 0 {name=l37427 lab=BLB29}
N 5760 46560 5740 46560 {}
C {lab_pin.sym} 5740 46560 0 0 {name=l37428 lab=WL233}
N 5840 46640 5860 46640 {}
C {lab_pin.sym} 5860 46640 0 0 {name=l37429 lab=VDD}
N 5840 46560 5860 46560 {}
C {lab_pin.sym} 5860 46560 0 0 {name=l37430 lab=VSS}
C {bitcell_6t.sym} 6000 46600 0 0 {name=Xr233c30}
N 5960 46640 5940 46640 {}
C {lab_pin.sym} 5940 46640 0 0 {name=l37431 lab=BL30}
N 5960 46600 5940 46600 {}
C {lab_pin.sym} 5940 46600 0 0 {name=l37432 lab=BLB30}
N 5960 46560 5940 46560 {}
C {lab_pin.sym} 5940 46560 0 0 {name=l37433 lab=WL233}
N 6040 46640 6060 46640 {}
C {lab_pin.sym} 6060 46640 0 0 {name=l37434 lab=VDD}
N 6040 46560 6060 46560 {}
C {lab_pin.sym} 6060 46560 0 0 {name=l37435 lab=VSS}
C {bitcell_6t.sym} 6200 46600 0 0 {name=Xr233c31}
N 6160 46640 6140 46640 {}
C {lab_pin.sym} 6140 46640 0 0 {name=l37436 lab=BL31}
N 6160 46600 6140 46600 {}
C {lab_pin.sym} 6140 46600 0 0 {name=l37437 lab=BLB31}
N 6160 46560 6140 46560 {}
C {lab_pin.sym} 6140 46560 0 0 {name=l37438 lab=WL233}
N 6240 46640 6260 46640 {}
C {lab_pin.sym} 6260 46640 0 0 {name=l37439 lab=VDD}
N 6240 46560 6260 46560 {}
C {lab_pin.sym} 6260 46560 0 0 {name=l37440 lab=VSS}
C {bitcell_6t.sym} 0 46800 0 0 {name=Xr234c0}
N -40 46840 -60 46840 {}
C {lab_pin.sym} -60 46840 0 0 {name=l37441 lab=BL0}
N -40 46800 -60 46800 {}
C {lab_pin.sym} -60 46800 0 0 {name=l37442 lab=BLB0}
N -40 46760 -60 46760 {}
C {lab_pin.sym} -60 46760 0 0 {name=l37443 lab=WL234}
N 40 46840 60 46840 {}
C {lab_pin.sym} 60 46840 0 0 {name=l37444 lab=VDD}
N 40 46760 60 46760 {}
C {lab_pin.sym} 60 46760 0 0 {name=l37445 lab=VSS}
C {bitcell_6t.sym} 200 46800 0 0 {name=Xr234c1}
N 160 46840 140 46840 {}
C {lab_pin.sym} 140 46840 0 0 {name=l37446 lab=BL1}
N 160 46800 140 46800 {}
C {lab_pin.sym} 140 46800 0 0 {name=l37447 lab=BLB1}
N 160 46760 140 46760 {}
C {lab_pin.sym} 140 46760 0 0 {name=l37448 lab=WL234}
N 240 46840 260 46840 {}
C {lab_pin.sym} 260 46840 0 0 {name=l37449 lab=VDD}
N 240 46760 260 46760 {}
C {lab_pin.sym} 260 46760 0 0 {name=l37450 lab=VSS}
C {bitcell_6t.sym} 400 46800 0 0 {name=Xr234c2}
N 360 46840 340 46840 {}
C {lab_pin.sym} 340 46840 0 0 {name=l37451 lab=BL2}
N 360 46800 340 46800 {}
C {lab_pin.sym} 340 46800 0 0 {name=l37452 lab=BLB2}
N 360 46760 340 46760 {}
C {lab_pin.sym} 340 46760 0 0 {name=l37453 lab=WL234}
N 440 46840 460 46840 {}
C {lab_pin.sym} 460 46840 0 0 {name=l37454 lab=VDD}
N 440 46760 460 46760 {}
C {lab_pin.sym} 460 46760 0 0 {name=l37455 lab=VSS}
C {bitcell_6t.sym} 600 46800 0 0 {name=Xr234c3}
N 560 46840 540 46840 {}
C {lab_pin.sym} 540 46840 0 0 {name=l37456 lab=BL3}
N 560 46800 540 46800 {}
C {lab_pin.sym} 540 46800 0 0 {name=l37457 lab=BLB3}
N 560 46760 540 46760 {}
C {lab_pin.sym} 540 46760 0 0 {name=l37458 lab=WL234}
N 640 46840 660 46840 {}
C {lab_pin.sym} 660 46840 0 0 {name=l37459 lab=VDD}
N 640 46760 660 46760 {}
C {lab_pin.sym} 660 46760 0 0 {name=l37460 lab=VSS}
C {bitcell_6t.sym} 800 46800 0 0 {name=Xr234c4}
N 760 46840 740 46840 {}
C {lab_pin.sym} 740 46840 0 0 {name=l37461 lab=BL4}
N 760 46800 740 46800 {}
C {lab_pin.sym} 740 46800 0 0 {name=l37462 lab=BLB4}
N 760 46760 740 46760 {}
C {lab_pin.sym} 740 46760 0 0 {name=l37463 lab=WL234}
N 840 46840 860 46840 {}
C {lab_pin.sym} 860 46840 0 0 {name=l37464 lab=VDD}
N 840 46760 860 46760 {}
C {lab_pin.sym} 860 46760 0 0 {name=l37465 lab=VSS}
C {bitcell_6t.sym} 1000 46800 0 0 {name=Xr234c5}
N 960 46840 940 46840 {}
C {lab_pin.sym} 940 46840 0 0 {name=l37466 lab=BL5}
N 960 46800 940 46800 {}
C {lab_pin.sym} 940 46800 0 0 {name=l37467 lab=BLB5}
N 960 46760 940 46760 {}
C {lab_pin.sym} 940 46760 0 0 {name=l37468 lab=WL234}
N 1040 46840 1060 46840 {}
C {lab_pin.sym} 1060 46840 0 0 {name=l37469 lab=VDD}
N 1040 46760 1060 46760 {}
C {lab_pin.sym} 1060 46760 0 0 {name=l37470 lab=VSS}
C {bitcell_6t.sym} 1200 46800 0 0 {name=Xr234c6}
N 1160 46840 1140 46840 {}
C {lab_pin.sym} 1140 46840 0 0 {name=l37471 lab=BL6}
N 1160 46800 1140 46800 {}
C {lab_pin.sym} 1140 46800 0 0 {name=l37472 lab=BLB6}
N 1160 46760 1140 46760 {}
C {lab_pin.sym} 1140 46760 0 0 {name=l37473 lab=WL234}
N 1240 46840 1260 46840 {}
C {lab_pin.sym} 1260 46840 0 0 {name=l37474 lab=VDD}
N 1240 46760 1260 46760 {}
C {lab_pin.sym} 1260 46760 0 0 {name=l37475 lab=VSS}
C {bitcell_6t.sym} 1400 46800 0 0 {name=Xr234c7}
N 1360 46840 1340 46840 {}
C {lab_pin.sym} 1340 46840 0 0 {name=l37476 lab=BL7}
N 1360 46800 1340 46800 {}
C {lab_pin.sym} 1340 46800 0 0 {name=l37477 lab=BLB7}
N 1360 46760 1340 46760 {}
C {lab_pin.sym} 1340 46760 0 0 {name=l37478 lab=WL234}
N 1440 46840 1460 46840 {}
C {lab_pin.sym} 1460 46840 0 0 {name=l37479 lab=VDD}
N 1440 46760 1460 46760 {}
C {lab_pin.sym} 1460 46760 0 0 {name=l37480 lab=VSS}
C {bitcell_6t.sym} 1600 46800 0 0 {name=Xr234c8}
N 1560 46840 1540 46840 {}
C {lab_pin.sym} 1540 46840 0 0 {name=l37481 lab=BL8}
N 1560 46800 1540 46800 {}
C {lab_pin.sym} 1540 46800 0 0 {name=l37482 lab=BLB8}
N 1560 46760 1540 46760 {}
C {lab_pin.sym} 1540 46760 0 0 {name=l37483 lab=WL234}
N 1640 46840 1660 46840 {}
C {lab_pin.sym} 1660 46840 0 0 {name=l37484 lab=VDD}
N 1640 46760 1660 46760 {}
C {lab_pin.sym} 1660 46760 0 0 {name=l37485 lab=VSS}
C {bitcell_6t.sym} 1800 46800 0 0 {name=Xr234c9}
N 1760 46840 1740 46840 {}
C {lab_pin.sym} 1740 46840 0 0 {name=l37486 lab=BL9}
N 1760 46800 1740 46800 {}
C {lab_pin.sym} 1740 46800 0 0 {name=l37487 lab=BLB9}
N 1760 46760 1740 46760 {}
C {lab_pin.sym} 1740 46760 0 0 {name=l37488 lab=WL234}
N 1840 46840 1860 46840 {}
C {lab_pin.sym} 1860 46840 0 0 {name=l37489 lab=VDD}
N 1840 46760 1860 46760 {}
C {lab_pin.sym} 1860 46760 0 0 {name=l37490 lab=VSS}
C {bitcell_6t.sym} 2000 46800 0 0 {name=Xr234c10}
N 1960 46840 1940 46840 {}
C {lab_pin.sym} 1940 46840 0 0 {name=l37491 lab=BL10}
N 1960 46800 1940 46800 {}
C {lab_pin.sym} 1940 46800 0 0 {name=l37492 lab=BLB10}
N 1960 46760 1940 46760 {}
C {lab_pin.sym} 1940 46760 0 0 {name=l37493 lab=WL234}
N 2040 46840 2060 46840 {}
C {lab_pin.sym} 2060 46840 0 0 {name=l37494 lab=VDD}
N 2040 46760 2060 46760 {}
C {lab_pin.sym} 2060 46760 0 0 {name=l37495 lab=VSS}
C {bitcell_6t.sym} 2200 46800 0 0 {name=Xr234c11}
N 2160 46840 2140 46840 {}
C {lab_pin.sym} 2140 46840 0 0 {name=l37496 lab=BL11}
N 2160 46800 2140 46800 {}
C {lab_pin.sym} 2140 46800 0 0 {name=l37497 lab=BLB11}
N 2160 46760 2140 46760 {}
C {lab_pin.sym} 2140 46760 0 0 {name=l37498 lab=WL234}
N 2240 46840 2260 46840 {}
C {lab_pin.sym} 2260 46840 0 0 {name=l37499 lab=VDD}
N 2240 46760 2260 46760 {}
C {lab_pin.sym} 2260 46760 0 0 {name=l37500 lab=VSS}
C {bitcell_6t.sym} 2400 46800 0 0 {name=Xr234c12}
N 2360 46840 2340 46840 {}
C {lab_pin.sym} 2340 46840 0 0 {name=l37501 lab=BL12}
N 2360 46800 2340 46800 {}
C {lab_pin.sym} 2340 46800 0 0 {name=l37502 lab=BLB12}
N 2360 46760 2340 46760 {}
C {lab_pin.sym} 2340 46760 0 0 {name=l37503 lab=WL234}
N 2440 46840 2460 46840 {}
C {lab_pin.sym} 2460 46840 0 0 {name=l37504 lab=VDD}
N 2440 46760 2460 46760 {}
C {lab_pin.sym} 2460 46760 0 0 {name=l37505 lab=VSS}
C {bitcell_6t.sym} 2600 46800 0 0 {name=Xr234c13}
N 2560 46840 2540 46840 {}
C {lab_pin.sym} 2540 46840 0 0 {name=l37506 lab=BL13}
N 2560 46800 2540 46800 {}
C {lab_pin.sym} 2540 46800 0 0 {name=l37507 lab=BLB13}
N 2560 46760 2540 46760 {}
C {lab_pin.sym} 2540 46760 0 0 {name=l37508 lab=WL234}
N 2640 46840 2660 46840 {}
C {lab_pin.sym} 2660 46840 0 0 {name=l37509 lab=VDD}
N 2640 46760 2660 46760 {}
C {lab_pin.sym} 2660 46760 0 0 {name=l37510 lab=VSS}
C {bitcell_6t.sym} 2800 46800 0 0 {name=Xr234c14}
N 2760 46840 2740 46840 {}
C {lab_pin.sym} 2740 46840 0 0 {name=l37511 lab=BL14}
N 2760 46800 2740 46800 {}
C {lab_pin.sym} 2740 46800 0 0 {name=l37512 lab=BLB14}
N 2760 46760 2740 46760 {}
C {lab_pin.sym} 2740 46760 0 0 {name=l37513 lab=WL234}
N 2840 46840 2860 46840 {}
C {lab_pin.sym} 2860 46840 0 0 {name=l37514 lab=VDD}
N 2840 46760 2860 46760 {}
C {lab_pin.sym} 2860 46760 0 0 {name=l37515 lab=VSS}
C {bitcell_6t.sym} 3000 46800 0 0 {name=Xr234c15}
N 2960 46840 2940 46840 {}
C {lab_pin.sym} 2940 46840 0 0 {name=l37516 lab=BL15}
N 2960 46800 2940 46800 {}
C {lab_pin.sym} 2940 46800 0 0 {name=l37517 lab=BLB15}
N 2960 46760 2940 46760 {}
C {lab_pin.sym} 2940 46760 0 0 {name=l37518 lab=WL234}
N 3040 46840 3060 46840 {}
C {lab_pin.sym} 3060 46840 0 0 {name=l37519 lab=VDD}
N 3040 46760 3060 46760 {}
C {lab_pin.sym} 3060 46760 0 0 {name=l37520 lab=VSS}
C {bitcell_6t.sym} 3200 46800 0 0 {name=Xr234c16}
N 3160 46840 3140 46840 {}
C {lab_pin.sym} 3140 46840 0 0 {name=l37521 lab=BL16}
N 3160 46800 3140 46800 {}
C {lab_pin.sym} 3140 46800 0 0 {name=l37522 lab=BLB16}
N 3160 46760 3140 46760 {}
C {lab_pin.sym} 3140 46760 0 0 {name=l37523 lab=WL234}
N 3240 46840 3260 46840 {}
C {lab_pin.sym} 3260 46840 0 0 {name=l37524 lab=VDD}
N 3240 46760 3260 46760 {}
C {lab_pin.sym} 3260 46760 0 0 {name=l37525 lab=VSS}
C {bitcell_6t.sym} 3400 46800 0 0 {name=Xr234c17}
N 3360 46840 3340 46840 {}
C {lab_pin.sym} 3340 46840 0 0 {name=l37526 lab=BL17}
N 3360 46800 3340 46800 {}
C {lab_pin.sym} 3340 46800 0 0 {name=l37527 lab=BLB17}
N 3360 46760 3340 46760 {}
C {lab_pin.sym} 3340 46760 0 0 {name=l37528 lab=WL234}
N 3440 46840 3460 46840 {}
C {lab_pin.sym} 3460 46840 0 0 {name=l37529 lab=VDD}
N 3440 46760 3460 46760 {}
C {lab_pin.sym} 3460 46760 0 0 {name=l37530 lab=VSS}
C {bitcell_6t.sym} 3600 46800 0 0 {name=Xr234c18}
N 3560 46840 3540 46840 {}
C {lab_pin.sym} 3540 46840 0 0 {name=l37531 lab=BL18}
N 3560 46800 3540 46800 {}
C {lab_pin.sym} 3540 46800 0 0 {name=l37532 lab=BLB18}
N 3560 46760 3540 46760 {}
C {lab_pin.sym} 3540 46760 0 0 {name=l37533 lab=WL234}
N 3640 46840 3660 46840 {}
C {lab_pin.sym} 3660 46840 0 0 {name=l37534 lab=VDD}
N 3640 46760 3660 46760 {}
C {lab_pin.sym} 3660 46760 0 0 {name=l37535 lab=VSS}
C {bitcell_6t.sym} 3800 46800 0 0 {name=Xr234c19}
N 3760 46840 3740 46840 {}
C {lab_pin.sym} 3740 46840 0 0 {name=l37536 lab=BL19}
N 3760 46800 3740 46800 {}
C {lab_pin.sym} 3740 46800 0 0 {name=l37537 lab=BLB19}
N 3760 46760 3740 46760 {}
C {lab_pin.sym} 3740 46760 0 0 {name=l37538 lab=WL234}
N 3840 46840 3860 46840 {}
C {lab_pin.sym} 3860 46840 0 0 {name=l37539 lab=VDD}
N 3840 46760 3860 46760 {}
C {lab_pin.sym} 3860 46760 0 0 {name=l37540 lab=VSS}
C {bitcell_6t.sym} 4000 46800 0 0 {name=Xr234c20}
N 3960 46840 3940 46840 {}
C {lab_pin.sym} 3940 46840 0 0 {name=l37541 lab=BL20}
N 3960 46800 3940 46800 {}
C {lab_pin.sym} 3940 46800 0 0 {name=l37542 lab=BLB20}
N 3960 46760 3940 46760 {}
C {lab_pin.sym} 3940 46760 0 0 {name=l37543 lab=WL234}
N 4040 46840 4060 46840 {}
C {lab_pin.sym} 4060 46840 0 0 {name=l37544 lab=VDD}
N 4040 46760 4060 46760 {}
C {lab_pin.sym} 4060 46760 0 0 {name=l37545 lab=VSS}
C {bitcell_6t.sym} 4200 46800 0 0 {name=Xr234c21}
N 4160 46840 4140 46840 {}
C {lab_pin.sym} 4140 46840 0 0 {name=l37546 lab=BL21}
N 4160 46800 4140 46800 {}
C {lab_pin.sym} 4140 46800 0 0 {name=l37547 lab=BLB21}
N 4160 46760 4140 46760 {}
C {lab_pin.sym} 4140 46760 0 0 {name=l37548 lab=WL234}
N 4240 46840 4260 46840 {}
C {lab_pin.sym} 4260 46840 0 0 {name=l37549 lab=VDD}
N 4240 46760 4260 46760 {}
C {lab_pin.sym} 4260 46760 0 0 {name=l37550 lab=VSS}
C {bitcell_6t.sym} 4400 46800 0 0 {name=Xr234c22}
N 4360 46840 4340 46840 {}
C {lab_pin.sym} 4340 46840 0 0 {name=l37551 lab=BL22}
N 4360 46800 4340 46800 {}
C {lab_pin.sym} 4340 46800 0 0 {name=l37552 lab=BLB22}
N 4360 46760 4340 46760 {}
C {lab_pin.sym} 4340 46760 0 0 {name=l37553 lab=WL234}
N 4440 46840 4460 46840 {}
C {lab_pin.sym} 4460 46840 0 0 {name=l37554 lab=VDD}
N 4440 46760 4460 46760 {}
C {lab_pin.sym} 4460 46760 0 0 {name=l37555 lab=VSS}
C {bitcell_6t.sym} 4600 46800 0 0 {name=Xr234c23}
N 4560 46840 4540 46840 {}
C {lab_pin.sym} 4540 46840 0 0 {name=l37556 lab=BL23}
N 4560 46800 4540 46800 {}
C {lab_pin.sym} 4540 46800 0 0 {name=l37557 lab=BLB23}
N 4560 46760 4540 46760 {}
C {lab_pin.sym} 4540 46760 0 0 {name=l37558 lab=WL234}
N 4640 46840 4660 46840 {}
C {lab_pin.sym} 4660 46840 0 0 {name=l37559 lab=VDD}
N 4640 46760 4660 46760 {}
C {lab_pin.sym} 4660 46760 0 0 {name=l37560 lab=VSS}
C {bitcell_6t.sym} 4800 46800 0 0 {name=Xr234c24}
N 4760 46840 4740 46840 {}
C {lab_pin.sym} 4740 46840 0 0 {name=l37561 lab=BL24}
N 4760 46800 4740 46800 {}
C {lab_pin.sym} 4740 46800 0 0 {name=l37562 lab=BLB24}
N 4760 46760 4740 46760 {}
C {lab_pin.sym} 4740 46760 0 0 {name=l37563 lab=WL234}
N 4840 46840 4860 46840 {}
C {lab_pin.sym} 4860 46840 0 0 {name=l37564 lab=VDD}
N 4840 46760 4860 46760 {}
C {lab_pin.sym} 4860 46760 0 0 {name=l37565 lab=VSS}
C {bitcell_6t.sym} 5000 46800 0 0 {name=Xr234c25}
N 4960 46840 4940 46840 {}
C {lab_pin.sym} 4940 46840 0 0 {name=l37566 lab=BL25}
N 4960 46800 4940 46800 {}
C {lab_pin.sym} 4940 46800 0 0 {name=l37567 lab=BLB25}
N 4960 46760 4940 46760 {}
C {lab_pin.sym} 4940 46760 0 0 {name=l37568 lab=WL234}
N 5040 46840 5060 46840 {}
C {lab_pin.sym} 5060 46840 0 0 {name=l37569 lab=VDD}
N 5040 46760 5060 46760 {}
C {lab_pin.sym} 5060 46760 0 0 {name=l37570 lab=VSS}
C {bitcell_6t.sym} 5200 46800 0 0 {name=Xr234c26}
N 5160 46840 5140 46840 {}
C {lab_pin.sym} 5140 46840 0 0 {name=l37571 lab=BL26}
N 5160 46800 5140 46800 {}
C {lab_pin.sym} 5140 46800 0 0 {name=l37572 lab=BLB26}
N 5160 46760 5140 46760 {}
C {lab_pin.sym} 5140 46760 0 0 {name=l37573 lab=WL234}
N 5240 46840 5260 46840 {}
C {lab_pin.sym} 5260 46840 0 0 {name=l37574 lab=VDD}
N 5240 46760 5260 46760 {}
C {lab_pin.sym} 5260 46760 0 0 {name=l37575 lab=VSS}
C {bitcell_6t.sym} 5400 46800 0 0 {name=Xr234c27}
N 5360 46840 5340 46840 {}
C {lab_pin.sym} 5340 46840 0 0 {name=l37576 lab=BL27}
N 5360 46800 5340 46800 {}
C {lab_pin.sym} 5340 46800 0 0 {name=l37577 lab=BLB27}
N 5360 46760 5340 46760 {}
C {lab_pin.sym} 5340 46760 0 0 {name=l37578 lab=WL234}
N 5440 46840 5460 46840 {}
C {lab_pin.sym} 5460 46840 0 0 {name=l37579 lab=VDD}
N 5440 46760 5460 46760 {}
C {lab_pin.sym} 5460 46760 0 0 {name=l37580 lab=VSS}
C {bitcell_6t.sym} 5600 46800 0 0 {name=Xr234c28}
N 5560 46840 5540 46840 {}
C {lab_pin.sym} 5540 46840 0 0 {name=l37581 lab=BL28}
N 5560 46800 5540 46800 {}
C {lab_pin.sym} 5540 46800 0 0 {name=l37582 lab=BLB28}
N 5560 46760 5540 46760 {}
C {lab_pin.sym} 5540 46760 0 0 {name=l37583 lab=WL234}
N 5640 46840 5660 46840 {}
C {lab_pin.sym} 5660 46840 0 0 {name=l37584 lab=VDD}
N 5640 46760 5660 46760 {}
C {lab_pin.sym} 5660 46760 0 0 {name=l37585 lab=VSS}
C {bitcell_6t.sym} 5800 46800 0 0 {name=Xr234c29}
N 5760 46840 5740 46840 {}
C {lab_pin.sym} 5740 46840 0 0 {name=l37586 lab=BL29}
N 5760 46800 5740 46800 {}
C {lab_pin.sym} 5740 46800 0 0 {name=l37587 lab=BLB29}
N 5760 46760 5740 46760 {}
C {lab_pin.sym} 5740 46760 0 0 {name=l37588 lab=WL234}
N 5840 46840 5860 46840 {}
C {lab_pin.sym} 5860 46840 0 0 {name=l37589 lab=VDD}
N 5840 46760 5860 46760 {}
C {lab_pin.sym} 5860 46760 0 0 {name=l37590 lab=VSS}
C {bitcell_6t.sym} 6000 46800 0 0 {name=Xr234c30}
N 5960 46840 5940 46840 {}
C {lab_pin.sym} 5940 46840 0 0 {name=l37591 lab=BL30}
N 5960 46800 5940 46800 {}
C {lab_pin.sym} 5940 46800 0 0 {name=l37592 lab=BLB30}
N 5960 46760 5940 46760 {}
C {lab_pin.sym} 5940 46760 0 0 {name=l37593 lab=WL234}
N 6040 46840 6060 46840 {}
C {lab_pin.sym} 6060 46840 0 0 {name=l37594 lab=VDD}
N 6040 46760 6060 46760 {}
C {lab_pin.sym} 6060 46760 0 0 {name=l37595 lab=VSS}
C {bitcell_6t.sym} 6200 46800 0 0 {name=Xr234c31}
N 6160 46840 6140 46840 {}
C {lab_pin.sym} 6140 46840 0 0 {name=l37596 lab=BL31}
N 6160 46800 6140 46800 {}
C {lab_pin.sym} 6140 46800 0 0 {name=l37597 lab=BLB31}
N 6160 46760 6140 46760 {}
C {lab_pin.sym} 6140 46760 0 0 {name=l37598 lab=WL234}
N 6240 46840 6260 46840 {}
C {lab_pin.sym} 6260 46840 0 0 {name=l37599 lab=VDD}
N 6240 46760 6260 46760 {}
C {lab_pin.sym} 6260 46760 0 0 {name=l37600 lab=VSS}
C {bitcell_6t.sym} 0 47000 0 0 {name=Xr235c0}
N -40 47040 -60 47040 {}
C {lab_pin.sym} -60 47040 0 0 {name=l37601 lab=BL0}
N -40 47000 -60 47000 {}
C {lab_pin.sym} -60 47000 0 0 {name=l37602 lab=BLB0}
N -40 46960 -60 46960 {}
C {lab_pin.sym} -60 46960 0 0 {name=l37603 lab=WL235}
N 40 47040 60 47040 {}
C {lab_pin.sym} 60 47040 0 0 {name=l37604 lab=VDD}
N 40 46960 60 46960 {}
C {lab_pin.sym} 60 46960 0 0 {name=l37605 lab=VSS}
C {bitcell_6t.sym} 200 47000 0 0 {name=Xr235c1}
N 160 47040 140 47040 {}
C {lab_pin.sym} 140 47040 0 0 {name=l37606 lab=BL1}
N 160 47000 140 47000 {}
C {lab_pin.sym} 140 47000 0 0 {name=l37607 lab=BLB1}
N 160 46960 140 46960 {}
C {lab_pin.sym} 140 46960 0 0 {name=l37608 lab=WL235}
N 240 47040 260 47040 {}
C {lab_pin.sym} 260 47040 0 0 {name=l37609 lab=VDD}
N 240 46960 260 46960 {}
C {lab_pin.sym} 260 46960 0 0 {name=l37610 lab=VSS}
C {bitcell_6t.sym} 400 47000 0 0 {name=Xr235c2}
N 360 47040 340 47040 {}
C {lab_pin.sym} 340 47040 0 0 {name=l37611 lab=BL2}
N 360 47000 340 47000 {}
C {lab_pin.sym} 340 47000 0 0 {name=l37612 lab=BLB2}
N 360 46960 340 46960 {}
C {lab_pin.sym} 340 46960 0 0 {name=l37613 lab=WL235}
N 440 47040 460 47040 {}
C {lab_pin.sym} 460 47040 0 0 {name=l37614 lab=VDD}
N 440 46960 460 46960 {}
C {lab_pin.sym} 460 46960 0 0 {name=l37615 lab=VSS}
C {bitcell_6t.sym} 600 47000 0 0 {name=Xr235c3}
N 560 47040 540 47040 {}
C {lab_pin.sym} 540 47040 0 0 {name=l37616 lab=BL3}
N 560 47000 540 47000 {}
C {lab_pin.sym} 540 47000 0 0 {name=l37617 lab=BLB3}
N 560 46960 540 46960 {}
C {lab_pin.sym} 540 46960 0 0 {name=l37618 lab=WL235}
N 640 47040 660 47040 {}
C {lab_pin.sym} 660 47040 0 0 {name=l37619 lab=VDD}
N 640 46960 660 46960 {}
C {lab_pin.sym} 660 46960 0 0 {name=l37620 lab=VSS}
C {bitcell_6t.sym} 800 47000 0 0 {name=Xr235c4}
N 760 47040 740 47040 {}
C {lab_pin.sym} 740 47040 0 0 {name=l37621 lab=BL4}
N 760 47000 740 47000 {}
C {lab_pin.sym} 740 47000 0 0 {name=l37622 lab=BLB4}
N 760 46960 740 46960 {}
C {lab_pin.sym} 740 46960 0 0 {name=l37623 lab=WL235}
N 840 47040 860 47040 {}
C {lab_pin.sym} 860 47040 0 0 {name=l37624 lab=VDD}
N 840 46960 860 46960 {}
C {lab_pin.sym} 860 46960 0 0 {name=l37625 lab=VSS}
C {bitcell_6t.sym} 1000 47000 0 0 {name=Xr235c5}
N 960 47040 940 47040 {}
C {lab_pin.sym} 940 47040 0 0 {name=l37626 lab=BL5}
N 960 47000 940 47000 {}
C {lab_pin.sym} 940 47000 0 0 {name=l37627 lab=BLB5}
N 960 46960 940 46960 {}
C {lab_pin.sym} 940 46960 0 0 {name=l37628 lab=WL235}
N 1040 47040 1060 47040 {}
C {lab_pin.sym} 1060 47040 0 0 {name=l37629 lab=VDD}
N 1040 46960 1060 46960 {}
C {lab_pin.sym} 1060 46960 0 0 {name=l37630 lab=VSS}
C {bitcell_6t.sym} 1200 47000 0 0 {name=Xr235c6}
N 1160 47040 1140 47040 {}
C {lab_pin.sym} 1140 47040 0 0 {name=l37631 lab=BL6}
N 1160 47000 1140 47000 {}
C {lab_pin.sym} 1140 47000 0 0 {name=l37632 lab=BLB6}
N 1160 46960 1140 46960 {}
C {lab_pin.sym} 1140 46960 0 0 {name=l37633 lab=WL235}
N 1240 47040 1260 47040 {}
C {lab_pin.sym} 1260 47040 0 0 {name=l37634 lab=VDD}
N 1240 46960 1260 46960 {}
C {lab_pin.sym} 1260 46960 0 0 {name=l37635 lab=VSS}
C {bitcell_6t.sym} 1400 47000 0 0 {name=Xr235c7}
N 1360 47040 1340 47040 {}
C {lab_pin.sym} 1340 47040 0 0 {name=l37636 lab=BL7}
N 1360 47000 1340 47000 {}
C {lab_pin.sym} 1340 47000 0 0 {name=l37637 lab=BLB7}
N 1360 46960 1340 46960 {}
C {lab_pin.sym} 1340 46960 0 0 {name=l37638 lab=WL235}
N 1440 47040 1460 47040 {}
C {lab_pin.sym} 1460 47040 0 0 {name=l37639 lab=VDD}
N 1440 46960 1460 46960 {}
C {lab_pin.sym} 1460 46960 0 0 {name=l37640 lab=VSS}
C {bitcell_6t.sym} 1600 47000 0 0 {name=Xr235c8}
N 1560 47040 1540 47040 {}
C {lab_pin.sym} 1540 47040 0 0 {name=l37641 lab=BL8}
N 1560 47000 1540 47000 {}
C {lab_pin.sym} 1540 47000 0 0 {name=l37642 lab=BLB8}
N 1560 46960 1540 46960 {}
C {lab_pin.sym} 1540 46960 0 0 {name=l37643 lab=WL235}
N 1640 47040 1660 47040 {}
C {lab_pin.sym} 1660 47040 0 0 {name=l37644 lab=VDD}
N 1640 46960 1660 46960 {}
C {lab_pin.sym} 1660 46960 0 0 {name=l37645 lab=VSS}
C {bitcell_6t.sym} 1800 47000 0 0 {name=Xr235c9}
N 1760 47040 1740 47040 {}
C {lab_pin.sym} 1740 47040 0 0 {name=l37646 lab=BL9}
N 1760 47000 1740 47000 {}
C {lab_pin.sym} 1740 47000 0 0 {name=l37647 lab=BLB9}
N 1760 46960 1740 46960 {}
C {lab_pin.sym} 1740 46960 0 0 {name=l37648 lab=WL235}
N 1840 47040 1860 47040 {}
C {lab_pin.sym} 1860 47040 0 0 {name=l37649 lab=VDD}
N 1840 46960 1860 46960 {}
C {lab_pin.sym} 1860 46960 0 0 {name=l37650 lab=VSS}
C {bitcell_6t.sym} 2000 47000 0 0 {name=Xr235c10}
N 1960 47040 1940 47040 {}
C {lab_pin.sym} 1940 47040 0 0 {name=l37651 lab=BL10}
N 1960 47000 1940 47000 {}
C {lab_pin.sym} 1940 47000 0 0 {name=l37652 lab=BLB10}
N 1960 46960 1940 46960 {}
C {lab_pin.sym} 1940 46960 0 0 {name=l37653 lab=WL235}
N 2040 47040 2060 47040 {}
C {lab_pin.sym} 2060 47040 0 0 {name=l37654 lab=VDD}
N 2040 46960 2060 46960 {}
C {lab_pin.sym} 2060 46960 0 0 {name=l37655 lab=VSS}
C {bitcell_6t.sym} 2200 47000 0 0 {name=Xr235c11}
N 2160 47040 2140 47040 {}
C {lab_pin.sym} 2140 47040 0 0 {name=l37656 lab=BL11}
N 2160 47000 2140 47000 {}
C {lab_pin.sym} 2140 47000 0 0 {name=l37657 lab=BLB11}
N 2160 46960 2140 46960 {}
C {lab_pin.sym} 2140 46960 0 0 {name=l37658 lab=WL235}
N 2240 47040 2260 47040 {}
C {lab_pin.sym} 2260 47040 0 0 {name=l37659 lab=VDD}
N 2240 46960 2260 46960 {}
C {lab_pin.sym} 2260 46960 0 0 {name=l37660 lab=VSS}
C {bitcell_6t.sym} 2400 47000 0 0 {name=Xr235c12}
N 2360 47040 2340 47040 {}
C {lab_pin.sym} 2340 47040 0 0 {name=l37661 lab=BL12}
N 2360 47000 2340 47000 {}
C {lab_pin.sym} 2340 47000 0 0 {name=l37662 lab=BLB12}
N 2360 46960 2340 46960 {}
C {lab_pin.sym} 2340 46960 0 0 {name=l37663 lab=WL235}
N 2440 47040 2460 47040 {}
C {lab_pin.sym} 2460 47040 0 0 {name=l37664 lab=VDD}
N 2440 46960 2460 46960 {}
C {lab_pin.sym} 2460 46960 0 0 {name=l37665 lab=VSS}
C {bitcell_6t.sym} 2600 47000 0 0 {name=Xr235c13}
N 2560 47040 2540 47040 {}
C {lab_pin.sym} 2540 47040 0 0 {name=l37666 lab=BL13}
N 2560 47000 2540 47000 {}
C {lab_pin.sym} 2540 47000 0 0 {name=l37667 lab=BLB13}
N 2560 46960 2540 46960 {}
C {lab_pin.sym} 2540 46960 0 0 {name=l37668 lab=WL235}
N 2640 47040 2660 47040 {}
C {lab_pin.sym} 2660 47040 0 0 {name=l37669 lab=VDD}
N 2640 46960 2660 46960 {}
C {lab_pin.sym} 2660 46960 0 0 {name=l37670 lab=VSS}
C {bitcell_6t.sym} 2800 47000 0 0 {name=Xr235c14}
N 2760 47040 2740 47040 {}
C {lab_pin.sym} 2740 47040 0 0 {name=l37671 lab=BL14}
N 2760 47000 2740 47000 {}
C {lab_pin.sym} 2740 47000 0 0 {name=l37672 lab=BLB14}
N 2760 46960 2740 46960 {}
C {lab_pin.sym} 2740 46960 0 0 {name=l37673 lab=WL235}
N 2840 47040 2860 47040 {}
C {lab_pin.sym} 2860 47040 0 0 {name=l37674 lab=VDD}
N 2840 46960 2860 46960 {}
C {lab_pin.sym} 2860 46960 0 0 {name=l37675 lab=VSS}
C {bitcell_6t.sym} 3000 47000 0 0 {name=Xr235c15}
N 2960 47040 2940 47040 {}
C {lab_pin.sym} 2940 47040 0 0 {name=l37676 lab=BL15}
N 2960 47000 2940 47000 {}
C {lab_pin.sym} 2940 47000 0 0 {name=l37677 lab=BLB15}
N 2960 46960 2940 46960 {}
C {lab_pin.sym} 2940 46960 0 0 {name=l37678 lab=WL235}
N 3040 47040 3060 47040 {}
C {lab_pin.sym} 3060 47040 0 0 {name=l37679 lab=VDD}
N 3040 46960 3060 46960 {}
C {lab_pin.sym} 3060 46960 0 0 {name=l37680 lab=VSS}
C {bitcell_6t.sym} 3200 47000 0 0 {name=Xr235c16}
N 3160 47040 3140 47040 {}
C {lab_pin.sym} 3140 47040 0 0 {name=l37681 lab=BL16}
N 3160 47000 3140 47000 {}
C {lab_pin.sym} 3140 47000 0 0 {name=l37682 lab=BLB16}
N 3160 46960 3140 46960 {}
C {lab_pin.sym} 3140 46960 0 0 {name=l37683 lab=WL235}
N 3240 47040 3260 47040 {}
C {lab_pin.sym} 3260 47040 0 0 {name=l37684 lab=VDD}
N 3240 46960 3260 46960 {}
C {lab_pin.sym} 3260 46960 0 0 {name=l37685 lab=VSS}
C {bitcell_6t.sym} 3400 47000 0 0 {name=Xr235c17}
N 3360 47040 3340 47040 {}
C {lab_pin.sym} 3340 47040 0 0 {name=l37686 lab=BL17}
N 3360 47000 3340 47000 {}
C {lab_pin.sym} 3340 47000 0 0 {name=l37687 lab=BLB17}
N 3360 46960 3340 46960 {}
C {lab_pin.sym} 3340 46960 0 0 {name=l37688 lab=WL235}
N 3440 47040 3460 47040 {}
C {lab_pin.sym} 3460 47040 0 0 {name=l37689 lab=VDD}
N 3440 46960 3460 46960 {}
C {lab_pin.sym} 3460 46960 0 0 {name=l37690 lab=VSS}
C {bitcell_6t.sym} 3600 47000 0 0 {name=Xr235c18}
N 3560 47040 3540 47040 {}
C {lab_pin.sym} 3540 47040 0 0 {name=l37691 lab=BL18}
N 3560 47000 3540 47000 {}
C {lab_pin.sym} 3540 47000 0 0 {name=l37692 lab=BLB18}
N 3560 46960 3540 46960 {}
C {lab_pin.sym} 3540 46960 0 0 {name=l37693 lab=WL235}
N 3640 47040 3660 47040 {}
C {lab_pin.sym} 3660 47040 0 0 {name=l37694 lab=VDD}
N 3640 46960 3660 46960 {}
C {lab_pin.sym} 3660 46960 0 0 {name=l37695 lab=VSS}
C {bitcell_6t.sym} 3800 47000 0 0 {name=Xr235c19}
N 3760 47040 3740 47040 {}
C {lab_pin.sym} 3740 47040 0 0 {name=l37696 lab=BL19}
N 3760 47000 3740 47000 {}
C {lab_pin.sym} 3740 47000 0 0 {name=l37697 lab=BLB19}
N 3760 46960 3740 46960 {}
C {lab_pin.sym} 3740 46960 0 0 {name=l37698 lab=WL235}
N 3840 47040 3860 47040 {}
C {lab_pin.sym} 3860 47040 0 0 {name=l37699 lab=VDD}
N 3840 46960 3860 46960 {}
C {lab_pin.sym} 3860 46960 0 0 {name=l37700 lab=VSS}
C {bitcell_6t.sym} 4000 47000 0 0 {name=Xr235c20}
N 3960 47040 3940 47040 {}
C {lab_pin.sym} 3940 47040 0 0 {name=l37701 lab=BL20}
N 3960 47000 3940 47000 {}
C {lab_pin.sym} 3940 47000 0 0 {name=l37702 lab=BLB20}
N 3960 46960 3940 46960 {}
C {lab_pin.sym} 3940 46960 0 0 {name=l37703 lab=WL235}
N 4040 47040 4060 47040 {}
C {lab_pin.sym} 4060 47040 0 0 {name=l37704 lab=VDD}
N 4040 46960 4060 46960 {}
C {lab_pin.sym} 4060 46960 0 0 {name=l37705 lab=VSS}
C {bitcell_6t.sym} 4200 47000 0 0 {name=Xr235c21}
N 4160 47040 4140 47040 {}
C {lab_pin.sym} 4140 47040 0 0 {name=l37706 lab=BL21}
N 4160 47000 4140 47000 {}
C {lab_pin.sym} 4140 47000 0 0 {name=l37707 lab=BLB21}
N 4160 46960 4140 46960 {}
C {lab_pin.sym} 4140 46960 0 0 {name=l37708 lab=WL235}
N 4240 47040 4260 47040 {}
C {lab_pin.sym} 4260 47040 0 0 {name=l37709 lab=VDD}
N 4240 46960 4260 46960 {}
C {lab_pin.sym} 4260 46960 0 0 {name=l37710 lab=VSS}
C {bitcell_6t.sym} 4400 47000 0 0 {name=Xr235c22}
N 4360 47040 4340 47040 {}
C {lab_pin.sym} 4340 47040 0 0 {name=l37711 lab=BL22}
N 4360 47000 4340 47000 {}
C {lab_pin.sym} 4340 47000 0 0 {name=l37712 lab=BLB22}
N 4360 46960 4340 46960 {}
C {lab_pin.sym} 4340 46960 0 0 {name=l37713 lab=WL235}
N 4440 47040 4460 47040 {}
C {lab_pin.sym} 4460 47040 0 0 {name=l37714 lab=VDD}
N 4440 46960 4460 46960 {}
C {lab_pin.sym} 4460 46960 0 0 {name=l37715 lab=VSS}
C {bitcell_6t.sym} 4600 47000 0 0 {name=Xr235c23}
N 4560 47040 4540 47040 {}
C {lab_pin.sym} 4540 47040 0 0 {name=l37716 lab=BL23}
N 4560 47000 4540 47000 {}
C {lab_pin.sym} 4540 47000 0 0 {name=l37717 lab=BLB23}
N 4560 46960 4540 46960 {}
C {lab_pin.sym} 4540 46960 0 0 {name=l37718 lab=WL235}
N 4640 47040 4660 47040 {}
C {lab_pin.sym} 4660 47040 0 0 {name=l37719 lab=VDD}
N 4640 46960 4660 46960 {}
C {lab_pin.sym} 4660 46960 0 0 {name=l37720 lab=VSS}
C {bitcell_6t.sym} 4800 47000 0 0 {name=Xr235c24}
N 4760 47040 4740 47040 {}
C {lab_pin.sym} 4740 47040 0 0 {name=l37721 lab=BL24}
N 4760 47000 4740 47000 {}
C {lab_pin.sym} 4740 47000 0 0 {name=l37722 lab=BLB24}
N 4760 46960 4740 46960 {}
C {lab_pin.sym} 4740 46960 0 0 {name=l37723 lab=WL235}
N 4840 47040 4860 47040 {}
C {lab_pin.sym} 4860 47040 0 0 {name=l37724 lab=VDD}
N 4840 46960 4860 46960 {}
C {lab_pin.sym} 4860 46960 0 0 {name=l37725 lab=VSS}
C {bitcell_6t.sym} 5000 47000 0 0 {name=Xr235c25}
N 4960 47040 4940 47040 {}
C {lab_pin.sym} 4940 47040 0 0 {name=l37726 lab=BL25}
N 4960 47000 4940 47000 {}
C {lab_pin.sym} 4940 47000 0 0 {name=l37727 lab=BLB25}
N 4960 46960 4940 46960 {}
C {lab_pin.sym} 4940 46960 0 0 {name=l37728 lab=WL235}
N 5040 47040 5060 47040 {}
C {lab_pin.sym} 5060 47040 0 0 {name=l37729 lab=VDD}
N 5040 46960 5060 46960 {}
C {lab_pin.sym} 5060 46960 0 0 {name=l37730 lab=VSS}
C {bitcell_6t.sym} 5200 47000 0 0 {name=Xr235c26}
N 5160 47040 5140 47040 {}
C {lab_pin.sym} 5140 47040 0 0 {name=l37731 lab=BL26}
N 5160 47000 5140 47000 {}
C {lab_pin.sym} 5140 47000 0 0 {name=l37732 lab=BLB26}
N 5160 46960 5140 46960 {}
C {lab_pin.sym} 5140 46960 0 0 {name=l37733 lab=WL235}
N 5240 47040 5260 47040 {}
C {lab_pin.sym} 5260 47040 0 0 {name=l37734 lab=VDD}
N 5240 46960 5260 46960 {}
C {lab_pin.sym} 5260 46960 0 0 {name=l37735 lab=VSS}
C {bitcell_6t.sym} 5400 47000 0 0 {name=Xr235c27}
N 5360 47040 5340 47040 {}
C {lab_pin.sym} 5340 47040 0 0 {name=l37736 lab=BL27}
N 5360 47000 5340 47000 {}
C {lab_pin.sym} 5340 47000 0 0 {name=l37737 lab=BLB27}
N 5360 46960 5340 46960 {}
C {lab_pin.sym} 5340 46960 0 0 {name=l37738 lab=WL235}
N 5440 47040 5460 47040 {}
C {lab_pin.sym} 5460 47040 0 0 {name=l37739 lab=VDD}
N 5440 46960 5460 46960 {}
C {lab_pin.sym} 5460 46960 0 0 {name=l37740 lab=VSS}
C {bitcell_6t.sym} 5600 47000 0 0 {name=Xr235c28}
N 5560 47040 5540 47040 {}
C {lab_pin.sym} 5540 47040 0 0 {name=l37741 lab=BL28}
N 5560 47000 5540 47000 {}
C {lab_pin.sym} 5540 47000 0 0 {name=l37742 lab=BLB28}
N 5560 46960 5540 46960 {}
C {lab_pin.sym} 5540 46960 0 0 {name=l37743 lab=WL235}
N 5640 47040 5660 47040 {}
C {lab_pin.sym} 5660 47040 0 0 {name=l37744 lab=VDD}
N 5640 46960 5660 46960 {}
C {lab_pin.sym} 5660 46960 0 0 {name=l37745 lab=VSS}
C {bitcell_6t.sym} 5800 47000 0 0 {name=Xr235c29}
N 5760 47040 5740 47040 {}
C {lab_pin.sym} 5740 47040 0 0 {name=l37746 lab=BL29}
N 5760 47000 5740 47000 {}
C {lab_pin.sym} 5740 47000 0 0 {name=l37747 lab=BLB29}
N 5760 46960 5740 46960 {}
C {lab_pin.sym} 5740 46960 0 0 {name=l37748 lab=WL235}
N 5840 47040 5860 47040 {}
C {lab_pin.sym} 5860 47040 0 0 {name=l37749 lab=VDD}
N 5840 46960 5860 46960 {}
C {lab_pin.sym} 5860 46960 0 0 {name=l37750 lab=VSS}
C {bitcell_6t.sym} 6000 47000 0 0 {name=Xr235c30}
N 5960 47040 5940 47040 {}
C {lab_pin.sym} 5940 47040 0 0 {name=l37751 lab=BL30}
N 5960 47000 5940 47000 {}
C {lab_pin.sym} 5940 47000 0 0 {name=l37752 lab=BLB30}
N 5960 46960 5940 46960 {}
C {lab_pin.sym} 5940 46960 0 0 {name=l37753 lab=WL235}
N 6040 47040 6060 47040 {}
C {lab_pin.sym} 6060 47040 0 0 {name=l37754 lab=VDD}
N 6040 46960 6060 46960 {}
C {lab_pin.sym} 6060 46960 0 0 {name=l37755 lab=VSS}
C {bitcell_6t.sym} 6200 47000 0 0 {name=Xr235c31}
N 6160 47040 6140 47040 {}
C {lab_pin.sym} 6140 47040 0 0 {name=l37756 lab=BL31}
N 6160 47000 6140 47000 {}
C {lab_pin.sym} 6140 47000 0 0 {name=l37757 lab=BLB31}
N 6160 46960 6140 46960 {}
C {lab_pin.sym} 6140 46960 0 0 {name=l37758 lab=WL235}
N 6240 47040 6260 47040 {}
C {lab_pin.sym} 6260 47040 0 0 {name=l37759 lab=VDD}
N 6240 46960 6260 46960 {}
C {lab_pin.sym} 6260 46960 0 0 {name=l37760 lab=VSS}
C {bitcell_6t.sym} 0 47200 0 0 {name=Xr236c0}
N -40 47240 -60 47240 {}
C {lab_pin.sym} -60 47240 0 0 {name=l37761 lab=BL0}
N -40 47200 -60 47200 {}
C {lab_pin.sym} -60 47200 0 0 {name=l37762 lab=BLB0}
N -40 47160 -60 47160 {}
C {lab_pin.sym} -60 47160 0 0 {name=l37763 lab=WL236}
N 40 47240 60 47240 {}
C {lab_pin.sym} 60 47240 0 0 {name=l37764 lab=VDD}
N 40 47160 60 47160 {}
C {lab_pin.sym} 60 47160 0 0 {name=l37765 lab=VSS}
C {bitcell_6t.sym} 200 47200 0 0 {name=Xr236c1}
N 160 47240 140 47240 {}
C {lab_pin.sym} 140 47240 0 0 {name=l37766 lab=BL1}
N 160 47200 140 47200 {}
C {lab_pin.sym} 140 47200 0 0 {name=l37767 lab=BLB1}
N 160 47160 140 47160 {}
C {lab_pin.sym} 140 47160 0 0 {name=l37768 lab=WL236}
N 240 47240 260 47240 {}
C {lab_pin.sym} 260 47240 0 0 {name=l37769 lab=VDD}
N 240 47160 260 47160 {}
C {lab_pin.sym} 260 47160 0 0 {name=l37770 lab=VSS}
C {bitcell_6t.sym} 400 47200 0 0 {name=Xr236c2}
N 360 47240 340 47240 {}
C {lab_pin.sym} 340 47240 0 0 {name=l37771 lab=BL2}
N 360 47200 340 47200 {}
C {lab_pin.sym} 340 47200 0 0 {name=l37772 lab=BLB2}
N 360 47160 340 47160 {}
C {lab_pin.sym} 340 47160 0 0 {name=l37773 lab=WL236}
N 440 47240 460 47240 {}
C {lab_pin.sym} 460 47240 0 0 {name=l37774 lab=VDD}
N 440 47160 460 47160 {}
C {lab_pin.sym} 460 47160 0 0 {name=l37775 lab=VSS}
C {bitcell_6t.sym} 600 47200 0 0 {name=Xr236c3}
N 560 47240 540 47240 {}
C {lab_pin.sym} 540 47240 0 0 {name=l37776 lab=BL3}
N 560 47200 540 47200 {}
C {lab_pin.sym} 540 47200 0 0 {name=l37777 lab=BLB3}
N 560 47160 540 47160 {}
C {lab_pin.sym} 540 47160 0 0 {name=l37778 lab=WL236}
N 640 47240 660 47240 {}
C {lab_pin.sym} 660 47240 0 0 {name=l37779 lab=VDD}
N 640 47160 660 47160 {}
C {lab_pin.sym} 660 47160 0 0 {name=l37780 lab=VSS}
C {bitcell_6t.sym} 800 47200 0 0 {name=Xr236c4}
N 760 47240 740 47240 {}
C {lab_pin.sym} 740 47240 0 0 {name=l37781 lab=BL4}
N 760 47200 740 47200 {}
C {lab_pin.sym} 740 47200 0 0 {name=l37782 lab=BLB4}
N 760 47160 740 47160 {}
C {lab_pin.sym} 740 47160 0 0 {name=l37783 lab=WL236}
N 840 47240 860 47240 {}
C {lab_pin.sym} 860 47240 0 0 {name=l37784 lab=VDD}
N 840 47160 860 47160 {}
C {lab_pin.sym} 860 47160 0 0 {name=l37785 lab=VSS}
C {bitcell_6t.sym} 1000 47200 0 0 {name=Xr236c5}
N 960 47240 940 47240 {}
C {lab_pin.sym} 940 47240 0 0 {name=l37786 lab=BL5}
N 960 47200 940 47200 {}
C {lab_pin.sym} 940 47200 0 0 {name=l37787 lab=BLB5}
N 960 47160 940 47160 {}
C {lab_pin.sym} 940 47160 0 0 {name=l37788 lab=WL236}
N 1040 47240 1060 47240 {}
C {lab_pin.sym} 1060 47240 0 0 {name=l37789 lab=VDD}
N 1040 47160 1060 47160 {}
C {lab_pin.sym} 1060 47160 0 0 {name=l37790 lab=VSS}
C {bitcell_6t.sym} 1200 47200 0 0 {name=Xr236c6}
N 1160 47240 1140 47240 {}
C {lab_pin.sym} 1140 47240 0 0 {name=l37791 lab=BL6}
N 1160 47200 1140 47200 {}
C {lab_pin.sym} 1140 47200 0 0 {name=l37792 lab=BLB6}
N 1160 47160 1140 47160 {}
C {lab_pin.sym} 1140 47160 0 0 {name=l37793 lab=WL236}
N 1240 47240 1260 47240 {}
C {lab_pin.sym} 1260 47240 0 0 {name=l37794 lab=VDD}
N 1240 47160 1260 47160 {}
C {lab_pin.sym} 1260 47160 0 0 {name=l37795 lab=VSS}
C {bitcell_6t.sym} 1400 47200 0 0 {name=Xr236c7}
N 1360 47240 1340 47240 {}
C {lab_pin.sym} 1340 47240 0 0 {name=l37796 lab=BL7}
N 1360 47200 1340 47200 {}
C {lab_pin.sym} 1340 47200 0 0 {name=l37797 lab=BLB7}
N 1360 47160 1340 47160 {}
C {lab_pin.sym} 1340 47160 0 0 {name=l37798 lab=WL236}
N 1440 47240 1460 47240 {}
C {lab_pin.sym} 1460 47240 0 0 {name=l37799 lab=VDD}
N 1440 47160 1460 47160 {}
C {lab_pin.sym} 1460 47160 0 0 {name=l37800 lab=VSS}
C {bitcell_6t.sym} 1600 47200 0 0 {name=Xr236c8}
N 1560 47240 1540 47240 {}
C {lab_pin.sym} 1540 47240 0 0 {name=l37801 lab=BL8}
N 1560 47200 1540 47200 {}
C {lab_pin.sym} 1540 47200 0 0 {name=l37802 lab=BLB8}
N 1560 47160 1540 47160 {}
C {lab_pin.sym} 1540 47160 0 0 {name=l37803 lab=WL236}
N 1640 47240 1660 47240 {}
C {lab_pin.sym} 1660 47240 0 0 {name=l37804 lab=VDD}
N 1640 47160 1660 47160 {}
C {lab_pin.sym} 1660 47160 0 0 {name=l37805 lab=VSS}
C {bitcell_6t.sym} 1800 47200 0 0 {name=Xr236c9}
N 1760 47240 1740 47240 {}
C {lab_pin.sym} 1740 47240 0 0 {name=l37806 lab=BL9}
N 1760 47200 1740 47200 {}
C {lab_pin.sym} 1740 47200 0 0 {name=l37807 lab=BLB9}
N 1760 47160 1740 47160 {}
C {lab_pin.sym} 1740 47160 0 0 {name=l37808 lab=WL236}
N 1840 47240 1860 47240 {}
C {lab_pin.sym} 1860 47240 0 0 {name=l37809 lab=VDD}
N 1840 47160 1860 47160 {}
C {lab_pin.sym} 1860 47160 0 0 {name=l37810 lab=VSS}
C {bitcell_6t.sym} 2000 47200 0 0 {name=Xr236c10}
N 1960 47240 1940 47240 {}
C {lab_pin.sym} 1940 47240 0 0 {name=l37811 lab=BL10}
N 1960 47200 1940 47200 {}
C {lab_pin.sym} 1940 47200 0 0 {name=l37812 lab=BLB10}
N 1960 47160 1940 47160 {}
C {lab_pin.sym} 1940 47160 0 0 {name=l37813 lab=WL236}
N 2040 47240 2060 47240 {}
C {lab_pin.sym} 2060 47240 0 0 {name=l37814 lab=VDD}
N 2040 47160 2060 47160 {}
C {lab_pin.sym} 2060 47160 0 0 {name=l37815 lab=VSS}
C {bitcell_6t.sym} 2200 47200 0 0 {name=Xr236c11}
N 2160 47240 2140 47240 {}
C {lab_pin.sym} 2140 47240 0 0 {name=l37816 lab=BL11}
N 2160 47200 2140 47200 {}
C {lab_pin.sym} 2140 47200 0 0 {name=l37817 lab=BLB11}
N 2160 47160 2140 47160 {}
C {lab_pin.sym} 2140 47160 0 0 {name=l37818 lab=WL236}
N 2240 47240 2260 47240 {}
C {lab_pin.sym} 2260 47240 0 0 {name=l37819 lab=VDD}
N 2240 47160 2260 47160 {}
C {lab_pin.sym} 2260 47160 0 0 {name=l37820 lab=VSS}
C {bitcell_6t.sym} 2400 47200 0 0 {name=Xr236c12}
N 2360 47240 2340 47240 {}
C {lab_pin.sym} 2340 47240 0 0 {name=l37821 lab=BL12}
N 2360 47200 2340 47200 {}
C {lab_pin.sym} 2340 47200 0 0 {name=l37822 lab=BLB12}
N 2360 47160 2340 47160 {}
C {lab_pin.sym} 2340 47160 0 0 {name=l37823 lab=WL236}
N 2440 47240 2460 47240 {}
C {lab_pin.sym} 2460 47240 0 0 {name=l37824 lab=VDD}
N 2440 47160 2460 47160 {}
C {lab_pin.sym} 2460 47160 0 0 {name=l37825 lab=VSS}
C {bitcell_6t.sym} 2600 47200 0 0 {name=Xr236c13}
N 2560 47240 2540 47240 {}
C {lab_pin.sym} 2540 47240 0 0 {name=l37826 lab=BL13}
N 2560 47200 2540 47200 {}
C {lab_pin.sym} 2540 47200 0 0 {name=l37827 lab=BLB13}
N 2560 47160 2540 47160 {}
C {lab_pin.sym} 2540 47160 0 0 {name=l37828 lab=WL236}
N 2640 47240 2660 47240 {}
C {lab_pin.sym} 2660 47240 0 0 {name=l37829 lab=VDD}
N 2640 47160 2660 47160 {}
C {lab_pin.sym} 2660 47160 0 0 {name=l37830 lab=VSS}
C {bitcell_6t.sym} 2800 47200 0 0 {name=Xr236c14}
N 2760 47240 2740 47240 {}
C {lab_pin.sym} 2740 47240 0 0 {name=l37831 lab=BL14}
N 2760 47200 2740 47200 {}
C {lab_pin.sym} 2740 47200 0 0 {name=l37832 lab=BLB14}
N 2760 47160 2740 47160 {}
C {lab_pin.sym} 2740 47160 0 0 {name=l37833 lab=WL236}
N 2840 47240 2860 47240 {}
C {lab_pin.sym} 2860 47240 0 0 {name=l37834 lab=VDD}
N 2840 47160 2860 47160 {}
C {lab_pin.sym} 2860 47160 0 0 {name=l37835 lab=VSS}
C {bitcell_6t.sym} 3000 47200 0 0 {name=Xr236c15}
N 2960 47240 2940 47240 {}
C {lab_pin.sym} 2940 47240 0 0 {name=l37836 lab=BL15}
N 2960 47200 2940 47200 {}
C {lab_pin.sym} 2940 47200 0 0 {name=l37837 lab=BLB15}
N 2960 47160 2940 47160 {}
C {lab_pin.sym} 2940 47160 0 0 {name=l37838 lab=WL236}
N 3040 47240 3060 47240 {}
C {lab_pin.sym} 3060 47240 0 0 {name=l37839 lab=VDD}
N 3040 47160 3060 47160 {}
C {lab_pin.sym} 3060 47160 0 0 {name=l37840 lab=VSS}
C {bitcell_6t.sym} 3200 47200 0 0 {name=Xr236c16}
N 3160 47240 3140 47240 {}
C {lab_pin.sym} 3140 47240 0 0 {name=l37841 lab=BL16}
N 3160 47200 3140 47200 {}
C {lab_pin.sym} 3140 47200 0 0 {name=l37842 lab=BLB16}
N 3160 47160 3140 47160 {}
C {lab_pin.sym} 3140 47160 0 0 {name=l37843 lab=WL236}
N 3240 47240 3260 47240 {}
C {lab_pin.sym} 3260 47240 0 0 {name=l37844 lab=VDD}
N 3240 47160 3260 47160 {}
C {lab_pin.sym} 3260 47160 0 0 {name=l37845 lab=VSS}
C {bitcell_6t.sym} 3400 47200 0 0 {name=Xr236c17}
N 3360 47240 3340 47240 {}
C {lab_pin.sym} 3340 47240 0 0 {name=l37846 lab=BL17}
N 3360 47200 3340 47200 {}
C {lab_pin.sym} 3340 47200 0 0 {name=l37847 lab=BLB17}
N 3360 47160 3340 47160 {}
C {lab_pin.sym} 3340 47160 0 0 {name=l37848 lab=WL236}
N 3440 47240 3460 47240 {}
C {lab_pin.sym} 3460 47240 0 0 {name=l37849 lab=VDD}
N 3440 47160 3460 47160 {}
C {lab_pin.sym} 3460 47160 0 0 {name=l37850 lab=VSS}
C {bitcell_6t.sym} 3600 47200 0 0 {name=Xr236c18}
N 3560 47240 3540 47240 {}
C {lab_pin.sym} 3540 47240 0 0 {name=l37851 lab=BL18}
N 3560 47200 3540 47200 {}
C {lab_pin.sym} 3540 47200 0 0 {name=l37852 lab=BLB18}
N 3560 47160 3540 47160 {}
C {lab_pin.sym} 3540 47160 0 0 {name=l37853 lab=WL236}
N 3640 47240 3660 47240 {}
C {lab_pin.sym} 3660 47240 0 0 {name=l37854 lab=VDD}
N 3640 47160 3660 47160 {}
C {lab_pin.sym} 3660 47160 0 0 {name=l37855 lab=VSS}
C {bitcell_6t.sym} 3800 47200 0 0 {name=Xr236c19}
N 3760 47240 3740 47240 {}
C {lab_pin.sym} 3740 47240 0 0 {name=l37856 lab=BL19}
N 3760 47200 3740 47200 {}
C {lab_pin.sym} 3740 47200 0 0 {name=l37857 lab=BLB19}
N 3760 47160 3740 47160 {}
C {lab_pin.sym} 3740 47160 0 0 {name=l37858 lab=WL236}
N 3840 47240 3860 47240 {}
C {lab_pin.sym} 3860 47240 0 0 {name=l37859 lab=VDD}
N 3840 47160 3860 47160 {}
C {lab_pin.sym} 3860 47160 0 0 {name=l37860 lab=VSS}
C {bitcell_6t.sym} 4000 47200 0 0 {name=Xr236c20}
N 3960 47240 3940 47240 {}
C {lab_pin.sym} 3940 47240 0 0 {name=l37861 lab=BL20}
N 3960 47200 3940 47200 {}
C {lab_pin.sym} 3940 47200 0 0 {name=l37862 lab=BLB20}
N 3960 47160 3940 47160 {}
C {lab_pin.sym} 3940 47160 0 0 {name=l37863 lab=WL236}
N 4040 47240 4060 47240 {}
C {lab_pin.sym} 4060 47240 0 0 {name=l37864 lab=VDD}
N 4040 47160 4060 47160 {}
C {lab_pin.sym} 4060 47160 0 0 {name=l37865 lab=VSS}
C {bitcell_6t.sym} 4200 47200 0 0 {name=Xr236c21}
N 4160 47240 4140 47240 {}
C {lab_pin.sym} 4140 47240 0 0 {name=l37866 lab=BL21}
N 4160 47200 4140 47200 {}
C {lab_pin.sym} 4140 47200 0 0 {name=l37867 lab=BLB21}
N 4160 47160 4140 47160 {}
C {lab_pin.sym} 4140 47160 0 0 {name=l37868 lab=WL236}
N 4240 47240 4260 47240 {}
C {lab_pin.sym} 4260 47240 0 0 {name=l37869 lab=VDD}
N 4240 47160 4260 47160 {}
C {lab_pin.sym} 4260 47160 0 0 {name=l37870 lab=VSS}
C {bitcell_6t.sym} 4400 47200 0 0 {name=Xr236c22}
N 4360 47240 4340 47240 {}
C {lab_pin.sym} 4340 47240 0 0 {name=l37871 lab=BL22}
N 4360 47200 4340 47200 {}
C {lab_pin.sym} 4340 47200 0 0 {name=l37872 lab=BLB22}
N 4360 47160 4340 47160 {}
C {lab_pin.sym} 4340 47160 0 0 {name=l37873 lab=WL236}
N 4440 47240 4460 47240 {}
C {lab_pin.sym} 4460 47240 0 0 {name=l37874 lab=VDD}
N 4440 47160 4460 47160 {}
C {lab_pin.sym} 4460 47160 0 0 {name=l37875 lab=VSS}
C {bitcell_6t.sym} 4600 47200 0 0 {name=Xr236c23}
N 4560 47240 4540 47240 {}
C {lab_pin.sym} 4540 47240 0 0 {name=l37876 lab=BL23}
N 4560 47200 4540 47200 {}
C {lab_pin.sym} 4540 47200 0 0 {name=l37877 lab=BLB23}
N 4560 47160 4540 47160 {}
C {lab_pin.sym} 4540 47160 0 0 {name=l37878 lab=WL236}
N 4640 47240 4660 47240 {}
C {lab_pin.sym} 4660 47240 0 0 {name=l37879 lab=VDD}
N 4640 47160 4660 47160 {}
C {lab_pin.sym} 4660 47160 0 0 {name=l37880 lab=VSS}
C {bitcell_6t.sym} 4800 47200 0 0 {name=Xr236c24}
N 4760 47240 4740 47240 {}
C {lab_pin.sym} 4740 47240 0 0 {name=l37881 lab=BL24}
N 4760 47200 4740 47200 {}
C {lab_pin.sym} 4740 47200 0 0 {name=l37882 lab=BLB24}
N 4760 47160 4740 47160 {}
C {lab_pin.sym} 4740 47160 0 0 {name=l37883 lab=WL236}
N 4840 47240 4860 47240 {}
C {lab_pin.sym} 4860 47240 0 0 {name=l37884 lab=VDD}
N 4840 47160 4860 47160 {}
C {lab_pin.sym} 4860 47160 0 0 {name=l37885 lab=VSS}
C {bitcell_6t.sym} 5000 47200 0 0 {name=Xr236c25}
N 4960 47240 4940 47240 {}
C {lab_pin.sym} 4940 47240 0 0 {name=l37886 lab=BL25}
N 4960 47200 4940 47200 {}
C {lab_pin.sym} 4940 47200 0 0 {name=l37887 lab=BLB25}
N 4960 47160 4940 47160 {}
C {lab_pin.sym} 4940 47160 0 0 {name=l37888 lab=WL236}
N 5040 47240 5060 47240 {}
C {lab_pin.sym} 5060 47240 0 0 {name=l37889 lab=VDD}
N 5040 47160 5060 47160 {}
C {lab_pin.sym} 5060 47160 0 0 {name=l37890 lab=VSS}
C {bitcell_6t.sym} 5200 47200 0 0 {name=Xr236c26}
N 5160 47240 5140 47240 {}
C {lab_pin.sym} 5140 47240 0 0 {name=l37891 lab=BL26}
N 5160 47200 5140 47200 {}
C {lab_pin.sym} 5140 47200 0 0 {name=l37892 lab=BLB26}
N 5160 47160 5140 47160 {}
C {lab_pin.sym} 5140 47160 0 0 {name=l37893 lab=WL236}
N 5240 47240 5260 47240 {}
C {lab_pin.sym} 5260 47240 0 0 {name=l37894 lab=VDD}
N 5240 47160 5260 47160 {}
C {lab_pin.sym} 5260 47160 0 0 {name=l37895 lab=VSS}
C {bitcell_6t.sym} 5400 47200 0 0 {name=Xr236c27}
N 5360 47240 5340 47240 {}
C {lab_pin.sym} 5340 47240 0 0 {name=l37896 lab=BL27}
N 5360 47200 5340 47200 {}
C {lab_pin.sym} 5340 47200 0 0 {name=l37897 lab=BLB27}
N 5360 47160 5340 47160 {}
C {lab_pin.sym} 5340 47160 0 0 {name=l37898 lab=WL236}
N 5440 47240 5460 47240 {}
C {lab_pin.sym} 5460 47240 0 0 {name=l37899 lab=VDD}
N 5440 47160 5460 47160 {}
C {lab_pin.sym} 5460 47160 0 0 {name=l37900 lab=VSS}
C {bitcell_6t.sym} 5600 47200 0 0 {name=Xr236c28}
N 5560 47240 5540 47240 {}
C {lab_pin.sym} 5540 47240 0 0 {name=l37901 lab=BL28}
N 5560 47200 5540 47200 {}
C {lab_pin.sym} 5540 47200 0 0 {name=l37902 lab=BLB28}
N 5560 47160 5540 47160 {}
C {lab_pin.sym} 5540 47160 0 0 {name=l37903 lab=WL236}
N 5640 47240 5660 47240 {}
C {lab_pin.sym} 5660 47240 0 0 {name=l37904 lab=VDD}
N 5640 47160 5660 47160 {}
C {lab_pin.sym} 5660 47160 0 0 {name=l37905 lab=VSS}
C {bitcell_6t.sym} 5800 47200 0 0 {name=Xr236c29}
N 5760 47240 5740 47240 {}
C {lab_pin.sym} 5740 47240 0 0 {name=l37906 lab=BL29}
N 5760 47200 5740 47200 {}
C {lab_pin.sym} 5740 47200 0 0 {name=l37907 lab=BLB29}
N 5760 47160 5740 47160 {}
C {lab_pin.sym} 5740 47160 0 0 {name=l37908 lab=WL236}
N 5840 47240 5860 47240 {}
C {lab_pin.sym} 5860 47240 0 0 {name=l37909 lab=VDD}
N 5840 47160 5860 47160 {}
C {lab_pin.sym} 5860 47160 0 0 {name=l37910 lab=VSS}
C {bitcell_6t.sym} 6000 47200 0 0 {name=Xr236c30}
N 5960 47240 5940 47240 {}
C {lab_pin.sym} 5940 47240 0 0 {name=l37911 lab=BL30}
N 5960 47200 5940 47200 {}
C {lab_pin.sym} 5940 47200 0 0 {name=l37912 lab=BLB30}
N 5960 47160 5940 47160 {}
C {lab_pin.sym} 5940 47160 0 0 {name=l37913 lab=WL236}
N 6040 47240 6060 47240 {}
C {lab_pin.sym} 6060 47240 0 0 {name=l37914 lab=VDD}
N 6040 47160 6060 47160 {}
C {lab_pin.sym} 6060 47160 0 0 {name=l37915 lab=VSS}
C {bitcell_6t.sym} 6200 47200 0 0 {name=Xr236c31}
N 6160 47240 6140 47240 {}
C {lab_pin.sym} 6140 47240 0 0 {name=l37916 lab=BL31}
N 6160 47200 6140 47200 {}
C {lab_pin.sym} 6140 47200 0 0 {name=l37917 lab=BLB31}
N 6160 47160 6140 47160 {}
C {lab_pin.sym} 6140 47160 0 0 {name=l37918 lab=WL236}
N 6240 47240 6260 47240 {}
C {lab_pin.sym} 6260 47240 0 0 {name=l37919 lab=VDD}
N 6240 47160 6260 47160 {}
C {lab_pin.sym} 6260 47160 0 0 {name=l37920 lab=VSS}
C {bitcell_6t.sym} 0 47400 0 0 {name=Xr237c0}
N -40 47440 -60 47440 {}
C {lab_pin.sym} -60 47440 0 0 {name=l37921 lab=BL0}
N -40 47400 -60 47400 {}
C {lab_pin.sym} -60 47400 0 0 {name=l37922 lab=BLB0}
N -40 47360 -60 47360 {}
C {lab_pin.sym} -60 47360 0 0 {name=l37923 lab=WL237}
N 40 47440 60 47440 {}
C {lab_pin.sym} 60 47440 0 0 {name=l37924 lab=VDD}
N 40 47360 60 47360 {}
C {lab_pin.sym} 60 47360 0 0 {name=l37925 lab=VSS}
C {bitcell_6t.sym} 200 47400 0 0 {name=Xr237c1}
N 160 47440 140 47440 {}
C {lab_pin.sym} 140 47440 0 0 {name=l37926 lab=BL1}
N 160 47400 140 47400 {}
C {lab_pin.sym} 140 47400 0 0 {name=l37927 lab=BLB1}
N 160 47360 140 47360 {}
C {lab_pin.sym} 140 47360 0 0 {name=l37928 lab=WL237}
N 240 47440 260 47440 {}
C {lab_pin.sym} 260 47440 0 0 {name=l37929 lab=VDD}
N 240 47360 260 47360 {}
C {lab_pin.sym} 260 47360 0 0 {name=l37930 lab=VSS}
C {bitcell_6t.sym} 400 47400 0 0 {name=Xr237c2}
N 360 47440 340 47440 {}
C {lab_pin.sym} 340 47440 0 0 {name=l37931 lab=BL2}
N 360 47400 340 47400 {}
C {lab_pin.sym} 340 47400 0 0 {name=l37932 lab=BLB2}
N 360 47360 340 47360 {}
C {lab_pin.sym} 340 47360 0 0 {name=l37933 lab=WL237}
N 440 47440 460 47440 {}
C {lab_pin.sym} 460 47440 0 0 {name=l37934 lab=VDD}
N 440 47360 460 47360 {}
C {lab_pin.sym} 460 47360 0 0 {name=l37935 lab=VSS}
C {bitcell_6t.sym} 600 47400 0 0 {name=Xr237c3}
N 560 47440 540 47440 {}
C {lab_pin.sym} 540 47440 0 0 {name=l37936 lab=BL3}
N 560 47400 540 47400 {}
C {lab_pin.sym} 540 47400 0 0 {name=l37937 lab=BLB3}
N 560 47360 540 47360 {}
C {lab_pin.sym} 540 47360 0 0 {name=l37938 lab=WL237}
N 640 47440 660 47440 {}
C {lab_pin.sym} 660 47440 0 0 {name=l37939 lab=VDD}
N 640 47360 660 47360 {}
C {lab_pin.sym} 660 47360 0 0 {name=l37940 lab=VSS}
C {bitcell_6t.sym} 800 47400 0 0 {name=Xr237c4}
N 760 47440 740 47440 {}
C {lab_pin.sym} 740 47440 0 0 {name=l37941 lab=BL4}
N 760 47400 740 47400 {}
C {lab_pin.sym} 740 47400 0 0 {name=l37942 lab=BLB4}
N 760 47360 740 47360 {}
C {lab_pin.sym} 740 47360 0 0 {name=l37943 lab=WL237}
N 840 47440 860 47440 {}
C {lab_pin.sym} 860 47440 0 0 {name=l37944 lab=VDD}
N 840 47360 860 47360 {}
C {lab_pin.sym} 860 47360 0 0 {name=l37945 lab=VSS}
C {bitcell_6t.sym} 1000 47400 0 0 {name=Xr237c5}
N 960 47440 940 47440 {}
C {lab_pin.sym} 940 47440 0 0 {name=l37946 lab=BL5}
N 960 47400 940 47400 {}
C {lab_pin.sym} 940 47400 0 0 {name=l37947 lab=BLB5}
N 960 47360 940 47360 {}
C {lab_pin.sym} 940 47360 0 0 {name=l37948 lab=WL237}
N 1040 47440 1060 47440 {}
C {lab_pin.sym} 1060 47440 0 0 {name=l37949 lab=VDD}
N 1040 47360 1060 47360 {}
C {lab_pin.sym} 1060 47360 0 0 {name=l37950 lab=VSS}
C {bitcell_6t.sym} 1200 47400 0 0 {name=Xr237c6}
N 1160 47440 1140 47440 {}
C {lab_pin.sym} 1140 47440 0 0 {name=l37951 lab=BL6}
N 1160 47400 1140 47400 {}
C {lab_pin.sym} 1140 47400 0 0 {name=l37952 lab=BLB6}
N 1160 47360 1140 47360 {}
C {lab_pin.sym} 1140 47360 0 0 {name=l37953 lab=WL237}
N 1240 47440 1260 47440 {}
C {lab_pin.sym} 1260 47440 0 0 {name=l37954 lab=VDD}
N 1240 47360 1260 47360 {}
C {lab_pin.sym} 1260 47360 0 0 {name=l37955 lab=VSS}
C {bitcell_6t.sym} 1400 47400 0 0 {name=Xr237c7}
N 1360 47440 1340 47440 {}
C {lab_pin.sym} 1340 47440 0 0 {name=l37956 lab=BL7}
N 1360 47400 1340 47400 {}
C {lab_pin.sym} 1340 47400 0 0 {name=l37957 lab=BLB7}
N 1360 47360 1340 47360 {}
C {lab_pin.sym} 1340 47360 0 0 {name=l37958 lab=WL237}
N 1440 47440 1460 47440 {}
C {lab_pin.sym} 1460 47440 0 0 {name=l37959 lab=VDD}
N 1440 47360 1460 47360 {}
C {lab_pin.sym} 1460 47360 0 0 {name=l37960 lab=VSS}
C {bitcell_6t.sym} 1600 47400 0 0 {name=Xr237c8}
N 1560 47440 1540 47440 {}
C {lab_pin.sym} 1540 47440 0 0 {name=l37961 lab=BL8}
N 1560 47400 1540 47400 {}
C {lab_pin.sym} 1540 47400 0 0 {name=l37962 lab=BLB8}
N 1560 47360 1540 47360 {}
C {lab_pin.sym} 1540 47360 0 0 {name=l37963 lab=WL237}
N 1640 47440 1660 47440 {}
C {lab_pin.sym} 1660 47440 0 0 {name=l37964 lab=VDD}
N 1640 47360 1660 47360 {}
C {lab_pin.sym} 1660 47360 0 0 {name=l37965 lab=VSS}
C {bitcell_6t.sym} 1800 47400 0 0 {name=Xr237c9}
N 1760 47440 1740 47440 {}
C {lab_pin.sym} 1740 47440 0 0 {name=l37966 lab=BL9}
N 1760 47400 1740 47400 {}
C {lab_pin.sym} 1740 47400 0 0 {name=l37967 lab=BLB9}
N 1760 47360 1740 47360 {}
C {lab_pin.sym} 1740 47360 0 0 {name=l37968 lab=WL237}
N 1840 47440 1860 47440 {}
C {lab_pin.sym} 1860 47440 0 0 {name=l37969 lab=VDD}
N 1840 47360 1860 47360 {}
C {lab_pin.sym} 1860 47360 0 0 {name=l37970 lab=VSS}
C {bitcell_6t.sym} 2000 47400 0 0 {name=Xr237c10}
N 1960 47440 1940 47440 {}
C {lab_pin.sym} 1940 47440 0 0 {name=l37971 lab=BL10}
N 1960 47400 1940 47400 {}
C {lab_pin.sym} 1940 47400 0 0 {name=l37972 lab=BLB10}
N 1960 47360 1940 47360 {}
C {lab_pin.sym} 1940 47360 0 0 {name=l37973 lab=WL237}
N 2040 47440 2060 47440 {}
C {lab_pin.sym} 2060 47440 0 0 {name=l37974 lab=VDD}
N 2040 47360 2060 47360 {}
C {lab_pin.sym} 2060 47360 0 0 {name=l37975 lab=VSS}
C {bitcell_6t.sym} 2200 47400 0 0 {name=Xr237c11}
N 2160 47440 2140 47440 {}
C {lab_pin.sym} 2140 47440 0 0 {name=l37976 lab=BL11}
N 2160 47400 2140 47400 {}
C {lab_pin.sym} 2140 47400 0 0 {name=l37977 lab=BLB11}
N 2160 47360 2140 47360 {}
C {lab_pin.sym} 2140 47360 0 0 {name=l37978 lab=WL237}
N 2240 47440 2260 47440 {}
C {lab_pin.sym} 2260 47440 0 0 {name=l37979 lab=VDD}
N 2240 47360 2260 47360 {}
C {lab_pin.sym} 2260 47360 0 0 {name=l37980 lab=VSS}
C {bitcell_6t.sym} 2400 47400 0 0 {name=Xr237c12}
N 2360 47440 2340 47440 {}
C {lab_pin.sym} 2340 47440 0 0 {name=l37981 lab=BL12}
N 2360 47400 2340 47400 {}
C {lab_pin.sym} 2340 47400 0 0 {name=l37982 lab=BLB12}
N 2360 47360 2340 47360 {}
C {lab_pin.sym} 2340 47360 0 0 {name=l37983 lab=WL237}
N 2440 47440 2460 47440 {}
C {lab_pin.sym} 2460 47440 0 0 {name=l37984 lab=VDD}
N 2440 47360 2460 47360 {}
C {lab_pin.sym} 2460 47360 0 0 {name=l37985 lab=VSS}
C {bitcell_6t.sym} 2600 47400 0 0 {name=Xr237c13}
N 2560 47440 2540 47440 {}
C {lab_pin.sym} 2540 47440 0 0 {name=l37986 lab=BL13}
N 2560 47400 2540 47400 {}
C {lab_pin.sym} 2540 47400 0 0 {name=l37987 lab=BLB13}
N 2560 47360 2540 47360 {}
C {lab_pin.sym} 2540 47360 0 0 {name=l37988 lab=WL237}
N 2640 47440 2660 47440 {}
C {lab_pin.sym} 2660 47440 0 0 {name=l37989 lab=VDD}
N 2640 47360 2660 47360 {}
C {lab_pin.sym} 2660 47360 0 0 {name=l37990 lab=VSS}
C {bitcell_6t.sym} 2800 47400 0 0 {name=Xr237c14}
N 2760 47440 2740 47440 {}
C {lab_pin.sym} 2740 47440 0 0 {name=l37991 lab=BL14}
N 2760 47400 2740 47400 {}
C {lab_pin.sym} 2740 47400 0 0 {name=l37992 lab=BLB14}
N 2760 47360 2740 47360 {}
C {lab_pin.sym} 2740 47360 0 0 {name=l37993 lab=WL237}
N 2840 47440 2860 47440 {}
C {lab_pin.sym} 2860 47440 0 0 {name=l37994 lab=VDD}
N 2840 47360 2860 47360 {}
C {lab_pin.sym} 2860 47360 0 0 {name=l37995 lab=VSS}
C {bitcell_6t.sym} 3000 47400 0 0 {name=Xr237c15}
N 2960 47440 2940 47440 {}
C {lab_pin.sym} 2940 47440 0 0 {name=l37996 lab=BL15}
N 2960 47400 2940 47400 {}
C {lab_pin.sym} 2940 47400 0 0 {name=l37997 lab=BLB15}
N 2960 47360 2940 47360 {}
C {lab_pin.sym} 2940 47360 0 0 {name=l37998 lab=WL237}
N 3040 47440 3060 47440 {}
C {lab_pin.sym} 3060 47440 0 0 {name=l37999 lab=VDD}
N 3040 47360 3060 47360 {}
C {lab_pin.sym} 3060 47360 0 0 {name=l38000 lab=VSS}
C {bitcell_6t.sym} 3200 47400 0 0 {name=Xr237c16}
N 3160 47440 3140 47440 {}
C {lab_pin.sym} 3140 47440 0 0 {name=l38001 lab=BL16}
N 3160 47400 3140 47400 {}
C {lab_pin.sym} 3140 47400 0 0 {name=l38002 lab=BLB16}
N 3160 47360 3140 47360 {}
C {lab_pin.sym} 3140 47360 0 0 {name=l38003 lab=WL237}
N 3240 47440 3260 47440 {}
C {lab_pin.sym} 3260 47440 0 0 {name=l38004 lab=VDD}
N 3240 47360 3260 47360 {}
C {lab_pin.sym} 3260 47360 0 0 {name=l38005 lab=VSS}
C {bitcell_6t.sym} 3400 47400 0 0 {name=Xr237c17}
N 3360 47440 3340 47440 {}
C {lab_pin.sym} 3340 47440 0 0 {name=l38006 lab=BL17}
N 3360 47400 3340 47400 {}
C {lab_pin.sym} 3340 47400 0 0 {name=l38007 lab=BLB17}
N 3360 47360 3340 47360 {}
C {lab_pin.sym} 3340 47360 0 0 {name=l38008 lab=WL237}
N 3440 47440 3460 47440 {}
C {lab_pin.sym} 3460 47440 0 0 {name=l38009 lab=VDD}
N 3440 47360 3460 47360 {}
C {lab_pin.sym} 3460 47360 0 0 {name=l38010 lab=VSS}
C {bitcell_6t.sym} 3600 47400 0 0 {name=Xr237c18}
N 3560 47440 3540 47440 {}
C {lab_pin.sym} 3540 47440 0 0 {name=l38011 lab=BL18}
N 3560 47400 3540 47400 {}
C {lab_pin.sym} 3540 47400 0 0 {name=l38012 lab=BLB18}
N 3560 47360 3540 47360 {}
C {lab_pin.sym} 3540 47360 0 0 {name=l38013 lab=WL237}
N 3640 47440 3660 47440 {}
C {lab_pin.sym} 3660 47440 0 0 {name=l38014 lab=VDD}
N 3640 47360 3660 47360 {}
C {lab_pin.sym} 3660 47360 0 0 {name=l38015 lab=VSS}
C {bitcell_6t.sym} 3800 47400 0 0 {name=Xr237c19}
N 3760 47440 3740 47440 {}
C {lab_pin.sym} 3740 47440 0 0 {name=l38016 lab=BL19}
N 3760 47400 3740 47400 {}
C {lab_pin.sym} 3740 47400 0 0 {name=l38017 lab=BLB19}
N 3760 47360 3740 47360 {}
C {lab_pin.sym} 3740 47360 0 0 {name=l38018 lab=WL237}
N 3840 47440 3860 47440 {}
C {lab_pin.sym} 3860 47440 0 0 {name=l38019 lab=VDD}
N 3840 47360 3860 47360 {}
C {lab_pin.sym} 3860 47360 0 0 {name=l38020 lab=VSS}
C {bitcell_6t.sym} 4000 47400 0 0 {name=Xr237c20}
N 3960 47440 3940 47440 {}
C {lab_pin.sym} 3940 47440 0 0 {name=l38021 lab=BL20}
N 3960 47400 3940 47400 {}
C {lab_pin.sym} 3940 47400 0 0 {name=l38022 lab=BLB20}
N 3960 47360 3940 47360 {}
C {lab_pin.sym} 3940 47360 0 0 {name=l38023 lab=WL237}
N 4040 47440 4060 47440 {}
C {lab_pin.sym} 4060 47440 0 0 {name=l38024 lab=VDD}
N 4040 47360 4060 47360 {}
C {lab_pin.sym} 4060 47360 0 0 {name=l38025 lab=VSS}
C {bitcell_6t.sym} 4200 47400 0 0 {name=Xr237c21}
N 4160 47440 4140 47440 {}
C {lab_pin.sym} 4140 47440 0 0 {name=l38026 lab=BL21}
N 4160 47400 4140 47400 {}
C {lab_pin.sym} 4140 47400 0 0 {name=l38027 lab=BLB21}
N 4160 47360 4140 47360 {}
C {lab_pin.sym} 4140 47360 0 0 {name=l38028 lab=WL237}
N 4240 47440 4260 47440 {}
C {lab_pin.sym} 4260 47440 0 0 {name=l38029 lab=VDD}
N 4240 47360 4260 47360 {}
C {lab_pin.sym} 4260 47360 0 0 {name=l38030 lab=VSS}
C {bitcell_6t.sym} 4400 47400 0 0 {name=Xr237c22}
N 4360 47440 4340 47440 {}
C {lab_pin.sym} 4340 47440 0 0 {name=l38031 lab=BL22}
N 4360 47400 4340 47400 {}
C {lab_pin.sym} 4340 47400 0 0 {name=l38032 lab=BLB22}
N 4360 47360 4340 47360 {}
C {lab_pin.sym} 4340 47360 0 0 {name=l38033 lab=WL237}
N 4440 47440 4460 47440 {}
C {lab_pin.sym} 4460 47440 0 0 {name=l38034 lab=VDD}
N 4440 47360 4460 47360 {}
C {lab_pin.sym} 4460 47360 0 0 {name=l38035 lab=VSS}
C {bitcell_6t.sym} 4600 47400 0 0 {name=Xr237c23}
N 4560 47440 4540 47440 {}
C {lab_pin.sym} 4540 47440 0 0 {name=l38036 lab=BL23}
N 4560 47400 4540 47400 {}
C {lab_pin.sym} 4540 47400 0 0 {name=l38037 lab=BLB23}
N 4560 47360 4540 47360 {}
C {lab_pin.sym} 4540 47360 0 0 {name=l38038 lab=WL237}
N 4640 47440 4660 47440 {}
C {lab_pin.sym} 4660 47440 0 0 {name=l38039 lab=VDD}
N 4640 47360 4660 47360 {}
C {lab_pin.sym} 4660 47360 0 0 {name=l38040 lab=VSS}
C {bitcell_6t.sym} 4800 47400 0 0 {name=Xr237c24}
N 4760 47440 4740 47440 {}
C {lab_pin.sym} 4740 47440 0 0 {name=l38041 lab=BL24}
N 4760 47400 4740 47400 {}
C {lab_pin.sym} 4740 47400 0 0 {name=l38042 lab=BLB24}
N 4760 47360 4740 47360 {}
C {lab_pin.sym} 4740 47360 0 0 {name=l38043 lab=WL237}
N 4840 47440 4860 47440 {}
C {lab_pin.sym} 4860 47440 0 0 {name=l38044 lab=VDD}
N 4840 47360 4860 47360 {}
C {lab_pin.sym} 4860 47360 0 0 {name=l38045 lab=VSS}
C {bitcell_6t.sym} 5000 47400 0 0 {name=Xr237c25}
N 4960 47440 4940 47440 {}
C {lab_pin.sym} 4940 47440 0 0 {name=l38046 lab=BL25}
N 4960 47400 4940 47400 {}
C {lab_pin.sym} 4940 47400 0 0 {name=l38047 lab=BLB25}
N 4960 47360 4940 47360 {}
C {lab_pin.sym} 4940 47360 0 0 {name=l38048 lab=WL237}
N 5040 47440 5060 47440 {}
C {lab_pin.sym} 5060 47440 0 0 {name=l38049 lab=VDD}
N 5040 47360 5060 47360 {}
C {lab_pin.sym} 5060 47360 0 0 {name=l38050 lab=VSS}
C {bitcell_6t.sym} 5200 47400 0 0 {name=Xr237c26}
N 5160 47440 5140 47440 {}
C {lab_pin.sym} 5140 47440 0 0 {name=l38051 lab=BL26}
N 5160 47400 5140 47400 {}
C {lab_pin.sym} 5140 47400 0 0 {name=l38052 lab=BLB26}
N 5160 47360 5140 47360 {}
C {lab_pin.sym} 5140 47360 0 0 {name=l38053 lab=WL237}
N 5240 47440 5260 47440 {}
C {lab_pin.sym} 5260 47440 0 0 {name=l38054 lab=VDD}
N 5240 47360 5260 47360 {}
C {lab_pin.sym} 5260 47360 0 0 {name=l38055 lab=VSS}
C {bitcell_6t.sym} 5400 47400 0 0 {name=Xr237c27}
N 5360 47440 5340 47440 {}
C {lab_pin.sym} 5340 47440 0 0 {name=l38056 lab=BL27}
N 5360 47400 5340 47400 {}
C {lab_pin.sym} 5340 47400 0 0 {name=l38057 lab=BLB27}
N 5360 47360 5340 47360 {}
C {lab_pin.sym} 5340 47360 0 0 {name=l38058 lab=WL237}
N 5440 47440 5460 47440 {}
C {lab_pin.sym} 5460 47440 0 0 {name=l38059 lab=VDD}
N 5440 47360 5460 47360 {}
C {lab_pin.sym} 5460 47360 0 0 {name=l38060 lab=VSS}
C {bitcell_6t.sym} 5600 47400 0 0 {name=Xr237c28}
N 5560 47440 5540 47440 {}
C {lab_pin.sym} 5540 47440 0 0 {name=l38061 lab=BL28}
N 5560 47400 5540 47400 {}
C {lab_pin.sym} 5540 47400 0 0 {name=l38062 lab=BLB28}
N 5560 47360 5540 47360 {}
C {lab_pin.sym} 5540 47360 0 0 {name=l38063 lab=WL237}
N 5640 47440 5660 47440 {}
C {lab_pin.sym} 5660 47440 0 0 {name=l38064 lab=VDD}
N 5640 47360 5660 47360 {}
C {lab_pin.sym} 5660 47360 0 0 {name=l38065 lab=VSS}
C {bitcell_6t.sym} 5800 47400 0 0 {name=Xr237c29}
N 5760 47440 5740 47440 {}
C {lab_pin.sym} 5740 47440 0 0 {name=l38066 lab=BL29}
N 5760 47400 5740 47400 {}
C {lab_pin.sym} 5740 47400 0 0 {name=l38067 lab=BLB29}
N 5760 47360 5740 47360 {}
C {lab_pin.sym} 5740 47360 0 0 {name=l38068 lab=WL237}
N 5840 47440 5860 47440 {}
C {lab_pin.sym} 5860 47440 0 0 {name=l38069 lab=VDD}
N 5840 47360 5860 47360 {}
C {lab_pin.sym} 5860 47360 0 0 {name=l38070 lab=VSS}
C {bitcell_6t.sym} 6000 47400 0 0 {name=Xr237c30}
N 5960 47440 5940 47440 {}
C {lab_pin.sym} 5940 47440 0 0 {name=l38071 lab=BL30}
N 5960 47400 5940 47400 {}
C {lab_pin.sym} 5940 47400 0 0 {name=l38072 lab=BLB30}
N 5960 47360 5940 47360 {}
C {lab_pin.sym} 5940 47360 0 0 {name=l38073 lab=WL237}
N 6040 47440 6060 47440 {}
C {lab_pin.sym} 6060 47440 0 0 {name=l38074 lab=VDD}
N 6040 47360 6060 47360 {}
C {lab_pin.sym} 6060 47360 0 0 {name=l38075 lab=VSS}
C {bitcell_6t.sym} 6200 47400 0 0 {name=Xr237c31}
N 6160 47440 6140 47440 {}
C {lab_pin.sym} 6140 47440 0 0 {name=l38076 lab=BL31}
N 6160 47400 6140 47400 {}
C {lab_pin.sym} 6140 47400 0 0 {name=l38077 lab=BLB31}
N 6160 47360 6140 47360 {}
C {lab_pin.sym} 6140 47360 0 0 {name=l38078 lab=WL237}
N 6240 47440 6260 47440 {}
C {lab_pin.sym} 6260 47440 0 0 {name=l38079 lab=VDD}
N 6240 47360 6260 47360 {}
C {lab_pin.sym} 6260 47360 0 0 {name=l38080 lab=VSS}
C {bitcell_6t.sym} 0 47600 0 0 {name=Xr238c0}
N -40 47640 -60 47640 {}
C {lab_pin.sym} -60 47640 0 0 {name=l38081 lab=BL0}
N -40 47600 -60 47600 {}
C {lab_pin.sym} -60 47600 0 0 {name=l38082 lab=BLB0}
N -40 47560 -60 47560 {}
C {lab_pin.sym} -60 47560 0 0 {name=l38083 lab=WL238}
N 40 47640 60 47640 {}
C {lab_pin.sym} 60 47640 0 0 {name=l38084 lab=VDD}
N 40 47560 60 47560 {}
C {lab_pin.sym} 60 47560 0 0 {name=l38085 lab=VSS}
C {bitcell_6t.sym} 200 47600 0 0 {name=Xr238c1}
N 160 47640 140 47640 {}
C {lab_pin.sym} 140 47640 0 0 {name=l38086 lab=BL1}
N 160 47600 140 47600 {}
C {lab_pin.sym} 140 47600 0 0 {name=l38087 lab=BLB1}
N 160 47560 140 47560 {}
C {lab_pin.sym} 140 47560 0 0 {name=l38088 lab=WL238}
N 240 47640 260 47640 {}
C {lab_pin.sym} 260 47640 0 0 {name=l38089 lab=VDD}
N 240 47560 260 47560 {}
C {lab_pin.sym} 260 47560 0 0 {name=l38090 lab=VSS}
C {bitcell_6t.sym} 400 47600 0 0 {name=Xr238c2}
N 360 47640 340 47640 {}
C {lab_pin.sym} 340 47640 0 0 {name=l38091 lab=BL2}
N 360 47600 340 47600 {}
C {lab_pin.sym} 340 47600 0 0 {name=l38092 lab=BLB2}
N 360 47560 340 47560 {}
C {lab_pin.sym} 340 47560 0 0 {name=l38093 lab=WL238}
N 440 47640 460 47640 {}
C {lab_pin.sym} 460 47640 0 0 {name=l38094 lab=VDD}
N 440 47560 460 47560 {}
C {lab_pin.sym} 460 47560 0 0 {name=l38095 lab=VSS}
C {bitcell_6t.sym} 600 47600 0 0 {name=Xr238c3}
N 560 47640 540 47640 {}
C {lab_pin.sym} 540 47640 0 0 {name=l38096 lab=BL3}
N 560 47600 540 47600 {}
C {lab_pin.sym} 540 47600 0 0 {name=l38097 lab=BLB3}
N 560 47560 540 47560 {}
C {lab_pin.sym} 540 47560 0 0 {name=l38098 lab=WL238}
N 640 47640 660 47640 {}
C {lab_pin.sym} 660 47640 0 0 {name=l38099 lab=VDD}
N 640 47560 660 47560 {}
C {lab_pin.sym} 660 47560 0 0 {name=l38100 lab=VSS}
C {bitcell_6t.sym} 800 47600 0 0 {name=Xr238c4}
N 760 47640 740 47640 {}
C {lab_pin.sym} 740 47640 0 0 {name=l38101 lab=BL4}
N 760 47600 740 47600 {}
C {lab_pin.sym} 740 47600 0 0 {name=l38102 lab=BLB4}
N 760 47560 740 47560 {}
C {lab_pin.sym} 740 47560 0 0 {name=l38103 lab=WL238}
N 840 47640 860 47640 {}
C {lab_pin.sym} 860 47640 0 0 {name=l38104 lab=VDD}
N 840 47560 860 47560 {}
C {lab_pin.sym} 860 47560 0 0 {name=l38105 lab=VSS}
C {bitcell_6t.sym} 1000 47600 0 0 {name=Xr238c5}
N 960 47640 940 47640 {}
C {lab_pin.sym} 940 47640 0 0 {name=l38106 lab=BL5}
N 960 47600 940 47600 {}
C {lab_pin.sym} 940 47600 0 0 {name=l38107 lab=BLB5}
N 960 47560 940 47560 {}
C {lab_pin.sym} 940 47560 0 0 {name=l38108 lab=WL238}
N 1040 47640 1060 47640 {}
C {lab_pin.sym} 1060 47640 0 0 {name=l38109 lab=VDD}
N 1040 47560 1060 47560 {}
C {lab_pin.sym} 1060 47560 0 0 {name=l38110 lab=VSS}
C {bitcell_6t.sym} 1200 47600 0 0 {name=Xr238c6}
N 1160 47640 1140 47640 {}
C {lab_pin.sym} 1140 47640 0 0 {name=l38111 lab=BL6}
N 1160 47600 1140 47600 {}
C {lab_pin.sym} 1140 47600 0 0 {name=l38112 lab=BLB6}
N 1160 47560 1140 47560 {}
C {lab_pin.sym} 1140 47560 0 0 {name=l38113 lab=WL238}
N 1240 47640 1260 47640 {}
C {lab_pin.sym} 1260 47640 0 0 {name=l38114 lab=VDD}
N 1240 47560 1260 47560 {}
C {lab_pin.sym} 1260 47560 0 0 {name=l38115 lab=VSS}
C {bitcell_6t.sym} 1400 47600 0 0 {name=Xr238c7}
N 1360 47640 1340 47640 {}
C {lab_pin.sym} 1340 47640 0 0 {name=l38116 lab=BL7}
N 1360 47600 1340 47600 {}
C {lab_pin.sym} 1340 47600 0 0 {name=l38117 lab=BLB7}
N 1360 47560 1340 47560 {}
C {lab_pin.sym} 1340 47560 0 0 {name=l38118 lab=WL238}
N 1440 47640 1460 47640 {}
C {lab_pin.sym} 1460 47640 0 0 {name=l38119 lab=VDD}
N 1440 47560 1460 47560 {}
C {lab_pin.sym} 1460 47560 0 0 {name=l38120 lab=VSS}
C {bitcell_6t.sym} 1600 47600 0 0 {name=Xr238c8}
N 1560 47640 1540 47640 {}
C {lab_pin.sym} 1540 47640 0 0 {name=l38121 lab=BL8}
N 1560 47600 1540 47600 {}
C {lab_pin.sym} 1540 47600 0 0 {name=l38122 lab=BLB8}
N 1560 47560 1540 47560 {}
C {lab_pin.sym} 1540 47560 0 0 {name=l38123 lab=WL238}
N 1640 47640 1660 47640 {}
C {lab_pin.sym} 1660 47640 0 0 {name=l38124 lab=VDD}
N 1640 47560 1660 47560 {}
C {lab_pin.sym} 1660 47560 0 0 {name=l38125 lab=VSS}
C {bitcell_6t.sym} 1800 47600 0 0 {name=Xr238c9}
N 1760 47640 1740 47640 {}
C {lab_pin.sym} 1740 47640 0 0 {name=l38126 lab=BL9}
N 1760 47600 1740 47600 {}
C {lab_pin.sym} 1740 47600 0 0 {name=l38127 lab=BLB9}
N 1760 47560 1740 47560 {}
C {lab_pin.sym} 1740 47560 0 0 {name=l38128 lab=WL238}
N 1840 47640 1860 47640 {}
C {lab_pin.sym} 1860 47640 0 0 {name=l38129 lab=VDD}
N 1840 47560 1860 47560 {}
C {lab_pin.sym} 1860 47560 0 0 {name=l38130 lab=VSS}
C {bitcell_6t.sym} 2000 47600 0 0 {name=Xr238c10}
N 1960 47640 1940 47640 {}
C {lab_pin.sym} 1940 47640 0 0 {name=l38131 lab=BL10}
N 1960 47600 1940 47600 {}
C {lab_pin.sym} 1940 47600 0 0 {name=l38132 lab=BLB10}
N 1960 47560 1940 47560 {}
C {lab_pin.sym} 1940 47560 0 0 {name=l38133 lab=WL238}
N 2040 47640 2060 47640 {}
C {lab_pin.sym} 2060 47640 0 0 {name=l38134 lab=VDD}
N 2040 47560 2060 47560 {}
C {lab_pin.sym} 2060 47560 0 0 {name=l38135 lab=VSS}
C {bitcell_6t.sym} 2200 47600 0 0 {name=Xr238c11}
N 2160 47640 2140 47640 {}
C {lab_pin.sym} 2140 47640 0 0 {name=l38136 lab=BL11}
N 2160 47600 2140 47600 {}
C {lab_pin.sym} 2140 47600 0 0 {name=l38137 lab=BLB11}
N 2160 47560 2140 47560 {}
C {lab_pin.sym} 2140 47560 0 0 {name=l38138 lab=WL238}
N 2240 47640 2260 47640 {}
C {lab_pin.sym} 2260 47640 0 0 {name=l38139 lab=VDD}
N 2240 47560 2260 47560 {}
C {lab_pin.sym} 2260 47560 0 0 {name=l38140 lab=VSS}
C {bitcell_6t.sym} 2400 47600 0 0 {name=Xr238c12}
N 2360 47640 2340 47640 {}
C {lab_pin.sym} 2340 47640 0 0 {name=l38141 lab=BL12}
N 2360 47600 2340 47600 {}
C {lab_pin.sym} 2340 47600 0 0 {name=l38142 lab=BLB12}
N 2360 47560 2340 47560 {}
C {lab_pin.sym} 2340 47560 0 0 {name=l38143 lab=WL238}
N 2440 47640 2460 47640 {}
C {lab_pin.sym} 2460 47640 0 0 {name=l38144 lab=VDD}
N 2440 47560 2460 47560 {}
C {lab_pin.sym} 2460 47560 0 0 {name=l38145 lab=VSS}
C {bitcell_6t.sym} 2600 47600 0 0 {name=Xr238c13}
N 2560 47640 2540 47640 {}
C {lab_pin.sym} 2540 47640 0 0 {name=l38146 lab=BL13}
N 2560 47600 2540 47600 {}
C {lab_pin.sym} 2540 47600 0 0 {name=l38147 lab=BLB13}
N 2560 47560 2540 47560 {}
C {lab_pin.sym} 2540 47560 0 0 {name=l38148 lab=WL238}
N 2640 47640 2660 47640 {}
C {lab_pin.sym} 2660 47640 0 0 {name=l38149 lab=VDD}
N 2640 47560 2660 47560 {}
C {lab_pin.sym} 2660 47560 0 0 {name=l38150 lab=VSS}
C {bitcell_6t.sym} 2800 47600 0 0 {name=Xr238c14}
N 2760 47640 2740 47640 {}
C {lab_pin.sym} 2740 47640 0 0 {name=l38151 lab=BL14}
N 2760 47600 2740 47600 {}
C {lab_pin.sym} 2740 47600 0 0 {name=l38152 lab=BLB14}
N 2760 47560 2740 47560 {}
C {lab_pin.sym} 2740 47560 0 0 {name=l38153 lab=WL238}
N 2840 47640 2860 47640 {}
C {lab_pin.sym} 2860 47640 0 0 {name=l38154 lab=VDD}
N 2840 47560 2860 47560 {}
C {lab_pin.sym} 2860 47560 0 0 {name=l38155 lab=VSS}
C {bitcell_6t.sym} 3000 47600 0 0 {name=Xr238c15}
N 2960 47640 2940 47640 {}
C {lab_pin.sym} 2940 47640 0 0 {name=l38156 lab=BL15}
N 2960 47600 2940 47600 {}
C {lab_pin.sym} 2940 47600 0 0 {name=l38157 lab=BLB15}
N 2960 47560 2940 47560 {}
C {lab_pin.sym} 2940 47560 0 0 {name=l38158 lab=WL238}
N 3040 47640 3060 47640 {}
C {lab_pin.sym} 3060 47640 0 0 {name=l38159 lab=VDD}
N 3040 47560 3060 47560 {}
C {lab_pin.sym} 3060 47560 0 0 {name=l38160 lab=VSS}
C {bitcell_6t.sym} 3200 47600 0 0 {name=Xr238c16}
N 3160 47640 3140 47640 {}
C {lab_pin.sym} 3140 47640 0 0 {name=l38161 lab=BL16}
N 3160 47600 3140 47600 {}
C {lab_pin.sym} 3140 47600 0 0 {name=l38162 lab=BLB16}
N 3160 47560 3140 47560 {}
C {lab_pin.sym} 3140 47560 0 0 {name=l38163 lab=WL238}
N 3240 47640 3260 47640 {}
C {lab_pin.sym} 3260 47640 0 0 {name=l38164 lab=VDD}
N 3240 47560 3260 47560 {}
C {lab_pin.sym} 3260 47560 0 0 {name=l38165 lab=VSS}
C {bitcell_6t.sym} 3400 47600 0 0 {name=Xr238c17}
N 3360 47640 3340 47640 {}
C {lab_pin.sym} 3340 47640 0 0 {name=l38166 lab=BL17}
N 3360 47600 3340 47600 {}
C {lab_pin.sym} 3340 47600 0 0 {name=l38167 lab=BLB17}
N 3360 47560 3340 47560 {}
C {lab_pin.sym} 3340 47560 0 0 {name=l38168 lab=WL238}
N 3440 47640 3460 47640 {}
C {lab_pin.sym} 3460 47640 0 0 {name=l38169 lab=VDD}
N 3440 47560 3460 47560 {}
C {lab_pin.sym} 3460 47560 0 0 {name=l38170 lab=VSS}
C {bitcell_6t.sym} 3600 47600 0 0 {name=Xr238c18}
N 3560 47640 3540 47640 {}
C {lab_pin.sym} 3540 47640 0 0 {name=l38171 lab=BL18}
N 3560 47600 3540 47600 {}
C {lab_pin.sym} 3540 47600 0 0 {name=l38172 lab=BLB18}
N 3560 47560 3540 47560 {}
C {lab_pin.sym} 3540 47560 0 0 {name=l38173 lab=WL238}
N 3640 47640 3660 47640 {}
C {lab_pin.sym} 3660 47640 0 0 {name=l38174 lab=VDD}
N 3640 47560 3660 47560 {}
C {lab_pin.sym} 3660 47560 0 0 {name=l38175 lab=VSS}
C {bitcell_6t.sym} 3800 47600 0 0 {name=Xr238c19}
N 3760 47640 3740 47640 {}
C {lab_pin.sym} 3740 47640 0 0 {name=l38176 lab=BL19}
N 3760 47600 3740 47600 {}
C {lab_pin.sym} 3740 47600 0 0 {name=l38177 lab=BLB19}
N 3760 47560 3740 47560 {}
C {lab_pin.sym} 3740 47560 0 0 {name=l38178 lab=WL238}
N 3840 47640 3860 47640 {}
C {lab_pin.sym} 3860 47640 0 0 {name=l38179 lab=VDD}
N 3840 47560 3860 47560 {}
C {lab_pin.sym} 3860 47560 0 0 {name=l38180 lab=VSS}
C {bitcell_6t.sym} 4000 47600 0 0 {name=Xr238c20}
N 3960 47640 3940 47640 {}
C {lab_pin.sym} 3940 47640 0 0 {name=l38181 lab=BL20}
N 3960 47600 3940 47600 {}
C {lab_pin.sym} 3940 47600 0 0 {name=l38182 lab=BLB20}
N 3960 47560 3940 47560 {}
C {lab_pin.sym} 3940 47560 0 0 {name=l38183 lab=WL238}
N 4040 47640 4060 47640 {}
C {lab_pin.sym} 4060 47640 0 0 {name=l38184 lab=VDD}
N 4040 47560 4060 47560 {}
C {lab_pin.sym} 4060 47560 0 0 {name=l38185 lab=VSS}
C {bitcell_6t.sym} 4200 47600 0 0 {name=Xr238c21}
N 4160 47640 4140 47640 {}
C {lab_pin.sym} 4140 47640 0 0 {name=l38186 lab=BL21}
N 4160 47600 4140 47600 {}
C {lab_pin.sym} 4140 47600 0 0 {name=l38187 lab=BLB21}
N 4160 47560 4140 47560 {}
C {lab_pin.sym} 4140 47560 0 0 {name=l38188 lab=WL238}
N 4240 47640 4260 47640 {}
C {lab_pin.sym} 4260 47640 0 0 {name=l38189 lab=VDD}
N 4240 47560 4260 47560 {}
C {lab_pin.sym} 4260 47560 0 0 {name=l38190 lab=VSS}
C {bitcell_6t.sym} 4400 47600 0 0 {name=Xr238c22}
N 4360 47640 4340 47640 {}
C {lab_pin.sym} 4340 47640 0 0 {name=l38191 lab=BL22}
N 4360 47600 4340 47600 {}
C {lab_pin.sym} 4340 47600 0 0 {name=l38192 lab=BLB22}
N 4360 47560 4340 47560 {}
C {lab_pin.sym} 4340 47560 0 0 {name=l38193 lab=WL238}
N 4440 47640 4460 47640 {}
C {lab_pin.sym} 4460 47640 0 0 {name=l38194 lab=VDD}
N 4440 47560 4460 47560 {}
C {lab_pin.sym} 4460 47560 0 0 {name=l38195 lab=VSS}
C {bitcell_6t.sym} 4600 47600 0 0 {name=Xr238c23}
N 4560 47640 4540 47640 {}
C {lab_pin.sym} 4540 47640 0 0 {name=l38196 lab=BL23}
N 4560 47600 4540 47600 {}
C {lab_pin.sym} 4540 47600 0 0 {name=l38197 lab=BLB23}
N 4560 47560 4540 47560 {}
C {lab_pin.sym} 4540 47560 0 0 {name=l38198 lab=WL238}
N 4640 47640 4660 47640 {}
C {lab_pin.sym} 4660 47640 0 0 {name=l38199 lab=VDD}
N 4640 47560 4660 47560 {}
C {lab_pin.sym} 4660 47560 0 0 {name=l38200 lab=VSS}
C {bitcell_6t.sym} 4800 47600 0 0 {name=Xr238c24}
N 4760 47640 4740 47640 {}
C {lab_pin.sym} 4740 47640 0 0 {name=l38201 lab=BL24}
N 4760 47600 4740 47600 {}
C {lab_pin.sym} 4740 47600 0 0 {name=l38202 lab=BLB24}
N 4760 47560 4740 47560 {}
C {lab_pin.sym} 4740 47560 0 0 {name=l38203 lab=WL238}
N 4840 47640 4860 47640 {}
C {lab_pin.sym} 4860 47640 0 0 {name=l38204 lab=VDD}
N 4840 47560 4860 47560 {}
C {lab_pin.sym} 4860 47560 0 0 {name=l38205 lab=VSS}
C {bitcell_6t.sym} 5000 47600 0 0 {name=Xr238c25}
N 4960 47640 4940 47640 {}
C {lab_pin.sym} 4940 47640 0 0 {name=l38206 lab=BL25}
N 4960 47600 4940 47600 {}
C {lab_pin.sym} 4940 47600 0 0 {name=l38207 lab=BLB25}
N 4960 47560 4940 47560 {}
C {lab_pin.sym} 4940 47560 0 0 {name=l38208 lab=WL238}
N 5040 47640 5060 47640 {}
C {lab_pin.sym} 5060 47640 0 0 {name=l38209 lab=VDD}
N 5040 47560 5060 47560 {}
C {lab_pin.sym} 5060 47560 0 0 {name=l38210 lab=VSS}
C {bitcell_6t.sym} 5200 47600 0 0 {name=Xr238c26}
N 5160 47640 5140 47640 {}
C {lab_pin.sym} 5140 47640 0 0 {name=l38211 lab=BL26}
N 5160 47600 5140 47600 {}
C {lab_pin.sym} 5140 47600 0 0 {name=l38212 lab=BLB26}
N 5160 47560 5140 47560 {}
C {lab_pin.sym} 5140 47560 0 0 {name=l38213 lab=WL238}
N 5240 47640 5260 47640 {}
C {lab_pin.sym} 5260 47640 0 0 {name=l38214 lab=VDD}
N 5240 47560 5260 47560 {}
C {lab_pin.sym} 5260 47560 0 0 {name=l38215 lab=VSS}
C {bitcell_6t.sym} 5400 47600 0 0 {name=Xr238c27}
N 5360 47640 5340 47640 {}
C {lab_pin.sym} 5340 47640 0 0 {name=l38216 lab=BL27}
N 5360 47600 5340 47600 {}
C {lab_pin.sym} 5340 47600 0 0 {name=l38217 lab=BLB27}
N 5360 47560 5340 47560 {}
C {lab_pin.sym} 5340 47560 0 0 {name=l38218 lab=WL238}
N 5440 47640 5460 47640 {}
C {lab_pin.sym} 5460 47640 0 0 {name=l38219 lab=VDD}
N 5440 47560 5460 47560 {}
C {lab_pin.sym} 5460 47560 0 0 {name=l38220 lab=VSS}
C {bitcell_6t.sym} 5600 47600 0 0 {name=Xr238c28}
N 5560 47640 5540 47640 {}
C {lab_pin.sym} 5540 47640 0 0 {name=l38221 lab=BL28}
N 5560 47600 5540 47600 {}
C {lab_pin.sym} 5540 47600 0 0 {name=l38222 lab=BLB28}
N 5560 47560 5540 47560 {}
C {lab_pin.sym} 5540 47560 0 0 {name=l38223 lab=WL238}
N 5640 47640 5660 47640 {}
C {lab_pin.sym} 5660 47640 0 0 {name=l38224 lab=VDD}
N 5640 47560 5660 47560 {}
C {lab_pin.sym} 5660 47560 0 0 {name=l38225 lab=VSS}
C {bitcell_6t.sym} 5800 47600 0 0 {name=Xr238c29}
N 5760 47640 5740 47640 {}
C {lab_pin.sym} 5740 47640 0 0 {name=l38226 lab=BL29}
N 5760 47600 5740 47600 {}
C {lab_pin.sym} 5740 47600 0 0 {name=l38227 lab=BLB29}
N 5760 47560 5740 47560 {}
C {lab_pin.sym} 5740 47560 0 0 {name=l38228 lab=WL238}
N 5840 47640 5860 47640 {}
C {lab_pin.sym} 5860 47640 0 0 {name=l38229 lab=VDD}
N 5840 47560 5860 47560 {}
C {lab_pin.sym} 5860 47560 0 0 {name=l38230 lab=VSS}
C {bitcell_6t.sym} 6000 47600 0 0 {name=Xr238c30}
N 5960 47640 5940 47640 {}
C {lab_pin.sym} 5940 47640 0 0 {name=l38231 lab=BL30}
N 5960 47600 5940 47600 {}
C {lab_pin.sym} 5940 47600 0 0 {name=l38232 lab=BLB30}
N 5960 47560 5940 47560 {}
C {lab_pin.sym} 5940 47560 0 0 {name=l38233 lab=WL238}
N 6040 47640 6060 47640 {}
C {lab_pin.sym} 6060 47640 0 0 {name=l38234 lab=VDD}
N 6040 47560 6060 47560 {}
C {lab_pin.sym} 6060 47560 0 0 {name=l38235 lab=VSS}
C {bitcell_6t.sym} 6200 47600 0 0 {name=Xr238c31}
N 6160 47640 6140 47640 {}
C {lab_pin.sym} 6140 47640 0 0 {name=l38236 lab=BL31}
N 6160 47600 6140 47600 {}
C {lab_pin.sym} 6140 47600 0 0 {name=l38237 lab=BLB31}
N 6160 47560 6140 47560 {}
C {lab_pin.sym} 6140 47560 0 0 {name=l38238 lab=WL238}
N 6240 47640 6260 47640 {}
C {lab_pin.sym} 6260 47640 0 0 {name=l38239 lab=VDD}
N 6240 47560 6260 47560 {}
C {lab_pin.sym} 6260 47560 0 0 {name=l38240 lab=VSS}
C {bitcell_6t.sym} 0 47800 0 0 {name=Xr239c0}
N -40 47840 -60 47840 {}
C {lab_pin.sym} -60 47840 0 0 {name=l38241 lab=BL0}
N -40 47800 -60 47800 {}
C {lab_pin.sym} -60 47800 0 0 {name=l38242 lab=BLB0}
N -40 47760 -60 47760 {}
C {lab_pin.sym} -60 47760 0 0 {name=l38243 lab=WL239}
N 40 47840 60 47840 {}
C {lab_pin.sym} 60 47840 0 0 {name=l38244 lab=VDD}
N 40 47760 60 47760 {}
C {lab_pin.sym} 60 47760 0 0 {name=l38245 lab=VSS}
C {bitcell_6t.sym} 200 47800 0 0 {name=Xr239c1}
N 160 47840 140 47840 {}
C {lab_pin.sym} 140 47840 0 0 {name=l38246 lab=BL1}
N 160 47800 140 47800 {}
C {lab_pin.sym} 140 47800 0 0 {name=l38247 lab=BLB1}
N 160 47760 140 47760 {}
C {lab_pin.sym} 140 47760 0 0 {name=l38248 lab=WL239}
N 240 47840 260 47840 {}
C {lab_pin.sym} 260 47840 0 0 {name=l38249 lab=VDD}
N 240 47760 260 47760 {}
C {lab_pin.sym} 260 47760 0 0 {name=l38250 lab=VSS}
C {bitcell_6t.sym} 400 47800 0 0 {name=Xr239c2}
N 360 47840 340 47840 {}
C {lab_pin.sym} 340 47840 0 0 {name=l38251 lab=BL2}
N 360 47800 340 47800 {}
C {lab_pin.sym} 340 47800 0 0 {name=l38252 lab=BLB2}
N 360 47760 340 47760 {}
C {lab_pin.sym} 340 47760 0 0 {name=l38253 lab=WL239}
N 440 47840 460 47840 {}
C {lab_pin.sym} 460 47840 0 0 {name=l38254 lab=VDD}
N 440 47760 460 47760 {}
C {lab_pin.sym} 460 47760 0 0 {name=l38255 lab=VSS}
C {bitcell_6t.sym} 600 47800 0 0 {name=Xr239c3}
N 560 47840 540 47840 {}
C {lab_pin.sym} 540 47840 0 0 {name=l38256 lab=BL3}
N 560 47800 540 47800 {}
C {lab_pin.sym} 540 47800 0 0 {name=l38257 lab=BLB3}
N 560 47760 540 47760 {}
C {lab_pin.sym} 540 47760 0 0 {name=l38258 lab=WL239}
N 640 47840 660 47840 {}
C {lab_pin.sym} 660 47840 0 0 {name=l38259 lab=VDD}
N 640 47760 660 47760 {}
C {lab_pin.sym} 660 47760 0 0 {name=l38260 lab=VSS}
C {bitcell_6t.sym} 800 47800 0 0 {name=Xr239c4}
N 760 47840 740 47840 {}
C {lab_pin.sym} 740 47840 0 0 {name=l38261 lab=BL4}
N 760 47800 740 47800 {}
C {lab_pin.sym} 740 47800 0 0 {name=l38262 lab=BLB4}
N 760 47760 740 47760 {}
C {lab_pin.sym} 740 47760 0 0 {name=l38263 lab=WL239}
N 840 47840 860 47840 {}
C {lab_pin.sym} 860 47840 0 0 {name=l38264 lab=VDD}
N 840 47760 860 47760 {}
C {lab_pin.sym} 860 47760 0 0 {name=l38265 lab=VSS}
C {bitcell_6t.sym} 1000 47800 0 0 {name=Xr239c5}
N 960 47840 940 47840 {}
C {lab_pin.sym} 940 47840 0 0 {name=l38266 lab=BL5}
N 960 47800 940 47800 {}
C {lab_pin.sym} 940 47800 0 0 {name=l38267 lab=BLB5}
N 960 47760 940 47760 {}
C {lab_pin.sym} 940 47760 0 0 {name=l38268 lab=WL239}
N 1040 47840 1060 47840 {}
C {lab_pin.sym} 1060 47840 0 0 {name=l38269 lab=VDD}
N 1040 47760 1060 47760 {}
C {lab_pin.sym} 1060 47760 0 0 {name=l38270 lab=VSS}
C {bitcell_6t.sym} 1200 47800 0 0 {name=Xr239c6}
N 1160 47840 1140 47840 {}
C {lab_pin.sym} 1140 47840 0 0 {name=l38271 lab=BL6}
N 1160 47800 1140 47800 {}
C {lab_pin.sym} 1140 47800 0 0 {name=l38272 lab=BLB6}
N 1160 47760 1140 47760 {}
C {lab_pin.sym} 1140 47760 0 0 {name=l38273 lab=WL239}
N 1240 47840 1260 47840 {}
C {lab_pin.sym} 1260 47840 0 0 {name=l38274 lab=VDD}
N 1240 47760 1260 47760 {}
C {lab_pin.sym} 1260 47760 0 0 {name=l38275 lab=VSS}
C {bitcell_6t.sym} 1400 47800 0 0 {name=Xr239c7}
N 1360 47840 1340 47840 {}
C {lab_pin.sym} 1340 47840 0 0 {name=l38276 lab=BL7}
N 1360 47800 1340 47800 {}
C {lab_pin.sym} 1340 47800 0 0 {name=l38277 lab=BLB7}
N 1360 47760 1340 47760 {}
C {lab_pin.sym} 1340 47760 0 0 {name=l38278 lab=WL239}
N 1440 47840 1460 47840 {}
C {lab_pin.sym} 1460 47840 0 0 {name=l38279 lab=VDD}
N 1440 47760 1460 47760 {}
C {lab_pin.sym} 1460 47760 0 0 {name=l38280 lab=VSS}
C {bitcell_6t.sym} 1600 47800 0 0 {name=Xr239c8}
N 1560 47840 1540 47840 {}
C {lab_pin.sym} 1540 47840 0 0 {name=l38281 lab=BL8}
N 1560 47800 1540 47800 {}
C {lab_pin.sym} 1540 47800 0 0 {name=l38282 lab=BLB8}
N 1560 47760 1540 47760 {}
C {lab_pin.sym} 1540 47760 0 0 {name=l38283 lab=WL239}
N 1640 47840 1660 47840 {}
C {lab_pin.sym} 1660 47840 0 0 {name=l38284 lab=VDD}
N 1640 47760 1660 47760 {}
C {lab_pin.sym} 1660 47760 0 0 {name=l38285 lab=VSS}
C {bitcell_6t.sym} 1800 47800 0 0 {name=Xr239c9}
N 1760 47840 1740 47840 {}
C {lab_pin.sym} 1740 47840 0 0 {name=l38286 lab=BL9}
N 1760 47800 1740 47800 {}
C {lab_pin.sym} 1740 47800 0 0 {name=l38287 lab=BLB9}
N 1760 47760 1740 47760 {}
C {lab_pin.sym} 1740 47760 0 0 {name=l38288 lab=WL239}
N 1840 47840 1860 47840 {}
C {lab_pin.sym} 1860 47840 0 0 {name=l38289 lab=VDD}
N 1840 47760 1860 47760 {}
C {lab_pin.sym} 1860 47760 0 0 {name=l38290 lab=VSS}
C {bitcell_6t.sym} 2000 47800 0 0 {name=Xr239c10}
N 1960 47840 1940 47840 {}
C {lab_pin.sym} 1940 47840 0 0 {name=l38291 lab=BL10}
N 1960 47800 1940 47800 {}
C {lab_pin.sym} 1940 47800 0 0 {name=l38292 lab=BLB10}
N 1960 47760 1940 47760 {}
C {lab_pin.sym} 1940 47760 0 0 {name=l38293 lab=WL239}
N 2040 47840 2060 47840 {}
C {lab_pin.sym} 2060 47840 0 0 {name=l38294 lab=VDD}
N 2040 47760 2060 47760 {}
C {lab_pin.sym} 2060 47760 0 0 {name=l38295 lab=VSS}
C {bitcell_6t.sym} 2200 47800 0 0 {name=Xr239c11}
N 2160 47840 2140 47840 {}
C {lab_pin.sym} 2140 47840 0 0 {name=l38296 lab=BL11}
N 2160 47800 2140 47800 {}
C {lab_pin.sym} 2140 47800 0 0 {name=l38297 lab=BLB11}
N 2160 47760 2140 47760 {}
C {lab_pin.sym} 2140 47760 0 0 {name=l38298 lab=WL239}
N 2240 47840 2260 47840 {}
C {lab_pin.sym} 2260 47840 0 0 {name=l38299 lab=VDD}
N 2240 47760 2260 47760 {}
C {lab_pin.sym} 2260 47760 0 0 {name=l38300 lab=VSS}
C {bitcell_6t.sym} 2400 47800 0 0 {name=Xr239c12}
N 2360 47840 2340 47840 {}
C {lab_pin.sym} 2340 47840 0 0 {name=l38301 lab=BL12}
N 2360 47800 2340 47800 {}
C {lab_pin.sym} 2340 47800 0 0 {name=l38302 lab=BLB12}
N 2360 47760 2340 47760 {}
C {lab_pin.sym} 2340 47760 0 0 {name=l38303 lab=WL239}
N 2440 47840 2460 47840 {}
C {lab_pin.sym} 2460 47840 0 0 {name=l38304 lab=VDD}
N 2440 47760 2460 47760 {}
C {lab_pin.sym} 2460 47760 0 0 {name=l38305 lab=VSS}
C {bitcell_6t.sym} 2600 47800 0 0 {name=Xr239c13}
N 2560 47840 2540 47840 {}
C {lab_pin.sym} 2540 47840 0 0 {name=l38306 lab=BL13}
N 2560 47800 2540 47800 {}
C {lab_pin.sym} 2540 47800 0 0 {name=l38307 lab=BLB13}
N 2560 47760 2540 47760 {}
C {lab_pin.sym} 2540 47760 0 0 {name=l38308 lab=WL239}
N 2640 47840 2660 47840 {}
C {lab_pin.sym} 2660 47840 0 0 {name=l38309 lab=VDD}
N 2640 47760 2660 47760 {}
C {lab_pin.sym} 2660 47760 0 0 {name=l38310 lab=VSS}
C {bitcell_6t.sym} 2800 47800 0 0 {name=Xr239c14}
N 2760 47840 2740 47840 {}
C {lab_pin.sym} 2740 47840 0 0 {name=l38311 lab=BL14}
N 2760 47800 2740 47800 {}
C {lab_pin.sym} 2740 47800 0 0 {name=l38312 lab=BLB14}
N 2760 47760 2740 47760 {}
C {lab_pin.sym} 2740 47760 0 0 {name=l38313 lab=WL239}
N 2840 47840 2860 47840 {}
C {lab_pin.sym} 2860 47840 0 0 {name=l38314 lab=VDD}
N 2840 47760 2860 47760 {}
C {lab_pin.sym} 2860 47760 0 0 {name=l38315 lab=VSS}
C {bitcell_6t.sym} 3000 47800 0 0 {name=Xr239c15}
N 2960 47840 2940 47840 {}
C {lab_pin.sym} 2940 47840 0 0 {name=l38316 lab=BL15}
N 2960 47800 2940 47800 {}
C {lab_pin.sym} 2940 47800 0 0 {name=l38317 lab=BLB15}
N 2960 47760 2940 47760 {}
C {lab_pin.sym} 2940 47760 0 0 {name=l38318 lab=WL239}
N 3040 47840 3060 47840 {}
C {lab_pin.sym} 3060 47840 0 0 {name=l38319 lab=VDD}
N 3040 47760 3060 47760 {}
C {lab_pin.sym} 3060 47760 0 0 {name=l38320 lab=VSS}
C {bitcell_6t.sym} 3200 47800 0 0 {name=Xr239c16}
N 3160 47840 3140 47840 {}
C {lab_pin.sym} 3140 47840 0 0 {name=l38321 lab=BL16}
N 3160 47800 3140 47800 {}
C {lab_pin.sym} 3140 47800 0 0 {name=l38322 lab=BLB16}
N 3160 47760 3140 47760 {}
C {lab_pin.sym} 3140 47760 0 0 {name=l38323 lab=WL239}
N 3240 47840 3260 47840 {}
C {lab_pin.sym} 3260 47840 0 0 {name=l38324 lab=VDD}
N 3240 47760 3260 47760 {}
C {lab_pin.sym} 3260 47760 0 0 {name=l38325 lab=VSS}
C {bitcell_6t.sym} 3400 47800 0 0 {name=Xr239c17}
N 3360 47840 3340 47840 {}
C {lab_pin.sym} 3340 47840 0 0 {name=l38326 lab=BL17}
N 3360 47800 3340 47800 {}
C {lab_pin.sym} 3340 47800 0 0 {name=l38327 lab=BLB17}
N 3360 47760 3340 47760 {}
C {lab_pin.sym} 3340 47760 0 0 {name=l38328 lab=WL239}
N 3440 47840 3460 47840 {}
C {lab_pin.sym} 3460 47840 0 0 {name=l38329 lab=VDD}
N 3440 47760 3460 47760 {}
C {lab_pin.sym} 3460 47760 0 0 {name=l38330 lab=VSS}
C {bitcell_6t.sym} 3600 47800 0 0 {name=Xr239c18}
N 3560 47840 3540 47840 {}
C {lab_pin.sym} 3540 47840 0 0 {name=l38331 lab=BL18}
N 3560 47800 3540 47800 {}
C {lab_pin.sym} 3540 47800 0 0 {name=l38332 lab=BLB18}
N 3560 47760 3540 47760 {}
C {lab_pin.sym} 3540 47760 0 0 {name=l38333 lab=WL239}
N 3640 47840 3660 47840 {}
C {lab_pin.sym} 3660 47840 0 0 {name=l38334 lab=VDD}
N 3640 47760 3660 47760 {}
C {lab_pin.sym} 3660 47760 0 0 {name=l38335 lab=VSS}
C {bitcell_6t.sym} 3800 47800 0 0 {name=Xr239c19}
N 3760 47840 3740 47840 {}
C {lab_pin.sym} 3740 47840 0 0 {name=l38336 lab=BL19}
N 3760 47800 3740 47800 {}
C {lab_pin.sym} 3740 47800 0 0 {name=l38337 lab=BLB19}
N 3760 47760 3740 47760 {}
C {lab_pin.sym} 3740 47760 0 0 {name=l38338 lab=WL239}
N 3840 47840 3860 47840 {}
C {lab_pin.sym} 3860 47840 0 0 {name=l38339 lab=VDD}
N 3840 47760 3860 47760 {}
C {lab_pin.sym} 3860 47760 0 0 {name=l38340 lab=VSS}
C {bitcell_6t.sym} 4000 47800 0 0 {name=Xr239c20}
N 3960 47840 3940 47840 {}
C {lab_pin.sym} 3940 47840 0 0 {name=l38341 lab=BL20}
N 3960 47800 3940 47800 {}
C {lab_pin.sym} 3940 47800 0 0 {name=l38342 lab=BLB20}
N 3960 47760 3940 47760 {}
C {lab_pin.sym} 3940 47760 0 0 {name=l38343 lab=WL239}
N 4040 47840 4060 47840 {}
C {lab_pin.sym} 4060 47840 0 0 {name=l38344 lab=VDD}
N 4040 47760 4060 47760 {}
C {lab_pin.sym} 4060 47760 0 0 {name=l38345 lab=VSS}
C {bitcell_6t.sym} 4200 47800 0 0 {name=Xr239c21}
N 4160 47840 4140 47840 {}
C {lab_pin.sym} 4140 47840 0 0 {name=l38346 lab=BL21}
N 4160 47800 4140 47800 {}
C {lab_pin.sym} 4140 47800 0 0 {name=l38347 lab=BLB21}
N 4160 47760 4140 47760 {}
C {lab_pin.sym} 4140 47760 0 0 {name=l38348 lab=WL239}
N 4240 47840 4260 47840 {}
C {lab_pin.sym} 4260 47840 0 0 {name=l38349 lab=VDD}
N 4240 47760 4260 47760 {}
C {lab_pin.sym} 4260 47760 0 0 {name=l38350 lab=VSS}
C {bitcell_6t.sym} 4400 47800 0 0 {name=Xr239c22}
N 4360 47840 4340 47840 {}
C {lab_pin.sym} 4340 47840 0 0 {name=l38351 lab=BL22}
N 4360 47800 4340 47800 {}
C {lab_pin.sym} 4340 47800 0 0 {name=l38352 lab=BLB22}
N 4360 47760 4340 47760 {}
C {lab_pin.sym} 4340 47760 0 0 {name=l38353 lab=WL239}
N 4440 47840 4460 47840 {}
C {lab_pin.sym} 4460 47840 0 0 {name=l38354 lab=VDD}
N 4440 47760 4460 47760 {}
C {lab_pin.sym} 4460 47760 0 0 {name=l38355 lab=VSS}
C {bitcell_6t.sym} 4600 47800 0 0 {name=Xr239c23}
N 4560 47840 4540 47840 {}
C {lab_pin.sym} 4540 47840 0 0 {name=l38356 lab=BL23}
N 4560 47800 4540 47800 {}
C {lab_pin.sym} 4540 47800 0 0 {name=l38357 lab=BLB23}
N 4560 47760 4540 47760 {}
C {lab_pin.sym} 4540 47760 0 0 {name=l38358 lab=WL239}
N 4640 47840 4660 47840 {}
C {lab_pin.sym} 4660 47840 0 0 {name=l38359 lab=VDD}
N 4640 47760 4660 47760 {}
C {lab_pin.sym} 4660 47760 0 0 {name=l38360 lab=VSS}
C {bitcell_6t.sym} 4800 47800 0 0 {name=Xr239c24}
N 4760 47840 4740 47840 {}
C {lab_pin.sym} 4740 47840 0 0 {name=l38361 lab=BL24}
N 4760 47800 4740 47800 {}
C {lab_pin.sym} 4740 47800 0 0 {name=l38362 lab=BLB24}
N 4760 47760 4740 47760 {}
C {lab_pin.sym} 4740 47760 0 0 {name=l38363 lab=WL239}
N 4840 47840 4860 47840 {}
C {lab_pin.sym} 4860 47840 0 0 {name=l38364 lab=VDD}
N 4840 47760 4860 47760 {}
C {lab_pin.sym} 4860 47760 0 0 {name=l38365 lab=VSS}
C {bitcell_6t.sym} 5000 47800 0 0 {name=Xr239c25}
N 4960 47840 4940 47840 {}
C {lab_pin.sym} 4940 47840 0 0 {name=l38366 lab=BL25}
N 4960 47800 4940 47800 {}
C {lab_pin.sym} 4940 47800 0 0 {name=l38367 lab=BLB25}
N 4960 47760 4940 47760 {}
C {lab_pin.sym} 4940 47760 0 0 {name=l38368 lab=WL239}
N 5040 47840 5060 47840 {}
C {lab_pin.sym} 5060 47840 0 0 {name=l38369 lab=VDD}
N 5040 47760 5060 47760 {}
C {lab_pin.sym} 5060 47760 0 0 {name=l38370 lab=VSS}
C {bitcell_6t.sym} 5200 47800 0 0 {name=Xr239c26}
N 5160 47840 5140 47840 {}
C {lab_pin.sym} 5140 47840 0 0 {name=l38371 lab=BL26}
N 5160 47800 5140 47800 {}
C {lab_pin.sym} 5140 47800 0 0 {name=l38372 lab=BLB26}
N 5160 47760 5140 47760 {}
C {lab_pin.sym} 5140 47760 0 0 {name=l38373 lab=WL239}
N 5240 47840 5260 47840 {}
C {lab_pin.sym} 5260 47840 0 0 {name=l38374 lab=VDD}
N 5240 47760 5260 47760 {}
C {lab_pin.sym} 5260 47760 0 0 {name=l38375 lab=VSS}
C {bitcell_6t.sym} 5400 47800 0 0 {name=Xr239c27}
N 5360 47840 5340 47840 {}
C {lab_pin.sym} 5340 47840 0 0 {name=l38376 lab=BL27}
N 5360 47800 5340 47800 {}
C {lab_pin.sym} 5340 47800 0 0 {name=l38377 lab=BLB27}
N 5360 47760 5340 47760 {}
C {lab_pin.sym} 5340 47760 0 0 {name=l38378 lab=WL239}
N 5440 47840 5460 47840 {}
C {lab_pin.sym} 5460 47840 0 0 {name=l38379 lab=VDD}
N 5440 47760 5460 47760 {}
C {lab_pin.sym} 5460 47760 0 0 {name=l38380 lab=VSS}
C {bitcell_6t.sym} 5600 47800 0 0 {name=Xr239c28}
N 5560 47840 5540 47840 {}
C {lab_pin.sym} 5540 47840 0 0 {name=l38381 lab=BL28}
N 5560 47800 5540 47800 {}
C {lab_pin.sym} 5540 47800 0 0 {name=l38382 lab=BLB28}
N 5560 47760 5540 47760 {}
C {lab_pin.sym} 5540 47760 0 0 {name=l38383 lab=WL239}
N 5640 47840 5660 47840 {}
C {lab_pin.sym} 5660 47840 0 0 {name=l38384 lab=VDD}
N 5640 47760 5660 47760 {}
C {lab_pin.sym} 5660 47760 0 0 {name=l38385 lab=VSS}
C {bitcell_6t.sym} 5800 47800 0 0 {name=Xr239c29}
N 5760 47840 5740 47840 {}
C {lab_pin.sym} 5740 47840 0 0 {name=l38386 lab=BL29}
N 5760 47800 5740 47800 {}
C {lab_pin.sym} 5740 47800 0 0 {name=l38387 lab=BLB29}
N 5760 47760 5740 47760 {}
C {lab_pin.sym} 5740 47760 0 0 {name=l38388 lab=WL239}
N 5840 47840 5860 47840 {}
C {lab_pin.sym} 5860 47840 0 0 {name=l38389 lab=VDD}
N 5840 47760 5860 47760 {}
C {lab_pin.sym} 5860 47760 0 0 {name=l38390 lab=VSS}
C {bitcell_6t.sym} 6000 47800 0 0 {name=Xr239c30}
N 5960 47840 5940 47840 {}
C {lab_pin.sym} 5940 47840 0 0 {name=l38391 lab=BL30}
N 5960 47800 5940 47800 {}
C {lab_pin.sym} 5940 47800 0 0 {name=l38392 lab=BLB30}
N 5960 47760 5940 47760 {}
C {lab_pin.sym} 5940 47760 0 0 {name=l38393 lab=WL239}
N 6040 47840 6060 47840 {}
C {lab_pin.sym} 6060 47840 0 0 {name=l38394 lab=VDD}
N 6040 47760 6060 47760 {}
C {lab_pin.sym} 6060 47760 0 0 {name=l38395 lab=VSS}
C {bitcell_6t.sym} 6200 47800 0 0 {name=Xr239c31}
N 6160 47840 6140 47840 {}
C {lab_pin.sym} 6140 47840 0 0 {name=l38396 lab=BL31}
N 6160 47800 6140 47800 {}
C {lab_pin.sym} 6140 47800 0 0 {name=l38397 lab=BLB31}
N 6160 47760 6140 47760 {}
C {lab_pin.sym} 6140 47760 0 0 {name=l38398 lab=WL239}
N 6240 47840 6260 47840 {}
C {lab_pin.sym} 6260 47840 0 0 {name=l38399 lab=VDD}
N 6240 47760 6260 47760 {}
C {lab_pin.sym} 6260 47760 0 0 {name=l38400 lab=VSS}
C {bitcell_6t.sym} 0 48000 0 0 {name=Xr240c0}
N -40 48040 -60 48040 {}
C {lab_pin.sym} -60 48040 0 0 {name=l38401 lab=BL0}
N -40 48000 -60 48000 {}
C {lab_pin.sym} -60 48000 0 0 {name=l38402 lab=BLB0}
N -40 47960 -60 47960 {}
C {lab_pin.sym} -60 47960 0 0 {name=l38403 lab=WL240}
N 40 48040 60 48040 {}
C {lab_pin.sym} 60 48040 0 0 {name=l38404 lab=VDD}
N 40 47960 60 47960 {}
C {lab_pin.sym} 60 47960 0 0 {name=l38405 lab=VSS}
C {bitcell_6t.sym} 200 48000 0 0 {name=Xr240c1}
N 160 48040 140 48040 {}
C {lab_pin.sym} 140 48040 0 0 {name=l38406 lab=BL1}
N 160 48000 140 48000 {}
C {lab_pin.sym} 140 48000 0 0 {name=l38407 lab=BLB1}
N 160 47960 140 47960 {}
C {lab_pin.sym} 140 47960 0 0 {name=l38408 lab=WL240}
N 240 48040 260 48040 {}
C {lab_pin.sym} 260 48040 0 0 {name=l38409 lab=VDD}
N 240 47960 260 47960 {}
C {lab_pin.sym} 260 47960 0 0 {name=l38410 lab=VSS}
C {bitcell_6t.sym} 400 48000 0 0 {name=Xr240c2}
N 360 48040 340 48040 {}
C {lab_pin.sym} 340 48040 0 0 {name=l38411 lab=BL2}
N 360 48000 340 48000 {}
C {lab_pin.sym} 340 48000 0 0 {name=l38412 lab=BLB2}
N 360 47960 340 47960 {}
C {lab_pin.sym} 340 47960 0 0 {name=l38413 lab=WL240}
N 440 48040 460 48040 {}
C {lab_pin.sym} 460 48040 0 0 {name=l38414 lab=VDD}
N 440 47960 460 47960 {}
C {lab_pin.sym} 460 47960 0 0 {name=l38415 lab=VSS}
C {bitcell_6t.sym} 600 48000 0 0 {name=Xr240c3}
N 560 48040 540 48040 {}
C {lab_pin.sym} 540 48040 0 0 {name=l38416 lab=BL3}
N 560 48000 540 48000 {}
C {lab_pin.sym} 540 48000 0 0 {name=l38417 lab=BLB3}
N 560 47960 540 47960 {}
C {lab_pin.sym} 540 47960 0 0 {name=l38418 lab=WL240}
N 640 48040 660 48040 {}
C {lab_pin.sym} 660 48040 0 0 {name=l38419 lab=VDD}
N 640 47960 660 47960 {}
C {lab_pin.sym} 660 47960 0 0 {name=l38420 lab=VSS}
C {bitcell_6t.sym} 800 48000 0 0 {name=Xr240c4}
N 760 48040 740 48040 {}
C {lab_pin.sym} 740 48040 0 0 {name=l38421 lab=BL4}
N 760 48000 740 48000 {}
C {lab_pin.sym} 740 48000 0 0 {name=l38422 lab=BLB4}
N 760 47960 740 47960 {}
C {lab_pin.sym} 740 47960 0 0 {name=l38423 lab=WL240}
N 840 48040 860 48040 {}
C {lab_pin.sym} 860 48040 0 0 {name=l38424 lab=VDD}
N 840 47960 860 47960 {}
C {lab_pin.sym} 860 47960 0 0 {name=l38425 lab=VSS}
C {bitcell_6t.sym} 1000 48000 0 0 {name=Xr240c5}
N 960 48040 940 48040 {}
C {lab_pin.sym} 940 48040 0 0 {name=l38426 lab=BL5}
N 960 48000 940 48000 {}
C {lab_pin.sym} 940 48000 0 0 {name=l38427 lab=BLB5}
N 960 47960 940 47960 {}
C {lab_pin.sym} 940 47960 0 0 {name=l38428 lab=WL240}
N 1040 48040 1060 48040 {}
C {lab_pin.sym} 1060 48040 0 0 {name=l38429 lab=VDD}
N 1040 47960 1060 47960 {}
C {lab_pin.sym} 1060 47960 0 0 {name=l38430 lab=VSS}
C {bitcell_6t.sym} 1200 48000 0 0 {name=Xr240c6}
N 1160 48040 1140 48040 {}
C {lab_pin.sym} 1140 48040 0 0 {name=l38431 lab=BL6}
N 1160 48000 1140 48000 {}
C {lab_pin.sym} 1140 48000 0 0 {name=l38432 lab=BLB6}
N 1160 47960 1140 47960 {}
C {lab_pin.sym} 1140 47960 0 0 {name=l38433 lab=WL240}
N 1240 48040 1260 48040 {}
C {lab_pin.sym} 1260 48040 0 0 {name=l38434 lab=VDD}
N 1240 47960 1260 47960 {}
C {lab_pin.sym} 1260 47960 0 0 {name=l38435 lab=VSS}
C {bitcell_6t.sym} 1400 48000 0 0 {name=Xr240c7}
N 1360 48040 1340 48040 {}
C {lab_pin.sym} 1340 48040 0 0 {name=l38436 lab=BL7}
N 1360 48000 1340 48000 {}
C {lab_pin.sym} 1340 48000 0 0 {name=l38437 lab=BLB7}
N 1360 47960 1340 47960 {}
C {lab_pin.sym} 1340 47960 0 0 {name=l38438 lab=WL240}
N 1440 48040 1460 48040 {}
C {lab_pin.sym} 1460 48040 0 0 {name=l38439 lab=VDD}
N 1440 47960 1460 47960 {}
C {lab_pin.sym} 1460 47960 0 0 {name=l38440 lab=VSS}
C {bitcell_6t.sym} 1600 48000 0 0 {name=Xr240c8}
N 1560 48040 1540 48040 {}
C {lab_pin.sym} 1540 48040 0 0 {name=l38441 lab=BL8}
N 1560 48000 1540 48000 {}
C {lab_pin.sym} 1540 48000 0 0 {name=l38442 lab=BLB8}
N 1560 47960 1540 47960 {}
C {lab_pin.sym} 1540 47960 0 0 {name=l38443 lab=WL240}
N 1640 48040 1660 48040 {}
C {lab_pin.sym} 1660 48040 0 0 {name=l38444 lab=VDD}
N 1640 47960 1660 47960 {}
C {lab_pin.sym} 1660 47960 0 0 {name=l38445 lab=VSS}
C {bitcell_6t.sym} 1800 48000 0 0 {name=Xr240c9}
N 1760 48040 1740 48040 {}
C {lab_pin.sym} 1740 48040 0 0 {name=l38446 lab=BL9}
N 1760 48000 1740 48000 {}
C {lab_pin.sym} 1740 48000 0 0 {name=l38447 lab=BLB9}
N 1760 47960 1740 47960 {}
C {lab_pin.sym} 1740 47960 0 0 {name=l38448 lab=WL240}
N 1840 48040 1860 48040 {}
C {lab_pin.sym} 1860 48040 0 0 {name=l38449 lab=VDD}
N 1840 47960 1860 47960 {}
C {lab_pin.sym} 1860 47960 0 0 {name=l38450 lab=VSS}
C {bitcell_6t.sym} 2000 48000 0 0 {name=Xr240c10}
N 1960 48040 1940 48040 {}
C {lab_pin.sym} 1940 48040 0 0 {name=l38451 lab=BL10}
N 1960 48000 1940 48000 {}
C {lab_pin.sym} 1940 48000 0 0 {name=l38452 lab=BLB10}
N 1960 47960 1940 47960 {}
C {lab_pin.sym} 1940 47960 0 0 {name=l38453 lab=WL240}
N 2040 48040 2060 48040 {}
C {lab_pin.sym} 2060 48040 0 0 {name=l38454 lab=VDD}
N 2040 47960 2060 47960 {}
C {lab_pin.sym} 2060 47960 0 0 {name=l38455 lab=VSS}
C {bitcell_6t.sym} 2200 48000 0 0 {name=Xr240c11}
N 2160 48040 2140 48040 {}
C {lab_pin.sym} 2140 48040 0 0 {name=l38456 lab=BL11}
N 2160 48000 2140 48000 {}
C {lab_pin.sym} 2140 48000 0 0 {name=l38457 lab=BLB11}
N 2160 47960 2140 47960 {}
C {lab_pin.sym} 2140 47960 0 0 {name=l38458 lab=WL240}
N 2240 48040 2260 48040 {}
C {lab_pin.sym} 2260 48040 0 0 {name=l38459 lab=VDD}
N 2240 47960 2260 47960 {}
C {lab_pin.sym} 2260 47960 0 0 {name=l38460 lab=VSS}
C {bitcell_6t.sym} 2400 48000 0 0 {name=Xr240c12}
N 2360 48040 2340 48040 {}
C {lab_pin.sym} 2340 48040 0 0 {name=l38461 lab=BL12}
N 2360 48000 2340 48000 {}
C {lab_pin.sym} 2340 48000 0 0 {name=l38462 lab=BLB12}
N 2360 47960 2340 47960 {}
C {lab_pin.sym} 2340 47960 0 0 {name=l38463 lab=WL240}
N 2440 48040 2460 48040 {}
C {lab_pin.sym} 2460 48040 0 0 {name=l38464 lab=VDD}
N 2440 47960 2460 47960 {}
C {lab_pin.sym} 2460 47960 0 0 {name=l38465 lab=VSS}
C {bitcell_6t.sym} 2600 48000 0 0 {name=Xr240c13}
N 2560 48040 2540 48040 {}
C {lab_pin.sym} 2540 48040 0 0 {name=l38466 lab=BL13}
N 2560 48000 2540 48000 {}
C {lab_pin.sym} 2540 48000 0 0 {name=l38467 lab=BLB13}
N 2560 47960 2540 47960 {}
C {lab_pin.sym} 2540 47960 0 0 {name=l38468 lab=WL240}
N 2640 48040 2660 48040 {}
C {lab_pin.sym} 2660 48040 0 0 {name=l38469 lab=VDD}
N 2640 47960 2660 47960 {}
C {lab_pin.sym} 2660 47960 0 0 {name=l38470 lab=VSS}
C {bitcell_6t.sym} 2800 48000 0 0 {name=Xr240c14}
N 2760 48040 2740 48040 {}
C {lab_pin.sym} 2740 48040 0 0 {name=l38471 lab=BL14}
N 2760 48000 2740 48000 {}
C {lab_pin.sym} 2740 48000 0 0 {name=l38472 lab=BLB14}
N 2760 47960 2740 47960 {}
C {lab_pin.sym} 2740 47960 0 0 {name=l38473 lab=WL240}
N 2840 48040 2860 48040 {}
C {lab_pin.sym} 2860 48040 0 0 {name=l38474 lab=VDD}
N 2840 47960 2860 47960 {}
C {lab_pin.sym} 2860 47960 0 0 {name=l38475 lab=VSS}
C {bitcell_6t.sym} 3000 48000 0 0 {name=Xr240c15}
N 2960 48040 2940 48040 {}
C {lab_pin.sym} 2940 48040 0 0 {name=l38476 lab=BL15}
N 2960 48000 2940 48000 {}
C {lab_pin.sym} 2940 48000 0 0 {name=l38477 lab=BLB15}
N 2960 47960 2940 47960 {}
C {lab_pin.sym} 2940 47960 0 0 {name=l38478 lab=WL240}
N 3040 48040 3060 48040 {}
C {lab_pin.sym} 3060 48040 0 0 {name=l38479 lab=VDD}
N 3040 47960 3060 47960 {}
C {lab_pin.sym} 3060 47960 0 0 {name=l38480 lab=VSS}
C {bitcell_6t.sym} 3200 48000 0 0 {name=Xr240c16}
N 3160 48040 3140 48040 {}
C {lab_pin.sym} 3140 48040 0 0 {name=l38481 lab=BL16}
N 3160 48000 3140 48000 {}
C {lab_pin.sym} 3140 48000 0 0 {name=l38482 lab=BLB16}
N 3160 47960 3140 47960 {}
C {lab_pin.sym} 3140 47960 0 0 {name=l38483 lab=WL240}
N 3240 48040 3260 48040 {}
C {lab_pin.sym} 3260 48040 0 0 {name=l38484 lab=VDD}
N 3240 47960 3260 47960 {}
C {lab_pin.sym} 3260 47960 0 0 {name=l38485 lab=VSS}
C {bitcell_6t.sym} 3400 48000 0 0 {name=Xr240c17}
N 3360 48040 3340 48040 {}
C {lab_pin.sym} 3340 48040 0 0 {name=l38486 lab=BL17}
N 3360 48000 3340 48000 {}
C {lab_pin.sym} 3340 48000 0 0 {name=l38487 lab=BLB17}
N 3360 47960 3340 47960 {}
C {lab_pin.sym} 3340 47960 0 0 {name=l38488 lab=WL240}
N 3440 48040 3460 48040 {}
C {lab_pin.sym} 3460 48040 0 0 {name=l38489 lab=VDD}
N 3440 47960 3460 47960 {}
C {lab_pin.sym} 3460 47960 0 0 {name=l38490 lab=VSS}
C {bitcell_6t.sym} 3600 48000 0 0 {name=Xr240c18}
N 3560 48040 3540 48040 {}
C {lab_pin.sym} 3540 48040 0 0 {name=l38491 lab=BL18}
N 3560 48000 3540 48000 {}
C {lab_pin.sym} 3540 48000 0 0 {name=l38492 lab=BLB18}
N 3560 47960 3540 47960 {}
C {lab_pin.sym} 3540 47960 0 0 {name=l38493 lab=WL240}
N 3640 48040 3660 48040 {}
C {lab_pin.sym} 3660 48040 0 0 {name=l38494 lab=VDD}
N 3640 47960 3660 47960 {}
C {lab_pin.sym} 3660 47960 0 0 {name=l38495 lab=VSS}
C {bitcell_6t.sym} 3800 48000 0 0 {name=Xr240c19}
N 3760 48040 3740 48040 {}
C {lab_pin.sym} 3740 48040 0 0 {name=l38496 lab=BL19}
N 3760 48000 3740 48000 {}
C {lab_pin.sym} 3740 48000 0 0 {name=l38497 lab=BLB19}
N 3760 47960 3740 47960 {}
C {lab_pin.sym} 3740 47960 0 0 {name=l38498 lab=WL240}
N 3840 48040 3860 48040 {}
C {lab_pin.sym} 3860 48040 0 0 {name=l38499 lab=VDD}
N 3840 47960 3860 47960 {}
C {lab_pin.sym} 3860 47960 0 0 {name=l38500 lab=VSS}
C {bitcell_6t.sym} 4000 48000 0 0 {name=Xr240c20}
N 3960 48040 3940 48040 {}
C {lab_pin.sym} 3940 48040 0 0 {name=l38501 lab=BL20}
N 3960 48000 3940 48000 {}
C {lab_pin.sym} 3940 48000 0 0 {name=l38502 lab=BLB20}
N 3960 47960 3940 47960 {}
C {lab_pin.sym} 3940 47960 0 0 {name=l38503 lab=WL240}
N 4040 48040 4060 48040 {}
C {lab_pin.sym} 4060 48040 0 0 {name=l38504 lab=VDD}
N 4040 47960 4060 47960 {}
C {lab_pin.sym} 4060 47960 0 0 {name=l38505 lab=VSS}
C {bitcell_6t.sym} 4200 48000 0 0 {name=Xr240c21}
N 4160 48040 4140 48040 {}
C {lab_pin.sym} 4140 48040 0 0 {name=l38506 lab=BL21}
N 4160 48000 4140 48000 {}
C {lab_pin.sym} 4140 48000 0 0 {name=l38507 lab=BLB21}
N 4160 47960 4140 47960 {}
C {lab_pin.sym} 4140 47960 0 0 {name=l38508 lab=WL240}
N 4240 48040 4260 48040 {}
C {lab_pin.sym} 4260 48040 0 0 {name=l38509 lab=VDD}
N 4240 47960 4260 47960 {}
C {lab_pin.sym} 4260 47960 0 0 {name=l38510 lab=VSS}
C {bitcell_6t.sym} 4400 48000 0 0 {name=Xr240c22}
N 4360 48040 4340 48040 {}
C {lab_pin.sym} 4340 48040 0 0 {name=l38511 lab=BL22}
N 4360 48000 4340 48000 {}
C {lab_pin.sym} 4340 48000 0 0 {name=l38512 lab=BLB22}
N 4360 47960 4340 47960 {}
C {lab_pin.sym} 4340 47960 0 0 {name=l38513 lab=WL240}
N 4440 48040 4460 48040 {}
C {lab_pin.sym} 4460 48040 0 0 {name=l38514 lab=VDD}
N 4440 47960 4460 47960 {}
C {lab_pin.sym} 4460 47960 0 0 {name=l38515 lab=VSS}
C {bitcell_6t.sym} 4600 48000 0 0 {name=Xr240c23}
N 4560 48040 4540 48040 {}
C {lab_pin.sym} 4540 48040 0 0 {name=l38516 lab=BL23}
N 4560 48000 4540 48000 {}
C {lab_pin.sym} 4540 48000 0 0 {name=l38517 lab=BLB23}
N 4560 47960 4540 47960 {}
C {lab_pin.sym} 4540 47960 0 0 {name=l38518 lab=WL240}
N 4640 48040 4660 48040 {}
C {lab_pin.sym} 4660 48040 0 0 {name=l38519 lab=VDD}
N 4640 47960 4660 47960 {}
C {lab_pin.sym} 4660 47960 0 0 {name=l38520 lab=VSS}
C {bitcell_6t.sym} 4800 48000 0 0 {name=Xr240c24}
N 4760 48040 4740 48040 {}
C {lab_pin.sym} 4740 48040 0 0 {name=l38521 lab=BL24}
N 4760 48000 4740 48000 {}
C {lab_pin.sym} 4740 48000 0 0 {name=l38522 lab=BLB24}
N 4760 47960 4740 47960 {}
C {lab_pin.sym} 4740 47960 0 0 {name=l38523 lab=WL240}
N 4840 48040 4860 48040 {}
C {lab_pin.sym} 4860 48040 0 0 {name=l38524 lab=VDD}
N 4840 47960 4860 47960 {}
C {lab_pin.sym} 4860 47960 0 0 {name=l38525 lab=VSS}
C {bitcell_6t.sym} 5000 48000 0 0 {name=Xr240c25}
N 4960 48040 4940 48040 {}
C {lab_pin.sym} 4940 48040 0 0 {name=l38526 lab=BL25}
N 4960 48000 4940 48000 {}
C {lab_pin.sym} 4940 48000 0 0 {name=l38527 lab=BLB25}
N 4960 47960 4940 47960 {}
C {lab_pin.sym} 4940 47960 0 0 {name=l38528 lab=WL240}
N 5040 48040 5060 48040 {}
C {lab_pin.sym} 5060 48040 0 0 {name=l38529 lab=VDD}
N 5040 47960 5060 47960 {}
C {lab_pin.sym} 5060 47960 0 0 {name=l38530 lab=VSS}
C {bitcell_6t.sym} 5200 48000 0 0 {name=Xr240c26}
N 5160 48040 5140 48040 {}
C {lab_pin.sym} 5140 48040 0 0 {name=l38531 lab=BL26}
N 5160 48000 5140 48000 {}
C {lab_pin.sym} 5140 48000 0 0 {name=l38532 lab=BLB26}
N 5160 47960 5140 47960 {}
C {lab_pin.sym} 5140 47960 0 0 {name=l38533 lab=WL240}
N 5240 48040 5260 48040 {}
C {lab_pin.sym} 5260 48040 0 0 {name=l38534 lab=VDD}
N 5240 47960 5260 47960 {}
C {lab_pin.sym} 5260 47960 0 0 {name=l38535 lab=VSS}
C {bitcell_6t.sym} 5400 48000 0 0 {name=Xr240c27}
N 5360 48040 5340 48040 {}
C {lab_pin.sym} 5340 48040 0 0 {name=l38536 lab=BL27}
N 5360 48000 5340 48000 {}
C {lab_pin.sym} 5340 48000 0 0 {name=l38537 lab=BLB27}
N 5360 47960 5340 47960 {}
C {lab_pin.sym} 5340 47960 0 0 {name=l38538 lab=WL240}
N 5440 48040 5460 48040 {}
C {lab_pin.sym} 5460 48040 0 0 {name=l38539 lab=VDD}
N 5440 47960 5460 47960 {}
C {lab_pin.sym} 5460 47960 0 0 {name=l38540 lab=VSS}
C {bitcell_6t.sym} 5600 48000 0 0 {name=Xr240c28}
N 5560 48040 5540 48040 {}
C {lab_pin.sym} 5540 48040 0 0 {name=l38541 lab=BL28}
N 5560 48000 5540 48000 {}
C {lab_pin.sym} 5540 48000 0 0 {name=l38542 lab=BLB28}
N 5560 47960 5540 47960 {}
C {lab_pin.sym} 5540 47960 0 0 {name=l38543 lab=WL240}
N 5640 48040 5660 48040 {}
C {lab_pin.sym} 5660 48040 0 0 {name=l38544 lab=VDD}
N 5640 47960 5660 47960 {}
C {lab_pin.sym} 5660 47960 0 0 {name=l38545 lab=VSS}
C {bitcell_6t.sym} 5800 48000 0 0 {name=Xr240c29}
N 5760 48040 5740 48040 {}
C {lab_pin.sym} 5740 48040 0 0 {name=l38546 lab=BL29}
N 5760 48000 5740 48000 {}
C {lab_pin.sym} 5740 48000 0 0 {name=l38547 lab=BLB29}
N 5760 47960 5740 47960 {}
C {lab_pin.sym} 5740 47960 0 0 {name=l38548 lab=WL240}
N 5840 48040 5860 48040 {}
C {lab_pin.sym} 5860 48040 0 0 {name=l38549 lab=VDD}
N 5840 47960 5860 47960 {}
C {lab_pin.sym} 5860 47960 0 0 {name=l38550 lab=VSS}
C {bitcell_6t.sym} 6000 48000 0 0 {name=Xr240c30}
N 5960 48040 5940 48040 {}
C {lab_pin.sym} 5940 48040 0 0 {name=l38551 lab=BL30}
N 5960 48000 5940 48000 {}
C {lab_pin.sym} 5940 48000 0 0 {name=l38552 lab=BLB30}
N 5960 47960 5940 47960 {}
C {lab_pin.sym} 5940 47960 0 0 {name=l38553 lab=WL240}
N 6040 48040 6060 48040 {}
C {lab_pin.sym} 6060 48040 0 0 {name=l38554 lab=VDD}
N 6040 47960 6060 47960 {}
C {lab_pin.sym} 6060 47960 0 0 {name=l38555 lab=VSS}
C {bitcell_6t.sym} 6200 48000 0 0 {name=Xr240c31}
N 6160 48040 6140 48040 {}
C {lab_pin.sym} 6140 48040 0 0 {name=l38556 lab=BL31}
N 6160 48000 6140 48000 {}
C {lab_pin.sym} 6140 48000 0 0 {name=l38557 lab=BLB31}
N 6160 47960 6140 47960 {}
C {lab_pin.sym} 6140 47960 0 0 {name=l38558 lab=WL240}
N 6240 48040 6260 48040 {}
C {lab_pin.sym} 6260 48040 0 0 {name=l38559 lab=VDD}
N 6240 47960 6260 47960 {}
C {lab_pin.sym} 6260 47960 0 0 {name=l38560 lab=VSS}
C {bitcell_6t.sym} 0 48200 0 0 {name=Xr241c0}
N -40 48240 -60 48240 {}
C {lab_pin.sym} -60 48240 0 0 {name=l38561 lab=BL0}
N -40 48200 -60 48200 {}
C {lab_pin.sym} -60 48200 0 0 {name=l38562 lab=BLB0}
N -40 48160 -60 48160 {}
C {lab_pin.sym} -60 48160 0 0 {name=l38563 lab=WL241}
N 40 48240 60 48240 {}
C {lab_pin.sym} 60 48240 0 0 {name=l38564 lab=VDD}
N 40 48160 60 48160 {}
C {lab_pin.sym} 60 48160 0 0 {name=l38565 lab=VSS}
C {bitcell_6t.sym} 200 48200 0 0 {name=Xr241c1}
N 160 48240 140 48240 {}
C {lab_pin.sym} 140 48240 0 0 {name=l38566 lab=BL1}
N 160 48200 140 48200 {}
C {lab_pin.sym} 140 48200 0 0 {name=l38567 lab=BLB1}
N 160 48160 140 48160 {}
C {lab_pin.sym} 140 48160 0 0 {name=l38568 lab=WL241}
N 240 48240 260 48240 {}
C {lab_pin.sym} 260 48240 0 0 {name=l38569 lab=VDD}
N 240 48160 260 48160 {}
C {lab_pin.sym} 260 48160 0 0 {name=l38570 lab=VSS}
C {bitcell_6t.sym} 400 48200 0 0 {name=Xr241c2}
N 360 48240 340 48240 {}
C {lab_pin.sym} 340 48240 0 0 {name=l38571 lab=BL2}
N 360 48200 340 48200 {}
C {lab_pin.sym} 340 48200 0 0 {name=l38572 lab=BLB2}
N 360 48160 340 48160 {}
C {lab_pin.sym} 340 48160 0 0 {name=l38573 lab=WL241}
N 440 48240 460 48240 {}
C {lab_pin.sym} 460 48240 0 0 {name=l38574 lab=VDD}
N 440 48160 460 48160 {}
C {lab_pin.sym} 460 48160 0 0 {name=l38575 lab=VSS}
C {bitcell_6t.sym} 600 48200 0 0 {name=Xr241c3}
N 560 48240 540 48240 {}
C {lab_pin.sym} 540 48240 0 0 {name=l38576 lab=BL3}
N 560 48200 540 48200 {}
C {lab_pin.sym} 540 48200 0 0 {name=l38577 lab=BLB3}
N 560 48160 540 48160 {}
C {lab_pin.sym} 540 48160 0 0 {name=l38578 lab=WL241}
N 640 48240 660 48240 {}
C {lab_pin.sym} 660 48240 0 0 {name=l38579 lab=VDD}
N 640 48160 660 48160 {}
C {lab_pin.sym} 660 48160 0 0 {name=l38580 lab=VSS}
C {bitcell_6t.sym} 800 48200 0 0 {name=Xr241c4}
N 760 48240 740 48240 {}
C {lab_pin.sym} 740 48240 0 0 {name=l38581 lab=BL4}
N 760 48200 740 48200 {}
C {lab_pin.sym} 740 48200 0 0 {name=l38582 lab=BLB4}
N 760 48160 740 48160 {}
C {lab_pin.sym} 740 48160 0 0 {name=l38583 lab=WL241}
N 840 48240 860 48240 {}
C {lab_pin.sym} 860 48240 0 0 {name=l38584 lab=VDD}
N 840 48160 860 48160 {}
C {lab_pin.sym} 860 48160 0 0 {name=l38585 lab=VSS}
C {bitcell_6t.sym} 1000 48200 0 0 {name=Xr241c5}
N 960 48240 940 48240 {}
C {lab_pin.sym} 940 48240 0 0 {name=l38586 lab=BL5}
N 960 48200 940 48200 {}
C {lab_pin.sym} 940 48200 0 0 {name=l38587 lab=BLB5}
N 960 48160 940 48160 {}
C {lab_pin.sym} 940 48160 0 0 {name=l38588 lab=WL241}
N 1040 48240 1060 48240 {}
C {lab_pin.sym} 1060 48240 0 0 {name=l38589 lab=VDD}
N 1040 48160 1060 48160 {}
C {lab_pin.sym} 1060 48160 0 0 {name=l38590 lab=VSS}
C {bitcell_6t.sym} 1200 48200 0 0 {name=Xr241c6}
N 1160 48240 1140 48240 {}
C {lab_pin.sym} 1140 48240 0 0 {name=l38591 lab=BL6}
N 1160 48200 1140 48200 {}
C {lab_pin.sym} 1140 48200 0 0 {name=l38592 lab=BLB6}
N 1160 48160 1140 48160 {}
C {lab_pin.sym} 1140 48160 0 0 {name=l38593 lab=WL241}
N 1240 48240 1260 48240 {}
C {lab_pin.sym} 1260 48240 0 0 {name=l38594 lab=VDD}
N 1240 48160 1260 48160 {}
C {lab_pin.sym} 1260 48160 0 0 {name=l38595 lab=VSS}
C {bitcell_6t.sym} 1400 48200 0 0 {name=Xr241c7}
N 1360 48240 1340 48240 {}
C {lab_pin.sym} 1340 48240 0 0 {name=l38596 lab=BL7}
N 1360 48200 1340 48200 {}
C {lab_pin.sym} 1340 48200 0 0 {name=l38597 lab=BLB7}
N 1360 48160 1340 48160 {}
C {lab_pin.sym} 1340 48160 0 0 {name=l38598 lab=WL241}
N 1440 48240 1460 48240 {}
C {lab_pin.sym} 1460 48240 0 0 {name=l38599 lab=VDD}
N 1440 48160 1460 48160 {}
C {lab_pin.sym} 1460 48160 0 0 {name=l38600 lab=VSS}
C {bitcell_6t.sym} 1600 48200 0 0 {name=Xr241c8}
N 1560 48240 1540 48240 {}
C {lab_pin.sym} 1540 48240 0 0 {name=l38601 lab=BL8}
N 1560 48200 1540 48200 {}
C {lab_pin.sym} 1540 48200 0 0 {name=l38602 lab=BLB8}
N 1560 48160 1540 48160 {}
C {lab_pin.sym} 1540 48160 0 0 {name=l38603 lab=WL241}
N 1640 48240 1660 48240 {}
C {lab_pin.sym} 1660 48240 0 0 {name=l38604 lab=VDD}
N 1640 48160 1660 48160 {}
C {lab_pin.sym} 1660 48160 0 0 {name=l38605 lab=VSS}
C {bitcell_6t.sym} 1800 48200 0 0 {name=Xr241c9}
N 1760 48240 1740 48240 {}
C {lab_pin.sym} 1740 48240 0 0 {name=l38606 lab=BL9}
N 1760 48200 1740 48200 {}
C {lab_pin.sym} 1740 48200 0 0 {name=l38607 lab=BLB9}
N 1760 48160 1740 48160 {}
C {lab_pin.sym} 1740 48160 0 0 {name=l38608 lab=WL241}
N 1840 48240 1860 48240 {}
C {lab_pin.sym} 1860 48240 0 0 {name=l38609 lab=VDD}
N 1840 48160 1860 48160 {}
C {lab_pin.sym} 1860 48160 0 0 {name=l38610 lab=VSS}
C {bitcell_6t.sym} 2000 48200 0 0 {name=Xr241c10}
N 1960 48240 1940 48240 {}
C {lab_pin.sym} 1940 48240 0 0 {name=l38611 lab=BL10}
N 1960 48200 1940 48200 {}
C {lab_pin.sym} 1940 48200 0 0 {name=l38612 lab=BLB10}
N 1960 48160 1940 48160 {}
C {lab_pin.sym} 1940 48160 0 0 {name=l38613 lab=WL241}
N 2040 48240 2060 48240 {}
C {lab_pin.sym} 2060 48240 0 0 {name=l38614 lab=VDD}
N 2040 48160 2060 48160 {}
C {lab_pin.sym} 2060 48160 0 0 {name=l38615 lab=VSS}
C {bitcell_6t.sym} 2200 48200 0 0 {name=Xr241c11}
N 2160 48240 2140 48240 {}
C {lab_pin.sym} 2140 48240 0 0 {name=l38616 lab=BL11}
N 2160 48200 2140 48200 {}
C {lab_pin.sym} 2140 48200 0 0 {name=l38617 lab=BLB11}
N 2160 48160 2140 48160 {}
C {lab_pin.sym} 2140 48160 0 0 {name=l38618 lab=WL241}
N 2240 48240 2260 48240 {}
C {lab_pin.sym} 2260 48240 0 0 {name=l38619 lab=VDD}
N 2240 48160 2260 48160 {}
C {lab_pin.sym} 2260 48160 0 0 {name=l38620 lab=VSS}
C {bitcell_6t.sym} 2400 48200 0 0 {name=Xr241c12}
N 2360 48240 2340 48240 {}
C {lab_pin.sym} 2340 48240 0 0 {name=l38621 lab=BL12}
N 2360 48200 2340 48200 {}
C {lab_pin.sym} 2340 48200 0 0 {name=l38622 lab=BLB12}
N 2360 48160 2340 48160 {}
C {lab_pin.sym} 2340 48160 0 0 {name=l38623 lab=WL241}
N 2440 48240 2460 48240 {}
C {lab_pin.sym} 2460 48240 0 0 {name=l38624 lab=VDD}
N 2440 48160 2460 48160 {}
C {lab_pin.sym} 2460 48160 0 0 {name=l38625 lab=VSS}
C {bitcell_6t.sym} 2600 48200 0 0 {name=Xr241c13}
N 2560 48240 2540 48240 {}
C {lab_pin.sym} 2540 48240 0 0 {name=l38626 lab=BL13}
N 2560 48200 2540 48200 {}
C {lab_pin.sym} 2540 48200 0 0 {name=l38627 lab=BLB13}
N 2560 48160 2540 48160 {}
C {lab_pin.sym} 2540 48160 0 0 {name=l38628 lab=WL241}
N 2640 48240 2660 48240 {}
C {lab_pin.sym} 2660 48240 0 0 {name=l38629 lab=VDD}
N 2640 48160 2660 48160 {}
C {lab_pin.sym} 2660 48160 0 0 {name=l38630 lab=VSS}
C {bitcell_6t.sym} 2800 48200 0 0 {name=Xr241c14}
N 2760 48240 2740 48240 {}
C {lab_pin.sym} 2740 48240 0 0 {name=l38631 lab=BL14}
N 2760 48200 2740 48200 {}
C {lab_pin.sym} 2740 48200 0 0 {name=l38632 lab=BLB14}
N 2760 48160 2740 48160 {}
C {lab_pin.sym} 2740 48160 0 0 {name=l38633 lab=WL241}
N 2840 48240 2860 48240 {}
C {lab_pin.sym} 2860 48240 0 0 {name=l38634 lab=VDD}
N 2840 48160 2860 48160 {}
C {lab_pin.sym} 2860 48160 0 0 {name=l38635 lab=VSS}
C {bitcell_6t.sym} 3000 48200 0 0 {name=Xr241c15}
N 2960 48240 2940 48240 {}
C {lab_pin.sym} 2940 48240 0 0 {name=l38636 lab=BL15}
N 2960 48200 2940 48200 {}
C {lab_pin.sym} 2940 48200 0 0 {name=l38637 lab=BLB15}
N 2960 48160 2940 48160 {}
C {lab_pin.sym} 2940 48160 0 0 {name=l38638 lab=WL241}
N 3040 48240 3060 48240 {}
C {lab_pin.sym} 3060 48240 0 0 {name=l38639 lab=VDD}
N 3040 48160 3060 48160 {}
C {lab_pin.sym} 3060 48160 0 0 {name=l38640 lab=VSS}
C {bitcell_6t.sym} 3200 48200 0 0 {name=Xr241c16}
N 3160 48240 3140 48240 {}
C {lab_pin.sym} 3140 48240 0 0 {name=l38641 lab=BL16}
N 3160 48200 3140 48200 {}
C {lab_pin.sym} 3140 48200 0 0 {name=l38642 lab=BLB16}
N 3160 48160 3140 48160 {}
C {lab_pin.sym} 3140 48160 0 0 {name=l38643 lab=WL241}
N 3240 48240 3260 48240 {}
C {lab_pin.sym} 3260 48240 0 0 {name=l38644 lab=VDD}
N 3240 48160 3260 48160 {}
C {lab_pin.sym} 3260 48160 0 0 {name=l38645 lab=VSS}
C {bitcell_6t.sym} 3400 48200 0 0 {name=Xr241c17}
N 3360 48240 3340 48240 {}
C {lab_pin.sym} 3340 48240 0 0 {name=l38646 lab=BL17}
N 3360 48200 3340 48200 {}
C {lab_pin.sym} 3340 48200 0 0 {name=l38647 lab=BLB17}
N 3360 48160 3340 48160 {}
C {lab_pin.sym} 3340 48160 0 0 {name=l38648 lab=WL241}
N 3440 48240 3460 48240 {}
C {lab_pin.sym} 3460 48240 0 0 {name=l38649 lab=VDD}
N 3440 48160 3460 48160 {}
C {lab_pin.sym} 3460 48160 0 0 {name=l38650 lab=VSS}
C {bitcell_6t.sym} 3600 48200 0 0 {name=Xr241c18}
N 3560 48240 3540 48240 {}
C {lab_pin.sym} 3540 48240 0 0 {name=l38651 lab=BL18}
N 3560 48200 3540 48200 {}
C {lab_pin.sym} 3540 48200 0 0 {name=l38652 lab=BLB18}
N 3560 48160 3540 48160 {}
C {lab_pin.sym} 3540 48160 0 0 {name=l38653 lab=WL241}
N 3640 48240 3660 48240 {}
C {lab_pin.sym} 3660 48240 0 0 {name=l38654 lab=VDD}
N 3640 48160 3660 48160 {}
C {lab_pin.sym} 3660 48160 0 0 {name=l38655 lab=VSS}
C {bitcell_6t.sym} 3800 48200 0 0 {name=Xr241c19}
N 3760 48240 3740 48240 {}
C {lab_pin.sym} 3740 48240 0 0 {name=l38656 lab=BL19}
N 3760 48200 3740 48200 {}
C {lab_pin.sym} 3740 48200 0 0 {name=l38657 lab=BLB19}
N 3760 48160 3740 48160 {}
C {lab_pin.sym} 3740 48160 0 0 {name=l38658 lab=WL241}
N 3840 48240 3860 48240 {}
C {lab_pin.sym} 3860 48240 0 0 {name=l38659 lab=VDD}
N 3840 48160 3860 48160 {}
C {lab_pin.sym} 3860 48160 0 0 {name=l38660 lab=VSS}
C {bitcell_6t.sym} 4000 48200 0 0 {name=Xr241c20}
N 3960 48240 3940 48240 {}
C {lab_pin.sym} 3940 48240 0 0 {name=l38661 lab=BL20}
N 3960 48200 3940 48200 {}
C {lab_pin.sym} 3940 48200 0 0 {name=l38662 lab=BLB20}
N 3960 48160 3940 48160 {}
C {lab_pin.sym} 3940 48160 0 0 {name=l38663 lab=WL241}
N 4040 48240 4060 48240 {}
C {lab_pin.sym} 4060 48240 0 0 {name=l38664 lab=VDD}
N 4040 48160 4060 48160 {}
C {lab_pin.sym} 4060 48160 0 0 {name=l38665 lab=VSS}
C {bitcell_6t.sym} 4200 48200 0 0 {name=Xr241c21}
N 4160 48240 4140 48240 {}
C {lab_pin.sym} 4140 48240 0 0 {name=l38666 lab=BL21}
N 4160 48200 4140 48200 {}
C {lab_pin.sym} 4140 48200 0 0 {name=l38667 lab=BLB21}
N 4160 48160 4140 48160 {}
C {lab_pin.sym} 4140 48160 0 0 {name=l38668 lab=WL241}
N 4240 48240 4260 48240 {}
C {lab_pin.sym} 4260 48240 0 0 {name=l38669 lab=VDD}
N 4240 48160 4260 48160 {}
C {lab_pin.sym} 4260 48160 0 0 {name=l38670 lab=VSS}
C {bitcell_6t.sym} 4400 48200 0 0 {name=Xr241c22}
N 4360 48240 4340 48240 {}
C {lab_pin.sym} 4340 48240 0 0 {name=l38671 lab=BL22}
N 4360 48200 4340 48200 {}
C {lab_pin.sym} 4340 48200 0 0 {name=l38672 lab=BLB22}
N 4360 48160 4340 48160 {}
C {lab_pin.sym} 4340 48160 0 0 {name=l38673 lab=WL241}
N 4440 48240 4460 48240 {}
C {lab_pin.sym} 4460 48240 0 0 {name=l38674 lab=VDD}
N 4440 48160 4460 48160 {}
C {lab_pin.sym} 4460 48160 0 0 {name=l38675 lab=VSS}
C {bitcell_6t.sym} 4600 48200 0 0 {name=Xr241c23}
N 4560 48240 4540 48240 {}
C {lab_pin.sym} 4540 48240 0 0 {name=l38676 lab=BL23}
N 4560 48200 4540 48200 {}
C {lab_pin.sym} 4540 48200 0 0 {name=l38677 lab=BLB23}
N 4560 48160 4540 48160 {}
C {lab_pin.sym} 4540 48160 0 0 {name=l38678 lab=WL241}
N 4640 48240 4660 48240 {}
C {lab_pin.sym} 4660 48240 0 0 {name=l38679 lab=VDD}
N 4640 48160 4660 48160 {}
C {lab_pin.sym} 4660 48160 0 0 {name=l38680 lab=VSS}
C {bitcell_6t.sym} 4800 48200 0 0 {name=Xr241c24}
N 4760 48240 4740 48240 {}
C {lab_pin.sym} 4740 48240 0 0 {name=l38681 lab=BL24}
N 4760 48200 4740 48200 {}
C {lab_pin.sym} 4740 48200 0 0 {name=l38682 lab=BLB24}
N 4760 48160 4740 48160 {}
C {lab_pin.sym} 4740 48160 0 0 {name=l38683 lab=WL241}
N 4840 48240 4860 48240 {}
C {lab_pin.sym} 4860 48240 0 0 {name=l38684 lab=VDD}
N 4840 48160 4860 48160 {}
C {lab_pin.sym} 4860 48160 0 0 {name=l38685 lab=VSS}
C {bitcell_6t.sym} 5000 48200 0 0 {name=Xr241c25}
N 4960 48240 4940 48240 {}
C {lab_pin.sym} 4940 48240 0 0 {name=l38686 lab=BL25}
N 4960 48200 4940 48200 {}
C {lab_pin.sym} 4940 48200 0 0 {name=l38687 lab=BLB25}
N 4960 48160 4940 48160 {}
C {lab_pin.sym} 4940 48160 0 0 {name=l38688 lab=WL241}
N 5040 48240 5060 48240 {}
C {lab_pin.sym} 5060 48240 0 0 {name=l38689 lab=VDD}
N 5040 48160 5060 48160 {}
C {lab_pin.sym} 5060 48160 0 0 {name=l38690 lab=VSS}
C {bitcell_6t.sym} 5200 48200 0 0 {name=Xr241c26}
N 5160 48240 5140 48240 {}
C {lab_pin.sym} 5140 48240 0 0 {name=l38691 lab=BL26}
N 5160 48200 5140 48200 {}
C {lab_pin.sym} 5140 48200 0 0 {name=l38692 lab=BLB26}
N 5160 48160 5140 48160 {}
C {lab_pin.sym} 5140 48160 0 0 {name=l38693 lab=WL241}
N 5240 48240 5260 48240 {}
C {lab_pin.sym} 5260 48240 0 0 {name=l38694 lab=VDD}
N 5240 48160 5260 48160 {}
C {lab_pin.sym} 5260 48160 0 0 {name=l38695 lab=VSS}
C {bitcell_6t.sym} 5400 48200 0 0 {name=Xr241c27}
N 5360 48240 5340 48240 {}
C {lab_pin.sym} 5340 48240 0 0 {name=l38696 lab=BL27}
N 5360 48200 5340 48200 {}
C {lab_pin.sym} 5340 48200 0 0 {name=l38697 lab=BLB27}
N 5360 48160 5340 48160 {}
C {lab_pin.sym} 5340 48160 0 0 {name=l38698 lab=WL241}
N 5440 48240 5460 48240 {}
C {lab_pin.sym} 5460 48240 0 0 {name=l38699 lab=VDD}
N 5440 48160 5460 48160 {}
C {lab_pin.sym} 5460 48160 0 0 {name=l38700 lab=VSS}
C {bitcell_6t.sym} 5600 48200 0 0 {name=Xr241c28}
N 5560 48240 5540 48240 {}
C {lab_pin.sym} 5540 48240 0 0 {name=l38701 lab=BL28}
N 5560 48200 5540 48200 {}
C {lab_pin.sym} 5540 48200 0 0 {name=l38702 lab=BLB28}
N 5560 48160 5540 48160 {}
C {lab_pin.sym} 5540 48160 0 0 {name=l38703 lab=WL241}
N 5640 48240 5660 48240 {}
C {lab_pin.sym} 5660 48240 0 0 {name=l38704 lab=VDD}
N 5640 48160 5660 48160 {}
C {lab_pin.sym} 5660 48160 0 0 {name=l38705 lab=VSS}
C {bitcell_6t.sym} 5800 48200 0 0 {name=Xr241c29}
N 5760 48240 5740 48240 {}
C {lab_pin.sym} 5740 48240 0 0 {name=l38706 lab=BL29}
N 5760 48200 5740 48200 {}
C {lab_pin.sym} 5740 48200 0 0 {name=l38707 lab=BLB29}
N 5760 48160 5740 48160 {}
C {lab_pin.sym} 5740 48160 0 0 {name=l38708 lab=WL241}
N 5840 48240 5860 48240 {}
C {lab_pin.sym} 5860 48240 0 0 {name=l38709 lab=VDD}
N 5840 48160 5860 48160 {}
C {lab_pin.sym} 5860 48160 0 0 {name=l38710 lab=VSS}
C {bitcell_6t.sym} 6000 48200 0 0 {name=Xr241c30}
N 5960 48240 5940 48240 {}
C {lab_pin.sym} 5940 48240 0 0 {name=l38711 lab=BL30}
N 5960 48200 5940 48200 {}
C {lab_pin.sym} 5940 48200 0 0 {name=l38712 lab=BLB30}
N 5960 48160 5940 48160 {}
C {lab_pin.sym} 5940 48160 0 0 {name=l38713 lab=WL241}
N 6040 48240 6060 48240 {}
C {lab_pin.sym} 6060 48240 0 0 {name=l38714 lab=VDD}
N 6040 48160 6060 48160 {}
C {lab_pin.sym} 6060 48160 0 0 {name=l38715 lab=VSS}
C {bitcell_6t.sym} 6200 48200 0 0 {name=Xr241c31}
N 6160 48240 6140 48240 {}
C {lab_pin.sym} 6140 48240 0 0 {name=l38716 lab=BL31}
N 6160 48200 6140 48200 {}
C {lab_pin.sym} 6140 48200 0 0 {name=l38717 lab=BLB31}
N 6160 48160 6140 48160 {}
C {lab_pin.sym} 6140 48160 0 0 {name=l38718 lab=WL241}
N 6240 48240 6260 48240 {}
C {lab_pin.sym} 6260 48240 0 0 {name=l38719 lab=VDD}
N 6240 48160 6260 48160 {}
C {lab_pin.sym} 6260 48160 0 0 {name=l38720 lab=VSS}
C {bitcell_6t.sym} 0 48400 0 0 {name=Xr242c0}
N -40 48440 -60 48440 {}
C {lab_pin.sym} -60 48440 0 0 {name=l38721 lab=BL0}
N -40 48400 -60 48400 {}
C {lab_pin.sym} -60 48400 0 0 {name=l38722 lab=BLB0}
N -40 48360 -60 48360 {}
C {lab_pin.sym} -60 48360 0 0 {name=l38723 lab=WL242}
N 40 48440 60 48440 {}
C {lab_pin.sym} 60 48440 0 0 {name=l38724 lab=VDD}
N 40 48360 60 48360 {}
C {lab_pin.sym} 60 48360 0 0 {name=l38725 lab=VSS}
C {bitcell_6t.sym} 200 48400 0 0 {name=Xr242c1}
N 160 48440 140 48440 {}
C {lab_pin.sym} 140 48440 0 0 {name=l38726 lab=BL1}
N 160 48400 140 48400 {}
C {lab_pin.sym} 140 48400 0 0 {name=l38727 lab=BLB1}
N 160 48360 140 48360 {}
C {lab_pin.sym} 140 48360 0 0 {name=l38728 lab=WL242}
N 240 48440 260 48440 {}
C {lab_pin.sym} 260 48440 0 0 {name=l38729 lab=VDD}
N 240 48360 260 48360 {}
C {lab_pin.sym} 260 48360 0 0 {name=l38730 lab=VSS}
C {bitcell_6t.sym} 400 48400 0 0 {name=Xr242c2}
N 360 48440 340 48440 {}
C {lab_pin.sym} 340 48440 0 0 {name=l38731 lab=BL2}
N 360 48400 340 48400 {}
C {lab_pin.sym} 340 48400 0 0 {name=l38732 lab=BLB2}
N 360 48360 340 48360 {}
C {lab_pin.sym} 340 48360 0 0 {name=l38733 lab=WL242}
N 440 48440 460 48440 {}
C {lab_pin.sym} 460 48440 0 0 {name=l38734 lab=VDD}
N 440 48360 460 48360 {}
C {lab_pin.sym} 460 48360 0 0 {name=l38735 lab=VSS}
C {bitcell_6t.sym} 600 48400 0 0 {name=Xr242c3}
N 560 48440 540 48440 {}
C {lab_pin.sym} 540 48440 0 0 {name=l38736 lab=BL3}
N 560 48400 540 48400 {}
C {lab_pin.sym} 540 48400 0 0 {name=l38737 lab=BLB3}
N 560 48360 540 48360 {}
C {lab_pin.sym} 540 48360 0 0 {name=l38738 lab=WL242}
N 640 48440 660 48440 {}
C {lab_pin.sym} 660 48440 0 0 {name=l38739 lab=VDD}
N 640 48360 660 48360 {}
C {lab_pin.sym} 660 48360 0 0 {name=l38740 lab=VSS}
C {bitcell_6t.sym} 800 48400 0 0 {name=Xr242c4}
N 760 48440 740 48440 {}
C {lab_pin.sym} 740 48440 0 0 {name=l38741 lab=BL4}
N 760 48400 740 48400 {}
C {lab_pin.sym} 740 48400 0 0 {name=l38742 lab=BLB4}
N 760 48360 740 48360 {}
C {lab_pin.sym} 740 48360 0 0 {name=l38743 lab=WL242}
N 840 48440 860 48440 {}
C {lab_pin.sym} 860 48440 0 0 {name=l38744 lab=VDD}
N 840 48360 860 48360 {}
C {lab_pin.sym} 860 48360 0 0 {name=l38745 lab=VSS}
C {bitcell_6t.sym} 1000 48400 0 0 {name=Xr242c5}
N 960 48440 940 48440 {}
C {lab_pin.sym} 940 48440 0 0 {name=l38746 lab=BL5}
N 960 48400 940 48400 {}
C {lab_pin.sym} 940 48400 0 0 {name=l38747 lab=BLB5}
N 960 48360 940 48360 {}
C {lab_pin.sym} 940 48360 0 0 {name=l38748 lab=WL242}
N 1040 48440 1060 48440 {}
C {lab_pin.sym} 1060 48440 0 0 {name=l38749 lab=VDD}
N 1040 48360 1060 48360 {}
C {lab_pin.sym} 1060 48360 0 0 {name=l38750 lab=VSS}
C {bitcell_6t.sym} 1200 48400 0 0 {name=Xr242c6}
N 1160 48440 1140 48440 {}
C {lab_pin.sym} 1140 48440 0 0 {name=l38751 lab=BL6}
N 1160 48400 1140 48400 {}
C {lab_pin.sym} 1140 48400 0 0 {name=l38752 lab=BLB6}
N 1160 48360 1140 48360 {}
C {lab_pin.sym} 1140 48360 0 0 {name=l38753 lab=WL242}
N 1240 48440 1260 48440 {}
C {lab_pin.sym} 1260 48440 0 0 {name=l38754 lab=VDD}
N 1240 48360 1260 48360 {}
C {lab_pin.sym} 1260 48360 0 0 {name=l38755 lab=VSS}
C {bitcell_6t.sym} 1400 48400 0 0 {name=Xr242c7}
N 1360 48440 1340 48440 {}
C {lab_pin.sym} 1340 48440 0 0 {name=l38756 lab=BL7}
N 1360 48400 1340 48400 {}
C {lab_pin.sym} 1340 48400 0 0 {name=l38757 lab=BLB7}
N 1360 48360 1340 48360 {}
C {lab_pin.sym} 1340 48360 0 0 {name=l38758 lab=WL242}
N 1440 48440 1460 48440 {}
C {lab_pin.sym} 1460 48440 0 0 {name=l38759 lab=VDD}
N 1440 48360 1460 48360 {}
C {lab_pin.sym} 1460 48360 0 0 {name=l38760 lab=VSS}
C {bitcell_6t.sym} 1600 48400 0 0 {name=Xr242c8}
N 1560 48440 1540 48440 {}
C {lab_pin.sym} 1540 48440 0 0 {name=l38761 lab=BL8}
N 1560 48400 1540 48400 {}
C {lab_pin.sym} 1540 48400 0 0 {name=l38762 lab=BLB8}
N 1560 48360 1540 48360 {}
C {lab_pin.sym} 1540 48360 0 0 {name=l38763 lab=WL242}
N 1640 48440 1660 48440 {}
C {lab_pin.sym} 1660 48440 0 0 {name=l38764 lab=VDD}
N 1640 48360 1660 48360 {}
C {lab_pin.sym} 1660 48360 0 0 {name=l38765 lab=VSS}
C {bitcell_6t.sym} 1800 48400 0 0 {name=Xr242c9}
N 1760 48440 1740 48440 {}
C {lab_pin.sym} 1740 48440 0 0 {name=l38766 lab=BL9}
N 1760 48400 1740 48400 {}
C {lab_pin.sym} 1740 48400 0 0 {name=l38767 lab=BLB9}
N 1760 48360 1740 48360 {}
C {lab_pin.sym} 1740 48360 0 0 {name=l38768 lab=WL242}
N 1840 48440 1860 48440 {}
C {lab_pin.sym} 1860 48440 0 0 {name=l38769 lab=VDD}
N 1840 48360 1860 48360 {}
C {lab_pin.sym} 1860 48360 0 0 {name=l38770 lab=VSS}
C {bitcell_6t.sym} 2000 48400 0 0 {name=Xr242c10}
N 1960 48440 1940 48440 {}
C {lab_pin.sym} 1940 48440 0 0 {name=l38771 lab=BL10}
N 1960 48400 1940 48400 {}
C {lab_pin.sym} 1940 48400 0 0 {name=l38772 lab=BLB10}
N 1960 48360 1940 48360 {}
C {lab_pin.sym} 1940 48360 0 0 {name=l38773 lab=WL242}
N 2040 48440 2060 48440 {}
C {lab_pin.sym} 2060 48440 0 0 {name=l38774 lab=VDD}
N 2040 48360 2060 48360 {}
C {lab_pin.sym} 2060 48360 0 0 {name=l38775 lab=VSS}
C {bitcell_6t.sym} 2200 48400 0 0 {name=Xr242c11}
N 2160 48440 2140 48440 {}
C {lab_pin.sym} 2140 48440 0 0 {name=l38776 lab=BL11}
N 2160 48400 2140 48400 {}
C {lab_pin.sym} 2140 48400 0 0 {name=l38777 lab=BLB11}
N 2160 48360 2140 48360 {}
C {lab_pin.sym} 2140 48360 0 0 {name=l38778 lab=WL242}
N 2240 48440 2260 48440 {}
C {lab_pin.sym} 2260 48440 0 0 {name=l38779 lab=VDD}
N 2240 48360 2260 48360 {}
C {lab_pin.sym} 2260 48360 0 0 {name=l38780 lab=VSS}
C {bitcell_6t.sym} 2400 48400 0 0 {name=Xr242c12}
N 2360 48440 2340 48440 {}
C {lab_pin.sym} 2340 48440 0 0 {name=l38781 lab=BL12}
N 2360 48400 2340 48400 {}
C {lab_pin.sym} 2340 48400 0 0 {name=l38782 lab=BLB12}
N 2360 48360 2340 48360 {}
C {lab_pin.sym} 2340 48360 0 0 {name=l38783 lab=WL242}
N 2440 48440 2460 48440 {}
C {lab_pin.sym} 2460 48440 0 0 {name=l38784 lab=VDD}
N 2440 48360 2460 48360 {}
C {lab_pin.sym} 2460 48360 0 0 {name=l38785 lab=VSS}
C {bitcell_6t.sym} 2600 48400 0 0 {name=Xr242c13}
N 2560 48440 2540 48440 {}
C {lab_pin.sym} 2540 48440 0 0 {name=l38786 lab=BL13}
N 2560 48400 2540 48400 {}
C {lab_pin.sym} 2540 48400 0 0 {name=l38787 lab=BLB13}
N 2560 48360 2540 48360 {}
C {lab_pin.sym} 2540 48360 0 0 {name=l38788 lab=WL242}
N 2640 48440 2660 48440 {}
C {lab_pin.sym} 2660 48440 0 0 {name=l38789 lab=VDD}
N 2640 48360 2660 48360 {}
C {lab_pin.sym} 2660 48360 0 0 {name=l38790 lab=VSS}
C {bitcell_6t.sym} 2800 48400 0 0 {name=Xr242c14}
N 2760 48440 2740 48440 {}
C {lab_pin.sym} 2740 48440 0 0 {name=l38791 lab=BL14}
N 2760 48400 2740 48400 {}
C {lab_pin.sym} 2740 48400 0 0 {name=l38792 lab=BLB14}
N 2760 48360 2740 48360 {}
C {lab_pin.sym} 2740 48360 0 0 {name=l38793 lab=WL242}
N 2840 48440 2860 48440 {}
C {lab_pin.sym} 2860 48440 0 0 {name=l38794 lab=VDD}
N 2840 48360 2860 48360 {}
C {lab_pin.sym} 2860 48360 0 0 {name=l38795 lab=VSS}
C {bitcell_6t.sym} 3000 48400 0 0 {name=Xr242c15}
N 2960 48440 2940 48440 {}
C {lab_pin.sym} 2940 48440 0 0 {name=l38796 lab=BL15}
N 2960 48400 2940 48400 {}
C {lab_pin.sym} 2940 48400 0 0 {name=l38797 lab=BLB15}
N 2960 48360 2940 48360 {}
C {lab_pin.sym} 2940 48360 0 0 {name=l38798 lab=WL242}
N 3040 48440 3060 48440 {}
C {lab_pin.sym} 3060 48440 0 0 {name=l38799 lab=VDD}
N 3040 48360 3060 48360 {}
C {lab_pin.sym} 3060 48360 0 0 {name=l38800 lab=VSS}
C {bitcell_6t.sym} 3200 48400 0 0 {name=Xr242c16}
N 3160 48440 3140 48440 {}
C {lab_pin.sym} 3140 48440 0 0 {name=l38801 lab=BL16}
N 3160 48400 3140 48400 {}
C {lab_pin.sym} 3140 48400 0 0 {name=l38802 lab=BLB16}
N 3160 48360 3140 48360 {}
C {lab_pin.sym} 3140 48360 0 0 {name=l38803 lab=WL242}
N 3240 48440 3260 48440 {}
C {lab_pin.sym} 3260 48440 0 0 {name=l38804 lab=VDD}
N 3240 48360 3260 48360 {}
C {lab_pin.sym} 3260 48360 0 0 {name=l38805 lab=VSS}
C {bitcell_6t.sym} 3400 48400 0 0 {name=Xr242c17}
N 3360 48440 3340 48440 {}
C {lab_pin.sym} 3340 48440 0 0 {name=l38806 lab=BL17}
N 3360 48400 3340 48400 {}
C {lab_pin.sym} 3340 48400 0 0 {name=l38807 lab=BLB17}
N 3360 48360 3340 48360 {}
C {lab_pin.sym} 3340 48360 0 0 {name=l38808 lab=WL242}
N 3440 48440 3460 48440 {}
C {lab_pin.sym} 3460 48440 0 0 {name=l38809 lab=VDD}
N 3440 48360 3460 48360 {}
C {lab_pin.sym} 3460 48360 0 0 {name=l38810 lab=VSS}
C {bitcell_6t.sym} 3600 48400 0 0 {name=Xr242c18}
N 3560 48440 3540 48440 {}
C {lab_pin.sym} 3540 48440 0 0 {name=l38811 lab=BL18}
N 3560 48400 3540 48400 {}
C {lab_pin.sym} 3540 48400 0 0 {name=l38812 lab=BLB18}
N 3560 48360 3540 48360 {}
C {lab_pin.sym} 3540 48360 0 0 {name=l38813 lab=WL242}
N 3640 48440 3660 48440 {}
C {lab_pin.sym} 3660 48440 0 0 {name=l38814 lab=VDD}
N 3640 48360 3660 48360 {}
C {lab_pin.sym} 3660 48360 0 0 {name=l38815 lab=VSS}
C {bitcell_6t.sym} 3800 48400 0 0 {name=Xr242c19}
N 3760 48440 3740 48440 {}
C {lab_pin.sym} 3740 48440 0 0 {name=l38816 lab=BL19}
N 3760 48400 3740 48400 {}
C {lab_pin.sym} 3740 48400 0 0 {name=l38817 lab=BLB19}
N 3760 48360 3740 48360 {}
C {lab_pin.sym} 3740 48360 0 0 {name=l38818 lab=WL242}
N 3840 48440 3860 48440 {}
C {lab_pin.sym} 3860 48440 0 0 {name=l38819 lab=VDD}
N 3840 48360 3860 48360 {}
C {lab_pin.sym} 3860 48360 0 0 {name=l38820 lab=VSS}
C {bitcell_6t.sym} 4000 48400 0 0 {name=Xr242c20}
N 3960 48440 3940 48440 {}
C {lab_pin.sym} 3940 48440 0 0 {name=l38821 lab=BL20}
N 3960 48400 3940 48400 {}
C {lab_pin.sym} 3940 48400 0 0 {name=l38822 lab=BLB20}
N 3960 48360 3940 48360 {}
C {lab_pin.sym} 3940 48360 0 0 {name=l38823 lab=WL242}
N 4040 48440 4060 48440 {}
C {lab_pin.sym} 4060 48440 0 0 {name=l38824 lab=VDD}
N 4040 48360 4060 48360 {}
C {lab_pin.sym} 4060 48360 0 0 {name=l38825 lab=VSS}
C {bitcell_6t.sym} 4200 48400 0 0 {name=Xr242c21}
N 4160 48440 4140 48440 {}
C {lab_pin.sym} 4140 48440 0 0 {name=l38826 lab=BL21}
N 4160 48400 4140 48400 {}
C {lab_pin.sym} 4140 48400 0 0 {name=l38827 lab=BLB21}
N 4160 48360 4140 48360 {}
C {lab_pin.sym} 4140 48360 0 0 {name=l38828 lab=WL242}
N 4240 48440 4260 48440 {}
C {lab_pin.sym} 4260 48440 0 0 {name=l38829 lab=VDD}
N 4240 48360 4260 48360 {}
C {lab_pin.sym} 4260 48360 0 0 {name=l38830 lab=VSS}
C {bitcell_6t.sym} 4400 48400 0 0 {name=Xr242c22}
N 4360 48440 4340 48440 {}
C {lab_pin.sym} 4340 48440 0 0 {name=l38831 lab=BL22}
N 4360 48400 4340 48400 {}
C {lab_pin.sym} 4340 48400 0 0 {name=l38832 lab=BLB22}
N 4360 48360 4340 48360 {}
C {lab_pin.sym} 4340 48360 0 0 {name=l38833 lab=WL242}
N 4440 48440 4460 48440 {}
C {lab_pin.sym} 4460 48440 0 0 {name=l38834 lab=VDD}
N 4440 48360 4460 48360 {}
C {lab_pin.sym} 4460 48360 0 0 {name=l38835 lab=VSS}
C {bitcell_6t.sym} 4600 48400 0 0 {name=Xr242c23}
N 4560 48440 4540 48440 {}
C {lab_pin.sym} 4540 48440 0 0 {name=l38836 lab=BL23}
N 4560 48400 4540 48400 {}
C {lab_pin.sym} 4540 48400 0 0 {name=l38837 lab=BLB23}
N 4560 48360 4540 48360 {}
C {lab_pin.sym} 4540 48360 0 0 {name=l38838 lab=WL242}
N 4640 48440 4660 48440 {}
C {lab_pin.sym} 4660 48440 0 0 {name=l38839 lab=VDD}
N 4640 48360 4660 48360 {}
C {lab_pin.sym} 4660 48360 0 0 {name=l38840 lab=VSS}
C {bitcell_6t.sym} 4800 48400 0 0 {name=Xr242c24}
N 4760 48440 4740 48440 {}
C {lab_pin.sym} 4740 48440 0 0 {name=l38841 lab=BL24}
N 4760 48400 4740 48400 {}
C {lab_pin.sym} 4740 48400 0 0 {name=l38842 lab=BLB24}
N 4760 48360 4740 48360 {}
C {lab_pin.sym} 4740 48360 0 0 {name=l38843 lab=WL242}
N 4840 48440 4860 48440 {}
C {lab_pin.sym} 4860 48440 0 0 {name=l38844 lab=VDD}
N 4840 48360 4860 48360 {}
C {lab_pin.sym} 4860 48360 0 0 {name=l38845 lab=VSS}
C {bitcell_6t.sym} 5000 48400 0 0 {name=Xr242c25}
N 4960 48440 4940 48440 {}
C {lab_pin.sym} 4940 48440 0 0 {name=l38846 lab=BL25}
N 4960 48400 4940 48400 {}
C {lab_pin.sym} 4940 48400 0 0 {name=l38847 lab=BLB25}
N 4960 48360 4940 48360 {}
C {lab_pin.sym} 4940 48360 0 0 {name=l38848 lab=WL242}
N 5040 48440 5060 48440 {}
C {lab_pin.sym} 5060 48440 0 0 {name=l38849 lab=VDD}
N 5040 48360 5060 48360 {}
C {lab_pin.sym} 5060 48360 0 0 {name=l38850 lab=VSS}
C {bitcell_6t.sym} 5200 48400 0 0 {name=Xr242c26}
N 5160 48440 5140 48440 {}
C {lab_pin.sym} 5140 48440 0 0 {name=l38851 lab=BL26}
N 5160 48400 5140 48400 {}
C {lab_pin.sym} 5140 48400 0 0 {name=l38852 lab=BLB26}
N 5160 48360 5140 48360 {}
C {lab_pin.sym} 5140 48360 0 0 {name=l38853 lab=WL242}
N 5240 48440 5260 48440 {}
C {lab_pin.sym} 5260 48440 0 0 {name=l38854 lab=VDD}
N 5240 48360 5260 48360 {}
C {lab_pin.sym} 5260 48360 0 0 {name=l38855 lab=VSS}
C {bitcell_6t.sym} 5400 48400 0 0 {name=Xr242c27}
N 5360 48440 5340 48440 {}
C {lab_pin.sym} 5340 48440 0 0 {name=l38856 lab=BL27}
N 5360 48400 5340 48400 {}
C {lab_pin.sym} 5340 48400 0 0 {name=l38857 lab=BLB27}
N 5360 48360 5340 48360 {}
C {lab_pin.sym} 5340 48360 0 0 {name=l38858 lab=WL242}
N 5440 48440 5460 48440 {}
C {lab_pin.sym} 5460 48440 0 0 {name=l38859 lab=VDD}
N 5440 48360 5460 48360 {}
C {lab_pin.sym} 5460 48360 0 0 {name=l38860 lab=VSS}
C {bitcell_6t.sym} 5600 48400 0 0 {name=Xr242c28}
N 5560 48440 5540 48440 {}
C {lab_pin.sym} 5540 48440 0 0 {name=l38861 lab=BL28}
N 5560 48400 5540 48400 {}
C {lab_pin.sym} 5540 48400 0 0 {name=l38862 lab=BLB28}
N 5560 48360 5540 48360 {}
C {lab_pin.sym} 5540 48360 0 0 {name=l38863 lab=WL242}
N 5640 48440 5660 48440 {}
C {lab_pin.sym} 5660 48440 0 0 {name=l38864 lab=VDD}
N 5640 48360 5660 48360 {}
C {lab_pin.sym} 5660 48360 0 0 {name=l38865 lab=VSS}
C {bitcell_6t.sym} 5800 48400 0 0 {name=Xr242c29}
N 5760 48440 5740 48440 {}
C {lab_pin.sym} 5740 48440 0 0 {name=l38866 lab=BL29}
N 5760 48400 5740 48400 {}
C {lab_pin.sym} 5740 48400 0 0 {name=l38867 lab=BLB29}
N 5760 48360 5740 48360 {}
C {lab_pin.sym} 5740 48360 0 0 {name=l38868 lab=WL242}
N 5840 48440 5860 48440 {}
C {lab_pin.sym} 5860 48440 0 0 {name=l38869 lab=VDD}
N 5840 48360 5860 48360 {}
C {lab_pin.sym} 5860 48360 0 0 {name=l38870 lab=VSS}
C {bitcell_6t.sym} 6000 48400 0 0 {name=Xr242c30}
N 5960 48440 5940 48440 {}
C {lab_pin.sym} 5940 48440 0 0 {name=l38871 lab=BL30}
N 5960 48400 5940 48400 {}
C {lab_pin.sym} 5940 48400 0 0 {name=l38872 lab=BLB30}
N 5960 48360 5940 48360 {}
C {lab_pin.sym} 5940 48360 0 0 {name=l38873 lab=WL242}
N 6040 48440 6060 48440 {}
C {lab_pin.sym} 6060 48440 0 0 {name=l38874 lab=VDD}
N 6040 48360 6060 48360 {}
C {lab_pin.sym} 6060 48360 0 0 {name=l38875 lab=VSS}
C {bitcell_6t.sym} 6200 48400 0 0 {name=Xr242c31}
N 6160 48440 6140 48440 {}
C {lab_pin.sym} 6140 48440 0 0 {name=l38876 lab=BL31}
N 6160 48400 6140 48400 {}
C {lab_pin.sym} 6140 48400 0 0 {name=l38877 lab=BLB31}
N 6160 48360 6140 48360 {}
C {lab_pin.sym} 6140 48360 0 0 {name=l38878 lab=WL242}
N 6240 48440 6260 48440 {}
C {lab_pin.sym} 6260 48440 0 0 {name=l38879 lab=VDD}
N 6240 48360 6260 48360 {}
C {lab_pin.sym} 6260 48360 0 0 {name=l38880 lab=VSS}
C {bitcell_6t.sym} 0 48600 0 0 {name=Xr243c0}
N -40 48640 -60 48640 {}
C {lab_pin.sym} -60 48640 0 0 {name=l38881 lab=BL0}
N -40 48600 -60 48600 {}
C {lab_pin.sym} -60 48600 0 0 {name=l38882 lab=BLB0}
N -40 48560 -60 48560 {}
C {lab_pin.sym} -60 48560 0 0 {name=l38883 lab=WL243}
N 40 48640 60 48640 {}
C {lab_pin.sym} 60 48640 0 0 {name=l38884 lab=VDD}
N 40 48560 60 48560 {}
C {lab_pin.sym} 60 48560 0 0 {name=l38885 lab=VSS}
C {bitcell_6t.sym} 200 48600 0 0 {name=Xr243c1}
N 160 48640 140 48640 {}
C {lab_pin.sym} 140 48640 0 0 {name=l38886 lab=BL1}
N 160 48600 140 48600 {}
C {lab_pin.sym} 140 48600 0 0 {name=l38887 lab=BLB1}
N 160 48560 140 48560 {}
C {lab_pin.sym} 140 48560 0 0 {name=l38888 lab=WL243}
N 240 48640 260 48640 {}
C {lab_pin.sym} 260 48640 0 0 {name=l38889 lab=VDD}
N 240 48560 260 48560 {}
C {lab_pin.sym} 260 48560 0 0 {name=l38890 lab=VSS}
C {bitcell_6t.sym} 400 48600 0 0 {name=Xr243c2}
N 360 48640 340 48640 {}
C {lab_pin.sym} 340 48640 0 0 {name=l38891 lab=BL2}
N 360 48600 340 48600 {}
C {lab_pin.sym} 340 48600 0 0 {name=l38892 lab=BLB2}
N 360 48560 340 48560 {}
C {lab_pin.sym} 340 48560 0 0 {name=l38893 lab=WL243}
N 440 48640 460 48640 {}
C {lab_pin.sym} 460 48640 0 0 {name=l38894 lab=VDD}
N 440 48560 460 48560 {}
C {lab_pin.sym} 460 48560 0 0 {name=l38895 lab=VSS}
C {bitcell_6t.sym} 600 48600 0 0 {name=Xr243c3}
N 560 48640 540 48640 {}
C {lab_pin.sym} 540 48640 0 0 {name=l38896 lab=BL3}
N 560 48600 540 48600 {}
C {lab_pin.sym} 540 48600 0 0 {name=l38897 lab=BLB3}
N 560 48560 540 48560 {}
C {lab_pin.sym} 540 48560 0 0 {name=l38898 lab=WL243}
N 640 48640 660 48640 {}
C {lab_pin.sym} 660 48640 0 0 {name=l38899 lab=VDD}
N 640 48560 660 48560 {}
C {lab_pin.sym} 660 48560 0 0 {name=l38900 lab=VSS}
C {bitcell_6t.sym} 800 48600 0 0 {name=Xr243c4}
N 760 48640 740 48640 {}
C {lab_pin.sym} 740 48640 0 0 {name=l38901 lab=BL4}
N 760 48600 740 48600 {}
C {lab_pin.sym} 740 48600 0 0 {name=l38902 lab=BLB4}
N 760 48560 740 48560 {}
C {lab_pin.sym} 740 48560 0 0 {name=l38903 lab=WL243}
N 840 48640 860 48640 {}
C {lab_pin.sym} 860 48640 0 0 {name=l38904 lab=VDD}
N 840 48560 860 48560 {}
C {lab_pin.sym} 860 48560 0 0 {name=l38905 lab=VSS}
C {bitcell_6t.sym} 1000 48600 0 0 {name=Xr243c5}
N 960 48640 940 48640 {}
C {lab_pin.sym} 940 48640 0 0 {name=l38906 lab=BL5}
N 960 48600 940 48600 {}
C {lab_pin.sym} 940 48600 0 0 {name=l38907 lab=BLB5}
N 960 48560 940 48560 {}
C {lab_pin.sym} 940 48560 0 0 {name=l38908 lab=WL243}
N 1040 48640 1060 48640 {}
C {lab_pin.sym} 1060 48640 0 0 {name=l38909 lab=VDD}
N 1040 48560 1060 48560 {}
C {lab_pin.sym} 1060 48560 0 0 {name=l38910 lab=VSS}
C {bitcell_6t.sym} 1200 48600 0 0 {name=Xr243c6}
N 1160 48640 1140 48640 {}
C {lab_pin.sym} 1140 48640 0 0 {name=l38911 lab=BL6}
N 1160 48600 1140 48600 {}
C {lab_pin.sym} 1140 48600 0 0 {name=l38912 lab=BLB6}
N 1160 48560 1140 48560 {}
C {lab_pin.sym} 1140 48560 0 0 {name=l38913 lab=WL243}
N 1240 48640 1260 48640 {}
C {lab_pin.sym} 1260 48640 0 0 {name=l38914 lab=VDD}
N 1240 48560 1260 48560 {}
C {lab_pin.sym} 1260 48560 0 0 {name=l38915 lab=VSS}
C {bitcell_6t.sym} 1400 48600 0 0 {name=Xr243c7}
N 1360 48640 1340 48640 {}
C {lab_pin.sym} 1340 48640 0 0 {name=l38916 lab=BL7}
N 1360 48600 1340 48600 {}
C {lab_pin.sym} 1340 48600 0 0 {name=l38917 lab=BLB7}
N 1360 48560 1340 48560 {}
C {lab_pin.sym} 1340 48560 0 0 {name=l38918 lab=WL243}
N 1440 48640 1460 48640 {}
C {lab_pin.sym} 1460 48640 0 0 {name=l38919 lab=VDD}
N 1440 48560 1460 48560 {}
C {lab_pin.sym} 1460 48560 0 0 {name=l38920 lab=VSS}
C {bitcell_6t.sym} 1600 48600 0 0 {name=Xr243c8}
N 1560 48640 1540 48640 {}
C {lab_pin.sym} 1540 48640 0 0 {name=l38921 lab=BL8}
N 1560 48600 1540 48600 {}
C {lab_pin.sym} 1540 48600 0 0 {name=l38922 lab=BLB8}
N 1560 48560 1540 48560 {}
C {lab_pin.sym} 1540 48560 0 0 {name=l38923 lab=WL243}
N 1640 48640 1660 48640 {}
C {lab_pin.sym} 1660 48640 0 0 {name=l38924 lab=VDD}
N 1640 48560 1660 48560 {}
C {lab_pin.sym} 1660 48560 0 0 {name=l38925 lab=VSS}
C {bitcell_6t.sym} 1800 48600 0 0 {name=Xr243c9}
N 1760 48640 1740 48640 {}
C {lab_pin.sym} 1740 48640 0 0 {name=l38926 lab=BL9}
N 1760 48600 1740 48600 {}
C {lab_pin.sym} 1740 48600 0 0 {name=l38927 lab=BLB9}
N 1760 48560 1740 48560 {}
C {lab_pin.sym} 1740 48560 0 0 {name=l38928 lab=WL243}
N 1840 48640 1860 48640 {}
C {lab_pin.sym} 1860 48640 0 0 {name=l38929 lab=VDD}
N 1840 48560 1860 48560 {}
C {lab_pin.sym} 1860 48560 0 0 {name=l38930 lab=VSS}
C {bitcell_6t.sym} 2000 48600 0 0 {name=Xr243c10}
N 1960 48640 1940 48640 {}
C {lab_pin.sym} 1940 48640 0 0 {name=l38931 lab=BL10}
N 1960 48600 1940 48600 {}
C {lab_pin.sym} 1940 48600 0 0 {name=l38932 lab=BLB10}
N 1960 48560 1940 48560 {}
C {lab_pin.sym} 1940 48560 0 0 {name=l38933 lab=WL243}
N 2040 48640 2060 48640 {}
C {lab_pin.sym} 2060 48640 0 0 {name=l38934 lab=VDD}
N 2040 48560 2060 48560 {}
C {lab_pin.sym} 2060 48560 0 0 {name=l38935 lab=VSS}
C {bitcell_6t.sym} 2200 48600 0 0 {name=Xr243c11}
N 2160 48640 2140 48640 {}
C {lab_pin.sym} 2140 48640 0 0 {name=l38936 lab=BL11}
N 2160 48600 2140 48600 {}
C {lab_pin.sym} 2140 48600 0 0 {name=l38937 lab=BLB11}
N 2160 48560 2140 48560 {}
C {lab_pin.sym} 2140 48560 0 0 {name=l38938 lab=WL243}
N 2240 48640 2260 48640 {}
C {lab_pin.sym} 2260 48640 0 0 {name=l38939 lab=VDD}
N 2240 48560 2260 48560 {}
C {lab_pin.sym} 2260 48560 0 0 {name=l38940 lab=VSS}
C {bitcell_6t.sym} 2400 48600 0 0 {name=Xr243c12}
N 2360 48640 2340 48640 {}
C {lab_pin.sym} 2340 48640 0 0 {name=l38941 lab=BL12}
N 2360 48600 2340 48600 {}
C {lab_pin.sym} 2340 48600 0 0 {name=l38942 lab=BLB12}
N 2360 48560 2340 48560 {}
C {lab_pin.sym} 2340 48560 0 0 {name=l38943 lab=WL243}
N 2440 48640 2460 48640 {}
C {lab_pin.sym} 2460 48640 0 0 {name=l38944 lab=VDD}
N 2440 48560 2460 48560 {}
C {lab_pin.sym} 2460 48560 0 0 {name=l38945 lab=VSS}
C {bitcell_6t.sym} 2600 48600 0 0 {name=Xr243c13}
N 2560 48640 2540 48640 {}
C {lab_pin.sym} 2540 48640 0 0 {name=l38946 lab=BL13}
N 2560 48600 2540 48600 {}
C {lab_pin.sym} 2540 48600 0 0 {name=l38947 lab=BLB13}
N 2560 48560 2540 48560 {}
C {lab_pin.sym} 2540 48560 0 0 {name=l38948 lab=WL243}
N 2640 48640 2660 48640 {}
C {lab_pin.sym} 2660 48640 0 0 {name=l38949 lab=VDD}
N 2640 48560 2660 48560 {}
C {lab_pin.sym} 2660 48560 0 0 {name=l38950 lab=VSS}
C {bitcell_6t.sym} 2800 48600 0 0 {name=Xr243c14}
N 2760 48640 2740 48640 {}
C {lab_pin.sym} 2740 48640 0 0 {name=l38951 lab=BL14}
N 2760 48600 2740 48600 {}
C {lab_pin.sym} 2740 48600 0 0 {name=l38952 lab=BLB14}
N 2760 48560 2740 48560 {}
C {lab_pin.sym} 2740 48560 0 0 {name=l38953 lab=WL243}
N 2840 48640 2860 48640 {}
C {lab_pin.sym} 2860 48640 0 0 {name=l38954 lab=VDD}
N 2840 48560 2860 48560 {}
C {lab_pin.sym} 2860 48560 0 0 {name=l38955 lab=VSS}
C {bitcell_6t.sym} 3000 48600 0 0 {name=Xr243c15}
N 2960 48640 2940 48640 {}
C {lab_pin.sym} 2940 48640 0 0 {name=l38956 lab=BL15}
N 2960 48600 2940 48600 {}
C {lab_pin.sym} 2940 48600 0 0 {name=l38957 lab=BLB15}
N 2960 48560 2940 48560 {}
C {lab_pin.sym} 2940 48560 0 0 {name=l38958 lab=WL243}
N 3040 48640 3060 48640 {}
C {lab_pin.sym} 3060 48640 0 0 {name=l38959 lab=VDD}
N 3040 48560 3060 48560 {}
C {lab_pin.sym} 3060 48560 0 0 {name=l38960 lab=VSS}
C {bitcell_6t.sym} 3200 48600 0 0 {name=Xr243c16}
N 3160 48640 3140 48640 {}
C {lab_pin.sym} 3140 48640 0 0 {name=l38961 lab=BL16}
N 3160 48600 3140 48600 {}
C {lab_pin.sym} 3140 48600 0 0 {name=l38962 lab=BLB16}
N 3160 48560 3140 48560 {}
C {lab_pin.sym} 3140 48560 0 0 {name=l38963 lab=WL243}
N 3240 48640 3260 48640 {}
C {lab_pin.sym} 3260 48640 0 0 {name=l38964 lab=VDD}
N 3240 48560 3260 48560 {}
C {lab_pin.sym} 3260 48560 0 0 {name=l38965 lab=VSS}
C {bitcell_6t.sym} 3400 48600 0 0 {name=Xr243c17}
N 3360 48640 3340 48640 {}
C {lab_pin.sym} 3340 48640 0 0 {name=l38966 lab=BL17}
N 3360 48600 3340 48600 {}
C {lab_pin.sym} 3340 48600 0 0 {name=l38967 lab=BLB17}
N 3360 48560 3340 48560 {}
C {lab_pin.sym} 3340 48560 0 0 {name=l38968 lab=WL243}
N 3440 48640 3460 48640 {}
C {lab_pin.sym} 3460 48640 0 0 {name=l38969 lab=VDD}
N 3440 48560 3460 48560 {}
C {lab_pin.sym} 3460 48560 0 0 {name=l38970 lab=VSS}
C {bitcell_6t.sym} 3600 48600 0 0 {name=Xr243c18}
N 3560 48640 3540 48640 {}
C {lab_pin.sym} 3540 48640 0 0 {name=l38971 lab=BL18}
N 3560 48600 3540 48600 {}
C {lab_pin.sym} 3540 48600 0 0 {name=l38972 lab=BLB18}
N 3560 48560 3540 48560 {}
C {lab_pin.sym} 3540 48560 0 0 {name=l38973 lab=WL243}
N 3640 48640 3660 48640 {}
C {lab_pin.sym} 3660 48640 0 0 {name=l38974 lab=VDD}
N 3640 48560 3660 48560 {}
C {lab_pin.sym} 3660 48560 0 0 {name=l38975 lab=VSS}
C {bitcell_6t.sym} 3800 48600 0 0 {name=Xr243c19}
N 3760 48640 3740 48640 {}
C {lab_pin.sym} 3740 48640 0 0 {name=l38976 lab=BL19}
N 3760 48600 3740 48600 {}
C {lab_pin.sym} 3740 48600 0 0 {name=l38977 lab=BLB19}
N 3760 48560 3740 48560 {}
C {lab_pin.sym} 3740 48560 0 0 {name=l38978 lab=WL243}
N 3840 48640 3860 48640 {}
C {lab_pin.sym} 3860 48640 0 0 {name=l38979 lab=VDD}
N 3840 48560 3860 48560 {}
C {lab_pin.sym} 3860 48560 0 0 {name=l38980 lab=VSS}
C {bitcell_6t.sym} 4000 48600 0 0 {name=Xr243c20}
N 3960 48640 3940 48640 {}
C {lab_pin.sym} 3940 48640 0 0 {name=l38981 lab=BL20}
N 3960 48600 3940 48600 {}
C {lab_pin.sym} 3940 48600 0 0 {name=l38982 lab=BLB20}
N 3960 48560 3940 48560 {}
C {lab_pin.sym} 3940 48560 0 0 {name=l38983 lab=WL243}
N 4040 48640 4060 48640 {}
C {lab_pin.sym} 4060 48640 0 0 {name=l38984 lab=VDD}
N 4040 48560 4060 48560 {}
C {lab_pin.sym} 4060 48560 0 0 {name=l38985 lab=VSS}
C {bitcell_6t.sym} 4200 48600 0 0 {name=Xr243c21}
N 4160 48640 4140 48640 {}
C {lab_pin.sym} 4140 48640 0 0 {name=l38986 lab=BL21}
N 4160 48600 4140 48600 {}
C {lab_pin.sym} 4140 48600 0 0 {name=l38987 lab=BLB21}
N 4160 48560 4140 48560 {}
C {lab_pin.sym} 4140 48560 0 0 {name=l38988 lab=WL243}
N 4240 48640 4260 48640 {}
C {lab_pin.sym} 4260 48640 0 0 {name=l38989 lab=VDD}
N 4240 48560 4260 48560 {}
C {lab_pin.sym} 4260 48560 0 0 {name=l38990 lab=VSS}
C {bitcell_6t.sym} 4400 48600 0 0 {name=Xr243c22}
N 4360 48640 4340 48640 {}
C {lab_pin.sym} 4340 48640 0 0 {name=l38991 lab=BL22}
N 4360 48600 4340 48600 {}
C {lab_pin.sym} 4340 48600 0 0 {name=l38992 lab=BLB22}
N 4360 48560 4340 48560 {}
C {lab_pin.sym} 4340 48560 0 0 {name=l38993 lab=WL243}
N 4440 48640 4460 48640 {}
C {lab_pin.sym} 4460 48640 0 0 {name=l38994 lab=VDD}
N 4440 48560 4460 48560 {}
C {lab_pin.sym} 4460 48560 0 0 {name=l38995 lab=VSS}
C {bitcell_6t.sym} 4600 48600 0 0 {name=Xr243c23}
N 4560 48640 4540 48640 {}
C {lab_pin.sym} 4540 48640 0 0 {name=l38996 lab=BL23}
N 4560 48600 4540 48600 {}
C {lab_pin.sym} 4540 48600 0 0 {name=l38997 lab=BLB23}
N 4560 48560 4540 48560 {}
C {lab_pin.sym} 4540 48560 0 0 {name=l38998 lab=WL243}
N 4640 48640 4660 48640 {}
C {lab_pin.sym} 4660 48640 0 0 {name=l38999 lab=VDD}
N 4640 48560 4660 48560 {}
C {lab_pin.sym} 4660 48560 0 0 {name=l39000 lab=VSS}
C {bitcell_6t.sym} 4800 48600 0 0 {name=Xr243c24}
N 4760 48640 4740 48640 {}
C {lab_pin.sym} 4740 48640 0 0 {name=l39001 lab=BL24}
N 4760 48600 4740 48600 {}
C {lab_pin.sym} 4740 48600 0 0 {name=l39002 lab=BLB24}
N 4760 48560 4740 48560 {}
C {lab_pin.sym} 4740 48560 0 0 {name=l39003 lab=WL243}
N 4840 48640 4860 48640 {}
C {lab_pin.sym} 4860 48640 0 0 {name=l39004 lab=VDD}
N 4840 48560 4860 48560 {}
C {lab_pin.sym} 4860 48560 0 0 {name=l39005 lab=VSS}
C {bitcell_6t.sym} 5000 48600 0 0 {name=Xr243c25}
N 4960 48640 4940 48640 {}
C {lab_pin.sym} 4940 48640 0 0 {name=l39006 lab=BL25}
N 4960 48600 4940 48600 {}
C {lab_pin.sym} 4940 48600 0 0 {name=l39007 lab=BLB25}
N 4960 48560 4940 48560 {}
C {lab_pin.sym} 4940 48560 0 0 {name=l39008 lab=WL243}
N 5040 48640 5060 48640 {}
C {lab_pin.sym} 5060 48640 0 0 {name=l39009 lab=VDD}
N 5040 48560 5060 48560 {}
C {lab_pin.sym} 5060 48560 0 0 {name=l39010 lab=VSS}
C {bitcell_6t.sym} 5200 48600 0 0 {name=Xr243c26}
N 5160 48640 5140 48640 {}
C {lab_pin.sym} 5140 48640 0 0 {name=l39011 lab=BL26}
N 5160 48600 5140 48600 {}
C {lab_pin.sym} 5140 48600 0 0 {name=l39012 lab=BLB26}
N 5160 48560 5140 48560 {}
C {lab_pin.sym} 5140 48560 0 0 {name=l39013 lab=WL243}
N 5240 48640 5260 48640 {}
C {lab_pin.sym} 5260 48640 0 0 {name=l39014 lab=VDD}
N 5240 48560 5260 48560 {}
C {lab_pin.sym} 5260 48560 0 0 {name=l39015 lab=VSS}
C {bitcell_6t.sym} 5400 48600 0 0 {name=Xr243c27}
N 5360 48640 5340 48640 {}
C {lab_pin.sym} 5340 48640 0 0 {name=l39016 lab=BL27}
N 5360 48600 5340 48600 {}
C {lab_pin.sym} 5340 48600 0 0 {name=l39017 lab=BLB27}
N 5360 48560 5340 48560 {}
C {lab_pin.sym} 5340 48560 0 0 {name=l39018 lab=WL243}
N 5440 48640 5460 48640 {}
C {lab_pin.sym} 5460 48640 0 0 {name=l39019 lab=VDD}
N 5440 48560 5460 48560 {}
C {lab_pin.sym} 5460 48560 0 0 {name=l39020 lab=VSS}
C {bitcell_6t.sym} 5600 48600 0 0 {name=Xr243c28}
N 5560 48640 5540 48640 {}
C {lab_pin.sym} 5540 48640 0 0 {name=l39021 lab=BL28}
N 5560 48600 5540 48600 {}
C {lab_pin.sym} 5540 48600 0 0 {name=l39022 lab=BLB28}
N 5560 48560 5540 48560 {}
C {lab_pin.sym} 5540 48560 0 0 {name=l39023 lab=WL243}
N 5640 48640 5660 48640 {}
C {lab_pin.sym} 5660 48640 0 0 {name=l39024 lab=VDD}
N 5640 48560 5660 48560 {}
C {lab_pin.sym} 5660 48560 0 0 {name=l39025 lab=VSS}
C {bitcell_6t.sym} 5800 48600 0 0 {name=Xr243c29}
N 5760 48640 5740 48640 {}
C {lab_pin.sym} 5740 48640 0 0 {name=l39026 lab=BL29}
N 5760 48600 5740 48600 {}
C {lab_pin.sym} 5740 48600 0 0 {name=l39027 lab=BLB29}
N 5760 48560 5740 48560 {}
C {lab_pin.sym} 5740 48560 0 0 {name=l39028 lab=WL243}
N 5840 48640 5860 48640 {}
C {lab_pin.sym} 5860 48640 0 0 {name=l39029 lab=VDD}
N 5840 48560 5860 48560 {}
C {lab_pin.sym} 5860 48560 0 0 {name=l39030 lab=VSS}
C {bitcell_6t.sym} 6000 48600 0 0 {name=Xr243c30}
N 5960 48640 5940 48640 {}
C {lab_pin.sym} 5940 48640 0 0 {name=l39031 lab=BL30}
N 5960 48600 5940 48600 {}
C {lab_pin.sym} 5940 48600 0 0 {name=l39032 lab=BLB30}
N 5960 48560 5940 48560 {}
C {lab_pin.sym} 5940 48560 0 0 {name=l39033 lab=WL243}
N 6040 48640 6060 48640 {}
C {lab_pin.sym} 6060 48640 0 0 {name=l39034 lab=VDD}
N 6040 48560 6060 48560 {}
C {lab_pin.sym} 6060 48560 0 0 {name=l39035 lab=VSS}
C {bitcell_6t.sym} 6200 48600 0 0 {name=Xr243c31}
N 6160 48640 6140 48640 {}
C {lab_pin.sym} 6140 48640 0 0 {name=l39036 lab=BL31}
N 6160 48600 6140 48600 {}
C {lab_pin.sym} 6140 48600 0 0 {name=l39037 lab=BLB31}
N 6160 48560 6140 48560 {}
C {lab_pin.sym} 6140 48560 0 0 {name=l39038 lab=WL243}
N 6240 48640 6260 48640 {}
C {lab_pin.sym} 6260 48640 0 0 {name=l39039 lab=VDD}
N 6240 48560 6260 48560 {}
C {lab_pin.sym} 6260 48560 0 0 {name=l39040 lab=VSS}
C {bitcell_6t.sym} 0 48800 0 0 {name=Xr244c0}
N -40 48840 -60 48840 {}
C {lab_pin.sym} -60 48840 0 0 {name=l39041 lab=BL0}
N -40 48800 -60 48800 {}
C {lab_pin.sym} -60 48800 0 0 {name=l39042 lab=BLB0}
N -40 48760 -60 48760 {}
C {lab_pin.sym} -60 48760 0 0 {name=l39043 lab=WL244}
N 40 48840 60 48840 {}
C {lab_pin.sym} 60 48840 0 0 {name=l39044 lab=VDD}
N 40 48760 60 48760 {}
C {lab_pin.sym} 60 48760 0 0 {name=l39045 lab=VSS}
C {bitcell_6t.sym} 200 48800 0 0 {name=Xr244c1}
N 160 48840 140 48840 {}
C {lab_pin.sym} 140 48840 0 0 {name=l39046 lab=BL1}
N 160 48800 140 48800 {}
C {lab_pin.sym} 140 48800 0 0 {name=l39047 lab=BLB1}
N 160 48760 140 48760 {}
C {lab_pin.sym} 140 48760 0 0 {name=l39048 lab=WL244}
N 240 48840 260 48840 {}
C {lab_pin.sym} 260 48840 0 0 {name=l39049 lab=VDD}
N 240 48760 260 48760 {}
C {lab_pin.sym} 260 48760 0 0 {name=l39050 lab=VSS}
C {bitcell_6t.sym} 400 48800 0 0 {name=Xr244c2}
N 360 48840 340 48840 {}
C {lab_pin.sym} 340 48840 0 0 {name=l39051 lab=BL2}
N 360 48800 340 48800 {}
C {lab_pin.sym} 340 48800 0 0 {name=l39052 lab=BLB2}
N 360 48760 340 48760 {}
C {lab_pin.sym} 340 48760 0 0 {name=l39053 lab=WL244}
N 440 48840 460 48840 {}
C {lab_pin.sym} 460 48840 0 0 {name=l39054 lab=VDD}
N 440 48760 460 48760 {}
C {lab_pin.sym} 460 48760 0 0 {name=l39055 lab=VSS}
C {bitcell_6t.sym} 600 48800 0 0 {name=Xr244c3}
N 560 48840 540 48840 {}
C {lab_pin.sym} 540 48840 0 0 {name=l39056 lab=BL3}
N 560 48800 540 48800 {}
C {lab_pin.sym} 540 48800 0 0 {name=l39057 lab=BLB3}
N 560 48760 540 48760 {}
C {lab_pin.sym} 540 48760 0 0 {name=l39058 lab=WL244}
N 640 48840 660 48840 {}
C {lab_pin.sym} 660 48840 0 0 {name=l39059 lab=VDD}
N 640 48760 660 48760 {}
C {lab_pin.sym} 660 48760 0 0 {name=l39060 lab=VSS}
C {bitcell_6t.sym} 800 48800 0 0 {name=Xr244c4}
N 760 48840 740 48840 {}
C {lab_pin.sym} 740 48840 0 0 {name=l39061 lab=BL4}
N 760 48800 740 48800 {}
C {lab_pin.sym} 740 48800 0 0 {name=l39062 lab=BLB4}
N 760 48760 740 48760 {}
C {lab_pin.sym} 740 48760 0 0 {name=l39063 lab=WL244}
N 840 48840 860 48840 {}
C {lab_pin.sym} 860 48840 0 0 {name=l39064 lab=VDD}
N 840 48760 860 48760 {}
C {lab_pin.sym} 860 48760 0 0 {name=l39065 lab=VSS}
C {bitcell_6t.sym} 1000 48800 0 0 {name=Xr244c5}
N 960 48840 940 48840 {}
C {lab_pin.sym} 940 48840 0 0 {name=l39066 lab=BL5}
N 960 48800 940 48800 {}
C {lab_pin.sym} 940 48800 0 0 {name=l39067 lab=BLB5}
N 960 48760 940 48760 {}
C {lab_pin.sym} 940 48760 0 0 {name=l39068 lab=WL244}
N 1040 48840 1060 48840 {}
C {lab_pin.sym} 1060 48840 0 0 {name=l39069 lab=VDD}
N 1040 48760 1060 48760 {}
C {lab_pin.sym} 1060 48760 0 0 {name=l39070 lab=VSS}
C {bitcell_6t.sym} 1200 48800 0 0 {name=Xr244c6}
N 1160 48840 1140 48840 {}
C {lab_pin.sym} 1140 48840 0 0 {name=l39071 lab=BL6}
N 1160 48800 1140 48800 {}
C {lab_pin.sym} 1140 48800 0 0 {name=l39072 lab=BLB6}
N 1160 48760 1140 48760 {}
C {lab_pin.sym} 1140 48760 0 0 {name=l39073 lab=WL244}
N 1240 48840 1260 48840 {}
C {lab_pin.sym} 1260 48840 0 0 {name=l39074 lab=VDD}
N 1240 48760 1260 48760 {}
C {lab_pin.sym} 1260 48760 0 0 {name=l39075 lab=VSS}
C {bitcell_6t.sym} 1400 48800 0 0 {name=Xr244c7}
N 1360 48840 1340 48840 {}
C {lab_pin.sym} 1340 48840 0 0 {name=l39076 lab=BL7}
N 1360 48800 1340 48800 {}
C {lab_pin.sym} 1340 48800 0 0 {name=l39077 lab=BLB7}
N 1360 48760 1340 48760 {}
C {lab_pin.sym} 1340 48760 0 0 {name=l39078 lab=WL244}
N 1440 48840 1460 48840 {}
C {lab_pin.sym} 1460 48840 0 0 {name=l39079 lab=VDD}
N 1440 48760 1460 48760 {}
C {lab_pin.sym} 1460 48760 0 0 {name=l39080 lab=VSS}
C {bitcell_6t.sym} 1600 48800 0 0 {name=Xr244c8}
N 1560 48840 1540 48840 {}
C {lab_pin.sym} 1540 48840 0 0 {name=l39081 lab=BL8}
N 1560 48800 1540 48800 {}
C {lab_pin.sym} 1540 48800 0 0 {name=l39082 lab=BLB8}
N 1560 48760 1540 48760 {}
C {lab_pin.sym} 1540 48760 0 0 {name=l39083 lab=WL244}
N 1640 48840 1660 48840 {}
C {lab_pin.sym} 1660 48840 0 0 {name=l39084 lab=VDD}
N 1640 48760 1660 48760 {}
C {lab_pin.sym} 1660 48760 0 0 {name=l39085 lab=VSS}
C {bitcell_6t.sym} 1800 48800 0 0 {name=Xr244c9}
N 1760 48840 1740 48840 {}
C {lab_pin.sym} 1740 48840 0 0 {name=l39086 lab=BL9}
N 1760 48800 1740 48800 {}
C {lab_pin.sym} 1740 48800 0 0 {name=l39087 lab=BLB9}
N 1760 48760 1740 48760 {}
C {lab_pin.sym} 1740 48760 0 0 {name=l39088 lab=WL244}
N 1840 48840 1860 48840 {}
C {lab_pin.sym} 1860 48840 0 0 {name=l39089 lab=VDD}
N 1840 48760 1860 48760 {}
C {lab_pin.sym} 1860 48760 0 0 {name=l39090 lab=VSS}
C {bitcell_6t.sym} 2000 48800 0 0 {name=Xr244c10}
N 1960 48840 1940 48840 {}
C {lab_pin.sym} 1940 48840 0 0 {name=l39091 lab=BL10}
N 1960 48800 1940 48800 {}
C {lab_pin.sym} 1940 48800 0 0 {name=l39092 lab=BLB10}
N 1960 48760 1940 48760 {}
C {lab_pin.sym} 1940 48760 0 0 {name=l39093 lab=WL244}
N 2040 48840 2060 48840 {}
C {lab_pin.sym} 2060 48840 0 0 {name=l39094 lab=VDD}
N 2040 48760 2060 48760 {}
C {lab_pin.sym} 2060 48760 0 0 {name=l39095 lab=VSS}
C {bitcell_6t.sym} 2200 48800 0 0 {name=Xr244c11}
N 2160 48840 2140 48840 {}
C {lab_pin.sym} 2140 48840 0 0 {name=l39096 lab=BL11}
N 2160 48800 2140 48800 {}
C {lab_pin.sym} 2140 48800 0 0 {name=l39097 lab=BLB11}
N 2160 48760 2140 48760 {}
C {lab_pin.sym} 2140 48760 0 0 {name=l39098 lab=WL244}
N 2240 48840 2260 48840 {}
C {lab_pin.sym} 2260 48840 0 0 {name=l39099 lab=VDD}
N 2240 48760 2260 48760 {}
C {lab_pin.sym} 2260 48760 0 0 {name=l39100 lab=VSS}
C {bitcell_6t.sym} 2400 48800 0 0 {name=Xr244c12}
N 2360 48840 2340 48840 {}
C {lab_pin.sym} 2340 48840 0 0 {name=l39101 lab=BL12}
N 2360 48800 2340 48800 {}
C {lab_pin.sym} 2340 48800 0 0 {name=l39102 lab=BLB12}
N 2360 48760 2340 48760 {}
C {lab_pin.sym} 2340 48760 0 0 {name=l39103 lab=WL244}
N 2440 48840 2460 48840 {}
C {lab_pin.sym} 2460 48840 0 0 {name=l39104 lab=VDD}
N 2440 48760 2460 48760 {}
C {lab_pin.sym} 2460 48760 0 0 {name=l39105 lab=VSS}
C {bitcell_6t.sym} 2600 48800 0 0 {name=Xr244c13}
N 2560 48840 2540 48840 {}
C {lab_pin.sym} 2540 48840 0 0 {name=l39106 lab=BL13}
N 2560 48800 2540 48800 {}
C {lab_pin.sym} 2540 48800 0 0 {name=l39107 lab=BLB13}
N 2560 48760 2540 48760 {}
C {lab_pin.sym} 2540 48760 0 0 {name=l39108 lab=WL244}
N 2640 48840 2660 48840 {}
C {lab_pin.sym} 2660 48840 0 0 {name=l39109 lab=VDD}
N 2640 48760 2660 48760 {}
C {lab_pin.sym} 2660 48760 0 0 {name=l39110 lab=VSS}
C {bitcell_6t.sym} 2800 48800 0 0 {name=Xr244c14}
N 2760 48840 2740 48840 {}
C {lab_pin.sym} 2740 48840 0 0 {name=l39111 lab=BL14}
N 2760 48800 2740 48800 {}
C {lab_pin.sym} 2740 48800 0 0 {name=l39112 lab=BLB14}
N 2760 48760 2740 48760 {}
C {lab_pin.sym} 2740 48760 0 0 {name=l39113 lab=WL244}
N 2840 48840 2860 48840 {}
C {lab_pin.sym} 2860 48840 0 0 {name=l39114 lab=VDD}
N 2840 48760 2860 48760 {}
C {lab_pin.sym} 2860 48760 0 0 {name=l39115 lab=VSS}
C {bitcell_6t.sym} 3000 48800 0 0 {name=Xr244c15}
N 2960 48840 2940 48840 {}
C {lab_pin.sym} 2940 48840 0 0 {name=l39116 lab=BL15}
N 2960 48800 2940 48800 {}
C {lab_pin.sym} 2940 48800 0 0 {name=l39117 lab=BLB15}
N 2960 48760 2940 48760 {}
C {lab_pin.sym} 2940 48760 0 0 {name=l39118 lab=WL244}
N 3040 48840 3060 48840 {}
C {lab_pin.sym} 3060 48840 0 0 {name=l39119 lab=VDD}
N 3040 48760 3060 48760 {}
C {lab_pin.sym} 3060 48760 0 0 {name=l39120 lab=VSS}
C {bitcell_6t.sym} 3200 48800 0 0 {name=Xr244c16}
N 3160 48840 3140 48840 {}
C {lab_pin.sym} 3140 48840 0 0 {name=l39121 lab=BL16}
N 3160 48800 3140 48800 {}
C {lab_pin.sym} 3140 48800 0 0 {name=l39122 lab=BLB16}
N 3160 48760 3140 48760 {}
C {lab_pin.sym} 3140 48760 0 0 {name=l39123 lab=WL244}
N 3240 48840 3260 48840 {}
C {lab_pin.sym} 3260 48840 0 0 {name=l39124 lab=VDD}
N 3240 48760 3260 48760 {}
C {lab_pin.sym} 3260 48760 0 0 {name=l39125 lab=VSS}
C {bitcell_6t.sym} 3400 48800 0 0 {name=Xr244c17}
N 3360 48840 3340 48840 {}
C {lab_pin.sym} 3340 48840 0 0 {name=l39126 lab=BL17}
N 3360 48800 3340 48800 {}
C {lab_pin.sym} 3340 48800 0 0 {name=l39127 lab=BLB17}
N 3360 48760 3340 48760 {}
C {lab_pin.sym} 3340 48760 0 0 {name=l39128 lab=WL244}
N 3440 48840 3460 48840 {}
C {lab_pin.sym} 3460 48840 0 0 {name=l39129 lab=VDD}
N 3440 48760 3460 48760 {}
C {lab_pin.sym} 3460 48760 0 0 {name=l39130 lab=VSS}
C {bitcell_6t.sym} 3600 48800 0 0 {name=Xr244c18}
N 3560 48840 3540 48840 {}
C {lab_pin.sym} 3540 48840 0 0 {name=l39131 lab=BL18}
N 3560 48800 3540 48800 {}
C {lab_pin.sym} 3540 48800 0 0 {name=l39132 lab=BLB18}
N 3560 48760 3540 48760 {}
C {lab_pin.sym} 3540 48760 0 0 {name=l39133 lab=WL244}
N 3640 48840 3660 48840 {}
C {lab_pin.sym} 3660 48840 0 0 {name=l39134 lab=VDD}
N 3640 48760 3660 48760 {}
C {lab_pin.sym} 3660 48760 0 0 {name=l39135 lab=VSS}
C {bitcell_6t.sym} 3800 48800 0 0 {name=Xr244c19}
N 3760 48840 3740 48840 {}
C {lab_pin.sym} 3740 48840 0 0 {name=l39136 lab=BL19}
N 3760 48800 3740 48800 {}
C {lab_pin.sym} 3740 48800 0 0 {name=l39137 lab=BLB19}
N 3760 48760 3740 48760 {}
C {lab_pin.sym} 3740 48760 0 0 {name=l39138 lab=WL244}
N 3840 48840 3860 48840 {}
C {lab_pin.sym} 3860 48840 0 0 {name=l39139 lab=VDD}
N 3840 48760 3860 48760 {}
C {lab_pin.sym} 3860 48760 0 0 {name=l39140 lab=VSS}
C {bitcell_6t.sym} 4000 48800 0 0 {name=Xr244c20}
N 3960 48840 3940 48840 {}
C {lab_pin.sym} 3940 48840 0 0 {name=l39141 lab=BL20}
N 3960 48800 3940 48800 {}
C {lab_pin.sym} 3940 48800 0 0 {name=l39142 lab=BLB20}
N 3960 48760 3940 48760 {}
C {lab_pin.sym} 3940 48760 0 0 {name=l39143 lab=WL244}
N 4040 48840 4060 48840 {}
C {lab_pin.sym} 4060 48840 0 0 {name=l39144 lab=VDD}
N 4040 48760 4060 48760 {}
C {lab_pin.sym} 4060 48760 0 0 {name=l39145 lab=VSS}
C {bitcell_6t.sym} 4200 48800 0 0 {name=Xr244c21}
N 4160 48840 4140 48840 {}
C {lab_pin.sym} 4140 48840 0 0 {name=l39146 lab=BL21}
N 4160 48800 4140 48800 {}
C {lab_pin.sym} 4140 48800 0 0 {name=l39147 lab=BLB21}
N 4160 48760 4140 48760 {}
C {lab_pin.sym} 4140 48760 0 0 {name=l39148 lab=WL244}
N 4240 48840 4260 48840 {}
C {lab_pin.sym} 4260 48840 0 0 {name=l39149 lab=VDD}
N 4240 48760 4260 48760 {}
C {lab_pin.sym} 4260 48760 0 0 {name=l39150 lab=VSS}
C {bitcell_6t.sym} 4400 48800 0 0 {name=Xr244c22}
N 4360 48840 4340 48840 {}
C {lab_pin.sym} 4340 48840 0 0 {name=l39151 lab=BL22}
N 4360 48800 4340 48800 {}
C {lab_pin.sym} 4340 48800 0 0 {name=l39152 lab=BLB22}
N 4360 48760 4340 48760 {}
C {lab_pin.sym} 4340 48760 0 0 {name=l39153 lab=WL244}
N 4440 48840 4460 48840 {}
C {lab_pin.sym} 4460 48840 0 0 {name=l39154 lab=VDD}
N 4440 48760 4460 48760 {}
C {lab_pin.sym} 4460 48760 0 0 {name=l39155 lab=VSS}
C {bitcell_6t.sym} 4600 48800 0 0 {name=Xr244c23}
N 4560 48840 4540 48840 {}
C {lab_pin.sym} 4540 48840 0 0 {name=l39156 lab=BL23}
N 4560 48800 4540 48800 {}
C {lab_pin.sym} 4540 48800 0 0 {name=l39157 lab=BLB23}
N 4560 48760 4540 48760 {}
C {lab_pin.sym} 4540 48760 0 0 {name=l39158 lab=WL244}
N 4640 48840 4660 48840 {}
C {lab_pin.sym} 4660 48840 0 0 {name=l39159 lab=VDD}
N 4640 48760 4660 48760 {}
C {lab_pin.sym} 4660 48760 0 0 {name=l39160 lab=VSS}
C {bitcell_6t.sym} 4800 48800 0 0 {name=Xr244c24}
N 4760 48840 4740 48840 {}
C {lab_pin.sym} 4740 48840 0 0 {name=l39161 lab=BL24}
N 4760 48800 4740 48800 {}
C {lab_pin.sym} 4740 48800 0 0 {name=l39162 lab=BLB24}
N 4760 48760 4740 48760 {}
C {lab_pin.sym} 4740 48760 0 0 {name=l39163 lab=WL244}
N 4840 48840 4860 48840 {}
C {lab_pin.sym} 4860 48840 0 0 {name=l39164 lab=VDD}
N 4840 48760 4860 48760 {}
C {lab_pin.sym} 4860 48760 0 0 {name=l39165 lab=VSS}
C {bitcell_6t.sym} 5000 48800 0 0 {name=Xr244c25}
N 4960 48840 4940 48840 {}
C {lab_pin.sym} 4940 48840 0 0 {name=l39166 lab=BL25}
N 4960 48800 4940 48800 {}
C {lab_pin.sym} 4940 48800 0 0 {name=l39167 lab=BLB25}
N 4960 48760 4940 48760 {}
C {lab_pin.sym} 4940 48760 0 0 {name=l39168 lab=WL244}
N 5040 48840 5060 48840 {}
C {lab_pin.sym} 5060 48840 0 0 {name=l39169 lab=VDD}
N 5040 48760 5060 48760 {}
C {lab_pin.sym} 5060 48760 0 0 {name=l39170 lab=VSS}
C {bitcell_6t.sym} 5200 48800 0 0 {name=Xr244c26}
N 5160 48840 5140 48840 {}
C {lab_pin.sym} 5140 48840 0 0 {name=l39171 lab=BL26}
N 5160 48800 5140 48800 {}
C {lab_pin.sym} 5140 48800 0 0 {name=l39172 lab=BLB26}
N 5160 48760 5140 48760 {}
C {lab_pin.sym} 5140 48760 0 0 {name=l39173 lab=WL244}
N 5240 48840 5260 48840 {}
C {lab_pin.sym} 5260 48840 0 0 {name=l39174 lab=VDD}
N 5240 48760 5260 48760 {}
C {lab_pin.sym} 5260 48760 0 0 {name=l39175 lab=VSS}
C {bitcell_6t.sym} 5400 48800 0 0 {name=Xr244c27}
N 5360 48840 5340 48840 {}
C {lab_pin.sym} 5340 48840 0 0 {name=l39176 lab=BL27}
N 5360 48800 5340 48800 {}
C {lab_pin.sym} 5340 48800 0 0 {name=l39177 lab=BLB27}
N 5360 48760 5340 48760 {}
C {lab_pin.sym} 5340 48760 0 0 {name=l39178 lab=WL244}
N 5440 48840 5460 48840 {}
C {lab_pin.sym} 5460 48840 0 0 {name=l39179 lab=VDD}
N 5440 48760 5460 48760 {}
C {lab_pin.sym} 5460 48760 0 0 {name=l39180 lab=VSS}
C {bitcell_6t.sym} 5600 48800 0 0 {name=Xr244c28}
N 5560 48840 5540 48840 {}
C {lab_pin.sym} 5540 48840 0 0 {name=l39181 lab=BL28}
N 5560 48800 5540 48800 {}
C {lab_pin.sym} 5540 48800 0 0 {name=l39182 lab=BLB28}
N 5560 48760 5540 48760 {}
C {lab_pin.sym} 5540 48760 0 0 {name=l39183 lab=WL244}
N 5640 48840 5660 48840 {}
C {lab_pin.sym} 5660 48840 0 0 {name=l39184 lab=VDD}
N 5640 48760 5660 48760 {}
C {lab_pin.sym} 5660 48760 0 0 {name=l39185 lab=VSS}
C {bitcell_6t.sym} 5800 48800 0 0 {name=Xr244c29}
N 5760 48840 5740 48840 {}
C {lab_pin.sym} 5740 48840 0 0 {name=l39186 lab=BL29}
N 5760 48800 5740 48800 {}
C {lab_pin.sym} 5740 48800 0 0 {name=l39187 lab=BLB29}
N 5760 48760 5740 48760 {}
C {lab_pin.sym} 5740 48760 0 0 {name=l39188 lab=WL244}
N 5840 48840 5860 48840 {}
C {lab_pin.sym} 5860 48840 0 0 {name=l39189 lab=VDD}
N 5840 48760 5860 48760 {}
C {lab_pin.sym} 5860 48760 0 0 {name=l39190 lab=VSS}
C {bitcell_6t.sym} 6000 48800 0 0 {name=Xr244c30}
N 5960 48840 5940 48840 {}
C {lab_pin.sym} 5940 48840 0 0 {name=l39191 lab=BL30}
N 5960 48800 5940 48800 {}
C {lab_pin.sym} 5940 48800 0 0 {name=l39192 lab=BLB30}
N 5960 48760 5940 48760 {}
C {lab_pin.sym} 5940 48760 0 0 {name=l39193 lab=WL244}
N 6040 48840 6060 48840 {}
C {lab_pin.sym} 6060 48840 0 0 {name=l39194 lab=VDD}
N 6040 48760 6060 48760 {}
C {lab_pin.sym} 6060 48760 0 0 {name=l39195 lab=VSS}
C {bitcell_6t.sym} 6200 48800 0 0 {name=Xr244c31}
N 6160 48840 6140 48840 {}
C {lab_pin.sym} 6140 48840 0 0 {name=l39196 lab=BL31}
N 6160 48800 6140 48800 {}
C {lab_pin.sym} 6140 48800 0 0 {name=l39197 lab=BLB31}
N 6160 48760 6140 48760 {}
C {lab_pin.sym} 6140 48760 0 0 {name=l39198 lab=WL244}
N 6240 48840 6260 48840 {}
C {lab_pin.sym} 6260 48840 0 0 {name=l39199 lab=VDD}
N 6240 48760 6260 48760 {}
C {lab_pin.sym} 6260 48760 0 0 {name=l39200 lab=VSS}
C {bitcell_6t.sym} 0 49000 0 0 {name=Xr245c0}
N -40 49040 -60 49040 {}
C {lab_pin.sym} -60 49040 0 0 {name=l39201 lab=BL0}
N -40 49000 -60 49000 {}
C {lab_pin.sym} -60 49000 0 0 {name=l39202 lab=BLB0}
N -40 48960 -60 48960 {}
C {lab_pin.sym} -60 48960 0 0 {name=l39203 lab=WL245}
N 40 49040 60 49040 {}
C {lab_pin.sym} 60 49040 0 0 {name=l39204 lab=VDD}
N 40 48960 60 48960 {}
C {lab_pin.sym} 60 48960 0 0 {name=l39205 lab=VSS}
C {bitcell_6t.sym} 200 49000 0 0 {name=Xr245c1}
N 160 49040 140 49040 {}
C {lab_pin.sym} 140 49040 0 0 {name=l39206 lab=BL1}
N 160 49000 140 49000 {}
C {lab_pin.sym} 140 49000 0 0 {name=l39207 lab=BLB1}
N 160 48960 140 48960 {}
C {lab_pin.sym} 140 48960 0 0 {name=l39208 lab=WL245}
N 240 49040 260 49040 {}
C {lab_pin.sym} 260 49040 0 0 {name=l39209 lab=VDD}
N 240 48960 260 48960 {}
C {lab_pin.sym} 260 48960 0 0 {name=l39210 lab=VSS}
C {bitcell_6t.sym} 400 49000 0 0 {name=Xr245c2}
N 360 49040 340 49040 {}
C {lab_pin.sym} 340 49040 0 0 {name=l39211 lab=BL2}
N 360 49000 340 49000 {}
C {lab_pin.sym} 340 49000 0 0 {name=l39212 lab=BLB2}
N 360 48960 340 48960 {}
C {lab_pin.sym} 340 48960 0 0 {name=l39213 lab=WL245}
N 440 49040 460 49040 {}
C {lab_pin.sym} 460 49040 0 0 {name=l39214 lab=VDD}
N 440 48960 460 48960 {}
C {lab_pin.sym} 460 48960 0 0 {name=l39215 lab=VSS}
C {bitcell_6t.sym} 600 49000 0 0 {name=Xr245c3}
N 560 49040 540 49040 {}
C {lab_pin.sym} 540 49040 0 0 {name=l39216 lab=BL3}
N 560 49000 540 49000 {}
C {lab_pin.sym} 540 49000 0 0 {name=l39217 lab=BLB3}
N 560 48960 540 48960 {}
C {lab_pin.sym} 540 48960 0 0 {name=l39218 lab=WL245}
N 640 49040 660 49040 {}
C {lab_pin.sym} 660 49040 0 0 {name=l39219 lab=VDD}
N 640 48960 660 48960 {}
C {lab_pin.sym} 660 48960 0 0 {name=l39220 lab=VSS}
C {bitcell_6t.sym} 800 49000 0 0 {name=Xr245c4}
N 760 49040 740 49040 {}
C {lab_pin.sym} 740 49040 0 0 {name=l39221 lab=BL4}
N 760 49000 740 49000 {}
C {lab_pin.sym} 740 49000 0 0 {name=l39222 lab=BLB4}
N 760 48960 740 48960 {}
C {lab_pin.sym} 740 48960 0 0 {name=l39223 lab=WL245}
N 840 49040 860 49040 {}
C {lab_pin.sym} 860 49040 0 0 {name=l39224 lab=VDD}
N 840 48960 860 48960 {}
C {lab_pin.sym} 860 48960 0 0 {name=l39225 lab=VSS}
C {bitcell_6t.sym} 1000 49000 0 0 {name=Xr245c5}
N 960 49040 940 49040 {}
C {lab_pin.sym} 940 49040 0 0 {name=l39226 lab=BL5}
N 960 49000 940 49000 {}
C {lab_pin.sym} 940 49000 0 0 {name=l39227 lab=BLB5}
N 960 48960 940 48960 {}
C {lab_pin.sym} 940 48960 0 0 {name=l39228 lab=WL245}
N 1040 49040 1060 49040 {}
C {lab_pin.sym} 1060 49040 0 0 {name=l39229 lab=VDD}
N 1040 48960 1060 48960 {}
C {lab_pin.sym} 1060 48960 0 0 {name=l39230 lab=VSS}
C {bitcell_6t.sym} 1200 49000 0 0 {name=Xr245c6}
N 1160 49040 1140 49040 {}
C {lab_pin.sym} 1140 49040 0 0 {name=l39231 lab=BL6}
N 1160 49000 1140 49000 {}
C {lab_pin.sym} 1140 49000 0 0 {name=l39232 lab=BLB6}
N 1160 48960 1140 48960 {}
C {lab_pin.sym} 1140 48960 0 0 {name=l39233 lab=WL245}
N 1240 49040 1260 49040 {}
C {lab_pin.sym} 1260 49040 0 0 {name=l39234 lab=VDD}
N 1240 48960 1260 48960 {}
C {lab_pin.sym} 1260 48960 0 0 {name=l39235 lab=VSS}
C {bitcell_6t.sym} 1400 49000 0 0 {name=Xr245c7}
N 1360 49040 1340 49040 {}
C {lab_pin.sym} 1340 49040 0 0 {name=l39236 lab=BL7}
N 1360 49000 1340 49000 {}
C {lab_pin.sym} 1340 49000 0 0 {name=l39237 lab=BLB7}
N 1360 48960 1340 48960 {}
C {lab_pin.sym} 1340 48960 0 0 {name=l39238 lab=WL245}
N 1440 49040 1460 49040 {}
C {lab_pin.sym} 1460 49040 0 0 {name=l39239 lab=VDD}
N 1440 48960 1460 48960 {}
C {lab_pin.sym} 1460 48960 0 0 {name=l39240 lab=VSS}
C {bitcell_6t.sym} 1600 49000 0 0 {name=Xr245c8}
N 1560 49040 1540 49040 {}
C {lab_pin.sym} 1540 49040 0 0 {name=l39241 lab=BL8}
N 1560 49000 1540 49000 {}
C {lab_pin.sym} 1540 49000 0 0 {name=l39242 lab=BLB8}
N 1560 48960 1540 48960 {}
C {lab_pin.sym} 1540 48960 0 0 {name=l39243 lab=WL245}
N 1640 49040 1660 49040 {}
C {lab_pin.sym} 1660 49040 0 0 {name=l39244 lab=VDD}
N 1640 48960 1660 48960 {}
C {lab_pin.sym} 1660 48960 0 0 {name=l39245 lab=VSS}
C {bitcell_6t.sym} 1800 49000 0 0 {name=Xr245c9}
N 1760 49040 1740 49040 {}
C {lab_pin.sym} 1740 49040 0 0 {name=l39246 lab=BL9}
N 1760 49000 1740 49000 {}
C {lab_pin.sym} 1740 49000 0 0 {name=l39247 lab=BLB9}
N 1760 48960 1740 48960 {}
C {lab_pin.sym} 1740 48960 0 0 {name=l39248 lab=WL245}
N 1840 49040 1860 49040 {}
C {lab_pin.sym} 1860 49040 0 0 {name=l39249 lab=VDD}
N 1840 48960 1860 48960 {}
C {lab_pin.sym} 1860 48960 0 0 {name=l39250 lab=VSS}
C {bitcell_6t.sym} 2000 49000 0 0 {name=Xr245c10}
N 1960 49040 1940 49040 {}
C {lab_pin.sym} 1940 49040 0 0 {name=l39251 lab=BL10}
N 1960 49000 1940 49000 {}
C {lab_pin.sym} 1940 49000 0 0 {name=l39252 lab=BLB10}
N 1960 48960 1940 48960 {}
C {lab_pin.sym} 1940 48960 0 0 {name=l39253 lab=WL245}
N 2040 49040 2060 49040 {}
C {lab_pin.sym} 2060 49040 0 0 {name=l39254 lab=VDD}
N 2040 48960 2060 48960 {}
C {lab_pin.sym} 2060 48960 0 0 {name=l39255 lab=VSS}
C {bitcell_6t.sym} 2200 49000 0 0 {name=Xr245c11}
N 2160 49040 2140 49040 {}
C {lab_pin.sym} 2140 49040 0 0 {name=l39256 lab=BL11}
N 2160 49000 2140 49000 {}
C {lab_pin.sym} 2140 49000 0 0 {name=l39257 lab=BLB11}
N 2160 48960 2140 48960 {}
C {lab_pin.sym} 2140 48960 0 0 {name=l39258 lab=WL245}
N 2240 49040 2260 49040 {}
C {lab_pin.sym} 2260 49040 0 0 {name=l39259 lab=VDD}
N 2240 48960 2260 48960 {}
C {lab_pin.sym} 2260 48960 0 0 {name=l39260 lab=VSS}
C {bitcell_6t.sym} 2400 49000 0 0 {name=Xr245c12}
N 2360 49040 2340 49040 {}
C {lab_pin.sym} 2340 49040 0 0 {name=l39261 lab=BL12}
N 2360 49000 2340 49000 {}
C {lab_pin.sym} 2340 49000 0 0 {name=l39262 lab=BLB12}
N 2360 48960 2340 48960 {}
C {lab_pin.sym} 2340 48960 0 0 {name=l39263 lab=WL245}
N 2440 49040 2460 49040 {}
C {lab_pin.sym} 2460 49040 0 0 {name=l39264 lab=VDD}
N 2440 48960 2460 48960 {}
C {lab_pin.sym} 2460 48960 0 0 {name=l39265 lab=VSS}
C {bitcell_6t.sym} 2600 49000 0 0 {name=Xr245c13}
N 2560 49040 2540 49040 {}
C {lab_pin.sym} 2540 49040 0 0 {name=l39266 lab=BL13}
N 2560 49000 2540 49000 {}
C {lab_pin.sym} 2540 49000 0 0 {name=l39267 lab=BLB13}
N 2560 48960 2540 48960 {}
C {lab_pin.sym} 2540 48960 0 0 {name=l39268 lab=WL245}
N 2640 49040 2660 49040 {}
C {lab_pin.sym} 2660 49040 0 0 {name=l39269 lab=VDD}
N 2640 48960 2660 48960 {}
C {lab_pin.sym} 2660 48960 0 0 {name=l39270 lab=VSS}
C {bitcell_6t.sym} 2800 49000 0 0 {name=Xr245c14}
N 2760 49040 2740 49040 {}
C {lab_pin.sym} 2740 49040 0 0 {name=l39271 lab=BL14}
N 2760 49000 2740 49000 {}
C {lab_pin.sym} 2740 49000 0 0 {name=l39272 lab=BLB14}
N 2760 48960 2740 48960 {}
C {lab_pin.sym} 2740 48960 0 0 {name=l39273 lab=WL245}
N 2840 49040 2860 49040 {}
C {lab_pin.sym} 2860 49040 0 0 {name=l39274 lab=VDD}
N 2840 48960 2860 48960 {}
C {lab_pin.sym} 2860 48960 0 0 {name=l39275 lab=VSS}
C {bitcell_6t.sym} 3000 49000 0 0 {name=Xr245c15}
N 2960 49040 2940 49040 {}
C {lab_pin.sym} 2940 49040 0 0 {name=l39276 lab=BL15}
N 2960 49000 2940 49000 {}
C {lab_pin.sym} 2940 49000 0 0 {name=l39277 lab=BLB15}
N 2960 48960 2940 48960 {}
C {lab_pin.sym} 2940 48960 0 0 {name=l39278 lab=WL245}
N 3040 49040 3060 49040 {}
C {lab_pin.sym} 3060 49040 0 0 {name=l39279 lab=VDD}
N 3040 48960 3060 48960 {}
C {lab_pin.sym} 3060 48960 0 0 {name=l39280 lab=VSS}
C {bitcell_6t.sym} 3200 49000 0 0 {name=Xr245c16}
N 3160 49040 3140 49040 {}
C {lab_pin.sym} 3140 49040 0 0 {name=l39281 lab=BL16}
N 3160 49000 3140 49000 {}
C {lab_pin.sym} 3140 49000 0 0 {name=l39282 lab=BLB16}
N 3160 48960 3140 48960 {}
C {lab_pin.sym} 3140 48960 0 0 {name=l39283 lab=WL245}
N 3240 49040 3260 49040 {}
C {lab_pin.sym} 3260 49040 0 0 {name=l39284 lab=VDD}
N 3240 48960 3260 48960 {}
C {lab_pin.sym} 3260 48960 0 0 {name=l39285 lab=VSS}
C {bitcell_6t.sym} 3400 49000 0 0 {name=Xr245c17}
N 3360 49040 3340 49040 {}
C {lab_pin.sym} 3340 49040 0 0 {name=l39286 lab=BL17}
N 3360 49000 3340 49000 {}
C {lab_pin.sym} 3340 49000 0 0 {name=l39287 lab=BLB17}
N 3360 48960 3340 48960 {}
C {lab_pin.sym} 3340 48960 0 0 {name=l39288 lab=WL245}
N 3440 49040 3460 49040 {}
C {lab_pin.sym} 3460 49040 0 0 {name=l39289 lab=VDD}
N 3440 48960 3460 48960 {}
C {lab_pin.sym} 3460 48960 0 0 {name=l39290 lab=VSS}
C {bitcell_6t.sym} 3600 49000 0 0 {name=Xr245c18}
N 3560 49040 3540 49040 {}
C {lab_pin.sym} 3540 49040 0 0 {name=l39291 lab=BL18}
N 3560 49000 3540 49000 {}
C {lab_pin.sym} 3540 49000 0 0 {name=l39292 lab=BLB18}
N 3560 48960 3540 48960 {}
C {lab_pin.sym} 3540 48960 0 0 {name=l39293 lab=WL245}
N 3640 49040 3660 49040 {}
C {lab_pin.sym} 3660 49040 0 0 {name=l39294 lab=VDD}
N 3640 48960 3660 48960 {}
C {lab_pin.sym} 3660 48960 0 0 {name=l39295 lab=VSS}
C {bitcell_6t.sym} 3800 49000 0 0 {name=Xr245c19}
N 3760 49040 3740 49040 {}
C {lab_pin.sym} 3740 49040 0 0 {name=l39296 lab=BL19}
N 3760 49000 3740 49000 {}
C {lab_pin.sym} 3740 49000 0 0 {name=l39297 lab=BLB19}
N 3760 48960 3740 48960 {}
C {lab_pin.sym} 3740 48960 0 0 {name=l39298 lab=WL245}
N 3840 49040 3860 49040 {}
C {lab_pin.sym} 3860 49040 0 0 {name=l39299 lab=VDD}
N 3840 48960 3860 48960 {}
C {lab_pin.sym} 3860 48960 0 0 {name=l39300 lab=VSS}
C {bitcell_6t.sym} 4000 49000 0 0 {name=Xr245c20}
N 3960 49040 3940 49040 {}
C {lab_pin.sym} 3940 49040 0 0 {name=l39301 lab=BL20}
N 3960 49000 3940 49000 {}
C {lab_pin.sym} 3940 49000 0 0 {name=l39302 lab=BLB20}
N 3960 48960 3940 48960 {}
C {lab_pin.sym} 3940 48960 0 0 {name=l39303 lab=WL245}
N 4040 49040 4060 49040 {}
C {lab_pin.sym} 4060 49040 0 0 {name=l39304 lab=VDD}
N 4040 48960 4060 48960 {}
C {lab_pin.sym} 4060 48960 0 0 {name=l39305 lab=VSS}
C {bitcell_6t.sym} 4200 49000 0 0 {name=Xr245c21}
N 4160 49040 4140 49040 {}
C {lab_pin.sym} 4140 49040 0 0 {name=l39306 lab=BL21}
N 4160 49000 4140 49000 {}
C {lab_pin.sym} 4140 49000 0 0 {name=l39307 lab=BLB21}
N 4160 48960 4140 48960 {}
C {lab_pin.sym} 4140 48960 0 0 {name=l39308 lab=WL245}
N 4240 49040 4260 49040 {}
C {lab_pin.sym} 4260 49040 0 0 {name=l39309 lab=VDD}
N 4240 48960 4260 48960 {}
C {lab_pin.sym} 4260 48960 0 0 {name=l39310 lab=VSS}
C {bitcell_6t.sym} 4400 49000 0 0 {name=Xr245c22}
N 4360 49040 4340 49040 {}
C {lab_pin.sym} 4340 49040 0 0 {name=l39311 lab=BL22}
N 4360 49000 4340 49000 {}
C {lab_pin.sym} 4340 49000 0 0 {name=l39312 lab=BLB22}
N 4360 48960 4340 48960 {}
C {lab_pin.sym} 4340 48960 0 0 {name=l39313 lab=WL245}
N 4440 49040 4460 49040 {}
C {lab_pin.sym} 4460 49040 0 0 {name=l39314 lab=VDD}
N 4440 48960 4460 48960 {}
C {lab_pin.sym} 4460 48960 0 0 {name=l39315 lab=VSS}
C {bitcell_6t.sym} 4600 49000 0 0 {name=Xr245c23}
N 4560 49040 4540 49040 {}
C {lab_pin.sym} 4540 49040 0 0 {name=l39316 lab=BL23}
N 4560 49000 4540 49000 {}
C {lab_pin.sym} 4540 49000 0 0 {name=l39317 lab=BLB23}
N 4560 48960 4540 48960 {}
C {lab_pin.sym} 4540 48960 0 0 {name=l39318 lab=WL245}
N 4640 49040 4660 49040 {}
C {lab_pin.sym} 4660 49040 0 0 {name=l39319 lab=VDD}
N 4640 48960 4660 48960 {}
C {lab_pin.sym} 4660 48960 0 0 {name=l39320 lab=VSS}
C {bitcell_6t.sym} 4800 49000 0 0 {name=Xr245c24}
N 4760 49040 4740 49040 {}
C {lab_pin.sym} 4740 49040 0 0 {name=l39321 lab=BL24}
N 4760 49000 4740 49000 {}
C {lab_pin.sym} 4740 49000 0 0 {name=l39322 lab=BLB24}
N 4760 48960 4740 48960 {}
C {lab_pin.sym} 4740 48960 0 0 {name=l39323 lab=WL245}
N 4840 49040 4860 49040 {}
C {lab_pin.sym} 4860 49040 0 0 {name=l39324 lab=VDD}
N 4840 48960 4860 48960 {}
C {lab_pin.sym} 4860 48960 0 0 {name=l39325 lab=VSS}
C {bitcell_6t.sym} 5000 49000 0 0 {name=Xr245c25}
N 4960 49040 4940 49040 {}
C {lab_pin.sym} 4940 49040 0 0 {name=l39326 lab=BL25}
N 4960 49000 4940 49000 {}
C {lab_pin.sym} 4940 49000 0 0 {name=l39327 lab=BLB25}
N 4960 48960 4940 48960 {}
C {lab_pin.sym} 4940 48960 0 0 {name=l39328 lab=WL245}
N 5040 49040 5060 49040 {}
C {lab_pin.sym} 5060 49040 0 0 {name=l39329 lab=VDD}
N 5040 48960 5060 48960 {}
C {lab_pin.sym} 5060 48960 0 0 {name=l39330 lab=VSS}
C {bitcell_6t.sym} 5200 49000 0 0 {name=Xr245c26}
N 5160 49040 5140 49040 {}
C {lab_pin.sym} 5140 49040 0 0 {name=l39331 lab=BL26}
N 5160 49000 5140 49000 {}
C {lab_pin.sym} 5140 49000 0 0 {name=l39332 lab=BLB26}
N 5160 48960 5140 48960 {}
C {lab_pin.sym} 5140 48960 0 0 {name=l39333 lab=WL245}
N 5240 49040 5260 49040 {}
C {lab_pin.sym} 5260 49040 0 0 {name=l39334 lab=VDD}
N 5240 48960 5260 48960 {}
C {lab_pin.sym} 5260 48960 0 0 {name=l39335 lab=VSS}
C {bitcell_6t.sym} 5400 49000 0 0 {name=Xr245c27}
N 5360 49040 5340 49040 {}
C {lab_pin.sym} 5340 49040 0 0 {name=l39336 lab=BL27}
N 5360 49000 5340 49000 {}
C {lab_pin.sym} 5340 49000 0 0 {name=l39337 lab=BLB27}
N 5360 48960 5340 48960 {}
C {lab_pin.sym} 5340 48960 0 0 {name=l39338 lab=WL245}
N 5440 49040 5460 49040 {}
C {lab_pin.sym} 5460 49040 0 0 {name=l39339 lab=VDD}
N 5440 48960 5460 48960 {}
C {lab_pin.sym} 5460 48960 0 0 {name=l39340 lab=VSS}
C {bitcell_6t.sym} 5600 49000 0 0 {name=Xr245c28}
N 5560 49040 5540 49040 {}
C {lab_pin.sym} 5540 49040 0 0 {name=l39341 lab=BL28}
N 5560 49000 5540 49000 {}
C {lab_pin.sym} 5540 49000 0 0 {name=l39342 lab=BLB28}
N 5560 48960 5540 48960 {}
C {lab_pin.sym} 5540 48960 0 0 {name=l39343 lab=WL245}
N 5640 49040 5660 49040 {}
C {lab_pin.sym} 5660 49040 0 0 {name=l39344 lab=VDD}
N 5640 48960 5660 48960 {}
C {lab_pin.sym} 5660 48960 0 0 {name=l39345 lab=VSS}
C {bitcell_6t.sym} 5800 49000 0 0 {name=Xr245c29}
N 5760 49040 5740 49040 {}
C {lab_pin.sym} 5740 49040 0 0 {name=l39346 lab=BL29}
N 5760 49000 5740 49000 {}
C {lab_pin.sym} 5740 49000 0 0 {name=l39347 lab=BLB29}
N 5760 48960 5740 48960 {}
C {lab_pin.sym} 5740 48960 0 0 {name=l39348 lab=WL245}
N 5840 49040 5860 49040 {}
C {lab_pin.sym} 5860 49040 0 0 {name=l39349 lab=VDD}
N 5840 48960 5860 48960 {}
C {lab_pin.sym} 5860 48960 0 0 {name=l39350 lab=VSS}
C {bitcell_6t.sym} 6000 49000 0 0 {name=Xr245c30}
N 5960 49040 5940 49040 {}
C {lab_pin.sym} 5940 49040 0 0 {name=l39351 lab=BL30}
N 5960 49000 5940 49000 {}
C {lab_pin.sym} 5940 49000 0 0 {name=l39352 lab=BLB30}
N 5960 48960 5940 48960 {}
C {lab_pin.sym} 5940 48960 0 0 {name=l39353 lab=WL245}
N 6040 49040 6060 49040 {}
C {lab_pin.sym} 6060 49040 0 0 {name=l39354 lab=VDD}
N 6040 48960 6060 48960 {}
C {lab_pin.sym} 6060 48960 0 0 {name=l39355 lab=VSS}
C {bitcell_6t.sym} 6200 49000 0 0 {name=Xr245c31}
N 6160 49040 6140 49040 {}
C {lab_pin.sym} 6140 49040 0 0 {name=l39356 lab=BL31}
N 6160 49000 6140 49000 {}
C {lab_pin.sym} 6140 49000 0 0 {name=l39357 lab=BLB31}
N 6160 48960 6140 48960 {}
C {lab_pin.sym} 6140 48960 0 0 {name=l39358 lab=WL245}
N 6240 49040 6260 49040 {}
C {lab_pin.sym} 6260 49040 0 0 {name=l39359 lab=VDD}
N 6240 48960 6260 48960 {}
C {lab_pin.sym} 6260 48960 0 0 {name=l39360 lab=VSS}
C {bitcell_6t.sym} 0 49200 0 0 {name=Xr246c0}
N -40 49240 -60 49240 {}
C {lab_pin.sym} -60 49240 0 0 {name=l39361 lab=BL0}
N -40 49200 -60 49200 {}
C {lab_pin.sym} -60 49200 0 0 {name=l39362 lab=BLB0}
N -40 49160 -60 49160 {}
C {lab_pin.sym} -60 49160 0 0 {name=l39363 lab=WL246}
N 40 49240 60 49240 {}
C {lab_pin.sym} 60 49240 0 0 {name=l39364 lab=VDD}
N 40 49160 60 49160 {}
C {lab_pin.sym} 60 49160 0 0 {name=l39365 lab=VSS}
C {bitcell_6t.sym} 200 49200 0 0 {name=Xr246c1}
N 160 49240 140 49240 {}
C {lab_pin.sym} 140 49240 0 0 {name=l39366 lab=BL1}
N 160 49200 140 49200 {}
C {lab_pin.sym} 140 49200 0 0 {name=l39367 lab=BLB1}
N 160 49160 140 49160 {}
C {lab_pin.sym} 140 49160 0 0 {name=l39368 lab=WL246}
N 240 49240 260 49240 {}
C {lab_pin.sym} 260 49240 0 0 {name=l39369 lab=VDD}
N 240 49160 260 49160 {}
C {lab_pin.sym} 260 49160 0 0 {name=l39370 lab=VSS}
C {bitcell_6t.sym} 400 49200 0 0 {name=Xr246c2}
N 360 49240 340 49240 {}
C {lab_pin.sym} 340 49240 0 0 {name=l39371 lab=BL2}
N 360 49200 340 49200 {}
C {lab_pin.sym} 340 49200 0 0 {name=l39372 lab=BLB2}
N 360 49160 340 49160 {}
C {lab_pin.sym} 340 49160 0 0 {name=l39373 lab=WL246}
N 440 49240 460 49240 {}
C {lab_pin.sym} 460 49240 0 0 {name=l39374 lab=VDD}
N 440 49160 460 49160 {}
C {lab_pin.sym} 460 49160 0 0 {name=l39375 lab=VSS}
C {bitcell_6t.sym} 600 49200 0 0 {name=Xr246c3}
N 560 49240 540 49240 {}
C {lab_pin.sym} 540 49240 0 0 {name=l39376 lab=BL3}
N 560 49200 540 49200 {}
C {lab_pin.sym} 540 49200 0 0 {name=l39377 lab=BLB3}
N 560 49160 540 49160 {}
C {lab_pin.sym} 540 49160 0 0 {name=l39378 lab=WL246}
N 640 49240 660 49240 {}
C {lab_pin.sym} 660 49240 0 0 {name=l39379 lab=VDD}
N 640 49160 660 49160 {}
C {lab_pin.sym} 660 49160 0 0 {name=l39380 lab=VSS}
C {bitcell_6t.sym} 800 49200 0 0 {name=Xr246c4}
N 760 49240 740 49240 {}
C {lab_pin.sym} 740 49240 0 0 {name=l39381 lab=BL4}
N 760 49200 740 49200 {}
C {lab_pin.sym} 740 49200 0 0 {name=l39382 lab=BLB4}
N 760 49160 740 49160 {}
C {lab_pin.sym} 740 49160 0 0 {name=l39383 lab=WL246}
N 840 49240 860 49240 {}
C {lab_pin.sym} 860 49240 0 0 {name=l39384 lab=VDD}
N 840 49160 860 49160 {}
C {lab_pin.sym} 860 49160 0 0 {name=l39385 lab=VSS}
C {bitcell_6t.sym} 1000 49200 0 0 {name=Xr246c5}
N 960 49240 940 49240 {}
C {lab_pin.sym} 940 49240 0 0 {name=l39386 lab=BL5}
N 960 49200 940 49200 {}
C {lab_pin.sym} 940 49200 0 0 {name=l39387 lab=BLB5}
N 960 49160 940 49160 {}
C {lab_pin.sym} 940 49160 0 0 {name=l39388 lab=WL246}
N 1040 49240 1060 49240 {}
C {lab_pin.sym} 1060 49240 0 0 {name=l39389 lab=VDD}
N 1040 49160 1060 49160 {}
C {lab_pin.sym} 1060 49160 0 0 {name=l39390 lab=VSS}
C {bitcell_6t.sym} 1200 49200 0 0 {name=Xr246c6}
N 1160 49240 1140 49240 {}
C {lab_pin.sym} 1140 49240 0 0 {name=l39391 lab=BL6}
N 1160 49200 1140 49200 {}
C {lab_pin.sym} 1140 49200 0 0 {name=l39392 lab=BLB6}
N 1160 49160 1140 49160 {}
C {lab_pin.sym} 1140 49160 0 0 {name=l39393 lab=WL246}
N 1240 49240 1260 49240 {}
C {lab_pin.sym} 1260 49240 0 0 {name=l39394 lab=VDD}
N 1240 49160 1260 49160 {}
C {lab_pin.sym} 1260 49160 0 0 {name=l39395 lab=VSS}
C {bitcell_6t.sym} 1400 49200 0 0 {name=Xr246c7}
N 1360 49240 1340 49240 {}
C {lab_pin.sym} 1340 49240 0 0 {name=l39396 lab=BL7}
N 1360 49200 1340 49200 {}
C {lab_pin.sym} 1340 49200 0 0 {name=l39397 lab=BLB7}
N 1360 49160 1340 49160 {}
C {lab_pin.sym} 1340 49160 0 0 {name=l39398 lab=WL246}
N 1440 49240 1460 49240 {}
C {lab_pin.sym} 1460 49240 0 0 {name=l39399 lab=VDD}
N 1440 49160 1460 49160 {}
C {lab_pin.sym} 1460 49160 0 0 {name=l39400 lab=VSS}
C {bitcell_6t.sym} 1600 49200 0 0 {name=Xr246c8}
N 1560 49240 1540 49240 {}
C {lab_pin.sym} 1540 49240 0 0 {name=l39401 lab=BL8}
N 1560 49200 1540 49200 {}
C {lab_pin.sym} 1540 49200 0 0 {name=l39402 lab=BLB8}
N 1560 49160 1540 49160 {}
C {lab_pin.sym} 1540 49160 0 0 {name=l39403 lab=WL246}
N 1640 49240 1660 49240 {}
C {lab_pin.sym} 1660 49240 0 0 {name=l39404 lab=VDD}
N 1640 49160 1660 49160 {}
C {lab_pin.sym} 1660 49160 0 0 {name=l39405 lab=VSS}
C {bitcell_6t.sym} 1800 49200 0 0 {name=Xr246c9}
N 1760 49240 1740 49240 {}
C {lab_pin.sym} 1740 49240 0 0 {name=l39406 lab=BL9}
N 1760 49200 1740 49200 {}
C {lab_pin.sym} 1740 49200 0 0 {name=l39407 lab=BLB9}
N 1760 49160 1740 49160 {}
C {lab_pin.sym} 1740 49160 0 0 {name=l39408 lab=WL246}
N 1840 49240 1860 49240 {}
C {lab_pin.sym} 1860 49240 0 0 {name=l39409 lab=VDD}
N 1840 49160 1860 49160 {}
C {lab_pin.sym} 1860 49160 0 0 {name=l39410 lab=VSS}
C {bitcell_6t.sym} 2000 49200 0 0 {name=Xr246c10}
N 1960 49240 1940 49240 {}
C {lab_pin.sym} 1940 49240 0 0 {name=l39411 lab=BL10}
N 1960 49200 1940 49200 {}
C {lab_pin.sym} 1940 49200 0 0 {name=l39412 lab=BLB10}
N 1960 49160 1940 49160 {}
C {lab_pin.sym} 1940 49160 0 0 {name=l39413 lab=WL246}
N 2040 49240 2060 49240 {}
C {lab_pin.sym} 2060 49240 0 0 {name=l39414 lab=VDD}
N 2040 49160 2060 49160 {}
C {lab_pin.sym} 2060 49160 0 0 {name=l39415 lab=VSS}
C {bitcell_6t.sym} 2200 49200 0 0 {name=Xr246c11}
N 2160 49240 2140 49240 {}
C {lab_pin.sym} 2140 49240 0 0 {name=l39416 lab=BL11}
N 2160 49200 2140 49200 {}
C {lab_pin.sym} 2140 49200 0 0 {name=l39417 lab=BLB11}
N 2160 49160 2140 49160 {}
C {lab_pin.sym} 2140 49160 0 0 {name=l39418 lab=WL246}
N 2240 49240 2260 49240 {}
C {lab_pin.sym} 2260 49240 0 0 {name=l39419 lab=VDD}
N 2240 49160 2260 49160 {}
C {lab_pin.sym} 2260 49160 0 0 {name=l39420 lab=VSS}
C {bitcell_6t.sym} 2400 49200 0 0 {name=Xr246c12}
N 2360 49240 2340 49240 {}
C {lab_pin.sym} 2340 49240 0 0 {name=l39421 lab=BL12}
N 2360 49200 2340 49200 {}
C {lab_pin.sym} 2340 49200 0 0 {name=l39422 lab=BLB12}
N 2360 49160 2340 49160 {}
C {lab_pin.sym} 2340 49160 0 0 {name=l39423 lab=WL246}
N 2440 49240 2460 49240 {}
C {lab_pin.sym} 2460 49240 0 0 {name=l39424 lab=VDD}
N 2440 49160 2460 49160 {}
C {lab_pin.sym} 2460 49160 0 0 {name=l39425 lab=VSS}
C {bitcell_6t.sym} 2600 49200 0 0 {name=Xr246c13}
N 2560 49240 2540 49240 {}
C {lab_pin.sym} 2540 49240 0 0 {name=l39426 lab=BL13}
N 2560 49200 2540 49200 {}
C {lab_pin.sym} 2540 49200 0 0 {name=l39427 lab=BLB13}
N 2560 49160 2540 49160 {}
C {lab_pin.sym} 2540 49160 0 0 {name=l39428 lab=WL246}
N 2640 49240 2660 49240 {}
C {lab_pin.sym} 2660 49240 0 0 {name=l39429 lab=VDD}
N 2640 49160 2660 49160 {}
C {lab_pin.sym} 2660 49160 0 0 {name=l39430 lab=VSS}
C {bitcell_6t.sym} 2800 49200 0 0 {name=Xr246c14}
N 2760 49240 2740 49240 {}
C {lab_pin.sym} 2740 49240 0 0 {name=l39431 lab=BL14}
N 2760 49200 2740 49200 {}
C {lab_pin.sym} 2740 49200 0 0 {name=l39432 lab=BLB14}
N 2760 49160 2740 49160 {}
C {lab_pin.sym} 2740 49160 0 0 {name=l39433 lab=WL246}
N 2840 49240 2860 49240 {}
C {lab_pin.sym} 2860 49240 0 0 {name=l39434 lab=VDD}
N 2840 49160 2860 49160 {}
C {lab_pin.sym} 2860 49160 0 0 {name=l39435 lab=VSS}
C {bitcell_6t.sym} 3000 49200 0 0 {name=Xr246c15}
N 2960 49240 2940 49240 {}
C {lab_pin.sym} 2940 49240 0 0 {name=l39436 lab=BL15}
N 2960 49200 2940 49200 {}
C {lab_pin.sym} 2940 49200 0 0 {name=l39437 lab=BLB15}
N 2960 49160 2940 49160 {}
C {lab_pin.sym} 2940 49160 0 0 {name=l39438 lab=WL246}
N 3040 49240 3060 49240 {}
C {lab_pin.sym} 3060 49240 0 0 {name=l39439 lab=VDD}
N 3040 49160 3060 49160 {}
C {lab_pin.sym} 3060 49160 0 0 {name=l39440 lab=VSS}
C {bitcell_6t.sym} 3200 49200 0 0 {name=Xr246c16}
N 3160 49240 3140 49240 {}
C {lab_pin.sym} 3140 49240 0 0 {name=l39441 lab=BL16}
N 3160 49200 3140 49200 {}
C {lab_pin.sym} 3140 49200 0 0 {name=l39442 lab=BLB16}
N 3160 49160 3140 49160 {}
C {lab_pin.sym} 3140 49160 0 0 {name=l39443 lab=WL246}
N 3240 49240 3260 49240 {}
C {lab_pin.sym} 3260 49240 0 0 {name=l39444 lab=VDD}
N 3240 49160 3260 49160 {}
C {lab_pin.sym} 3260 49160 0 0 {name=l39445 lab=VSS}
C {bitcell_6t.sym} 3400 49200 0 0 {name=Xr246c17}
N 3360 49240 3340 49240 {}
C {lab_pin.sym} 3340 49240 0 0 {name=l39446 lab=BL17}
N 3360 49200 3340 49200 {}
C {lab_pin.sym} 3340 49200 0 0 {name=l39447 lab=BLB17}
N 3360 49160 3340 49160 {}
C {lab_pin.sym} 3340 49160 0 0 {name=l39448 lab=WL246}
N 3440 49240 3460 49240 {}
C {lab_pin.sym} 3460 49240 0 0 {name=l39449 lab=VDD}
N 3440 49160 3460 49160 {}
C {lab_pin.sym} 3460 49160 0 0 {name=l39450 lab=VSS}
C {bitcell_6t.sym} 3600 49200 0 0 {name=Xr246c18}
N 3560 49240 3540 49240 {}
C {lab_pin.sym} 3540 49240 0 0 {name=l39451 lab=BL18}
N 3560 49200 3540 49200 {}
C {lab_pin.sym} 3540 49200 0 0 {name=l39452 lab=BLB18}
N 3560 49160 3540 49160 {}
C {lab_pin.sym} 3540 49160 0 0 {name=l39453 lab=WL246}
N 3640 49240 3660 49240 {}
C {lab_pin.sym} 3660 49240 0 0 {name=l39454 lab=VDD}
N 3640 49160 3660 49160 {}
C {lab_pin.sym} 3660 49160 0 0 {name=l39455 lab=VSS}
C {bitcell_6t.sym} 3800 49200 0 0 {name=Xr246c19}
N 3760 49240 3740 49240 {}
C {lab_pin.sym} 3740 49240 0 0 {name=l39456 lab=BL19}
N 3760 49200 3740 49200 {}
C {lab_pin.sym} 3740 49200 0 0 {name=l39457 lab=BLB19}
N 3760 49160 3740 49160 {}
C {lab_pin.sym} 3740 49160 0 0 {name=l39458 lab=WL246}
N 3840 49240 3860 49240 {}
C {lab_pin.sym} 3860 49240 0 0 {name=l39459 lab=VDD}
N 3840 49160 3860 49160 {}
C {lab_pin.sym} 3860 49160 0 0 {name=l39460 lab=VSS}
C {bitcell_6t.sym} 4000 49200 0 0 {name=Xr246c20}
N 3960 49240 3940 49240 {}
C {lab_pin.sym} 3940 49240 0 0 {name=l39461 lab=BL20}
N 3960 49200 3940 49200 {}
C {lab_pin.sym} 3940 49200 0 0 {name=l39462 lab=BLB20}
N 3960 49160 3940 49160 {}
C {lab_pin.sym} 3940 49160 0 0 {name=l39463 lab=WL246}
N 4040 49240 4060 49240 {}
C {lab_pin.sym} 4060 49240 0 0 {name=l39464 lab=VDD}
N 4040 49160 4060 49160 {}
C {lab_pin.sym} 4060 49160 0 0 {name=l39465 lab=VSS}
C {bitcell_6t.sym} 4200 49200 0 0 {name=Xr246c21}
N 4160 49240 4140 49240 {}
C {lab_pin.sym} 4140 49240 0 0 {name=l39466 lab=BL21}
N 4160 49200 4140 49200 {}
C {lab_pin.sym} 4140 49200 0 0 {name=l39467 lab=BLB21}
N 4160 49160 4140 49160 {}
C {lab_pin.sym} 4140 49160 0 0 {name=l39468 lab=WL246}
N 4240 49240 4260 49240 {}
C {lab_pin.sym} 4260 49240 0 0 {name=l39469 lab=VDD}
N 4240 49160 4260 49160 {}
C {lab_pin.sym} 4260 49160 0 0 {name=l39470 lab=VSS}
C {bitcell_6t.sym} 4400 49200 0 0 {name=Xr246c22}
N 4360 49240 4340 49240 {}
C {lab_pin.sym} 4340 49240 0 0 {name=l39471 lab=BL22}
N 4360 49200 4340 49200 {}
C {lab_pin.sym} 4340 49200 0 0 {name=l39472 lab=BLB22}
N 4360 49160 4340 49160 {}
C {lab_pin.sym} 4340 49160 0 0 {name=l39473 lab=WL246}
N 4440 49240 4460 49240 {}
C {lab_pin.sym} 4460 49240 0 0 {name=l39474 lab=VDD}
N 4440 49160 4460 49160 {}
C {lab_pin.sym} 4460 49160 0 0 {name=l39475 lab=VSS}
C {bitcell_6t.sym} 4600 49200 0 0 {name=Xr246c23}
N 4560 49240 4540 49240 {}
C {lab_pin.sym} 4540 49240 0 0 {name=l39476 lab=BL23}
N 4560 49200 4540 49200 {}
C {lab_pin.sym} 4540 49200 0 0 {name=l39477 lab=BLB23}
N 4560 49160 4540 49160 {}
C {lab_pin.sym} 4540 49160 0 0 {name=l39478 lab=WL246}
N 4640 49240 4660 49240 {}
C {lab_pin.sym} 4660 49240 0 0 {name=l39479 lab=VDD}
N 4640 49160 4660 49160 {}
C {lab_pin.sym} 4660 49160 0 0 {name=l39480 lab=VSS}
C {bitcell_6t.sym} 4800 49200 0 0 {name=Xr246c24}
N 4760 49240 4740 49240 {}
C {lab_pin.sym} 4740 49240 0 0 {name=l39481 lab=BL24}
N 4760 49200 4740 49200 {}
C {lab_pin.sym} 4740 49200 0 0 {name=l39482 lab=BLB24}
N 4760 49160 4740 49160 {}
C {lab_pin.sym} 4740 49160 0 0 {name=l39483 lab=WL246}
N 4840 49240 4860 49240 {}
C {lab_pin.sym} 4860 49240 0 0 {name=l39484 lab=VDD}
N 4840 49160 4860 49160 {}
C {lab_pin.sym} 4860 49160 0 0 {name=l39485 lab=VSS}
C {bitcell_6t.sym} 5000 49200 0 0 {name=Xr246c25}
N 4960 49240 4940 49240 {}
C {lab_pin.sym} 4940 49240 0 0 {name=l39486 lab=BL25}
N 4960 49200 4940 49200 {}
C {lab_pin.sym} 4940 49200 0 0 {name=l39487 lab=BLB25}
N 4960 49160 4940 49160 {}
C {lab_pin.sym} 4940 49160 0 0 {name=l39488 lab=WL246}
N 5040 49240 5060 49240 {}
C {lab_pin.sym} 5060 49240 0 0 {name=l39489 lab=VDD}
N 5040 49160 5060 49160 {}
C {lab_pin.sym} 5060 49160 0 0 {name=l39490 lab=VSS}
C {bitcell_6t.sym} 5200 49200 0 0 {name=Xr246c26}
N 5160 49240 5140 49240 {}
C {lab_pin.sym} 5140 49240 0 0 {name=l39491 lab=BL26}
N 5160 49200 5140 49200 {}
C {lab_pin.sym} 5140 49200 0 0 {name=l39492 lab=BLB26}
N 5160 49160 5140 49160 {}
C {lab_pin.sym} 5140 49160 0 0 {name=l39493 lab=WL246}
N 5240 49240 5260 49240 {}
C {lab_pin.sym} 5260 49240 0 0 {name=l39494 lab=VDD}
N 5240 49160 5260 49160 {}
C {lab_pin.sym} 5260 49160 0 0 {name=l39495 lab=VSS}
C {bitcell_6t.sym} 5400 49200 0 0 {name=Xr246c27}
N 5360 49240 5340 49240 {}
C {lab_pin.sym} 5340 49240 0 0 {name=l39496 lab=BL27}
N 5360 49200 5340 49200 {}
C {lab_pin.sym} 5340 49200 0 0 {name=l39497 lab=BLB27}
N 5360 49160 5340 49160 {}
C {lab_pin.sym} 5340 49160 0 0 {name=l39498 lab=WL246}
N 5440 49240 5460 49240 {}
C {lab_pin.sym} 5460 49240 0 0 {name=l39499 lab=VDD}
N 5440 49160 5460 49160 {}
C {lab_pin.sym} 5460 49160 0 0 {name=l39500 lab=VSS}
C {bitcell_6t.sym} 5600 49200 0 0 {name=Xr246c28}
N 5560 49240 5540 49240 {}
C {lab_pin.sym} 5540 49240 0 0 {name=l39501 lab=BL28}
N 5560 49200 5540 49200 {}
C {lab_pin.sym} 5540 49200 0 0 {name=l39502 lab=BLB28}
N 5560 49160 5540 49160 {}
C {lab_pin.sym} 5540 49160 0 0 {name=l39503 lab=WL246}
N 5640 49240 5660 49240 {}
C {lab_pin.sym} 5660 49240 0 0 {name=l39504 lab=VDD}
N 5640 49160 5660 49160 {}
C {lab_pin.sym} 5660 49160 0 0 {name=l39505 lab=VSS}
C {bitcell_6t.sym} 5800 49200 0 0 {name=Xr246c29}
N 5760 49240 5740 49240 {}
C {lab_pin.sym} 5740 49240 0 0 {name=l39506 lab=BL29}
N 5760 49200 5740 49200 {}
C {lab_pin.sym} 5740 49200 0 0 {name=l39507 lab=BLB29}
N 5760 49160 5740 49160 {}
C {lab_pin.sym} 5740 49160 0 0 {name=l39508 lab=WL246}
N 5840 49240 5860 49240 {}
C {lab_pin.sym} 5860 49240 0 0 {name=l39509 lab=VDD}
N 5840 49160 5860 49160 {}
C {lab_pin.sym} 5860 49160 0 0 {name=l39510 lab=VSS}
C {bitcell_6t.sym} 6000 49200 0 0 {name=Xr246c30}
N 5960 49240 5940 49240 {}
C {lab_pin.sym} 5940 49240 0 0 {name=l39511 lab=BL30}
N 5960 49200 5940 49200 {}
C {lab_pin.sym} 5940 49200 0 0 {name=l39512 lab=BLB30}
N 5960 49160 5940 49160 {}
C {lab_pin.sym} 5940 49160 0 0 {name=l39513 lab=WL246}
N 6040 49240 6060 49240 {}
C {lab_pin.sym} 6060 49240 0 0 {name=l39514 lab=VDD}
N 6040 49160 6060 49160 {}
C {lab_pin.sym} 6060 49160 0 0 {name=l39515 lab=VSS}
C {bitcell_6t.sym} 6200 49200 0 0 {name=Xr246c31}
N 6160 49240 6140 49240 {}
C {lab_pin.sym} 6140 49240 0 0 {name=l39516 lab=BL31}
N 6160 49200 6140 49200 {}
C {lab_pin.sym} 6140 49200 0 0 {name=l39517 lab=BLB31}
N 6160 49160 6140 49160 {}
C {lab_pin.sym} 6140 49160 0 0 {name=l39518 lab=WL246}
N 6240 49240 6260 49240 {}
C {lab_pin.sym} 6260 49240 0 0 {name=l39519 lab=VDD}
N 6240 49160 6260 49160 {}
C {lab_pin.sym} 6260 49160 0 0 {name=l39520 lab=VSS}
C {bitcell_6t.sym} 0 49400 0 0 {name=Xr247c0}
N -40 49440 -60 49440 {}
C {lab_pin.sym} -60 49440 0 0 {name=l39521 lab=BL0}
N -40 49400 -60 49400 {}
C {lab_pin.sym} -60 49400 0 0 {name=l39522 lab=BLB0}
N -40 49360 -60 49360 {}
C {lab_pin.sym} -60 49360 0 0 {name=l39523 lab=WL247}
N 40 49440 60 49440 {}
C {lab_pin.sym} 60 49440 0 0 {name=l39524 lab=VDD}
N 40 49360 60 49360 {}
C {lab_pin.sym} 60 49360 0 0 {name=l39525 lab=VSS}
C {bitcell_6t.sym} 200 49400 0 0 {name=Xr247c1}
N 160 49440 140 49440 {}
C {lab_pin.sym} 140 49440 0 0 {name=l39526 lab=BL1}
N 160 49400 140 49400 {}
C {lab_pin.sym} 140 49400 0 0 {name=l39527 lab=BLB1}
N 160 49360 140 49360 {}
C {lab_pin.sym} 140 49360 0 0 {name=l39528 lab=WL247}
N 240 49440 260 49440 {}
C {lab_pin.sym} 260 49440 0 0 {name=l39529 lab=VDD}
N 240 49360 260 49360 {}
C {lab_pin.sym} 260 49360 0 0 {name=l39530 lab=VSS}
C {bitcell_6t.sym} 400 49400 0 0 {name=Xr247c2}
N 360 49440 340 49440 {}
C {lab_pin.sym} 340 49440 0 0 {name=l39531 lab=BL2}
N 360 49400 340 49400 {}
C {lab_pin.sym} 340 49400 0 0 {name=l39532 lab=BLB2}
N 360 49360 340 49360 {}
C {lab_pin.sym} 340 49360 0 0 {name=l39533 lab=WL247}
N 440 49440 460 49440 {}
C {lab_pin.sym} 460 49440 0 0 {name=l39534 lab=VDD}
N 440 49360 460 49360 {}
C {lab_pin.sym} 460 49360 0 0 {name=l39535 lab=VSS}
C {bitcell_6t.sym} 600 49400 0 0 {name=Xr247c3}
N 560 49440 540 49440 {}
C {lab_pin.sym} 540 49440 0 0 {name=l39536 lab=BL3}
N 560 49400 540 49400 {}
C {lab_pin.sym} 540 49400 0 0 {name=l39537 lab=BLB3}
N 560 49360 540 49360 {}
C {lab_pin.sym} 540 49360 0 0 {name=l39538 lab=WL247}
N 640 49440 660 49440 {}
C {lab_pin.sym} 660 49440 0 0 {name=l39539 lab=VDD}
N 640 49360 660 49360 {}
C {lab_pin.sym} 660 49360 0 0 {name=l39540 lab=VSS}
C {bitcell_6t.sym} 800 49400 0 0 {name=Xr247c4}
N 760 49440 740 49440 {}
C {lab_pin.sym} 740 49440 0 0 {name=l39541 lab=BL4}
N 760 49400 740 49400 {}
C {lab_pin.sym} 740 49400 0 0 {name=l39542 lab=BLB4}
N 760 49360 740 49360 {}
C {lab_pin.sym} 740 49360 0 0 {name=l39543 lab=WL247}
N 840 49440 860 49440 {}
C {lab_pin.sym} 860 49440 0 0 {name=l39544 lab=VDD}
N 840 49360 860 49360 {}
C {lab_pin.sym} 860 49360 0 0 {name=l39545 lab=VSS}
C {bitcell_6t.sym} 1000 49400 0 0 {name=Xr247c5}
N 960 49440 940 49440 {}
C {lab_pin.sym} 940 49440 0 0 {name=l39546 lab=BL5}
N 960 49400 940 49400 {}
C {lab_pin.sym} 940 49400 0 0 {name=l39547 lab=BLB5}
N 960 49360 940 49360 {}
C {lab_pin.sym} 940 49360 0 0 {name=l39548 lab=WL247}
N 1040 49440 1060 49440 {}
C {lab_pin.sym} 1060 49440 0 0 {name=l39549 lab=VDD}
N 1040 49360 1060 49360 {}
C {lab_pin.sym} 1060 49360 0 0 {name=l39550 lab=VSS}
C {bitcell_6t.sym} 1200 49400 0 0 {name=Xr247c6}
N 1160 49440 1140 49440 {}
C {lab_pin.sym} 1140 49440 0 0 {name=l39551 lab=BL6}
N 1160 49400 1140 49400 {}
C {lab_pin.sym} 1140 49400 0 0 {name=l39552 lab=BLB6}
N 1160 49360 1140 49360 {}
C {lab_pin.sym} 1140 49360 0 0 {name=l39553 lab=WL247}
N 1240 49440 1260 49440 {}
C {lab_pin.sym} 1260 49440 0 0 {name=l39554 lab=VDD}
N 1240 49360 1260 49360 {}
C {lab_pin.sym} 1260 49360 0 0 {name=l39555 lab=VSS}
C {bitcell_6t.sym} 1400 49400 0 0 {name=Xr247c7}
N 1360 49440 1340 49440 {}
C {lab_pin.sym} 1340 49440 0 0 {name=l39556 lab=BL7}
N 1360 49400 1340 49400 {}
C {lab_pin.sym} 1340 49400 0 0 {name=l39557 lab=BLB7}
N 1360 49360 1340 49360 {}
C {lab_pin.sym} 1340 49360 0 0 {name=l39558 lab=WL247}
N 1440 49440 1460 49440 {}
C {lab_pin.sym} 1460 49440 0 0 {name=l39559 lab=VDD}
N 1440 49360 1460 49360 {}
C {lab_pin.sym} 1460 49360 0 0 {name=l39560 lab=VSS}
C {bitcell_6t.sym} 1600 49400 0 0 {name=Xr247c8}
N 1560 49440 1540 49440 {}
C {lab_pin.sym} 1540 49440 0 0 {name=l39561 lab=BL8}
N 1560 49400 1540 49400 {}
C {lab_pin.sym} 1540 49400 0 0 {name=l39562 lab=BLB8}
N 1560 49360 1540 49360 {}
C {lab_pin.sym} 1540 49360 0 0 {name=l39563 lab=WL247}
N 1640 49440 1660 49440 {}
C {lab_pin.sym} 1660 49440 0 0 {name=l39564 lab=VDD}
N 1640 49360 1660 49360 {}
C {lab_pin.sym} 1660 49360 0 0 {name=l39565 lab=VSS}
C {bitcell_6t.sym} 1800 49400 0 0 {name=Xr247c9}
N 1760 49440 1740 49440 {}
C {lab_pin.sym} 1740 49440 0 0 {name=l39566 lab=BL9}
N 1760 49400 1740 49400 {}
C {lab_pin.sym} 1740 49400 0 0 {name=l39567 lab=BLB9}
N 1760 49360 1740 49360 {}
C {lab_pin.sym} 1740 49360 0 0 {name=l39568 lab=WL247}
N 1840 49440 1860 49440 {}
C {lab_pin.sym} 1860 49440 0 0 {name=l39569 lab=VDD}
N 1840 49360 1860 49360 {}
C {lab_pin.sym} 1860 49360 0 0 {name=l39570 lab=VSS}
C {bitcell_6t.sym} 2000 49400 0 0 {name=Xr247c10}
N 1960 49440 1940 49440 {}
C {lab_pin.sym} 1940 49440 0 0 {name=l39571 lab=BL10}
N 1960 49400 1940 49400 {}
C {lab_pin.sym} 1940 49400 0 0 {name=l39572 lab=BLB10}
N 1960 49360 1940 49360 {}
C {lab_pin.sym} 1940 49360 0 0 {name=l39573 lab=WL247}
N 2040 49440 2060 49440 {}
C {lab_pin.sym} 2060 49440 0 0 {name=l39574 lab=VDD}
N 2040 49360 2060 49360 {}
C {lab_pin.sym} 2060 49360 0 0 {name=l39575 lab=VSS}
C {bitcell_6t.sym} 2200 49400 0 0 {name=Xr247c11}
N 2160 49440 2140 49440 {}
C {lab_pin.sym} 2140 49440 0 0 {name=l39576 lab=BL11}
N 2160 49400 2140 49400 {}
C {lab_pin.sym} 2140 49400 0 0 {name=l39577 lab=BLB11}
N 2160 49360 2140 49360 {}
C {lab_pin.sym} 2140 49360 0 0 {name=l39578 lab=WL247}
N 2240 49440 2260 49440 {}
C {lab_pin.sym} 2260 49440 0 0 {name=l39579 lab=VDD}
N 2240 49360 2260 49360 {}
C {lab_pin.sym} 2260 49360 0 0 {name=l39580 lab=VSS}
C {bitcell_6t.sym} 2400 49400 0 0 {name=Xr247c12}
N 2360 49440 2340 49440 {}
C {lab_pin.sym} 2340 49440 0 0 {name=l39581 lab=BL12}
N 2360 49400 2340 49400 {}
C {lab_pin.sym} 2340 49400 0 0 {name=l39582 lab=BLB12}
N 2360 49360 2340 49360 {}
C {lab_pin.sym} 2340 49360 0 0 {name=l39583 lab=WL247}
N 2440 49440 2460 49440 {}
C {lab_pin.sym} 2460 49440 0 0 {name=l39584 lab=VDD}
N 2440 49360 2460 49360 {}
C {lab_pin.sym} 2460 49360 0 0 {name=l39585 lab=VSS}
C {bitcell_6t.sym} 2600 49400 0 0 {name=Xr247c13}
N 2560 49440 2540 49440 {}
C {lab_pin.sym} 2540 49440 0 0 {name=l39586 lab=BL13}
N 2560 49400 2540 49400 {}
C {lab_pin.sym} 2540 49400 0 0 {name=l39587 lab=BLB13}
N 2560 49360 2540 49360 {}
C {lab_pin.sym} 2540 49360 0 0 {name=l39588 lab=WL247}
N 2640 49440 2660 49440 {}
C {lab_pin.sym} 2660 49440 0 0 {name=l39589 lab=VDD}
N 2640 49360 2660 49360 {}
C {lab_pin.sym} 2660 49360 0 0 {name=l39590 lab=VSS}
C {bitcell_6t.sym} 2800 49400 0 0 {name=Xr247c14}
N 2760 49440 2740 49440 {}
C {lab_pin.sym} 2740 49440 0 0 {name=l39591 lab=BL14}
N 2760 49400 2740 49400 {}
C {lab_pin.sym} 2740 49400 0 0 {name=l39592 lab=BLB14}
N 2760 49360 2740 49360 {}
C {lab_pin.sym} 2740 49360 0 0 {name=l39593 lab=WL247}
N 2840 49440 2860 49440 {}
C {lab_pin.sym} 2860 49440 0 0 {name=l39594 lab=VDD}
N 2840 49360 2860 49360 {}
C {lab_pin.sym} 2860 49360 0 0 {name=l39595 lab=VSS}
C {bitcell_6t.sym} 3000 49400 0 0 {name=Xr247c15}
N 2960 49440 2940 49440 {}
C {lab_pin.sym} 2940 49440 0 0 {name=l39596 lab=BL15}
N 2960 49400 2940 49400 {}
C {lab_pin.sym} 2940 49400 0 0 {name=l39597 lab=BLB15}
N 2960 49360 2940 49360 {}
C {lab_pin.sym} 2940 49360 0 0 {name=l39598 lab=WL247}
N 3040 49440 3060 49440 {}
C {lab_pin.sym} 3060 49440 0 0 {name=l39599 lab=VDD}
N 3040 49360 3060 49360 {}
C {lab_pin.sym} 3060 49360 0 0 {name=l39600 lab=VSS}
C {bitcell_6t.sym} 3200 49400 0 0 {name=Xr247c16}
N 3160 49440 3140 49440 {}
C {lab_pin.sym} 3140 49440 0 0 {name=l39601 lab=BL16}
N 3160 49400 3140 49400 {}
C {lab_pin.sym} 3140 49400 0 0 {name=l39602 lab=BLB16}
N 3160 49360 3140 49360 {}
C {lab_pin.sym} 3140 49360 0 0 {name=l39603 lab=WL247}
N 3240 49440 3260 49440 {}
C {lab_pin.sym} 3260 49440 0 0 {name=l39604 lab=VDD}
N 3240 49360 3260 49360 {}
C {lab_pin.sym} 3260 49360 0 0 {name=l39605 lab=VSS}
C {bitcell_6t.sym} 3400 49400 0 0 {name=Xr247c17}
N 3360 49440 3340 49440 {}
C {lab_pin.sym} 3340 49440 0 0 {name=l39606 lab=BL17}
N 3360 49400 3340 49400 {}
C {lab_pin.sym} 3340 49400 0 0 {name=l39607 lab=BLB17}
N 3360 49360 3340 49360 {}
C {lab_pin.sym} 3340 49360 0 0 {name=l39608 lab=WL247}
N 3440 49440 3460 49440 {}
C {lab_pin.sym} 3460 49440 0 0 {name=l39609 lab=VDD}
N 3440 49360 3460 49360 {}
C {lab_pin.sym} 3460 49360 0 0 {name=l39610 lab=VSS}
C {bitcell_6t.sym} 3600 49400 0 0 {name=Xr247c18}
N 3560 49440 3540 49440 {}
C {lab_pin.sym} 3540 49440 0 0 {name=l39611 lab=BL18}
N 3560 49400 3540 49400 {}
C {lab_pin.sym} 3540 49400 0 0 {name=l39612 lab=BLB18}
N 3560 49360 3540 49360 {}
C {lab_pin.sym} 3540 49360 0 0 {name=l39613 lab=WL247}
N 3640 49440 3660 49440 {}
C {lab_pin.sym} 3660 49440 0 0 {name=l39614 lab=VDD}
N 3640 49360 3660 49360 {}
C {lab_pin.sym} 3660 49360 0 0 {name=l39615 lab=VSS}
C {bitcell_6t.sym} 3800 49400 0 0 {name=Xr247c19}
N 3760 49440 3740 49440 {}
C {lab_pin.sym} 3740 49440 0 0 {name=l39616 lab=BL19}
N 3760 49400 3740 49400 {}
C {lab_pin.sym} 3740 49400 0 0 {name=l39617 lab=BLB19}
N 3760 49360 3740 49360 {}
C {lab_pin.sym} 3740 49360 0 0 {name=l39618 lab=WL247}
N 3840 49440 3860 49440 {}
C {lab_pin.sym} 3860 49440 0 0 {name=l39619 lab=VDD}
N 3840 49360 3860 49360 {}
C {lab_pin.sym} 3860 49360 0 0 {name=l39620 lab=VSS}
C {bitcell_6t.sym} 4000 49400 0 0 {name=Xr247c20}
N 3960 49440 3940 49440 {}
C {lab_pin.sym} 3940 49440 0 0 {name=l39621 lab=BL20}
N 3960 49400 3940 49400 {}
C {lab_pin.sym} 3940 49400 0 0 {name=l39622 lab=BLB20}
N 3960 49360 3940 49360 {}
C {lab_pin.sym} 3940 49360 0 0 {name=l39623 lab=WL247}
N 4040 49440 4060 49440 {}
C {lab_pin.sym} 4060 49440 0 0 {name=l39624 lab=VDD}
N 4040 49360 4060 49360 {}
C {lab_pin.sym} 4060 49360 0 0 {name=l39625 lab=VSS}
C {bitcell_6t.sym} 4200 49400 0 0 {name=Xr247c21}
N 4160 49440 4140 49440 {}
C {lab_pin.sym} 4140 49440 0 0 {name=l39626 lab=BL21}
N 4160 49400 4140 49400 {}
C {lab_pin.sym} 4140 49400 0 0 {name=l39627 lab=BLB21}
N 4160 49360 4140 49360 {}
C {lab_pin.sym} 4140 49360 0 0 {name=l39628 lab=WL247}
N 4240 49440 4260 49440 {}
C {lab_pin.sym} 4260 49440 0 0 {name=l39629 lab=VDD}
N 4240 49360 4260 49360 {}
C {lab_pin.sym} 4260 49360 0 0 {name=l39630 lab=VSS}
C {bitcell_6t.sym} 4400 49400 0 0 {name=Xr247c22}
N 4360 49440 4340 49440 {}
C {lab_pin.sym} 4340 49440 0 0 {name=l39631 lab=BL22}
N 4360 49400 4340 49400 {}
C {lab_pin.sym} 4340 49400 0 0 {name=l39632 lab=BLB22}
N 4360 49360 4340 49360 {}
C {lab_pin.sym} 4340 49360 0 0 {name=l39633 lab=WL247}
N 4440 49440 4460 49440 {}
C {lab_pin.sym} 4460 49440 0 0 {name=l39634 lab=VDD}
N 4440 49360 4460 49360 {}
C {lab_pin.sym} 4460 49360 0 0 {name=l39635 lab=VSS}
C {bitcell_6t.sym} 4600 49400 0 0 {name=Xr247c23}
N 4560 49440 4540 49440 {}
C {lab_pin.sym} 4540 49440 0 0 {name=l39636 lab=BL23}
N 4560 49400 4540 49400 {}
C {lab_pin.sym} 4540 49400 0 0 {name=l39637 lab=BLB23}
N 4560 49360 4540 49360 {}
C {lab_pin.sym} 4540 49360 0 0 {name=l39638 lab=WL247}
N 4640 49440 4660 49440 {}
C {lab_pin.sym} 4660 49440 0 0 {name=l39639 lab=VDD}
N 4640 49360 4660 49360 {}
C {lab_pin.sym} 4660 49360 0 0 {name=l39640 lab=VSS}
C {bitcell_6t.sym} 4800 49400 0 0 {name=Xr247c24}
N 4760 49440 4740 49440 {}
C {lab_pin.sym} 4740 49440 0 0 {name=l39641 lab=BL24}
N 4760 49400 4740 49400 {}
C {lab_pin.sym} 4740 49400 0 0 {name=l39642 lab=BLB24}
N 4760 49360 4740 49360 {}
C {lab_pin.sym} 4740 49360 0 0 {name=l39643 lab=WL247}
N 4840 49440 4860 49440 {}
C {lab_pin.sym} 4860 49440 0 0 {name=l39644 lab=VDD}
N 4840 49360 4860 49360 {}
C {lab_pin.sym} 4860 49360 0 0 {name=l39645 lab=VSS}
C {bitcell_6t.sym} 5000 49400 0 0 {name=Xr247c25}
N 4960 49440 4940 49440 {}
C {lab_pin.sym} 4940 49440 0 0 {name=l39646 lab=BL25}
N 4960 49400 4940 49400 {}
C {lab_pin.sym} 4940 49400 0 0 {name=l39647 lab=BLB25}
N 4960 49360 4940 49360 {}
C {lab_pin.sym} 4940 49360 0 0 {name=l39648 lab=WL247}
N 5040 49440 5060 49440 {}
C {lab_pin.sym} 5060 49440 0 0 {name=l39649 lab=VDD}
N 5040 49360 5060 49360 {}
C {lab_pin.sym} 5060 49360 0 0 {name=l39650 lab=VSS}
C {bitcell_6t.sym} 5200 49400 0 0 {name=Xr247c26}
N 5160 49440 5140 49440 {}
C {lab_pin.sym} 5140 49440 0 0 {name=l39651 lab=BL26}
N 5160 49400 5140 49400 {}
C {lab_pin.sym} 5140 49400 0 0 {name=l39652 lab=BLB26}
N 5160 49360 5140 49360 {}
C {lab_pin.sym} 5140 49360 0 0 {name=l39653 lab=WL247}
N 5240 49440 5260 49440 {}
C {lab_pin.sym} 5260 49440 0 0 {name=l39654 lab=VDD}
N 5240 49360 5260 49360 {}
C {lab_pin.sym} 5260 49360 0 0 {name=l39655 lab=VSS}
C {bitcell_6t.sym} 5400 49400 0 0 {name=Xr247c27}
N 5360 49440 5340 49440 {}
C {lab_pin.sym} 5340 49440 0 0 {name=l39656 lab=BL27}
N 5360 49400 5340 49400 {}
C {lab_pin.sym} 5340 49400 0 0 {name=l39657 lab=BLB27}
N 5360 49360 5340 49360 {}
C {lab_pin.sym} 5340 49360 0 0 {name=l39658 lab=WL247}
N 5440 49440 5460 49440 {}
C {lab_pin.sym} 5460 49440 0 0 {name=l39659 lab=VDD}
N 5440 49360 5460 49360 {}
C {lab_pin.sym} 5460 49360 0 0 {name=l39660 lab=VSS}
C {bitcell_6t.sym} 5600 49400 0 0 {name=Xr247c28}
N 5560 49440 5540 49440 {}
C {lab_pin.sym} 5540 49440 0 0 {name=l39661 lab=BL28}
N 5560 49400 5540 49400 {}
C {lab_pin.sym} 5540 49400 0 0 {name=l39662 lab=BLB28}
N 5560 49360 5540 49360 {}
C {lab_pin.sym} 5540 49360 0 0 {name=l39663 lab=WL247}
N 5640 49440 5660 49440 {}
C {lab_pin.sym} 5660 49440 0 0 {name=l39664 lab=VDD}
N 5640 49360 5660 49360 {}
C {lab_pin.sym} 5660 49360 0 0 {name=l39665 lab=VSS}
C {bitcell_6t.sym} 5800 49400 0 0 {name=Xr247c29}
N 5760 49440 5740 49440 {}
C {lab_pin.sym} 5740 49440 0 0 {name=l39666 lab=BL29}
N 5760 49400 5740 49400 {}
C {lab_pin.sym} 5740 49400 0 0 {name=l39667 lab=BLB29}
N 5760 49360 5740 49360 {}
C {lab_pin.sym} 5740 49360 0 0 {name=l39668 lab=WL247}
N 5840 49440 5860 49440 {}
C {lab_pin.sym} 5860 49440 0 0 {name=l39669 lab=VDD}
N 5840 49360 5860 49360 {}
C {lab_pin.sym} 5860 49360 0 0 {name=l39670 lab=VSS}
C {bitcell_6t.sym} 6000 49400 0 0 {name=Xr247c30}
N 5960 49440 5940 49440 {}
C {lab_pin.sym} 5940 49440 0 0 {name=l39671 lab=BL30}
N 5960 49400 5940 49400 {}
C {lab_pin.sym} 5940 49400 0 0 {name=l39672 lab=BLB30}
N 5960 49360 5940 49360 {}
C {lab_pin.sym} 5940 49360 0 0 {name=l39673 lab=WL247}
N 6040 49440 6060 49440 {}
C {lab_pin.sym} 6060 49440 0 0 {name=l39674 lab=VDD}
N 6040 49360 6060 49360 {}
C {lab_pin.sym} 6060 49360 0 0 {name=l39675 lab=VSS}
C {bitcell_6t.sym} 6200 49400 0 0 {name=Xr247c31}
N 6160 49440 6140 49440 {}
C {lab_pin.sym} 6140 49440 0 0 {name=l39676 lab=BL31}
N 6160 49400 6140 49400 {}
C {lab_pin.sym} 6140 49400 0 0 {name=l39677 lab=BLB31}
N 6160 49360 6140 49360 {}
C {lab_pin.sym} 6140 49360 0 0 {name=l39678 lab=WL247}
N 6240 49440 6260 49440 {}
C {lab_pin.sym} 6260 49440 0 0 {name=l39679 lab=VDD}
N 6240 49360 6260 49360 {}
C {lab_pin.sym} 6260 49360 0 0 {name=l39680 lab=VSS}
C {bitcell_6t.sym} 0 49600 0 0 {name=Xr248c0}
N -40 49640 -60 49640 {}
C {lab_pin.sym} -60 49640 0 0 {name=l39681 lab=BL0}
N -40 49600 -60 49600 {}
C {lab_pin.sym} -60 49600 0 0 {name=l39682 lab=BLB0}
N -40 49560 -60 49560 {}
C {lab_pin.sym} -60 49560 0 0 {name=l39683 lab=WL248}
N 40 49640 60 49640 {}
C {lab_pin.sym} 60 49640 0 0 {name=l39684 lab=VDD}
N 40 49560 60 49560 {}
C {lab_pin.sym} 60 49560 0 0 {name=l39685 lab=VSS}
C {bitcell_6t.sym} 200 49600 0 0 {name=Xr248c1}
N 160 49640 140 49640 {}
C {lab_pin.sym} 140 49640 0 0 {name=l39686 lab=BL1}
N 160 49600 140 49600 {}
C {lab_pin.sym} 140 49600 0 0 {name=l39687 lab=BLB1}
N 160 49560 140 49560 {}
C {lab_pin.sym} 140 49560 0 0 {name=l39688 lab=WL248}
N 240 49640 260 49640 {}
C {lab_pin.sym} 260 49640 0 0 {name=l39689 lab=VDD}
N 240 49560 260 49560 {}
C {lab_pin.sym} 260 49560 0 0 {name=l39690 lab=VSS}
C {bitcell_6t.sym} 400 49600 0 0 {name=Xr248c2}
N 360 49640 340 49640 {}
C {lab_pin.sym} 340 49640 0 0 {name=l39691 lab=BL2}
N 360 49600 340 49600 {}
C {lab_pin.sym} 340 49600 0 0 {name=l39692 lab=BLB2}
N 360 49560 340 49560 {}
C {lab_pin.sym} 340 49560 0 0 {name=l39693 lab=WL248}
N 440 49640 460 49640 {}
C {lab_pin.sym} 460 49640 0 0 {name=l39694 lab=VDD}
N 440 49560 460 49560 {}
C {lab_pin.sym} 460 49560 0 0 {name=l39695 lab=VSS}
C {bitcell_6t.sym} 600 49600 0 0 {name=Xr248c3}
N 560 49640 540 49640 {}
C {lab_pin.sym} 540 49640 0 0 {name=l39696 lab=BL3}
N 560 49600 540 49600 {}
C {lab_pin.sym} 540 49600 0 0 {name=l39697 lab=BLB3}
N 560 49560 540 49560 {}
C {lab_pin.sym} 540 49560 0 0 {name=l39698 lab=WL248}
N 640 49640 660 49640 {}
C {lab_pin.sym} 660 49640 0 0 {name=l39699 lab=VDD}
N 640 49560 660 49560 {}
C {lab_pin.sym} 660 49560 0 0 {name=l39700 lab=VSS}
C {bitcell_6t.sym} 800 49600 0 0 {name=Xr248c4}
N 760 49640 740 49640 {}
C {lab_pin.sym} 740 49640 0 0 {name=l39701 lab=BL4}
N 760 49600 740 49600 {}
C {lab_pin.sym} 740 49600 0 0 {name=l39702 lab=BLB4}
N 760 49560 740 49560 {}
C {lab_pin.sym} 740 49560 0 0 {name=l39703 lab=WL248}
N 840 49640 860 49640 {}
C {lab_pin.sym} 860 49640 0 0 {name=l39704 lab=VDD}
N 840 49560 860 49560 {}
C {lab_pin.sym} 860 49560 0 0 {name=l39705 lab=VSS}
C {bitcell_6t.sym} 1000 49600 0 0 {name=Xr248c5}
N 960 49640 940 49640 {}
C {lab_pin.sym} 940 49640 0 0 {name=l39706 lab=BL5}
N 960 49600 940 49600 {}
C {lab_pin.sym} 940 49600 0 0 {name=l39707 lab=BLB5}
N 960 49560 940 49560 {}
C {lab_pin.sym} 940 49560 0 0 {name=l39708 lab=WL248}
N 1040 49640 1060 49640 {}
C {lab_pin.sym} 1060 49640 0 0 {name=l39709 lab=VDD}
N 1040 49560 1060 49560 {}
C {lab_pin.sym} 1060 49560 0 0 {name=l39710 lab=VSS}
C {bitcell_6t.sym} 1200 49600 0 0 {name=Xr248c6}
N 1160 49640 1140 49640 {}
C {lab_pin.sym} 1140 49640 0 0 {name=l39711 lab=BL6}
N 1160 49600 1140 49600 {}
C {lab_pin.sym} 1140 49600 0 0 {name=l39712 lab=BLB6}
N 1160 49560 1140 49560 {}
C {lab_pin.sym} 1140 49560 0 0 {name=l39713 lab=WL248}
N 1240 49640 1260 49640 {}
C {lab_pin.sym} 1260 49640 0 0 {name=l39714 lab=VDD}
N 1240 49560 1260 49560 {}
C {lab_pin.sym} 1260 49560 0 0 {name=l39715 lab=VSS}
C {bitcell_6t.sym} 1400 49600 0 0 {name=Xr248c7}
N 1360 49640 1340 49640 {}
C {lab_pin.sym} 1340 49640 0 0 {name=l39716 lab=BL7}
N 1360 49600 1340 49600 {}
C {lab_pin.sym} 1340 49600 0 0 {name=l39717 lab=BLB7}
N 1360 49560 1340 49560 {}
C {lab_pin.sym} 1340 49560 0 0 {name=l39718 lab=WL248}
N 1440 49640 1460 49640 {}
C {lab_pin.sym} 1460 49640 0 0 {name=l39719 lab=VDD}
N 1440 49560 1460 49560 {}
C {lab_pin.sym} 1460 49560 0 0 {name=l39720 lab=VSS}
C {bitcell_6t.sym} 1600 49600 0 0 {name=Xr248c8}
N 1560 49640 1540 49640 {}
C {lab_pin.sym} 1540 49640 0 0 {name=l39721 lab=BL8}
N 1560 49600 1540 49600 {}
C {lab_pin.sym} 1540 49600 0 0 {name=l39722 lab=BLB8}
N 1560 49560 1540 49560 {}
C {lab_pin.sym} 1540 49560 0 0 {name=l39723 lab=WL248}
N 1640 49640 1660 49640 {}
C {lab_pin.sym} 1660 49640 0 0 {name=l39724 lab=VDD}
N 1640 49560 1660 49560 {}
C {lab_pin.sym} 1660 49560 0 0 {name=l39725 lab=VSS}
C {bitcell_6t.sym} 1800 49600 0 0 {name=Xr248c9}
N 1760 49640 1740 49640 {}
C {lab_pin.sym} 1740 49640 0 0 {name=l39726 lab=BL9}
N 1760 49600 1740 49600 {}
C {lab_pin.sym} 1740 49600 0 0 {name=l39727 lab=BLB9}
N 1760 49560 1740 49560 {}
C {lab_pin.sym} 1740 49560 0 0 {name=l39728 lab=WL248}
N 1840 49640 1860 49640 {}
C {lab_pin.sym} 1860 49640 0 0 {name=l39729 lab=VDD}
N 1840 49560 1860 49560 {}
C {lab_pin.sym} 1860 49560 0 0 {name=l39730 lab=VSS}
C {bitcell_6t.sym} 2000 49600 0 0 {name=Xr248c10}
N 1960 49640 1940 49640 {}
C {lab_pin.sym} 1940 49640 0 0 {name=l39731 lab=BL10}
N 1960 49600 1940 49600 {}
C {lab_pin.sym} 1940 49600 0 0 {name=l39732 lab=BLB10}
N 1960 49560 1940 49560 {}
C {lab_pin.sym} 1940 49560 0 0 {name=l39733 lab=WL248}
N 2040 49640 2060 49640 {}
C {lab_pin.sym} 2060 49640 0 0 {name=l39734 lab=VDD}
N 2040 49560 2060 49560 {}
C {lab_pin.sym} 2060 49560 0 0 {name=l39735 lab=VSS}
C {bitcell_6t.sym} 2200 49600 0 0 {name=Xr248c11}
N 2160 49640 2140 49640 {}
C {lab_pin.sym} 2140 49640 0 0 {name=l39736 lab=BL11}
N 2160 49600 2140 49600 {}
C {lab_pin.sym} 2140 49600 0 0 {name=l39737 lab=BLB11}
N 2160 49560 2140 49560 {}
C {lab_pin.sym} 2140 49560 0 0 {name=l39738 lab=WL248}
N 2240 49640 2260 49640 {}
C {lab_pin.sym} 2260 49640 0 0 {name=l39739 lab=VDD}
N 2240 49560 2260 49560 {}
C {lab_pin.sym} 2260 49560 0 0 {name=l39740 lab=VSS}
C {bitcell_6t.sym} 2400 49600 0 0 {name=Xr248c12}
N 2360 49640 2340 49640 {}
C {lab_pin.sym} 2340 49640 0 0 {name=l39741 lab=BL12}
N 2360 49600 2340 49600 {}
C {lab_pin.sym} 2340 49600 0 0 {name=l39742 lab=BLB12}
N 2360 49560 2340 49560 {}
C {lab_pin.sym} 2340 49560 0 0 {name=l39743 lab=WL248}
N 2440 49640 2460 49640 {}
C {lab_pin.sym} 2460 49640 0 0 {name=l39744 lab=VDD}
N 2440 49560 2460 49560 {}
C {lab_pin.sym} 2460 49560 0 0 {name=l39745 lab=VSS}
C {bitcell_6t.sym} 2600 49600 0 0 {name=Xr248c13}
N 2560 49640 2540 49640 {}
C {lab_pin.sym} 2540 49640 0 0 {name=l39746 lab=BL13}
N 2560 49600 2540 49600 {}
C {lab_pin.sym} 2540 49600 0 0 {name=l39747 lab=BLB13}
N 2560 49560 2540 49560 {}
C {lab_pin.sym} 2540 49560 0 0 {name=l39748 lab=WL248}
N 2640 49640 2660 49640 {}
C {lab_pin.sym} 2660 49640 0 0 {name=l39749 lab=VDD}
N 2640 49560 2660 49560 {}
C {lab_pin.sym} 2660 49560 0 0 {name=l39750 lab=VSS}
C {bitcell_6t.sym} 2800 49600 0 0 {name=Xr248c14}
N 2760 49640 2740 49640 {}
C {lab_pin.sym} 2740 49640 0 0 {name=l39751 lab=BL14}
N 2760 49600 2740 49600 {}
C {lab_pin.sym} 2740 49600 0 0 {name=l39752 lab=BLB14}
N 2760 49560 2740 49560 {}
C {lab_pin.sym} 2740 49560 0 0 {name=l39753 lab=WL248}
N 2840 49640 2860 49640 {}
C {lab_pin.sym} 2860 49640 0 0 {name=l39754 lab=VDD}
N 2840 49560 2860 49560 {}
C {lab_pin.sym} 2860 49560 0 0 {name=l39755 lab=VSS}
C {bitcell_6t.sym} 3000 49600 0 0 {name=Xr248c15}
N 2960 49640 2940 49640 {}
C {lab_pin.sym} 2940 49640 0 0 {name=l39756 lab=BL15}
N 2960 49600 2940 49600 {}
C {lab_pin.sym} 2940 49600 0 0 {name=l39757 lab=BLB15}
N 2960 49560 2940 49560 {}
C {lab_pin.sym} 2940 49560 0 0 {name=l39758 lab=WL248}
N 3040 49640 3060 49640 {}
C {lab_pin.sym} 3060 49640 0 0 {name=l39759 lab=VDD}
N 3040 49560 3060 49560 {}
C {lab_pin.sym} 3060 49560 0 0 {name=l39760 lab=VSS}
C {bitcell_6t.sym} 3200 49600 0 0 {name=Xr248c16}
N 3160 49640 3140 49640 {}
C {lab_pin.sym} 3140 49640 0 0 {name=l39761 lab=BL16}
N 3160 49600 3140 49600 {}
C {lab_pin.sym} 3140 49600 0 0 {name=l39762 lab=BLB16}
N 3160 49560 3140 49560 {}
C {lab_pin.sym} 3140 49560 0 0 {name=l39763 lab=WL248}
N 3240 49640 3260 49640 {}
C {lab_pin.sym} 3260 49640 0 0 {name=l39764 lab=VDD}
N 3240 49560 3260 49560 {}
C {lab_pin.sym} 3260 49560 0 0 {name=l39765 lab=VSS}
C {bitcell_6t.sym} 3400 49600 0 0 {name=Xr248c17}
N 3360 49640 3340 49640 {}
C {lab_pin.sym} 3340 49640 0 0 {name=l39766 lab=BL17}
N 3360 49600 3340 49600 {}
C {lab_pin.sym} 3340 49600 0 0 {name=l39767 lab=BLB17}
N 3360 49560 3340 49560 {}
C {lab_pin.sym} 3340 49560 0 0 {name=l39768 lab=WL248}
N 3440 49640 3460 49640 {}
C {lab_pin.sym} 3460 49640 0 0 {name=l39769 lab=VDD}
N 3440 49560 3460 49560 {}
C {lab_pin.sym} 3460 49560 0 0 {name=l39770 lab=VSS}
C {bitcell_6t.sym} 3600 49600 0 0 {name=Xr248c18}
N 3560 49640 3540 49640 {}
C {lab_pin.sym} 3540 49640 0 0 {name=l39771 lab=BL18}
N 3560 49600 3540 49600 {}
C {lab_pin.sym} 3540 49600 0 0 {name=l39772 lab=BLB18}
N 3560 49560 3540 49560 {}
C {lab_pin.sym} 3540 49560 0 0 {name=l39773 lab=WL248}
N 3640 49640 3660 49640 {}
C {lab_pin.sym} 3660 49640 0 0 {name=l39774 lab=VDD}
N 3640 49560 3660 49560 {}
C {lab_pin.sym} 3660 49560 0 0 {name=l39775 lab=VSS}
C {bitcell_6t.sym} 3800 49600 0 0 {name=Xr248c19}
N 3760 49640 3740 49640 {}
C {lab_pin.sym} 3740 49640 0 0 {name=l39776 lab=BL19}
N 3760 49600 3740 49600 {}
C {lab_pin.sym} 3740 49600 0 0 {name=l39777 lab=BLB19}
N 3760 49560 3740 49560 {}
C {lab_pin.sym} 3740 49560 0 0 {name=l39778 lab=WL248}
N 3840 49640 3860 49640 {}
C {lab_pin.sym} 3860 49640 0 0 {name=l39779 lab=VDD}
N 3840 49560 3860 49560 {}
C {lab_pin.sym} 3860 49560 0 0 {name=l39780 lab=VSS}
C {bitcell_6t.sym} 4000 49600 0 0 {name=Xr248c20}
N 3960 49640 3940 49640 {}
C {lab_pin.sym} 3940 49640 0 0 {name=l39781 lab=BL20}
N 3960 49600 3940 49600 {}
C {lab_pin.sym} 3940 49600 0 0 {name=l39782 lab=BLB20}
N 3960 49560 3940 49560 {}
C {lab_pin.sym} 3940 49560 0 0 {name=l39783 lab=WL248}
N 4040 49640 4060 49640 {}
C {lab_pin.sym} 4060 49640 0 0 {name=l39784 lab=VDD}
N 4040 49560 4060 49560 {}
C {lab_pin.sym} 4060 49560 0 0 {name=l39785 lab=VSS}
C {bitcell_6t.sym} 4200 49600 0 0 {name=Xr248c21}
N 4160 49640 4140 49640 {}
C {lab_pin.sym} 4140 49640 0 0 {name=l39786 lab=BL21}
N 4160 49600 4140 49600 {}
C {lab_pin.sym} 4140 49600 0 0 {name=l39787 lab=BLB21}
N 4160 49560 4140 49560 {}
C {lab_pin.sym} 4140 49560 0 0 {name=l39788 lab=WL248}
N 4240 49640 4260 49640 {}
C {lab_pin.sym} 4260 49640 0 0 {name=l39789 lab=VDD}
N 4240 49560 4260 49560 {}
C {lab_pin.sym} 4260 49560 0 0 {name=l39790 lab=VSS}
C {bitcell_6t.sym} 4400 49600 0 0 {name=Xr248c22}
N 4360 49640 4340 49640 {}
C {lab_pin.sym} 4340 49640 0 0 {name=l39791 lab=BL22}
N 4360 49600 4340 49600 {}
C {lab_pin.sym} 4340 49600 0 0 {name=l39792 lab=BLB22}
N 4360 49560 4340 49560 {}
C {lab_pin.sym} 4340 49560 0 0 {name=l39793 lab=WL248}
N 4440 49640 4460 49640 {}
C {lab_pin.sym} 4460 49640 0 0 {name=l39794 lab=VDD}
N 4440 49560 4460 49560 {}
C {lab_pin.sym} 4460 49560 0 0 {name=l39795 lab=VSS}
C {bitcell_6t.sym} 4600 49600 0 0 {name=Xr248c23}
N 4560 49640 4540 49640 {}
C {lab_pin.sym} 4540 49640 0 0 {name=l39796 lab=BL23}
N 4560 49600 4540 49600 {}
C {lab_pin.sym} 4540 49600 0 0 {name=l39797 lab=BLB23}
N 4560 49560 4540 49560 {}
C {lab_pin.sym} 4540 49560 0 0 {name=l39798 lab=WL248}
N 4640 49640 4660 49640 {}
C {lab_pin.sym} 4660 49640 0 0 {name=l39799 lab=VDD}
N 4640 49560 4660 49560 {}
C {lab_pin.sym} 4660 49560 0 0 {name=l39800 lab=VSS}
C {bitcell_6t.sym} 4800 49600 0 0 {name=Xr248c24}
N 4760 49640 4740 49640 {}
C {lab_pin.sym} 4740 49640 0 0 {name=l39801 lab=BL24}
N 4760 49600 4740 49600 {}
C {lab_pin.sym} 4740 49600 0 0 {name=l39802 lab=BLB24}
N 4760 49560 4740 49560 {}
C {lab_pin.sym} 4740 49560 0 0 {name=l39803 lab=WL248}
N 4840 49640 4860 49640 {}
C {lab_pin.sym} 4860 49640 0 0 {name=l39804 lab=VDD}
N 4840 49560 4860 49560 {}
C {lab_pin.sym} 4860 49560 0 0 {name=l39805 lab=VSS}
C {bitcell_6t.sym} 5000 49600 0 0 {name=Xr248c25}
N 4960 49640 4940 49640 {}
C {lab_pin.sym} 4940 49640 0 0 {name=l39806 lab=BL25}
N 4960 49600 4940 49600 {}
C {lab_pin.sym} 4940 49600 0 0 {name=l39807 lab=BLB25}
N 4960 49560 4940 49560 {}
C {lab_pin.sym} 4940 49560 0 0 {name=l39808 lab=WL248}
N 5040 49640 5060 49640 {}
C {lab_pin.sym} 5060 49640 0 0 {name=l39809 lab=VDD}
N 5040 49560 5060 49560 {}
C {lab_pin.sym} 5060 49560 0 0 {name=l39810 lab=VSS}
C {bitcell_6t.sym} 5200 49600 0 0 {name=Xr248c26}
N 5160 49640 5140 49640 {}
C {lab_pin.sym} 5140 49640 0 0 {name=l39811 lab=BL26}
N 5160 49600 5140 49600 {}
C {lab_pin.sym} 5140 49600 0 0 {name=l39812 lab=BLB26}
N 5160 49560 5140 49560 {}
C {lab_pin.sym} 5140 49560 0 0 {name=l39813 lab=WL248}
N 5240 49640 5260 49640 {}
C {lab_pin.sym} 5260 49640 0 0 {name=l39814 lab=VDD}
N 5240 49560 5260 49560 {}
C {lab_pin.sym} 5260 49560 0 0 {name=l39815 lab=VSS}
C {bitcell_6t.sym} 5400 49600 0 0 {name=Xr248c27}
N 5360 49640 5340 49640 {}
C {lab_pin.sym} 5340 49640 0 0 {name=l39816 lab=BL27}
N 5360 49600 5340 49600 {}
C {lab_pin.sym} 5340 49600 0 0 {name=l39817 lab=BLB27}
N 5360 49560 5340 49560 {}
C {lab_pin.sym} 5340 49560 0 0 {name=l39818 lab=WL248}
N 5440 49640 5460 49640 {}
C {lab_pin.sym} 5460 49640 0 0 {name=l39819 lab=VDD}
N 5440 49560 5460 49560 {}
C {lab_pin.sym} 5460 49560 0 0 {name=l39820 lab=VSS}
C {bitcell_6t.sym} 5600 49600 0 0 {name=Xr248c28}
N 5560 49640 5540 49640 {}
C {lab_pin.sym} 5540 49640 0 0 {name=l39821 lab=BL28}
N 5560 49600 5540 49600 {}
C {lab_pin.sym} 5540 49600 0 0 {name=l39822 lab=BLB28}
N 5560 49560 5540 49560 {}
C {lab_pin.sym} 5540 49560 0 0 {name=l39823 lab=WL248}
N 5640 49640 5660 49640 {}
C {lab_pin.sym} 5660 49640 0 0 {name=l39824 lab=VDD}
N 5640 49560 5660 49560 {}
C {lab_pin.sym} 5660 49560 0 0 {name=l39825 lab=VSS}
C {bitcell_6t.sym} 5800 49600 0 0 {name=Xr248c29}
N 5760 49640 5740 49640 {}
C {lab_pin.sym} 5740 49640 0 0 {name=l39826 lab=BL29}
N 5760 49600 5740 49600 {}
C {lab_pin.sym} 5740 49600 0 0 {name=l39827 lab=BLB29}
N 5760 49560 5740 49560 {}
C {lab_pin.sym} 5740 49560 0 0 {name=l39828 lab=WL248}
N 5840 49640 5860 49640 {}
C {lab_pin.sym} 5860 49640 0 0 {name=l39829 lab=VDD}
N 5840 49560 5860 49560 {}
C {lab_pin.sym} 5860 49560 0 0 {name=l39830 lab=VSS}
C {bitcell_6t.sym} 6000 49600 0 0 {name=Xr248c30}
N 5960 49640 5940 49640 {}
C {lab_pin.sym} 5940 49640 0 0 {name=l39831 lab=BL30}
N 5960 49600 5940 49600 {}
C {lab_pin.sym} 5940 49600 0 0 {name=l39832 lab=BLB30}
N 5960 49560 5940 49560 {}
C {lab_pin.sym} 5940 49560 0 0 {name=l39833 lab=WL248}
N 6040 49640 6060 49640 {}
C {lab_pin.sym} 6060 49640 0 0 {name=l39834 lab=VDD}
N 6040 49560 6060 49560 {}
C {lab_pin.sym} 6060 49560 0 0 {name=l39835 lab=VSS}
C {bitcell_6t.sym} 6200 49600 0 0 {name=Xr248c31}
N 6160 49640 6140 49640 {}
C {lab_pin.sym} 6140 49640 0 0 {name=l39836 lab=BL31}
N 6160 49600 6140 49600 {}
C {lab_pin.sym} 6140 49600 0 0 {name=l39837 lab=BLB31}
N 6160 49560 6140 49560 {}
C {lab_pin.sym} 6140 49560 0 0 {name=l39838 lab=WL248}
N 6240 49640 6260 49640 {}
C {lab_pin.sym} 6260 49640 0 0 {name=l39839 lab=VDD}
N 6240 49560 6260 49560 {}
C {lab_pin.sym} 6260 49560 0 0 {name=l39840 lab=VSS}
C {bitcell_6t.sym} 0 49800 0 0 {name=Xr249c0}
N -40 49840 -60 49840 {}
C {lab_pin.sym} -60 49840 0 0 {name=l39841 lab=BL0}
N -40 49800 -60 49800 {}
C {lab_pin.sym} -60 49800 0 0 {name=l39842 lab=BLB0}
N -40 49760 -60 49760 {}
C {lab_pin.sym} -60 49760 0 0 {name=l39843 lab=WL249}
N 40 49840 60 49840 {}
C {lab_pin.sym} 60 49840 0 0 {name=l39844 lab=VDD}
N 40 49760 60 49760 {}
C {lab_pin.sym} 60 49760 0 0 {name=l39845 lab=VSS}
C {bitcell_6t.sym} 200 49800 0 0 {name=Xr249c1}
N 160 49840 140 49840 {}
C {lab_pin.sym} 140 49840 0 0 {name=l39846 lab=BL1}
N 160 49800 140 49800 {}
C {lab_pin.sym} 140 49800 0 0 {name=l39847 lab=BLB1}
N 160 49760 140 49760 {}
C {lab_pin.sym} 140 49760 0 0 {name=l39848 lab=WL249}
N 240 49840 260 49840 {}
C {lab_pin.sym} 260 49840 0 0 {name=l39849 lab=VDD}
N 240 49760 260 49760 {}
C {lab_pin.sym} 260 49760 0 0 {name=l39850 lab=VSS}
C {bitcell_6t.sym} 400 49800 0 0 {name=Xr249c2}
N 360 49840 340 49840 {}
C {lab_pin.sym} 340 49840 0 0 {name=l39851 lab=BL2}
N 360 49800 340 49800 {}
C {lab_pin.sym} 340 49800 0 0 {name=l39852 lab=BLB2}
N 360 49760 340 49760 {}
C {lab_pin.sym} 340 49760 0 0 {name=l39853 lab=WL249}
N 440 49840 460 49840 {}
C {lab_pin.sym} 460 49840 0 0 {name=l39854 lab=VDD}
N 440 49760 460 49760 {}
C {lab_pin.sym} 460 49760 0 0 {name=l39855 lab=VSS}
C {bitcell_6t.sym} 600 49800 0 0 {name=Xr249c3}
N 560 49840 540 49840 {}
C {lab_pin.sym} 540 49840 0 0 {name=l39856 lab=BL3}
N 560 49800 540 49800 {}
C {lab_pin.sym} 540 49800 0 0 {name=l39857 lab=BLB3}
N 560 49760 540 49760 {}
C {lab_pin.sym} 540 49760 0 0 {name=l39858 lab=WL249}
N 640 49840 660 49840 {}
C {lab_pin.sym} 660 49840 0 0 {name=l39859 lab=VDD}
N 640 49760 660 49760 {}
C {lab_pin.sym} 660 49760 0 0 {name=l39860 lab=VSS}
C {bitcell_6t.sym} 800 49800 0 0 {name=Xr249c4}
N 760 49840 740 49840 {}
C {lab_pin.sym} 740 49840 0 0 {name=l39861 lab=BL4}
N 760 49800 740 49800 {}
C {lab_pin.sym} 740 49800 0 0 {name=l39862 lab=BLB4}
N 760 49760 740 49760 {}
C {lab_pin.sym} 740 49760 0 0 {name=l39863 lab=WL249}
N 840 49840 860 49840 {}
C {lab_pin.sym} 860 49840 0 0 {name=l39864 lab=VDD}
N 840 49760 860 49760 {}
C {lab_pin.sym} 860 49760 0 0 {name=l39865 lab=VSS}
C {bitcell_6t.sym} 1000 49800 0 0 {name=Xr249c5}
N 960 49840 940 49840 {}
C {lab_pin.sym} 940 49840 0 0 {name=l39866 lab=BL5}
N 960 49800 940 49800 {}
C {lab_pin.sym} 940 49800 0 0 {name=l39867 lab=BLB5}
N 960 49760 940 49760 {}
C {lab_pin.sym} 940 49760 0 0 {name=l39868 lab=WL249}
N 1040 49840 1060 49840 {}
C {lab_pin.sym} 1060 49840 0 0 {name=l39869 lab=VDD}
N 1040 49760 1060 49760 {}
C {lab_pin.sym} 1060 49760 0 0 {name=l39870 lab=VSS}
C {bitcell_6t.sym} 1200 49800 0 0 {name=Xr249c6}
N 1160 49840 1140 49840 {}
C {lab_pin.sym} 1140 49840 0 0 {name=l39871 lab=BL6}
N 1160 49800 1140 49800 {}
C {lab_pin.sym} 1140 49800 0 0 {name=l39872 lab=BLB6}
N 1160 49760 1140 49760 {}
C {lab_pin.sym} 1140 49760 0 0 {name=l39873 lab=WL249}
N 1240 49840 1260 49840 {}
C {lab_pin.sym} 1260 49840 0 0 {name=l39874 lab=VDD}
N 1240 49760 1260 49760 {}
C {lab_pin.sym} 1260 49760 0 0 {name=l39875 lab=VSS}
C {bitcell_6t.sym} 1400 49800 0 0 {name=Xr249c7}
N 1360 49840 1340 49840 {}
C {lab_pin.sym} 1340 49840 0 0 {name=l39876 lab=BL7}
N 1360 49800 1340 49800 {}
C {lab_pin.sym} 1340 49800 0 0 {name=l39877 lab=BLB7}
N 1360 49760 1340 49760 {}
C {lab_pin.sym} 1340 49760 0 0 {name=l39878 lab=WL249}
N 1440 49840 1460 49840 {}
C {lab_pin.sym} 1460 49840 0 0 {name=l39879 lab=VDD}
N 1440 49760 1460 49760 {}
C {lab_pin.sym} 1460 49760 0 0 {name=l39880 lab=VSS}
C {bitcell_6t.sym} 1600 49800 0 0 {name=Xr249c8}
N 1560 49840 1540 49840 {}
C {lab_pin.sym} 1540 49840 0 0 {name=l39881 lab=BL8}
N 1560 49800 1540 49800 {}
C {lab_pin.sym} 1540 49800 0 0 {name=l39882 lab=BLB8}
N 1560 49760 1540 49760 {}
C {lab_pin.sym} 1540 49760 0 0 {name=l39883 lab=WL249}
N 1640 49840 1660 49840 {}
C {lab_pin.sym} 1660 49840 0 0 {name=l39884 lab=VDD}
N 1640 49760 1660 49760 {}
C {lab_pin.sym} 1660 49760 0 0 {name=l39885 lab=VSS}
C {bitcell_6t.sym} 1800 49800 0 0 {name=Xr249c9}
N 1760 49840 1740 49840 {}
C {lab_pin.sym} 1740 49840 0 0 {name=l39886 lab=BL9}
N 1760 49800 1740 49800 {}
C {lab_pin.sym} 1740 49800 0 0 {name=l39887 lab=BLB9}
N 1760 49760 1740 49760 {}
C {lab_pin.sym} 1740 49760 0 0 {name=l39888 lab=WL249}
N 1840 49840 1860 49840 {}
C {lab_pin.sym} 1860 49840 0 0 {name=l39889 lab=VDD}
N 1840 49760 1860 49760 {}
C {lab_pin.sym} 1860 49760 0 0 {name=l39890 lab=VSS}
C {bitcell_6t.sym} 2000 49800 0 0 {name=Xr249c10}
N 1960 49840 1940 49840 {}
C {lab_pin.sym} 1940 49840 0 0 {name=l39891 lab=BL10}
N 1960 49800 1940 49800 {}
C {lab_pin.sym} 1940 49800 0 0 {name=l39892 lab=BLB10}
N 1960 49760 1940 49760 {}
C {lab_pin.sym} 1940 49760 0 0 {name=l39893 lab=WL249}
N 2040 49840 2060 49840 {}
C {lab_pin.sym} 2060 49840 0 0 {name=l39894 lab=VDD}
N 2040 49760 2060 49760 {}
C {lab_pin.sym} 2060 49760 0 0 {name=l39895 lab=VSS}
C {bitcell_6t.sym} 2200 49800 0 0 {name=Xr249c11}
N 2160 49840 2140 49840 {}
C {lab_pin.sym} 2140 49840 0 0 {name=l39896 lab=BL11}
N 2160 49800 2140 49800 {}
C {lab_pin.sym} 2140 49800 0 0 {name=l39897 lab=BLB11}
N 2160 49760 2140 49760 {}
C {lab_pin.sym} 2140 49760 0 0 {name=l39898 lab=WL249}
N 2240 49840 2260 49840 {}
C {lab_pin.sym} 2260 49840 0 0 {name=l39899 lab=VDD}
N 2240 49760 2260 49760 {}
C {lab_pin.sym} 2260 49760 0 0 {name=l39900 lab=VSS}
C {bitcell_6t.sym} 2400 49800 0 0 {name=Xr249c12}
N 2360 49840 2340 49840 {}
C {lab_pin.sym} 2340 49840 0 0 {name=l39901 lab=BL12}
N 2360 49800 2340 49800 {}
C {lab_pin.sym} 2340 49800 0 0 {name=l39902 lab=BLB12}
N 2360 49760 2340 49760 {}
C {lab_pin.sym} 2340 49760 0 0 {name=l39903 lab=WL249}
N 2440 49840 2460 49840 {}
C {lab_pin.sym} 2460 49840 0 0 {name=l39904 lab=VDD}
N 2440 49760 2460 49760 {}
C {lab_pin.sym} 2460 49760 0 0 {name=l39905 lab=VSS}
C {bitcell_6t.sym} 2600 49800 0 0 {name=Xr249c13}
N 2560 49840 2540 49840 {}
C {lab_pin.sym} 2540 49840 0 0 {name=l39906 lab=BL13}
N 2560 49800 2540 49800 {}
C {lab_pin.sym} 2540 49800 0 0 {name=l39907 lab=BLB13}
N 2560 49760 2540 49760 {}
C {lab_pin.sym} 2540 49760 0 0 {name=l39908 lab=WL249}
N 2640 49840 2660 49840 {}
C {lab_pin.sym} 2660 49840 0 0 {name=l39909 lab=VDD}
N 2640 49760 2660 49760 {}
C {lab_pin.sym} 2660 49760 0 0 {name=l39910 lab=VSS}
C {bitcell_6t.sym} 2800 49800 0 0 {name=Xr249c14}
N 2760 49840 2740 49840 {}
C {lab_pin.sym} 2740 49840 0 0 {name=l39911 lab=BL14}
N 2760 49800 2740 49800 {}
C {lab_pin.sym} 2740 49800 0 0 {name=l39912 lab=BLB14}
N 2760 49760 2740 49760 {}
C {lab_pin.sym} 2740 49760 0 0 {name=l39913 lab=WL249}
N 2840 49840 2860 49840 {}
C {lab_pin.sym} 2860 49840 0 0 {name=l39914 lab=VDD}
N 2840 49760 2860 49760 {}
C {lab_pin.sym} 2860 49760 0 0 {name=l39915 lab=VSS}
C {bitcell_6t.sym} 3000 49800 0 0 {name=Xr249c15}
N 2960 49840 2940 49840 {}
C {lab_pin.sym} 2940 49840 0 0 {name=l39916 lab=BL15}
N 2960 49800 2940 49800 {}
C {lab_pin.sym} 2940 49800 0 0 {name=l39917 lab=BLB15}
N 2960 49760 2940 49760 {}
C {lab_pin.sym} 2940 49760 0 0 {name=l39918 lab=WL249}
N 3040 49840 3060 49840 {}
C {lab_pin.sym} 3060 49840 0 0 {name=l39919 lab=VDD}
N 3040 49760 3060 49760 {}
C {lab_pin.sym} 3060 49760 0 0 {name=l39920 lab=VSS}
C {bitcell_6t.sym} 3200 49800 0 0 {name=Xr249c16}
N 3160 49840 3140 49840 {}
C {lab_pin.sym} 3140 49840 0 0 {name=l39921 lab=BL16}
N 3160 49800 3140 49800 {}
C {lab_pin.sym} 3140 49800 0 0 {name=l39922 lab=BLB16}
N 3160 49760 3140 49760 {}
C {lab_pin.sym} 3140 49760 0 0 {name=l39923 lab=WL249}
N 3240 49840 3260 49840 {}
C {lab_pin.sym} 3260 49840 0 0 {name=l39924 lab=VDD}
N 3240 49760 3260 49760 {}
C {lab_pin.sym} 3260 49760 0 0 {name=l39925 lab=VSS}
C {bitcell_6t.sym} 3400 49800 0 0 {name=Xr249c17}
N 3360 49840 3340 49840 {}
C {lab_pin.sym} 3340 49840 0 0 {name=l39926 lab=BL17}
N 3360 49800 3340 49800 {}
C {lab_pin.sym} 3340 49800 0 0 {name=l39927 lab=BLB17}
N 3360 49760 3340 49760 {}
C {lab_pin.sym} 3340 49760 0 0 {name=l39928 lab=WL249}
N 3440 49840 3460 49840 {}
C {lab_pin.sym} 3460 49840 0 0 {name=l39929 lab=VDD}
N 3440 49760 3460 49760 {}
C {lab_pin.sym} 3460 49760 0 0 {name=l39930 lab=VSS}
C {bitcell_6t.sym} 3600 49800 0 0 {name=Xr249c18}
N 3560 49840 3540 49840 {}
C {lab_pin.sym} 3540 49840 0 0 {name=l39931 lab=BL18}
N 3560 49800 3540 49800 {}
C {lab_pin.sym} 3540 49800 0 0 {name=l39932 lab=BLB18}
N 3560 49760 3540 49760 {}
C {lab_pin.sym} 3540 49760 0 0 {name=l39933 lab=WL249}
N 3640 49840 3660 49840 {}
C {lab_pin.sym} 3660 49840 0 0 {name=l39934 lab=VDD}
N 3640 49760 3660 49760 {}
C {lab_pin.sym} 3660 49760 0 0 {name=l39935 lab=VSS}
C {bitcell_6t.sym} 3800 49800 0 0 {name=Xr249c19}
N 3760 49840 3740 49840 {}
C {lab_pin.sym} 3740 49840 0 0 {name=l39936 lab=BL19}
N 3760 49800 3740 49800 {}
C {lab_pin.sym} 3740 49800 0 0 {name=l39937 lab=BLB19}
N 3760 49760 3740 49760 {}
C {lab_pin.sym} 3740 49760 0 0 {name=l39938 lab=WL249}
N 3840 49840 3860 49840 {}
C {lab_pin.sym} 3860 49840 0 0 {name=l39939 lab=VDD}
N 3840 49760 3860 49760 {}
C {lab_pin.sym} 3860 49760 0 0 {name=l39940 lab=VSS}
C {bitcell_6t.sym} 4000 49800 0 0 {name=Xr249c20}
N 3960 49840 3940 49840 {}
C {lab_pin.sym} 3940 49840 0 0 {name=l39941 lab=BL20}
N 3960 49800 3940 49800 {}
C {lab_pin.sym} 3940 49800 0 0 {name=l39942 lab=BLB20}
N 3960 49760 3940 49760 {}
C {lab_pin.sym} 3940 49760 0 0 {name=l39943 lab=WL249}
N 4040 49840 4060 49840 {}
C {lab_pin.sym} 4060 49840 0 0 {name=l39944 lab=VDD}
N 4040 49760 4060 49760 {}
C {lab_pin.sym} 4060 49760 0 0 {name=l39945 lab=VSS}
C {bitcell_6t.sym} 4200 49800 0 0 {name=Xr249c21}
N 4160 49840 4140 49840 {}
C {lab_pin.sym} 4140 49840 0 0 {name=l39946 lab=BL21}
N 4160 49800 4140 49800 {}
C {lab_pin.sym} 4140 49800 0 0 {name=l39947 lab=BLB21}
N 4160 49760 4140 49760 {}
C {lab_pin.sym} 4140 49760 0 0 {name=l39948 lab=WL249}
N 4240 49840 4260 49840 {}
C {lab_pin.sym} 4260 49840 0 0 {name=l39949 lab=VDD}
N 4240 49760 4260 49760 {}
C {lab_pin.sym} 4260 49760 0 0 {name=l39950 lab=VSS}
C {bitcell_6t.sym} 4400 49800 0 0 {name=Xr249c22}
N 4360 49840 4340 49840 {}
C {lab_pin.sym} 4340 49840 0 0 {name=l39951 lab=BL22}
N 4360 49800 4340 49800 {}
C {lab_pin.sym} 4340 49800 0 0 {name=l39952 lab=BLB22}
N 4360 49760 4340 49760 {}
C {lab_pin.sym} 4340 49760 0 0 {name=l39953 lab=WL249}
N 4440 49840 4460 49840 {}
C {lab_pin.sym} 4460 49840 0 0 {name=l39954 lab=VDD}
N 4440 49760 4460 49760 {}
C {lab_pin.sym} 4460 49760 0 0 {name=l39955 lab=VSS}
C {bitcell_6t.sym} 4600 49800 0 0 {name=Xr249c23}
N 4560 49840 4540 49840 {}
C {lab_pin.sym} 4540 49840 0 0 {name=l39956 lab=BL23}
N 4560 49800 4540 49800 {}
C {lab_pin.sym} 4540 49800 0 0 {name=l39957 lab=BLB23}
N 4560 49760 4540 49760 {}
C {lab_pin.sym} 4540 49760 0 0 {name=l39958 lab=WL249}
N 4640 49840 4660 49840 {}
C {lab_pin.sym} 4660 49840 0 0 {name=l39959 lab=VDD}
N 4640 49760 4660 49760 {}
C {lab_pin.sym} 4660 49760 0 0 {name=l39960 lab=VSS}
C {bitcell_6t.sym} 4800 49800 0 0 {name=Xr249c24}
N 4760 49840 4740 49840 {}
C {lab_pin.sym} 4740 49840 0 0 {name=l39961 lab=BL24}
N 4760 49800 4740 49800 {}
C {lab_pin.sym} 4740 49800 0 0 {name=l39962 lab=BLB24}
N 4760 49760 4740 49760 {}
C {lab_pin.sym} 4740 49760 0 0 {name=l39963 lab=WL249}
N 4840 49840 4860 49840 {}
C {lab_pin.sym} 4860 49840 0 0 {name=l39964 lab=VDD}
N 4840 49760 4860 49760 {}
C {lab_pin.sym} 4860 49760 0 0 {name=l39965 lab=VSS}
C {bitcell_6t.sym} 5000 49800 0 0 {name=Xr249c25}
N 4960 49840 4940 49840 {}
C {lab_pin.sym} 4940 49840 0 0 {name=l39966 lab=BL25}
N 4960 49800 4940 49800 {}
C {lab_pin.sym} 4940 49800 0 0 {name=l39967 lab=BLB25}
N 4960 49760 4940 49760 {}
C {lab_pin.sym} 4940 49760 0 0 {name=l39968 lab=WL249}
N 5040 49840 5060 49840 {}
C {lab_pin.sym} 5060 49840 0 0 {name=l39969 lab=VDD}
N 5040 49760 5060 49760 {}
C {lab_pin.sym} 5060 49760 0 0 {name=l39970 lab=VSS}
C {bitcell_6t.sym} 5200 49800 0 0 {name=Xr249c26}
N 5160 49840 5140 49840 {}
C {lab_pin.sym} 5140 49840 0 0 {name=l39971 lab=BL26}
N 5160 49800 5140 49800 {}
C {lab_pin.sym} 5140 49800 0 0 {name=l39972 lab=BLB26}
N 5160 49760 5140 49760 {}
C {lab_pin.sym} 5140 49760 0 0 {name=l39973 lab=WL249}
N 5240 49840 5260 49840 {}
C {lab_pin.sym} 5260 49840 0 0 {name=l39974 lab=VDD}
N 5240 49760 5260 49760 {}
C {lab_pin.sym} 5260 49760 0 0 {name=l39975 lab=VSS}
C {bitcell_6t.sym} 5400 49800 0 0 {name=Xr249c27}
N 5360 49840 5340 49840 {}
C {lab_pin.sym} 5340 49840 0 0 {name=l39976 lab=BL27}
N 5360 49800 5340 49800 {}
C {lab_pin.sym} 5340 49800 0 0 {name=l39977 lab=BLB27}
N 5360 49760 5340 49760 {}
C {lab_pin.sym} 5340 49760 0 0 {name=l39978 lab=WL249}
N 5440 49840 5460 49840 {}
C {lab_pin.sym} 5460 49840 0 0 {name=l39979 lab=VDD}
N 5440 49760 5460 49760 {}
C {lab_pin.sym} 5460 49760 0 0 {name=l39980 lab=VSS}
C {bitcell_6t.sym} 5600 49800 0 0 {name=Xr249c28}
N 5560 49840 5540 49840 {}
C {lab_pin.sym} 5540 49840 0 0 {name=l39981 lab=BL28}
N 5560 49800 5540 49800 {}
C {lab_pin.sym} 5540 49800 0 0 {name=l39982 lab=BLB28}
N 5560 49760 5540 49760 {}
C {lab_pin.sym} 5540 49760 0 0 {name=l39983 lab=WL249}
N 5640 49840 5660 49840 {}
C {lab_pin.sym} 5660 49840 0 0 {name=l39984 lab=VDD}
N 5640 49760 5660 49760 {}
C {lab_pin.sym} 5660 49760 0 0 {name=l39985 lab=VSS}
C {bitcell_6t.sym} 5800 49800 0 0 {name=Xr249c29}
N 5760 49840 5740 49840 {}
C {lab_pin.sym} 5740 49840 0 0 {name=l39986 lab=BL29}
N 5760 49800 5740 49800 {}
C {lab_pin.sym} 5740 49800 0 0 {name=l39987 lab=BLB29}
N 5760 49760 5740 49760 {}
C {lab_pin.sym} 5740 49760 0 0 {name=l39988 lab=WL249}
N 5840 49840 5860 49840 {}
C {lab_pin.sym} 5860 49840 0 0 {name=l39989 lab=VDD}
N 5840 49760 5860 49760 {}
C {lab_pin.sym} 5860 49760 0 0 {name=l39990 lab=VSS}
C {bitcell_6t.sym} 6000 49800 0 0 {name=Xr249c30}
N 5960 49840 5940 49840 {}
C {lab_pin.sym} 5940 49840 0 0 {name=l39991 lab=BL30}
N 5960 49800 5940 49800 {}
C {lab_pin.sym} 5940 49800 0 0 {name=l39992 lab=BLB30}
N 5960 49760 5940 49760 {}
C {lab_pin.sym} 5940 49760 0 0 {name=l39993 lab=WL249}
N 6040 49840 6060 49840 {}
C {lab_pin.sym} 6060 49840 0 0 {name=l39994 lab=VDD}
N 6040 49760 6060 49760 {}
C {lab_pin.sym} 6060 49760 0 0 {name=l39995 lab=VSS}
C {bitcell_6t.sym} 6200 49800 0 0 {name=Xr249c31}
N 6160 49840 6140 49840 {}
C {lab_pin.sym} 6140 49840 0 0 {name=l39996 lab=BL31}
N 6160 49800 6140 49800 {}
C {lab_pin.sym} 6140 49800 0 0 {name=l39997 lab=BLB31}
N 6160 49760 6140 49760 {}
C {lab_pin.sym} 6140 49760 0 0 {name=l39998 lab=WL249}
N 6240 49840 6260 49840 {}
C {lab_pin.sym} 6260 49840 0 0 {name=l39999 lab=VDD}
N 6240 49760 6260 49760 {}
C {lab_pin.sym} 6260 49760 0 0 {name=l40000 lab=VSS}
C {bitcell_6t.sym} 0 50000 0 0 {name=Xr250c0}
N -40 50040 -60 50040 {}
C {lab_pin.sym} -60 50040 0 0 {name=l40001 lab=BL0}
N -40 50000 -60 50000 {}
C {lab_pin.sym} -60 50000 0 0 {name=l40002 lab=BLB0}
N -40 49960 -60 49960 {}
C {lab_pin.sym} -60 49960 0 0 {name=l40003 lab=WL250}
N 40 50040 60 50040 {}
C {lab_pin.sym} 60 50040 0 0 {name=l40004 lab=VDD}
N 40 49960 60 49960 {}
C {lab_pin.sym} 60 49960 0 0 {name=l40005 lab=VSS}
C {bitcell_6t.sym} 200 50000 0 0 {name=Xr250c1}
N 160 50040 140 50040 {}
C {lab_pin.sym} 140 50040 0 0 {name=l40006 lab=BL1}
N 160 50000 140 50000 {}
C {lab_pin.sym} 140 50000 0 0 {name=l40007 lab=BLB1}
N 160 49960 140 49960 {}
C {lab_pin.sym} 140 49960 0 0 {name=l40008 lab=WL250}
N 240 50040 260 50040 {}
C {lab_pin.sym} 260 50040 0 0 {name=l40009 lab=VDD}
N 240 49960 260 49960 {}
C {lab_pin.sym} 260 49960 0 0 {name=l40010 lab=VSS}
C {bitcell_6t.sym} 400 50000 0 0 {name=Xr250c2}
N 360 50040 340 50040 {}
C {lab_pin.sym} 340 50040 0 0 {name=l40011 lab=BL2}
N 360 50000 340 50000 {}
C {lab_pin.sym} 340 50000 0 0 {name=l40012 lab=BLB2}
N 360 49960 340 49960 {}
C {lab_pin.sym} 340 49960 0 0 {name=l40013 lab=WL250}
N 440 50040 460 50040 {}
C {lab_pin.sym} 460 50040 0 0 {name=l40014 lab=VDD}
N 440 49960 460 49960 {}
C {lab_pin.sym} 460 49960 0 0 {name=l40015 lab=VSS}
C {bitcell_6t.sym} 600 50000 0 0 {name=Xr250c3}
N 560 50040 540 50040 {}
C {lab_pin.sym} 540 50040 0 0 {name=l40016 lab=BL3}
N 560 50000 540 50000 {}
C {lab_pin.sym} 540 50000 0 0 {name=l40017 lab=BLB3}
N 560 49960 540 49960 {}
C {lab_pin.sym} 540 49960 0 0 {name=l40018 lab=WL250}
N 640 50040 660 50040 {}
C {lab_pin.sym} 660 50040 0 0 {name=l40019 lab=VDD}
N 640 49960 660 49960 {}
C {lab_pin.sym} 660 49960 0 0 {name=l40020 lab=VSS}
C {bitcell_6t.sym} 800 50000 0 0 {name=Xr250c4}
N 760 50040 740 50040 {}
C {lab_pin.sym} 740 50040 0 0 {name=l40021 lab=BL4}
N 760 50000 740 50000 {}
C {lab_pin.sym} 740 50000 0 0 {name=l40022 lab=BLB4}
N 760 49960 740 49960 {}
C {lab_pin.sym} 740 49960 0 0 {name=l40023 lab=WL250}
N 840 50040 860 50040 {}
C {lab_pin.sym} 860 50040 0 0 {name=l40024 lab=VDD}
N 840 49960 860 49960 {}
C {lab_pin.sym} 860 49960 0 0 {name=l40025 lab=VSS}
C {bitcell_6t.sym} 1000 50000 0 0 {name=Xr250c5}
N 960 50040 940 50040 {}
C {lab_pin.sym} 940 50040 0 0 {name=l40026 lab=BL5}
N 960 50000 940 50000 {}
C {lab_pin.sym} 940 50000 0 0 {name=l40027 lab=BLB5}
N 960 49960 940 49960 {}
C {lab_pin.sym} 940 49960 0 0 {name=l40028 lab=WL250}
N 1040 50040 1060 50040 {}
C {lab_pin.sym} 1060 50040 0 0 {name=l40029 lab=VDD}
N 1040 49960 1060 49960 {}
C {lab_pin.sym} 1060 49960 0 0 {name=l40030 lab=VSS}
C {bitcell_6t.sym} 1200 50000 0 0 {name=Xr250c6}
N 1160 50040 1140 50040 {}
C {lab_pin.sym} 1140 50040 0 0 {name=l40031 lab=BL6}
N 1160 50000 1140 50000 {}
C {lab_pin.sym} 1140 50000 0 0 {name=l40032 lab=BLB6}
N 1160 49960 1140 49960 {}
C {lab_pin.sym} 1140 49960 0 0 {name=l40033 lab=WL250}
N 1240 50040 1260 50040 {}
C {lab_pin.sym} 1260 50040 0 0 {name=l40034 lab=VDD}
N 1240 49960 1260 49960 {}
C {lab_pin.sym} 1260 49960 0 0 {name=l40035 lab=VSS}
C {bitcell_6t.sym} 1400 50000 0 0 {name=Xr250c7}
N 1360 50040 1340 50040 {}
C {lab_pin.sym} 1340 50040 0 0 {name=l40036 lab=BL7}
N 1360 50000 1340 50000 {}
C {lab_pin.sym} 1340 50000 0 0 {name=l40037 lab=BLB7}
N 1360 49960 1340 49960 {}
C {lab_pin.sym} 1340 49960 0 0 {name=l40038 lab=WL250}
N 1440 50040 1460 50040 {}
C {lab_pin.sym} 1460 50040 0 0 {name=l40039 lab=VDD}
N 1440 49960 1460 49960 {}
C {lab_pin.sym} 1460 49960 0 0 {name=l40040 lab=VSS}
C {bitcell_6t.sym} 1600 50000 0 0 {name=Xr250c8}
N 1560 50040 1540 50040 {}
C {lab_pin.sym} 1540 50040 0 0 {name=l40041 lab=BL8}
N 1560 50000 1540 50000 {}
C {lab_pin.sym} 1540 50000 0 0 {name=l40042 lab=BLB8}
N 1560 49960 1540 49960 {}
C {lab_pin.sym} 1540 49960 0 0 {name=l40043 lab=WL250}
N 1640 50040 1660 50040 {}
C {lab_pin.sym} 1660 50040 0 0 {name=l40044 lab=VDD}
N 1640 49960 1660 49960 {}
C {lab_pin.sym} 1660 49960 0 0 {name=l40045 lab=VSS}
C {bitcell_6t.sym} 1800 50000 0 0 {name=Xr250c9}
N 1760 50040 1740 50040 {}
C {lab_pin.sym} 1740 50040 0 0 {name=l40046 lab=BL9}
N 1760 50000 1740 50000 {}
C {lab_pin.sym} 1740 50000 0 0 {name=l40047 lab=BLB9}
N 1760 49960 1740 49960 {}
C {lab_pin.sym} 1740 49960 0 0 {name=l40048 lab=WL250}
N 1840 50040 1860 50040 {}
C {lab_pin.sym} 1860 50040 0 0 {name=l40049 lab=VDD}
N 1840 49960 1860 49960 {}
C {lab_pin.sym} 1860 49960 0 0 {name=l40050 lab=VSS}
C {bitcell_6t.sym} 2000 50000 0 0 {name=Xr250c10}
N 1960 50040 1940 50040 {}
C {lab_pin.sym} 1940 50040 0 0 {name=l40051 lab=BL10}
N 1960 50000 1940 50000 {}
C {lab_pin.sym} 1940 50000 0 0 {name=l40052 lab=BLB10}
N 1960 49960 1940 49960 {}
C {lab_pin.sym} 1940 49960 0 0 {name=l40053 lab=WL250}
N 2040 50040 2060 50040 {}
C {lab_pin.sym} 2060 50040 0 0 {name=l40054 lab=VDD}
N 2040 49960 2060 49960 {}
C {lab_pin.sym} 2060 49960 0 0 {name=l40055 lab=VSS}
C {bitcell_6t.sym} 2200 50000 0 0 {name=Xr250c11}
N 2160 50040 2140 50040 {}
C {lab_pin.sym} 2140 50040 0 0 {name=l40056 lab=BL11}
N 2160 50000 2140 50000 {}
C {lab_pin.sym} 2140 50000 0 0 {name=l40057 lab=BLB11}
N 2160 49960 2140 49960 {}
C {lab_pin.sym} 2140 49960 0 0 {name=l40058 lab=WL250}
N 2240 50040 2260 50040 {}
C {lab_pin.sym} 2260 50040 0 0 {name=l40059 lab=VDD}
N 2240 49960 2260 49960 {}
C {lab_pin.sym} 2260 49960 0 0 {name=l40060 lab=VSS}
C {bitcell_6t.sym} 2400 50000 0 0 {name=Xr250c12}
N 2360 50040 2340 50040 {}
C {lab_pin.sym} 2340 50040 0 0 {name=l40061 lab=BL12}
N 2360 50000 2340 50000 {}
C {lab_pin.sym} 2340 50000 0 0 {name=l40062 lab=BLB12}
N 2360 49960 2340 49960 {}
C {lab_pin.sym} 2340 49960 0 0 {name=l40063 lab=WL250}
N 2440 50040 2460 50040 {}
C {lab_pin.sym} 2460 50040 0 0 {name=l40064 lab=VDD}
N 2440 49960 2460 49960 {}
C {lab_pin.sym} 2460 49960 0 0 {name=l40065 lab=VSS}
C {bitcell_6t.sym} 2600 50000 0 0 {name=Xr250c13}
N 2560 50040 2540 50040 {}
C {lab_pin.sym} 2540 50040 0 0 {name=l40066 lab=BL13}
N 2560 50000 2540 50000 {}
C {lab_pin.sym} 2540 50000 0 0 {name=l40067 lab=BLB13}
N 2560 49960 2540 49960 {}
C {lab_pin.sym} 2540 49960 0 0 {name=l40068 lab=WL250}
N 2640 50040 2660 50040 {}
C {lab_pin.sym} 2660 50040 0 0 {name=l40069 lab=VDD}
N 2640 49960 2660 49960 {}
C {lab_pin.sym} 2660 49960 0 0 {name=l40070 lab=VSS}
C {bitcell_6t.sym} 2800 50000 0 0 {name=Xr250c14}
N 2760 50040 2740 50040 {}
C {lab_pin.sym} 2740 50040 0 0 {name=l40071 lab=BL14}
N 2760 50000 2740 50000 {}
C {lab_pin.sym} 2740 50000 0 0 {name=l40072 lab=BLB14}
N 2760 49960 2740 49960 {}
C {lab_pin.sym} 2740 49960 0 0 {name=l40073 lab=WL250}
N 2840 50040 2860 50040 {}
C {lab_pin.sym} 2860 50040 0 0 {name=l40074 lab=VDD}
N 2840 49960 2860 49960 {}
C {lab_pin.sym} 2860 49960 0 0 {name=l40075 lab=VSS}
C {bitcell_6t.sym} 3000 50000 0 0 {name=Xr250c15}
N 2960 50040 2940 50040 {}
C {lab_pin.sym} 2940 50040 0 0 {name=l40076 lab=BL15}
N 2960 50000 2940 50000 {}
C {lab_pin.sym} 2940 50000 0 0 {name=l40077 lab=BLB15}
N 2960 49960 2940 49960 {}
C {lab_pin.sym} 2940 49960 0 0 {name=l40078 lab=WL250}
N 3040 50040 3060 50040 {}
C {lab_pin.sym} 3060 50040 0 0 {name=l40079 lab=VDD}
N 3040 49960 3060 49960 {}
C {lab_pin.sym} 3060 49960 0 0 {name=l40080 lab=VSS}
C {bitcell_6t.sym} 3200 50000 0 0 {name=Xr250c16}
N 3160 50040 3140 50040 {}
C {lab_pin.sym} 3140 50040 0 0 {name=l40081 lab=BL16}
N 3160 50000 3140 50000 {}
C {lab_pin.sym} 3140 50000 0 0 {name=l40082 lab=BLB16}
N 3160 49960 3140 49960 {}
C {lab_pin.sym} 3140 49960 0 0 {name=l40083 lab=WL250}
N 3240 50040 3260 50040 {}
C {lab_pin.sym} 3260 50040 0 0 {name=l40084 lab=VDD}
N 3240 49960 3260 49960 {}
C {lab_pin.sym} 3260 49960 0 0 {name=l40085 lab=VSS}
C {bitcell_6t.sym} 3400 50000 0 0 {name=Xr250c17}
N 3360 50040 3340 50040 {}
C {lab_pin.sym} 3340 50040 0 0 {name=l40086 lab=BL17}
N 3360 50000 3340 50000 {}
C {lab_pin.sym} 3340 50000 0 0 {name=l40087 lab=BLB17}
N 3360 49960 3340 49960 {}
C {lab_pin.sym} 3340 49960 0 0 {name=l40088 lab=WL250}
N 3440 50040 3460 50040 {}
C {lab_pin.sym} 3460 50040 0 0 {name=l40089 lab=VDD}
N 3440 49960 3460 49960 {}
C {lab_pin.sym} 3460 49960 0 0 {name=l40090 lab=VSS}
C {bitcell_6t.sym} 3600 50000 0 0 {name=Xr250c18}
N 3560 50040 3540 50040 {}
C {lab_pin.sym} 3540 50040 0 0 {name=l40091 lab=BL18}
N 3560 50000 3540 50000 {}
C {lab_pin.sym} 3540 50000 0 0 {name=l40092 lab=BLB18}
N 3560 49960 3540 49960 {}
C {lab_pin.sym} 3540 49960 0 0 {name=l40093 lab=WL250}
N 3640 50040 3660 50040 {}
C {lab_pin.sym} 3660 50040 0 0 {name=l40094 lab=VDD}
N 3640 49960 3660 49960 {}
C {lab_pin.sym} 3660 49960 0 0 {name=l40095 lab=VSS}
C {bitcell_6t.sym} 3800 50000 0 0 {name=Xr250c19}
N 3760 50040 3740 50040 {}
C {lab_pin.sym} 3740 50040 0 0 {name=l40096 lab=BL19}
N 3760 50000 3740 50000 {}
C {lab_pin.sym} 3740 50000 0 0 {name=l40097 lab=BLB19}
N 3760 49960 3740 49960 {}
C {lab_pin.sym} 3740 49960 0 0 {name=l40098 lab=WL250}
N 3840 50040 3860 50040 {}
C {lab_pin.sym} 3860 50040 0 0 {name=l40099 lab=VDD}
N 3840 49960 3860 49960 {}
C {lab_pin.sym} 3860 49960 0 0 {name=l40100 lab=VSS}
C {bitcell_6t.sym} 4000 50000 0 0 {name=Xr250c20}
N 3960 50040 3940 50040 {}
C {lab_pin.sym} 3940 50040 0 0 {name=l40101 lab=BL20}
N 3960 50000 3940 50000 {}
C {lab_pin.sym} 3940 50000 0 0 {name=l40102 lab=BLB20}
N 3960 49960 3940 49960 {}
C {lab_pin.sym} 3940 49960 0 0 {name=l40103 lab=WL250}
N 4040 50040 4060 50040 {}
C {lab_pin.sym} 4060 50040 0 0 {name=l40104 lab=VDD}
N 4040 49960 4060 49960 {}
C {lab_pin.sym} 4060 49960 0 0 {name=l40105 lab=VSS}
C {bitcell_6t.sym} 4200 50000 0 0 {name=Xr250c21}
N 4160 50040 4140 50040 {}
C {lab_pin.sym} 4140 50040 0 0 {name=l40106 lab=BL21}
N 4160 50000 4140 50000 {}
C {lab_pin.sym} 4140 50000 0 0 {name=l40107 lab=BLB21}
N 4160 49960 4140 49960 {}
C {lab_pin.sym} 4140 49960 0 0 {name=l40108 lab=WL250}
N 4240 50040 4260 50040 {}
C {lab_pin.sym} 4260 50040 0 0 {name=l40109 lab=VDD}
N 4240 49960 4260 49960 {}
C {lab_pin.sym} 4260 49960 0 0 {name=l40110 lab=VSS}
C {bitcell_6t.sym} 4400 50000 0 0 {name=Xr250c22}
N 4360 50040 4340 50040 {}
C {lab_pin.sym} 4340 50040 0 0 {name=l40111 lab=BL22}
N 4360 50000 4340 50000 {}
C {lab_pin.sym} 4340 50000 0 0 {name=l40112 lab=BLB22}
N 4360 49960 4340 49960 {}
C {lab_pin.sym} 4340 49960 0 0 {name=l40113 lab=WL250}
N 4440 50040 4460 50040 {}
C {lab_pin.sym} 4460 50040 0 0 {name=l40114 lab=VDD}
N 4440 49960 4460 49960 {}
C {lab_pin.sym} 4460 49960 0 0 {name=l40115 lab=VSS}
C {bitcell_6t.sym} 4600 50000 0 0 {name=Xr250c23}
N 4560 50040 4540 50040 {}
C {lab_pin.sym} 4540 50040 0 0 {name=l40116 lab=BL23}
N 4560 50000 4540 50000 {}
C {lab_pin.sym} 4540 50000 0 0 {name=l40117 lab=BLB23}
N 4560 49960 4540 49960 {}
C {lab_pin.sym} 4540 49960 0 0 {name=l40118 lab=WL250}
N 4640 50040 4660 50040 {}
C {lab_pin.sym} 4660 50040 0 0 {name=l40119 lab=VDD}
N 4640 49960 4660 49960 {}
C {lab_pin.sym} 4660 49960 0 0 {name=l40120 lab=VSS}
C {bitcell_6t.sym} 4800 50000 0 0 {name=Xr250c24}
N 4760 50040 4740 50040 {}
C {lab_pin.sym} 4740 50040 0 0 {name=l40121 lab=BL24}
N 4760 50000 4740 50000 {}
C {lab_pin.sym} 4740 50000 0 0 {name=l40122 lab=BLB24}
N 4760 49960 4740 49960 {}
C {lab_pin.sym} 4740 49960 0 0 {name=l40123 lab=WL250}
N 4840 50040 4860 50040 {}
C {lab_pin.sym} 4860 50040 0 0 {name=l40124 lab=VDD}
N 4840 49960 4860 49960 {}
C {lab_pin.sym} 4860 49960 0 0 {name=l40125 lab=VSS}
C {bitcell_6t.sym} 5000 50000 0 0 {name=Xr250c25}
N 4960 50040 4940 50040 {}
C {lab_pin.sym} 4940 50040 0 0 {name=l40126 lab=BL25}
N 4960 50000 4940 50000 {}
C {lab_pin.sym} 4940 50000 0 0 {name=l40127 lab=BLB25}
N 4960 49960 4940 49960 {}
C {lab_pin.sym} 4940 49960 0 0 {name=l40128 lab=WL250}
N 5040 50040 5060 50040 {}
C {lab_pin.sym} 5060 50040 0 0 {name=l40129 lab=VDD}
N 5040 49960 5060 49960 {}
C {lab_pin.sym} 5060 49960 0 0 {name=l40130 lab=VSS}
C {bitcell_6t.sym} 5200 50000 0 0 {name=Xr250c26}
N 5160 50040 5140 50040 {}
C {lab_pin.sym} 5140 50040 0 0 {name=l40131 lab=BL26}
N 5160 50000 5140 50000 {}
C {lab_pin.sym} 5140 50000 0 0 {name=l40132 lab=BLB26}
N 5160 49960 5140 49960 {}
C {lab_pin.sym} 5140 49960 0 0 {name=l40133 lab=WL250}
N 5240 50040 5260 50040 {}
C {lab_pin.sym} 5260 50040 0 0 {name=l40134 lab=VDD}
N 5240 49960 5260 49960 {}
C {lab_pin.sym} 5260 49960 0 0 {name=l40135 lab=VSS}
C {bitcell_6t.sym} 5400 50000 0 0 {name=Xr250c27}
N 5360 50040 5340 50040 {}
C {lab_pin.sym} 5340 50040 0 0 {name=l40136 lab=BL27}
N 5360 50000 5340 50000 {}
C {lab_pin.sym} 5340 50000 0 0 {name=l40137 lab=BLB27}
N 5360 49960 5340 49960 {}
C {lab_pin.sym} 5340 49960 0 0 {name=l40138 lab=WL250}
N 5440 50040 5460 50040 {}
C {lab_pin.sym} 5460 50040 0 0 {name=l40139 lab=VDD}
N 5440 49960 5460 49960 {}
C {lab_pin.sym} 5460 49960 0 0 {name=l40140 lab=VSS}
C {bitcell_6t.sym} 5600 50000 0 0 {name=Xr250c28}
N 5560 50040 5540 50040 {}
C {lab_pin.sym} 5540 50040 0 0 {name=l40141 lab=BL28}
N 5560 50000 5540 50000 {}
C {lab_pin.sym} 5540 50000 0 0 {name=l40142 lab=BLB28}
N 5560 49960 5540 49960 {}
C {lab_pin.sym} 5540 49960 0 0 {name=l40143 lab=WL250}
N 5640 50040 5660 50040 {}
C {lab_pin.sym} 5660 50040 0 0 {name=l40144 lab=VDD}
N 5640 49960 5660 49960 {}
C {lab_pin.sym} 5660 49960 0 0 {name=l40145 lab=VSS}
C {bitcell_6t.sym} 5800 50000 0 0 {name=Xr250c29}
N 5760 50040 5740 50040 {}
C {lab_pin.sym} 5740 50040 0 0 {name=l40146 lab=BL29}
N 5760 50000 5740 50000 {}
C {lab_pin.sym} 5740 50000 0 0 {name=l40147 lab=BLB29}
N 5760 49960 5740 49960 {}
C {lab_pin.sym} 5740 49960 0 0 {name=l40148 lab=WL250}
N 5840 50040 5860 50040 {}
C {lab_pin.sym} 5860 50040 0 0 {name=l40149 lab=VDD}
N 5840 49960 5860 49960 {}
C {lab_pin.sym} 5860 49960 0 0 {name=l40150 lab=VSS}
C {bitcell_6t.sym} 6000 50000 0 0 {name=Xr250c30}
N 5960 50040 5940 50040 {}
C {lab_pin.sym} 5940 50040 0 0 {name=l40151 lab=BL30}
N 5960 50000 5940 50000 {}
C {lab_pin.sym} 5940 50000 0 0 {name=l40152 lab=BLB30}
N 5960 49960 5940 49960 {}
C {lab_pin.sym} 5940 49960 0 0 {name=l40153 lab=WL250}
N 6040 50040 6060 50040 {}
C {lab_pin.sym} 6060 50040 0 0 {name=l40154 lab=VDD}
N 6040 49960 6060 49960 {}
C {lab_pin.sym} 6060 49960 0 0 {name=l40155 lab=VSS}
C {bitcell_6t.sym} 6200 50000 0 0 {name=Xr250c31}
N 6160 50040 6140 50040 {}
C {lab_pin.sym} 6140 50040 0 0 {name=l40156 lab=BL31}
N 6160 50000 6140 50000 {}
C {lab_pin.sym} 6140 50000 0 0 {name=l40157 lab=BLB31}
N 6160 49960 6140 49960 {}
C {lab_pin.sym} 6140 49960 0 0 {name=l40158 lab=WL250}
N 6240 50040 6260 50040 {}
C {lab_pin.sym} 6260 50040 0 0 {name=l40159 lab=VDD}
N 6240 49960 6260 49960 {}
C {lab_pin.sym} 6260 49960 0 0 {name=l40160 lab=VSS}
C {bitcell_6t.sym} 0 50200 0 0 {name=Xr251c0}
N -40 50240 -60 50240 {}
C {lab_pin.sym} -60 50240 0 0 {name=l40161 lab=BL0}
N -40 50200 -60 50200 {}
C {lab_pin.sym} -60 50200 0 0 {name=l40162 lab=BLB0}
N -40 50160 -60 50160 {}
C {lab_pin.sym} -60 50160 0 0 {name=l40163 lab=WL251}
N 40 50240 60 50240 {}
C {lab_pin.sym} 60 50240 0 0 {name=l40164 lab=VDD}
N 40 50160 60 50160 {}
C {lab_pin.sym} 60 50160 0 0 {name=l40165 lab=VSS}
C {bitcell_6t.sym} 200 50200 0 0 {name=Xr251c1}
N 160 50240 140 50240 {}
C {lab_pin.sym} 140 50240 0 0 {name=l40166 lab=BL1}
N 160 50200 140 50200 {}
C {lab_pin.sym} 140 50200 0 0 {name=l40167 lab=BLB1}
N 160 50160 140 50160 {}
C {lab_pin.sym} 140 50160 0 0 {name=l40168 lab=WL251}
N 240 50240 260 50240 {}
C {lab_pin.sym} 260 50240 0 0 {name=l40169 lab=VDD}
N 240 50160 260 50160 {}
C {lab_pin.sym} 260 50160 0 0 {name=l40170 lab=VSS}
C {bitcell_6t.sym} 400 50200 0 0 {name=Xr251c2}
N 360 50240 340 50240 {}
C {lab_pin.sym} 340 50240 0 0 {name=l40171 lab=BL2}
N 360 50200 340 50200 {}
C {lab_pin.sym} 340 50200 0 0 {name=l40172 lab=BLB2}
N 360 50160 340 50160 {}
C {lab_pin.sym} 340 50160 0 0 {name=l40173 lab=WL251}
N 440 50240 460 50240 {}
C {lab_pin.sym} 460 50240 0 0 {name=l40174 lab=VDD}
N 440 50160 460 50160 {}
C {lab_pin.sym} 460 50160 0 0 {name=l40175 lab=VSS}
C {bitcell_6t.sym} 600 50200 0 0 {name=Xr251c3}
N 560 50240 540 50240 {}
C {lab_pin.sym} 540 50240 0 0 {name=l40176 lab=BL3}
N 560 50200 540 50200 {}
C {lab_pin.sym} 540 50200 0 0 {name=l40177 lab=BLB3}
N 560 50160 540 50160 {}
C {lab_pin.sym} 540 50160 0 0 {name=l40178 lab=WL251}
N 640 50240 660 50240 {}
C {lab_pin.sym} 660 50240 0 0 {name=l40179 lab=VDD}
N 640 50160 660 50160 {}
C {lab_pin.sym} 660 50160 0 0 {name=l40180 lab=VSS}
C {bitcell_6t.sym} 800 50200 0 0 {name=Xr251c4}
N 760 50240 740 50240 {}
C {lab_pin.sym} 740 50240 0 0 {name=l40181 lab=BL4}
N 760 50200 740 50200 {}
C {lab_pin.sym} 740 50200 0 0 {name=l40182 lab=BLB4}
N 760 50160 740 50160 {}
C {lab_pin.sym} 740 50160 0 0 {name=l40183 lab=WL251}
N 840 50240 860 50240 {}
C {lab_pin.sym} 860 50240 0 0 {name=l40184 lab=VDD}
N 840 50160 860 50160 {}
C {lab_pin.sym} 860 50160 0 0 {name=l40185 lab=VSS}
C {bitcell_6t.sym} 1000 50200 0 0 {name=Xr251c5}
N 960 50240 940 50240 {}
C {lab_pin.sym} 940 50240 0 0 {name=l40186 lab=BL5}
N 960 50200 940 50200 {}
C {lab_pin.sym} 940 50200 0 0 {name=l40187 lab=BLB5}
N 960 50160 940 50160 {}
C {lab_pin.sym} 940 50160 0 0 {name=l40188 lab=WL251}
N 1040 50240 1060 50240 {}
C {lab_pin.sym} 1060 50240 0 0 {name=l40189 lab=VDD}
N 1040 50160 1060 50160 {}
C {lab_pin.sym} 1060 50160 0 0 {name=l40190 lab=VSS}
C {bitcell_6t.sym} 1200 50200 0 0 {name=Xr251c6}
N 1160 50240 1140 50240 {}
C {lab_pin.sym} 1140 50240 0 0 {name=l40191 lab=BL6}
N 1160 50200 1140 50200 {}
C {lab_pin.sym} 1140 50200 0 0 {name=l40192 lab=BLB6}
N 1160 50160 1140 50160 {}
C {lab_pin.sym} 1140 50160 0 0 {name=l40193 lab=WL251}
N 1240 50240 1260 50240 {}
C {lab_pin.sym} 1260 50240 0 0 {name=l40194 lab=VDD}
N 1240 50160 1260 50160 {}
C {lab_pin.sym} 1260 50160 0 0 {name=l40195 lab=VSS}
C {bitcell_6t.sym} 1400 50200 0 0 {name=Xr251c7}
N 1360 50240 1340 50240 {}
C {lab_pin.sym} 1340 50240 0 0 {name=l40196 lab=BL7}
N 1360 50200 1340 50200 {}
C {lab_pin.sym} 1340 50200 0 0 {name=l40197 lab=BLB7}
N 1360 50160 1340 50160 {}
C {lab_pin.sym} 1340 50160 0 0 {name=l40198 lab=WL251}
N 1440 50240 1460 50240 {}
C {lab_pin.sym} 1460 50240 0 0 {name=l40199 lab=VDD}
N 1440 50160 1460 50160 {}
C {lab_pin.sym} 1460 50160 0 0 {name=l40200 lab=VSS}
C {bitcell_6t.sym} 1600 50200 0 0 {name=Xr251c8}
N 1560 50240 1540 50240 {}
C {lab_pin.sym} 1540 50240 0 0 {name=l40201 lab=BL8}
N 1560 50200 1540 50200 {}
C {lab_pin.sym} 1540 50200 0 0 {name=l40202 lab=BLB8}
N 1560 50160 1540 50160 {}
C {lab_pin.sym} 1540 50160 0 0 {name=l40203 lab=WL251}
N 1640 50240 1660 50240 {}
C {lab_pin.sym} 1660 50240 0 0 {name=l40204 lab=VDD}
N 1640 50160 1660 50160 {}
C {lab_pin.sym} 1660 50160 0 0 {name=l40205 lab=VSS}
C {bitcell_6t.sym} 1800 50200 0 0 {name=Xr251c9}
N 1760 50240 1740 50240 {}
C {lab_pin.sym} 1740 50240 0 0 {name=l40206 lab=BL9}
N 1760 50200 1740 50200 {}
C {lab_pin.sym} 1740 50200 0 0 {name=l40207 lab=BLB9}
N 1760 50160 1740 50160 {}
C {lab_pin.sym} 1740 50160 0 0 {name=l40208 lab=WL251}
N 1840 50240 1860 50240 {}
C {lab_pin.sym} 1860 50240 0 0 {name=l40209 lab=VDD}
N 1840 50160 1860 50160 {}
C {lab_pin.sym} 1860 50160 0 0 {name=l40210 lab=VSS}
C {bitcell_6t.sym} 2000 50200 0 0 {name=Xr251c10}
N 1960 50240 1940 50240 {}
C {lab_pin.sym} 1940 50240 0 0 {name=l40211 lab=BL10}
N 1960 50200 1940 50200 {}
C {lab_pin.sym} 1940 50200 0 0 {name=l40212 lab=BLB10}
N 1960 50160 1940 50160 {}
C {lab_pin.sym} 1940 50160 0 0 {name=l40213 lab=WL251}
N 2040 50240 2060 50240 {}
C {lab_pin.sym} 2060 50240 0 0 {name=l40214 lab=VDD}
N 2040 50160 2060 50160 {}
C {lab_pin.sym} 2060 50160 0 0 {name=l40215 lab=VSS}
C {bitcell_6t.sym} 2200 50200 0 0 {name=Xr251c11}
N 2160 50240 2140 50240 {}
C {lab_pin.sym} 2140 50240 0 0 {name=l40216 lab=BL11}
N 2160 50200 2140 50200 {}
C {lab_pin.sym} 2140 50200 0 0 {name=l40217 lab=BLB11}
N 2160 50160 2140 50160 {}
C {lab_pin.sym} 2140 50160 0 0 {name=l40218 lab=WL251}
N 2240 50240 2260 50240 {}
C {lab_pin.sym} 2260 50240 0 0 {name=l40219 lab=VDD}
N 2240 50160 2260 50160 {}
C {lab_pin.sym} 2260 50160 0 0 {name=l40220 lab=VSS}
C {bitcell_6t.sym} 2400 50200 0 0 {name=Xr251c12}
N 2360 50240 2340 50240 {}
C {lab_pin.sym} 2340 50240 0 0 {name=l40221 lab=BL12}
N 2360 50200 2340 50200 {}
C {lab_pin.sym} 2340 50200 0 0 {name=l40222 lab=BLB12}
N 2360 50160 2340 50160 {}
C {lab_pin.sym} 2340 50160 0 0 {name=l40223 lab=WL251}
N 2440 50240 2460 50240 {}
C {lab_pin.sym} 2460 50240 0 0 {name=l40224 lab=VDD}
N 2440 50160 2460 50160 {}
C {lab_pin.sym} 2460 50160 0 0 {name=l40225 lab=VSS}
C {bitcell_6t.sym} 2600 50200 0 0 {name=Xr251c13}
N 2560 50240 2540 50240 {}
C {lab_pin.sym} 2540 50240 0 0 {name=l40226 lab=BL13}
N 2560 50200 2540 50200 {}
C {lab_pin.sym} 2540 50200 0 0 {name=l40227 lab=BLB13}
N 2560 50160 2540 50160 {}
C {lab_pin.sym} 2540 50160 0 0 {name=l40228 lab=WL251}
N 2640 50240 2660 50240 {}
C {lab_pin.sym} 2660 50240 0 0 {name=l40229 lab=VDD}
N 2640 50160 2660 50160 {}
C {lab_pin.sym} 2660 50160 0 0 {name=l40230 lab=VSS}
C {bitcell_6t.sym} 2800 50200 0 0 {name=Xr251c14}
N 2760 50240 2740 50240 {}
C {lab_pin.sym} 2740 50240 0 0 {name=l40231 lab=BL14}
N 2760 50200 2740 50200 {}
C {lab_pin.sym} 2740 50200 0 0 {name=l40232 lab=BLB14}
N 2760 50160 2740 50160 {}
C {lab_pin.sym} 2740 50160 0 0 {name=l40233 lab=WL251}
N 2840 50240 2860 50240 {}
C {lab_pin.sym} 2860 50240 0 0 {name=l40234 lab=VDD}
N 2840 50160 2860 50160 {}
C {lab_pin.sym} 2860 50160 0 0 {name=l40235 lab=VSS}
C {bitcell_6t.sym} 3000 50200 0 0 {name=Xr251c15}
N 2960 50240 2940 50240 {}
C {lab_pin.sym} 2940 50240 0 0 {name=l40236 lab=BL15}
N 2960 50200 2940 50200 {}
C {lab_pin.sym} 2940 50200 0 0 {name=l40237 lab=BLB15}
N 2960 50160 2940 50160 {}
C {lab_pin.sym} 2940 50160 0 0 {name=l40238 lab=WL251}
N 3040 50240 3060 50240 {}
C {lab_pin.sym} 3060 50240 0 0 {name=l40239 lab=VDD}
N 3040 50160 3060 50160 {}
C {lab_pin.sym} 3060 50160 0 0 {name=l40240 lab=VSS}
C {bitcell_6t.sym} 3200 50200 0 0 {name=Xr251c16}
N 3160 50240 3140 50240 {}
C {lab_pin.sym} 3140 50240 0 0 {name=l40241 lab=BL16}
N 3160 50200 3140 50200 {}
C {lab_pin.sym} 3140 50200 0 0 {name=l40242 lab=BLB16}
N 3160 50160 3140 50160 {}
C {lab_pin.sym} 3140 50160 0 0 {name=l40243 lab=WL251}
N 3240 50240 3260 50240 {}
C {lab_pin.sym} 3260 50240 0 0 {name=l40244 lab=VDD}
N 3240 50160 3260 50160 {}
C {lab_pin.sym} 3260 50160 0 0 {name=l40245 lab=VSS}
C {bitcell_6t.sym} 3400 50200 0 0 {name=Xr251c17}
N 3360 50240 3340 50240 {}
C {lab_pin.sym} 3340 50240 0 0 {name=l40246 lab=BL17}
N 3360 50200 3340 50200 {}
C {lab_pin.sym} 3340 50200 0 0 {name=l40247 lab=BLB17}
N 3360 50160 3340 50160 {}
C {lab_pin.sym} 3340 50160 0 0 {name=l40248 lab=WL251}
N 3440 50240 3460 50240 {}
C {lab_pin.sym} 3460 50240 0 0 {name=l40249 lab=VDD}
N 3440 50160 3460 50160 {}
C {lab_pin.sym} 3460 50160 0 0 {name=l40250 lab=VSS}
C {bitcell_6t.sym} 3600 50200 0 0 {name=Xr251c18}
N 3560 50240 3540 50240 {}
C {lab_pin.sym} 3540 50240 0 0 {name=l40251 lab=BL18}
N 3560 50200 3540 50200 {}
C {lab_pin.sym} 3540 50200 0 0 {name=l40252 lab=BLB18}
N 3560 50160 3540 50160 {}
C {lab_pin.sym} 3540 50160 0 0 {name=l40253 lab=WL251}
N 3640 50240 3660 50240 {}
C {lab_pin.sym} 3660 50240 0 0 {name=l40254 lab=VDD}
N 3640 50160 3660 50160 {}
C {lab_pin.sym} 3660 50160 0 0 {name=l40255 lab=VSS}
C {bitcell_6t.sym} 3800 50200 0 0 {name=Xr251c19}
N 3760 50240 3740 50240 {}
C {lab_pin.sym} 3740 50240 0 0 {name=l40256 lab=BL19}
N 3760 50200 3740 50200 {}
C {lab_pin.sym} 3740 50200 0 0 {name=l40257 lab=BLB19}
N 3760 50160 3740 50160 {}
C {lab_pin.sym} 3740 50160 0 0 {name=l40258 lab=WL251}
N 3840 50240 3860 50240 {}
C {lab_pin.sym} 3860 50240 0 0 {name=l40259 lab=VDD}
N 3840 50160 3860 50160 {}
C {lab_pin.sym} 3860 50160 0 0 {name=l40260 lab=VSS}
C {bitcell_6t.sym} 4000 50200 0 0 {name=Xr251c20}
N 3960 50240 3940 50240 {}
C {lab_pin.sym} 3940 50240 0 0 {name=l40261 lab=BL20}
N 3960 50200 3940 50200 {}
C {lab_pin.sym} 3940 50200 0 0 {name=l40262 lab=BLB20}
N 3960 50160 3940 50160 {}
C {lab_pin.sym} 3940 50160 0 0 {name=l40263 lab=WL251}
N 4040 50240 4060 50240 {}
C {lab_pin.sym} 4060 50240 0 0 {name=l40264 lab=VDD}
N 4040 50160 4060 50160 {}
C {lab_pin.sym} 4060 50160 0 0 {name=l40265 lab=VSS}
C {bitcell_6t.sym} 4200 50200 0 0 {name=Xr251c21}
N 4160 50240 4140 50240 {}
C {lab_pin.sym} 4140 50240 0 0 {name=l40266 lab=BL21}
N 4160 50200 4140 50200 {}
C {lab_pin.sym} 4140 50200 0 0 {name=l40267 lab=BLB21}
N 4160 50160 4140 50160 {}
C {lab_pin.sym} 4140 50160 0 0 {name=l40268 lab=WL251}
N 4240 50240 4260 50240 {}
C {lab_pin.sym} 4260 50240 0 0 {name=l40269 lab=VDD}
N 4240 50160 4260 50160 {}
C {lab_pin.sym} 4260 50160 0 0 {name=l40270 lab=VSS}
C {bitcell_6t.sym} 4400 50200 0 0 {name=Xr251c22}
N 4360 50240 4340 50240 {}
C {lab_pin.sym} 4340 50240 0 0 {name=l40271 lab=BL22}
N 4360 50200 4340 50200 {}
C {lab_pin.sym} 4340 50200 0 0 {name=l40272 lab=BLB22}
N 4360 50160 4340 50160 {}
C {lab_pin.sym} 4340 50160 0 0 {name=l40273 lab=WL251}
N 4440 50240 4460 50240 {}
C {lab_pin.sym} 4460 50240 0 0 {name=l40274 lab=VDD}
N 4440 50160 4460 50160 {}
C {lab_pin.sym} 4460 50160 0 0 {name=l40275 lab=VSS}
C {bitcell_6t.sym} 4600 50200 0 0 {name=Xr251c23}
N 4560 50240 4540 50240 {}
C {lab_pin.sym} 4540 50240 0 0 {name=l40276 lab=BL23}
N 4560 50200 4540 50200 {}
C {lab_pin.sym} 4540 50200 0 0 {name=l40277 lab=BLB23}
N 4560 50160 4540 50160 {}
C {lab_pin.sym} 4540 50160 0 0 {name=l40278 lab=WL251}
N 4640 50240 4660 50240 {}
C {lab_pin.sym} 4660 50240 0 0 {name=l40279 lab=VDD}
N 4640 50160 4660 50160 {}
C {lab_pin.sym} 4660 50160 0 0 {name=l40280 lab=VSS}
C {bitcell_6t.sym} 4800 50200 0 0 {name=Xr251c24}
N 4760 50240 4740 50240 {}
C {lab_pin.sym} 4740 50240 0 0 {name=l40281 lab=BL24}
N 4760 50200 4740 50200 {}
C {lab_pin.sym} 4740 50200 0 0 {name=l40282 lab=BLB24}
N 4760 50160 4740 50160 {}
C {lab_pin.sym} 4740 50160 0 0 {name=l40283 lab=WL251}
N 4840 50240 4860 50240 {}
C {lab_pin.sym} 4860 50240 0 0 {name=l40284 lab=VDD}
N 4840 50160 4860 50160 {}
C {lab_pin.sym} 4860 50160 0 0 {name=l40285 lab=VSS}
C {bitcell_6t.sym} 5000 50200 0 0 {name=Xr251c25}
N 4960 50240 4940 50240 {}
C {lab_pin.sym} 4940 50240 0 0 {name=l40286 lab=BL25}
N 4960 50200 4940 50200 {}
C {lab_pin.sym} 4940 50200 0 0 {name=l40287 lab=BLB25}
N 4960 50160 4940 50160 {}
C {lab_pin.sym} 4940 50160 0 0 {name=l40288 lab=WL251}
N 5040 50240 5060 50240 {}
C {lab_pin.sym} 5060 50240 0 0 {name=l40289 lab=VDD}
N 5040 50160 5060 50160 {}
C {lab_pin.sym} 5060 50160 0 0 {name=l40290 lab=VSS}
C {bitcell_6t.sym} 5200 50200 0 0 {name=Xr251c26}
N 5160 50240 5140 50240 {}
C {lab_pin.sym} 5140 50240 0 0 {name=l40291 lab=BL26}
N 5160 50200 5140 50200 {}
C {lab_pin.sym} 5140 50200 0 0 {name=l40292 lab=BLB26}
N 5160 50160 5140 50160 {}
C {lab_pin.sym} 5140 50160 0 0 {name=l40293 lab=WL251}
N 5240 50240 5260 50240 {}
C {lab_pin.sym} 5260 50240 0 0 {name=l40294 lab=VDD}
N 5240 50160 5260 50160 {}
C {lab_pin.sym} 5260 50160 0 0 {name=l40295 lab=VSS}
C {bitcell_6t.sym} 5400 50200 0 0 {name=Xr251c27}
N 5360 50240 5340 50240 {}
C {lab_pin.sym} 5340 50240 0 0 {name=l40296 lab=BL27}
N 5360 50200 5340 50200 {}
C {lab_pin.sym} 5340 50200 0 0 {name=l40297 lab=BLB27}
N 5360 50160 5340 50160 {}
C {lab_pin.sym} 5340 50160 0 0 {name=l40298 lab=WL251}
N 5440 50240 5460 50240 {}
C {lab_pin.sym} 5460 50240 0 0 {name=l40299 lab=VDD}
N 5440 50160 5460 50160 {}
C {lab_pin.sym} 5460 50160 0 0 {name=l40300 lab=VSS}
C {bitcell_6t.sym} 5600 50200 0 0 {name=Xr251c28}
N 5560 50240 5540 50240 {}
C {lab_pin.sym} 5540 50240 0 0 {name=l40301 lab=BL28}
N 5560 50200 5540 50200 {}
C {lab_pin.sym} 5540 50200 0 0 {name=l40302 lab=BLB28}
N 5560 50160 5540 50160 {}
C {lab_pin.sym} 5540 50160 0 0 {name=l40303 lab=WL251}
N 5640 50240 5660 50240 {}
C {lab_pin.sym} 5660 50240 0 0 {name=l40304 lab=VDD}
N 5640 50160 5660 50160 {}
C {lab_pin.sym} 5660 50160 0 0 {name=l40305 lab=VSS}
C {bitcell_6t.sym} 5800 50200 0 0 {name=Xr251c29}
N 5760 50240 5740 50240 {}
C {lab_pin.sym} 5740 50240 0 0 {name=l40306 lab=BL29}
N 5760 50200 5740 50200 {}
C {lab_pin.sym} 5740 50200 0 0 {name=l40307 lab=BLB29}
N 5760 50160 5740 50160 {}
C {lab_pin.sym} 5740 50160 0 0 {name=l40308 lab=WL251}
N 5840 50240 5860 50240 {}
C {lab_pin.sym} 5860 50240 0 0 {name=l40309 lab=VDD}
N 5840 50160 5860 50160 {}
C {lab_pin.sym} 5860 50160 0 0 {name=l40310 lab=VSS}
C {bitcell_6t.sym} 6000 50200 0 0 {name=Xr251c30}
N 5960 50240 5940 50240 {}
C {lab_pin.sym} 5940 50240 0 0 {name=l40311 lab=BL30}
N 5960 50200 5940 50200 {}
C {lab_pin.sym} 5940 50200 0 0 {name=l40312 lab=BLB30}
N 5960 50160 5940 50160 {}
C {lab_pin.sym} 5940 50160 0 0 {name=l40313 lab=WL251}
N 6040 50240 6060 50240 {}
C {lab_pin.sym} 6060 50240 0 0 {name=l40314 lab=VDD}
N 6040 50160 6060 50160 {}
C {lab_pin.sym} 6060 50160 0 0 {name=l40315 lab=VSS}
C {bitcell_6t.sym} 6200 50200 0 0 {name=Xr251c31}
N 6160 50240 6140 50240 {}
C {lab_pin.sym} 6140 50240 0 0 {name=l40316 lab=BL31}
N 6160 50200 6140 50200 {}
C {lab_pin.sym} 6140 50200 0 0 {name=l40317 lab=BLB31}
N 6160 50160 6140 50160 {}
C {lab_pin.sym} 6140 50160 0 0 {name=l40318 lab=WL251}
N 6240 50240 6260 50240 {}
C {lab_pin.sym} 6260 50240 0 0 {name=l40319 lab=VDD}
N 6240 50160 6260 50160 {}
C {lab_pin.sym} 6260 50160 0 0 {name=l40320 lab=VSS}
C {bitcell_6t.sym} 0 50400 0 0 {name=Xr252c0}
N -40 50440 -60 50440 {}
C {lab_pin.sym} -60 50440 0 0 {name=l40321 lab=BL0}
N -40 50400 -60 50400 {}
C {lab_pin.sym} -60 50400 0 0 {name=l40322 lab=BLB0}
N -40 50360 -60 50360 {}
C {lab_pin.sym} -60 50360 0 0 {name=l40323 lab=WL252}
N 40 50440 60 50440 {}
C {lab_pin.sym} 60 50440 0 0 {name=l40324 lab=VDD}
N 40 50360 60 50360 {}
C {lab_pin.sym} 60 50360 0 0 {name=l40325 lab=VSS}
C {bitcell_6t.sym} 200 50400 0 0 {name=Xr252c1}
N 160 50440 140 50440 {}
C {lab_pin.sym} 140 50440 0 0 {name=l40326 lab=BL1}
N 160 50400 140 50400 {}
C {lab_pin.sym} 140 50400 0 0 {name=l40327 lab=BLB1}
N 160 50360 140 50360 {}
C {lab_pin.sym} 140 50360 0 0 {name=l40328 lab=WL252}
N 240 50440 260 50440 {}
C {lab_pin.sym} 260 50440 0 0 {name=l40329 lab=VDD}
N 240 50360 260 50360 {}
C {lab_pin.sym} 260 50360 0 0 {name=l40330 lab=VSS}
C {bitcell_6t.sym} 400 50400 0 0 {name=Xr252c2}
N 360 50440 340 50440 {}
C {lab_pin.sym} 340 50440 0 0 {name=l40331 lab=BL2}
N 360 50400 340 50400 {}
C {lab_pin.sym} 340 50400 0 0 {name=l40332 lab=BLB2}
N 360 50360 340 50360 {}
C {lab_pin.sym} 340 50360 0 0 {name=l40333 lab=WL252}
N 440 50440 460 50440 {}
C {lab_pin.sym} 460 50440 0 0 {name=l40334 lab=VDD}
N 440 50360 460 50360 {}
C {lab_pin.sym} 460 50360 0 0 {name=l40335 lab=VSS}
C {bitcell_6t.sym} 600 50400 0 0 {name=Xr252c3}
N 560 50440 540 50440 {}
C {lab_pin.sym} 540 50440 0 0 {name=l40336 lab=BL3}
N 560 50400 540 50400 {}
C {lab_pin.sym} 540 50400 0 0 {name=l40337 lab=BLB3}
N 560 50360 540 50360 {}
C {lab_pin.sym} 540 50360 0 0 {name=l40338 lab=WL252}
N 640 50440 660 50440 {}
C {lab_pin.sym} 660 50440 0 0 {name=l40339 lab=VDD}
N 640 50360 660 50360 {}
C {lab_pin.sym} 660 50360 0 0 {name=l40340 lab=VSS}
C {bitcell_6t.sym} 800 50400 0 0 {name=Xr252c4}
N 760 50440 740 50440 {}
C {lab_pin.sym} 740 50440 0 0 {name=l40341 lab=BL4}
N 760 50400 740 50400 {}
C {lab_pin.sym} 740 50400 0 0 {name=l40342 lab=BLB4}
N 760 50360 740 50360 {}
C {lab_pin.sym} 740 50360 0 0 {name=l40343 lab=WL252}
N 840 50440 860 50440 {}
C {lab_pin.sym} 860 50440 0 0 {name=l40344 lab=VDD}
N 840 50360 860 50360 {}
C {lab_pin.sym} 860 50360 0 0 {name=l40345 lab=VSS}
C {bitcell_6t.sym} 1000 50400 0 0 {name=Xr252c5}
N 960 50440 940 50440 {}
C {lab_pin.sym} 940 50440 0 0 {name=l40346 lab=BL5}
N 960 50400 940 50400 {}
C {lab_pin.sym} 940 50400 0 0 {name=l40347 lab=BLB5}
N 960 50360 940 50360 {}
C {lab_pin.sym} 940 50360 0 0 {name=l40348 lab=WL252}
N 1040 50440 1060 50440 {}
C {lab_pin.sym} 1060 50440 0 0 {name=l40349 lab=VDD}
N 1040 50360 1060 50360 {}
C {lab_pin.sym} 1060 50360 0 0 {name=l40350 lab=VSS}
C {bitcell_6t.sym} 1200 50400 0 0 {name=Xr252c6}
N 1160 50440 1140 50440 {}
C {lab_pin.sym} 1140 50440 0 0 {name=l40351 lab=BL6}
N 1160 50400 1140 50400 {}
C {lab_pin.sym} 1140 50400 0 0 {name=l40352 lab=BLB6}
N 1160 50360 1140 50360 {}
C {lab_pin.sym} 1140 50360 0 0 {name=l40353 lab=WL252}
N 1240 50440 1260 50440 {}
C {lab_pin.sym} 1260 50440 0 0 {name=l40354 lab=VDD}
N 1240 50360 1260 50360 {}
C {lab_pin.sym} 1260 50360 0 0 {name=l40355 lab=VSS}
C {bitcell_6t.sym} 1400 50400 0 0 {name=Xr252c7}
N 1360 50440 1340 50440 {}
C {lab_pin.sym} 1340 50440 0 0 {name=l40356 lab=BL7}
N 1360 50400 1340 50400 {}
C {lab_pin.sym} 1340 50400 0 0 {name=l40357 lab=BLB7}
N 1360 50360 1340 50360 {}
C {lab_pin.sym} 1340 50360 0 0 {name=l40358 lab=WL252}
N 1440 50440 1460 50440 {}
C {lab_pin.sym} 1460 50440 0 0 {name=l40359 lab=VDD}
N 1440 50360 1460 50360 {}
C {lab_pin.sym} 1460 50360 0 0 {name=l40360 lab=VSS}
C {bitcell_6t.sym} 1600 50400 0 0 {name=Xr252c8}
N 1560 50440 1540 50440 {}
C {lab_pin.sym} 1540 50440 0 0 {name=l40361 lab=BL8}
N 1560 50400 1540 50400 {}
C {lab_pin.sym} 1540 50400 0 0 {name=l40362 lab=BLB8}
N 1560 50360 1540 50360 {}
C {lab_pin.sym} 1540 50360 0 0 {name=l40363 lab=WL252}
N 1640 50440 1660 50440 {}
C {lab_pin.sym} 1660 50440 0 0 {name=l40364 lab=VDD}
N 1640 50360 1660 50360 {}
C {lab_pin.sym} 1660 50360 0 0 {name=l40365 lab=VSS}
C {bitcell_6t.sym} 1800 50400 0 0 {name=Xr252c9}
N 1760 50440 1740 50440 {}
C {lab_pin.sym} 1740 50440 0 0 {name=l40366 lab=BL9}
N 1760 50400 1740 50400 {}
C {lab_pin.sym} 1740 50400 0 0 {name=l40367 lab=BLB9}
N 1760 50360 1740 50360 {}
C {lab_pin.sym} 1740 50360 0 0 {name=l40368 lab=WL252}
N 1840 50440 1860 50440 {}
C {lab_pin.sym} 1860 50440 0 0 {name=l40369 lab=VDD}
N 1840 50360 1860 50360 {}
C {lab_pin.sym} 1860 50360 0 0 {name=l40370 lab=VSS}
C {bitcell_6t.sym} 2000 50400 0 0 {name=Xr252c10}
N 1960 50440 1940 50440 {}
C {lab_pin.sym} 1940 50440 0 0 {name=l40371 lab=BL10}
N 1960 50400 1940 50400 {}
C {lab_pin.sym} 1940 50400 0 0 {name=l40372 lab=BLB10}
N 1960 50360 1940 50360 {}
C {lab_pin.sym} 1940 50360 0 0 {name=l40373 lab=WL252}
N 2040 50440 2060 50440 {}
C {lab_pin.sym} 2060 50440 0 0 {name=l40374 lab=VDD}
N 2040 50360 2060 50360 {}
C {lab_pin.sym} 2060 50360 0 0 {name=l40375 lab=VSS}
C {bitcell_6t.sym} 2200 50400 0 0 {name=Xr252c11}
N 2160 50440 2140 50440 {}
C {lab_pin.sym} 2140 50440 0 0 {name=l40376 lab=BL11}
N 2160 50400 2140 50400 {}
C {lab_pin.sym} 2140 50400 0 0 {name=l40377 lab=BLB11}
N 2160 50360 2140 50360 {}
C {lab_pin.sym} 2140 50360 0 0 {name=l40378 lab=WL252}
N 2240 50440 2260 50440 {}
C {lab_pin.sym} 2260 50440 0 0 {name=l40379 lab=VDD}
N 2240 50360 2260 50360 {}
C {lab_pin.sym} 2260 50360 0 0 {name=l40380 lab=VSS}
C {bitcell_6t.sym} 2400 50400 0 0 {name=Xr252c12}
N 2360 50440 2340 50440 {}
C {lab_pin.sym} 2340 50440 0 0 {name=l40381 lab=BL12}
N 2360 50400 2340 50400 {}
C {lab_pin.sym} 2340 50400 0 0 {name=l40382 lab=BLB12}
N 2360 50360 2340 50360 {}
C {lab_pin.sym} 2340 50360 0 0 {name=l40383 lab=WL252}
N 2440 50440 2460 50440 {}
C {lab_pin.sym} 2460 50440 0 0 {name=l40384 lab=VDD}
N 2440 50360 2460 50360 {}
C {lab_pin.sym} 2460 50360 0 0 {name=l40385 lab=VSS}
C {bitcell_6t.sym} 2600 50400 0 0 {name=Xr252c13}
N 2560 50440 2540 50440 {}
C {lab_pin.sym} 2540 50440 0 0 {name=l40386 lab=BL13}
N 2560 50400 2540 50400 {}
C {lab_pin.sym} 2540 50400 0 0 {name=l40387 lab=BLB13}
N 2560 50360 2540 50360 {}
C {lab_pin.sym} 2540 50360 0 0 {name=l40388 lab=WL252}
N 2640 50440 2660 50440 {}
C {lab_pin.sym} 2660 50440 0 0 {name=l40389 lab=VDD}
N 2640 50360 2660 50360 {}
C {lab_pin.sym} 2660 50360 0 0 {name=l40390 lab=VSS}
C {bitcell_6t.sym} 2800 50400 0 0 {name=Xr252c14}
N 2760 50440 2740 50440 {}
C {lab_pin.sym} 2740 50440 0 0 {name=l40391 lab=BL14}
N 2760 50400 2740 50400 {}
C {lab_pin.sym} 2740 50400 0 0 {name=l40392 lab=BLB14}
N 2760 50360 2740 50360 {}
C {lab_pin.sym} 2740 50360 0 0 {name=l40393 lab=WL252}
N 2840 50440 2860 50440 {}
C {lab_pin.sym} 2860 50440 0 0 {name=l40394 lab=VDD}
N 2840 50360 2860 50360 {}
C {lab_pin.sym} 2860 50360 0 0 {name=l40395 lab=VSS}
C {bitcell_6t.sym} 3000 50400 0 0 {name=Xr252c15}
N 2960 50440 2940 50440 {}
C {lab_pin.sym} 2940 50440 0 0 {name=l40396 lab=BL15}
N 2960 50400 2940 50400 {}
C {lab_pin.sym} 2940 50400 0 0 {name=l40397 lab=BLB15}
N 2960 50360 2940 50360 {}
C {lab_pin.sym} 2940 50360 0 0 {name=l40398 lab=WL252}
N 3040 50440 3060 50440 {}
C {lab_pin.sym} 3060 50440 0 0 {name=l40399 lab=VDD}
N 3040 50360 3060 50360 {}
C {lab_pin.sym} 3060 50360 0 0 {name=l40400 lab=VSS}
C {bitcell_6t.sym} 3200 50400 0 0 {name=Xr252c16}
N 3160 50440 3140 50440 {}
C {lab_pin.sym} 3140 50440 0 0 {name=l40401 lab=BL16}
N 3160 50400 3140 50400 {}
C {lab_pin.sym} 3140 50400 0 0 {name=l40402 lab=BLB16}
N 3160 50360 3140 50360 {}
C {lab_pin.sym} 3140 50360 0 0 {name=l40403 lab=WL252}
N 3240 50440 3260 50440 {}
C {lab_pin.sym} 3260 50440 0 0 {name=l40404 lab=VDD}
N 3240 50360 3260 50360 {}
C {lab_pin.sym} 3260 50360 0 0 {name=l40405 lab=VSS}
C {bitcell_6t.sym} 3400 50400 0 0 {name=Xr252c17}
N 3360 50440 3340 50440 {}
C {lab_pin.sym} 3340 50440 0 0 {name=l40406 lab=BL17}
N 3360 50400 3340 50400 {}
C {lab_pin.sym} 3340 50400 0 0 {name=l40407 lab=BLB17}
N 3360 50360 3340 50360 {}
C {lab_pin.sym} 3340 50360 0 0 {name=l40408 lab=WL252}
N 3440 50440 3460 50440 {}
C {lab_pin.sym} 3460 50440 0 0 {name=l40409 lab=VDD}
N 3440 50360 3460 50360 {}
C {lab_pin.sym} 3460 50360 0 0 {name=l40410 lab=VSS}
C {bitcell_6t.sym} 3600 50400 0 0 {name=Xr252c18}
N 3560 50440 3540 50440 {}
C {lab_pin.sym} 3540 50440 0 0 {name=l40411 lab=BL18}
N 3560 50400 3540 50400 {}
C {lab_pin.sym} 3540 50400 0 0 {name=l40412 lab=BLB18}
N 3560 50360 3540 50360 {}
