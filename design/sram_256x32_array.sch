N 2240 11640 2260 11640 {}
C {lab_pin.sym} 2260 11640 0 0 {name=l9339 lab=VDD}
N 2240 11560 2260 11560 {}
C {lab_pin.sym} 2260 11560 0 0 {name=l9340 lab=VSS}
C {bitcell_6t.sym} 2400 11600 0 0 {name=Xr58c12}
N 2360 11640 2340 11640 {}
C {lab_pin.sym} 2340 11640 0 0 {name=l9341 lab=BL12}
N 2360 11600 2340 11600 {}
C {lab_pin.sym} 2340 11600 0 0 {name=l9342 lab=BLB12}
N 2360 11560 2340 11560 {}
C {lab_pin.sym} 2340 11560 0 0 {name=l9343 lab=WL58}
N 2440 11640 2460 11640 {}
C {lab_pin.sym} 2460 11640 0 0 {name=l9344 lab=VDD}
N 2440 11560 2460 11560 {}
C {lab_pin.sym} 2460 11560 0 0 {name=l9345 lab=VSS}
C {bitcell_6t.sym} 2600 11600 0 0 {name=Xr58c13}
N 2560 11640 2540 11640 {}
C {lab_pin.sym} 2540 11640 0 0 {name=l9346 lab=BL13}
N 2560 11600 2540 11600 {}
C {lab_pin.sym} 2540 11600 0 0 {name=l9347 lab=BLB13}
N 2560 11560 2540 11560 {}
C {lab_pin.sym} 2540 11560 0 0 {name=l9348 lab=WL58}
N 2640 11640 2660 11640 {}
C {lab_pin.sym} 2660 11640 0 0 {name=l9349 lab=VDD}
N 2640 11560 2660 11560 {}
C {lab_pin.sym} 2660 11560 0 0 {name=l9350 lab=VSS}
C {bitcell_6t.sym} 2800 11600 0 0 {name=Xr58c14}
N 2760 11640 2740 11640 {}
C {lab_pin.sym} 2740 11640 0 0 {name=l9351 lab=BL14}
N 2760 11600 2740 11600 {}
C {lab_pin.sym} 2740 11600 0 0 {name=l9352 lab=BLB14}
N 2760 11560 2740 11560 {}
C {lab_pin.sym} 2740 11560 0 0 {name=l9353 lab=WL58}
N 2840 11640 2860 11640 {}
C {lab_pin.sym} 2860 11640 0 0 {name=l9354 lab=VDD}
N 2840 11560 2860 11560 {}
C {lab_pin.sym} 2860 11560 0 0 {name=l9355 lab=VSS}
C {bitcell_6t.sym} 3000 11600 0 0 {name=Xr58c15}
N 2960 11640 2940 11640 {}
C {lab_pin.sym} 2940 11640 0 0 {name=l9356 lab=BL15}
N 2960 11600 2940 11600 {}
C {lab_pin.sym} 2940 11600 0 0 {name=l9357 lab=BLB15}
N 2960 11560 2940 11560 {}
C {lab_pin.sym} 2940 11560 0 0 {name=l9358 lab=WL58}
N 3040 11640 3060 11640 {}
C {lab_pin.sym} 3060 11640 0 0 {name=l9359 lab=VDD}
N 3040 11560 3060 11560 {}
C {lab_pin.sym} 3060 11560 0 0 {name=l9360 lab=VSS}
C {bitcell_6t.sym} 3200 11600 0 0 {name=Xr58c16}
N 3160 11640 3140 11640 {}
C {lab_pin.sym} 3140 11640 0 0 {name=l9361 lab=BL16}
N 3160 11600 3140 11600 {}
C {lab_pin.sym} 3140 11600 0 0 {name=l9362 lab=BLB16}
N 3160 11560 3140 11560 {}
C {lab_pin.sym} 3140 11560 0 0 {name=l9363 lab=WL58}
N 3240 11640 3260 11640 {}
C {lab_pin.sym} 3260 11640 0 0 {name=l9364 lab=VDD}
N 3240 11560 3260 11560 {}
C {lab_pin.sym} 3260 11560 0 0 {name=l9365 lab=VSS}
C {bitcell_6t.sym} 3400 11600 0 0 {name=Xr58c17}
N 3360 11640 3340 11640 {}
C {lab_pin.sym} 3340 11640 0 0 {name=l9366 lab=BL17}
N 3360 11600 3340 11600 {}
C {lab_pin.sym} 3340 11600 0 0 {name=l9367 lab=BLB17}
N 3360 11560 3340 11560 {}
C {lab_pin.sym} 3340 11560 0 0 {name=l9368 lab=WL58}
N 3440 11640 3460 11640 {}
C {lab_pin.sym} 3460 11640 0 0 {name=l9369 lab=VDD}
N 3440 11560 3460 11560 {}
C {lab_pin.sym} 3460 11560 0 0 {name=l9370 lab=VSS}
C {bitcell_6t.sym} 3600 11600 0 0 {name=Xr58c18}
N 3560 11640 3540 11640 {}
C {lab_pin.sym} 3540 11640 0 0 {name=l9371 lab=BL18}
N 3560 11600 3540 11600 {}
C {lab_pin.sym} 3540 11600 0 0 {name=l9372 lab=BLB18}
N 3560 11560 3540 11560 {}
C {lab_pin.sym} 3540 11560 0 0 {name=l9373 lab=WL58}
N 3640 11640 3660 11640 {}
C {lab_pin.sym} 3660 11640 0 0 {name=l9374 lab=VDD}
N 3640 11560 3660 11560 {}
C {lab_pin.sym} 3660 11560 0 0 {name=l9375 lab=VSS}
C {bitcell_6t.sym} 3800 11600 0 0 {name=Xr58c19}
N 3760 11640 3740 11640 {}
C {lab_pin.sym} 3740 11640 0 0 {name=l9376 lab=BL19}
N 3760 11600 3740 11600 {}
C {lab_pin.sym} 3740 11600 0 0 {name=l9377 lab=BLB19}
N 3760 11560 3740 11560 {}
C {lab_pin.sym} 3740 11560 0 0 {name=l9378 lab=WL58}
N 3840 11640 3860 11640 {}
C {lab_pin.sym} 3860 11640 0 0 {name=l9379 lab=VDD}
N 3840 11560 3860 11560 {}
C {lab_pin.sym} 3860 11560 0 0 {name=l9380 lab=VSS}
C {bitcell_6t.sym} 4000 11600 0 0 {name=Xr58c20}
N 3960 11640 3940 11640 {}
C {lab_pin.sym} 3940 11640 0 0 {name=l9381 lab=BL20}
N 3960 11600 3940 11600 {}
C {lab_pin.sym} 3940 11600 0 0 {name=l9382 lab=BLB20}
N 3960 11560 3940 11560 {}
C {lab_pin.sym} 3940 11560 0 0 {name=l9383 lab=WL58}
N 4040 11640 4060 11640 {}
C {lab_pin.sym} 4060 11640 0 0 {name=l9384 lab=VDD}
N 4040 11560 4060 11560 {}
C {lab_pin.sym} 4060 11560 0 0 {name=l9385 lab=VSS}
C {bitcell_6t.sym} 4200 11600 0 0 {name=Xr58c21}
N 4160 11640 4140 11640 {}
C {lab_pin.sym} 4140 11640 0 0 {name=l9386 lab=BL21}
N 4160 11600 4140 11600 {}
C {lab_pin.sym} 4140 11600 0 0 {name=l9387 lab=BLB21}
N 4160 11560 4140 11560 {}
C {lab_pin.sym} 4140 11560 0 0 {name=l9388 lab=WL58}
N 4240 11640 4260 11640 {}
C {lab_pin.sym} 4260 11640 0 0 {name=l9389 lab=VDD}
N 4240 11560 4260 11560 {}
C {lab_pin.sym} 4260 11560 0 0 {name=l9390 lab=VSS}
C {bitcell_6t.sym} 4400 11600 0 0 {name=Xr58c22}
N 4360 11640 4340 11640 {}
C {lab_pin.sym} 4340 11640 0 0 {name=l9391 lab=BL22}
N 4360 11600 4340 11600 {}
C {lab_pin.sym} 4340 11600 0 0 {name=l9392 lab=BLB22}
N 4360 11560 4340 11560 {}
C {lab_pin.sym} 4340 11560 0 0 {name=l9393 lab=WL58}
N 4440 11640 4460 11640 {}
C {lab_pin.sym} 4460 11640 0 0 {name=l9394 lab=VDD}
N 4440 11560 4460 11560 {}
C {lab_pin.sym} 4460 11560 0 0 {name=l9395 lab=VSS}
C {bitcell_6t.sym} 4600 11600 0 0 {name=Xr58c23}
N 4560 11640 4540 11640 {}
C {lab_pin.sym} 4540 11640 0 0 {name=l9396 lab=BL23}
N 4560 11600 4540 11600 {}
C {lab_pin.sym} 4540 11600 0 0 {name=l9397 lab=BLB23}
N 4560 11560 4540 11560 {}
C {lab_pin.sym} 4540 11560 0 0 {name=l9398 lab=WL58}
N 4640 11640 4660 11640 {}
C {lab_pin.sym} 4660 11640 0 0 {name=l9399 lab=VDD}
N 4640 11560 4660 11560 {}
C {lab_pin.sym} 4660 11560 0 0 {name=l9400 lab=VSS}
C {bitcell_6t.sym} 4800 11600 0 0 {name=Xr58c24}
N 4760 11640 4740 11640 {}
C {lab_pin.sym} 4740 11640 0 0 {name=l9401 lab=BL24}
N 4760 11600 4740 11600 {}
C {lab_pin.sym} 4740 11600 0 0 {name=l9402 lab=BLB24}
N 4760 11560 4740 11560 {}
C {lab_pin.sym} 4740 11560 0 0 {name=l9403 lab=WL58}
N 4840 11640 4860 11640 {}
C {lab_pin.sym} 4860 11640 0 0 {name=l9404 lab=VDD}
N 4840 11560 4860 11560 {}
C {lab_pin.sym} 4860 11560 0 0 {name=l9405 lab=VSS}
C {bitcell_6t.sym} 5000 11600 0 0 {name=Xr58c25}
N 4960 11640 4940 11640 {}
C {lab_pin.sym} 4940 11640 0 0 {name=l9406 lab=BL25}
N 4960 11600 4940 11600 {}
C {lab_pin.sym} 4940 11600 0 0 {name=l9407 lab=BLB25}
N 4960 11560 4940 11560 {}
C {lab_pin.sym} 4940 11560 0 0 {name=l9408 lab=WL58}
N 5040 11640 5060 11640 {}
C {lab_pin.sym} 5060 11640 0 0 {name=l9409 lab=VDD}
N 5040 11560 5060 11560 {}
C {lab_pin.sym} 5060 11560 0 0 {name=l9410 lab=VSS}
C {bitcell_6t.sym} 5200 11600 0 0 {name=Xr58c26}
N 5160 11640 5140 11640 {}
C {lab_pin.sym} 5140 11640 0 0 {name=l9411 lab=BL26}
N 5160 11600 5140 11600 {}
C {lab_pin.sym} 5140 11600 0 0 {name=l9412 lab=BLB26}
N 5160 11560 5140 11560 {}
C {lab_pin.sym} 5140 11560 0 0 {name=l9413 lab=WL58}
N 5240 11640 5260 11640 {}
C {lab_pin.sym} 5260 11640 0 0 {name=l9414 lab=VDD}
N 5240 11560 5260 11560 {}
C {lab_pin.sym} 5260 11560 0 0 {name=l9415 lab=VSS}
C {bitcell_6t.sym} 5400 11600 0 0 {name=Xr58c27}
N 5360 11640 5340 11640 {}
C {lab_pin.sym} 5340 11640 0 0 {name=l9416 lab=BL27}
N 5360 11600 5340 11600 {}
C {lab_pin.sym} 5340 11600 0 0 {name=l9417 lab=BLB27}
N 5360 11560 5340 11560 {}
C {lab_pin.sym} 5340 11560 0 0 {name=l9418 lab=WL58}
N 5440 11640 5460 11640 {}
C {lab_pin.sym} 5460 11640 0 0 {name=l9419 lab=VDD}
N 5440 11560 5460 11560 {}
C {lab_pin.sym} 5460 11560 0 0 {name=l9420 lab=VSS}
C {bitcell_6t.sym} 5600 11600 0 0 {name=Xr58c28}
N 5560 11640 5540 11640 {}
C {lab_pin.sym} 5540 11640 0 0 {name=l9421 lab=BL28}
N 5560 11600 5540 11600 {}
C {lab_pin.sym} 5540 11600 0 0 {name=l9422 lab=BLB28}
N 5560 11560 5540 11560 {}
C {lab_pin.sym} 5540 11560 0 0 {name=l9423 lab=WL58}
N 5640 11640 5660 11640 {}
C {lab_pin.sym} 5660 11640 0 0 {name=l9424 lab=VDD}
N 5640 11560 5660 11560 {}
C {lab_pin.sym} 5660 11560 0 0 {name=l9425 lab=VSS}
C {bitcell_6t.sym} 5800 11600 0 0 {name=Xr58c29}
N 5760 11640 5740 11640 {}
C {lab_pin.sym} 5740 11640 0 0 {name=l9426 lab=BL29}
N 5760 11600 5740 11600 {}
C {lab_pin.sym} 5740 11600 0 0 {name=l9427 lab=BLB29}
N 5760 11560 5740 11560 {}
C {lab_pin.sym} 5740 11560 0 0 {name=l9428 lab=WL58}
N 5840 11640 5860 11640 {}
C {lab_pin.sym} 5860 11640 0 0 {name=l9429 lab=VDD}
N 5840 11560 5860 11560 {}
C {lab_pin.sym} 5860 11560 0 0 {name=l9430 lab=VSS}
C {bitcell_6t.sym} 6000 11600 0 0 {name=Xr58c30}
N 5960 11640 5940 11640 {}
C {lab_pin.sym} 5940 11640 0 0 {name=l9431 lab=BL30}
N 5960 11600 5940 11600 {}
C {lab_pin.sym} 5940 11600 0 0 {name=l9432 lab=BLB30}
N 5960 11560 5940 11560 {}
C {lab_pin.sym} 5940 11560 0 0 {name=l9433 lab=WL58}
N 6040 11640 6060 11640 {}
C {lab_pin.sym} 6060 11640 0 0 {name=l9434 lab=VDD}
N 6040 11560 6060 11560 {}
C {lab_pin.sym} 6060 11560 0 0 {name=l9435 lab=VSS}
C {bitcell_6t.sym} 6200 11600 0 0 {name=Xr58c31}
N 6160 11640 6140 11640 {}
C {lab_pin.sym} 6140 11640 0 0 {name=l9436 lab=BL31}
N 6160 11600 6140 11600 {}
C {lab_pin.sym} 6140 11600 0 0 {name=l9437 lab=BLB31}
N 6160 11560 6140 11560 {}
C {lab_pin.sym} 6140 11560 0 0 {name=l9438 lab=WL58}
N 6240 11640 6260 11640 {}
C {lab_pin.sym} 6260 11640 0 0 {name=l9439 lab=VDD}
N 6240 11560 6260 11560 {}
C {lab_pin.sym} 6260 11560 0 0 {name=l9440 lab=VSS}
C {bitcell_6t.sym} 0 11800 0 0 {name=Xr59c0}
N -40 11840 -60 11840 {}
C {lab_pin.sym} -60 11840 0 0 {name=l9441 lab=BL0}
N -40 11800 -60 11800 {}
C {lab_pin.sym} -60 11800 0 0 {name=l9442 lab=BLB0}
N -40 11760 -60 11760 {}
C {lab_pin.sym} -60 11760 0 0 {name=l9443 lab=WL59}
N 40 11840 60 11840 {}
C {lab_pin.sym} 60 11840 0 0 {name=l9444 lab=VDD}
N 40 11760 60 11760 {}
C {lab_pin.sym} 60 11760 0 0 {name=l9445 lab=VSS}
C {bitcell_6t.sym} 200 11800 0 0 {name=Xr59c1}
N 160 11840 140 11840 {}
C {lab_pin.sym} 140 11840 0 0 {name=l9446 lab=BL1}
N 160 11800 140 11800 {}
C {lab_pin.sym} 140 11800 0 0 {name=l9447 lab=BLB1}
N 160 11760 140 11760 {}
C {lab_pin.sym} 140 11760 0 0 {name=l9448 lab=WL59}
N 240 11840 260 11840 {}
C {lab_pin.sym} 260 11840 0 0 {name=l9449 lab=VDD}
N 240 11760 260 11760 {}
C {lab_pin.sym} 260 11760 0 0 {name=l9450 lab=VSS}
C {bitcell_6t.sym} 400 11800 0 0 {name=Xr59c2}
N 360 11840 340 11840 {}
C {lab_pin.sym} 340 11840 0 0 {name=l9451 lab=BL2}
N 360 11800 340 11800 {}
C {lab_pin.sym} 340 11800 0 0 {name=l9452 lab=BLB2}
N 360 11760 340 11760 {}
C {lab_pin.sym} 340 11760 0 0 {name=l9453 lab=WL59}
N 440 11840 460 11840 {}
C {lab_pin.sym} 460 11840 0 0 {name=l9454 lab=VDD}
N 440 11760 460 11760 {}
C {lab_pin.sym} 460 11760 0 0 {name=l9455 lab=VSS}
C {bitcell_6t.sym} 600 11800 0 0 {name=Xr59c3}
N 560 11840 540 11840 {}
C {lab_pin.sym} 540 11840 0 0 {name=l9456 lab=BL3}
N 560 11800 540 11800 {}
C {lab_pin.sym} 540 11800 0 0 {name=l9457 lab=BLB3}
N 560 11760 540 11760 {}
C {lab_pin.sym} 540 11760 0 0 {name=l9458 lab=WL59}
N 640 11840 660 11840 {}
C {lab_pin.sym} 660 11840 0 0 {name=l9459 lab=VDD}
N 640 11760 660 11760 {}
C {lab_pin.sym} 660 11760 0 0 {name=l9460 lab=VSS}
C {bitcell_6t.sym} 800 11800 0 0 {name=Xr59c4}
N 760 11840 740 11840 {}
C {lab_pin.sym} 740 11840 0 0 {name=l9461 lab=BL4}
N 760 11800 740 11800 {}
C {lab_pin.sym} 740 11800 0 0 {name=l9462 lab=BLB4}
N 760 11760 740 11760 {}
C {lab_pin.sym} 740 11760 0 0 {name=l9463 lab=WL59}
N 840 11840 860 11840 {}
C {lab_pin.sym} 860 11840 0 0 {name=l9464 lab=VDD}
N 840 11760 860 11760 {}
C {lab_pin.sym} 860 11760 0 0 {name=l9465 lab=VSS}
C {bitcell_6t.sym} 1000 11800 0 0 {name=Xr59c5}
N 960 11840 940 11840 {}
C {lab_pin.sym} 940 11840 0 0 {name=l9466 lab=BL5}
N 960 11800 940 11800 {}
C {lab_pin.sym} 940 11800 0 0 {name=l9467 lab=BLB5}
N 960 11760 940 11760 {}
C {lab_pin.sym} 940 11760 0 0 {name=l9468 lab=WL59}
N 1040 11840 1060 11840 {}
C {lab_pin.sym} 1060 11840 0 0 {name=l9469 lab=VDD}
N 1040 11760 1060 11760 {}
C {lab_pin.sym} 1060 11760 0 0 {name=l9470 lab=VSS}
C {bitcell_6t.sym} 1200 11800 0 0 {name=Xr59c6}
N 1160 11840 1140 11840 {}
C {lab_pin.sym} 1140 11840 0 0 {name=l9471 lab=BL6}
N 1160 11800 1140 11800 {}
C {lab_pin.sym} 1140 11800 0 0 {name=l9472 lab=BLB6}
N 1160 11760 1140 11760 {}
C {lab_pin.sym} 1140 11760 0 0 {name=l9473 lab=WL59}
N 1240 11840 1260 11840 {}
C {lab_pin.sym} 1260 11840 0 0 {name=l9474 lab=VDD}
N 1240 11760 1260 11760 {}
C {lab_pin.sym} 1260 11760 0 0 {name=l9475 lab=VSS}
C {bitcell_6t.sym} 1400 11800 0 0 {name=Xr59c7}
N 1360 11840 1340 11840 {}
C {lab_pin.sym} 1340 11840 0 0 {name=l9476 lab=BL7}
N 1360 11800 1340 11800 {}
C {lab_pin.sym} 1340 11800 0 0 {name=l9477 lab=BLB7}
N 1360 11760 1340 11760 {}
C {lab_pin.sym} 1340 11760 0 0 {name=l9478 lab=WL59}
N 1440 11840 1460 11840 {}
C {lab_pin.sym} 1460 11840 0 0 {name=l9479 lab=VDD}
N 1440 11760 1460 11760 {}
C {lab_pin.sym} 1460 11760 0 0 {name=l9480 lab=VSS}
C {bitcell_6t.sym} 1600 11800 0 0 {name=Xr59c8}
N 1560 11840 1540 11840 {}
C {lab_pin.sym} 1540 11840 0 0 {name=l9481 lab=BL8}
N 1560 11800 1540 11800 {}
C {lab_pin.sym} 1540 11800 0 0 {name=l9482 lab=BLB8}
N 1560 11760 1540 11760 {}
C {lab_pin.sym} 1540 11760 0 0 {name=l9483 lab=WL59}
N 1640 11840 1660 11840 {}
C {lab_pin.sym} 1660 11840 0 0 {name=l9484 lab=VDD}
N 1640 11760 1660 11760 {}
C {lab_pin.sym} 1660 11760 0 0 {name=l9485 lab=VSS}
C {bitcell_6t.sym} 1800 11800 0 0 {name=Xr59c9}
N 1760 11840 1740 11840 {}
C {lab_pin.sym} 1740 11840 0 0 {name=l9486 lab=BL9}
N 1760 11800 1740 11800 {}
C {lab_pin.sym} 1740 11800 0 0 {name=l9487 lab=BLB9}
N 1760 11760 1740 11760 {}
C {lab_pin.sym} 1740 11760 0 0 {name=l9488 lab=WL59}
N 1840 11840 1860 11840 {}
C {lab_pin.sym} 1860 11840 0 0 {name=l9489 lab=VDD}
N 1840 11760 1860 11760 {}
C {lab_pin.sym} 1860 11760 0 0 {name=l9490 lab=VSS}
C {bitcell_6t.sym} 2000 11800 0 0 {name=Xr59c10}
N 1960 11840 1940 11840 {}
C {lab_pin.sym} 1940 11840 0 0 {name=l9491 lab=BL10}
N 1960 11800 1940 11800 {}
C {lab_pin.sym} 1940 11800 0 0 {name=l9492 lab=BLB10}
N 1960 11760 1940 11760 {}
C {lab_pin.sym} 1940 11760 0 0 {name=l9493 lab=WL59}
N 2040 11840 2060 11840 {}
C {lab_pin.sym} 2060 11840 0 0 {name=l9494 lab=VDD}
N 2040 11760 2060 11760 {}
C {lab_pin.sym} 2060 11760 0 0 {name=l9495 lab=VSS}
C {bitcell_6t.sym} 2200 11800 0 0 {name=Xr59c11}
N 2160 11840 2140 11840 {}
C {lab_pin.sym} 2140 11840 0 0 {name=l9496 lab=BL11}
N 2160 11800 2140 11800 {}
C {lab_pin.sym} 2140 11800 0 0 {name=l9497 lab=BLB11}
N 2160 11760 2140 11760 {}
C {lab_pin.sym} 2140 11760 0 0 {name=l9498 lab=WL59}
N 2240 11840 2260 11840 {}
C {lab_pin.sym} 2260 11840 0 0 {name=l9499 lab=VDD}
N 2240 11760 2260 11760 {}
C {lab_pin.sym} 2260 11760 0 0 {name=l9500 lab=VSS}
C {bitcell_6t.sym} 2400 11800 0 0 {name=Xr59c12}
N 2360 11840 2340 11840 {}
C {lab_pin.sym} 2340 11840 0 0 {name=l9501 lab=BL12}
N 2360 11800 2340 11800 {}
C {lab_pin.sym} 2340 11800 0 0 {name=l9502 lab=BLB12}
N 2360 11760 2340 11760 {}
C {lab_pin.sym} 2340 11760 0 0 {name=l9503 lab=WL59}
N 2440 11840 2460 11840 {}
C {lab_pin.sym} 2460 11840 0 0 {name=l9504 lab=VDD}
N 2440 11760 2460 11760 {}
C {lab_pin.sym} 2460 11760 0 0 {name=l9505 lab=VSS}
C {bitcell_6t.sym} 2600 11800 0 0 {name=Xr59c13}
N 2560 11840 2540 11840 {}
C {lab_pin.sym} 2540 11840 0 0 {name=l9506 lab=BL13}
N 2560 11800 2540 11800 {}
C {lab_pin.sym} 2540 11800 0 0 {name=l9507 lab=BLB13}
N 2560 11760 2540 11760 {}
C {lab_pin.sym} 2540 11760 0 0 {name=l9508 lab=WL59}
N 2640 11840 2660 11840 {}
C {lab_pin.sym} 2660 11840 0 0 {name=l9509 lab=VDD}
N 2640 11760 2660 11760 {}
C {lab_pin.sym} 2660 11760 0 0 {name=l9510 lab=VSS}
C {bitcell_6t.sym} 2800 11800 0 0 {name=Xr59c14}
N 2760 11840 2740 11840 {}
C {lab_pin.sym} 2740 11840 0 0 {name=l9511 lab=BL14}
N 2760 11800 2740 11800 {}
C {lab_pin.sym} 2740 11800 0 0 {name=l9512 lab=BLB14}
N 2760 11760 2740 11760 {}
C {lab_pin.sym} 2740 11760 0 0 {name=l9513 lab=WL59}
N 2840 11840 2860 11840 {}
C {lab_pin.sym} 2860 11840 0 0 {name=l9514 lab=VDD}
N 2840 11760 2860 11760 {}
C {lab_pin.sym} 2860 11760 0 0 {name=l9515 lab=VSS}
C {bitcell_6t.sym} 3000 11800 0 0 {name=Xr59c15}
N 2960 11840 2940 11840 {}
C {lab_pin.sym} 2940 11840 0 0 {name=l9516 lab=BL15}
N 2960 11800 2940 11800 {}
C {lab_pin.sym} 2940 11800 0 0 {name=l9517 lab=BLB15}
N 2960 11760 2940 11760 {}
C {lab_pin.sym} 2940 11760 0 0 {name=l9518 lab=WL59}
N 3040 11840 3060 11840 {}
C {lab_pin.sym} 3060 11840 0 0 {name=l9519 lab=VDD}
N 3040 11760 3060 11760 {}
C {lab_pin.sym} 3060 11760 0 0 {name=l9520 lab=VSS}
C {bitcell_6t.sym} 3200 11800 0 0 {name=Xr59c16}
N 3160 11840 3140 11840 {}
C {lab_pin.sym} 3140 11840 0 0 {name=l9521 lab=BL16}
N 3160 11800 3140 11800 {}
C {lab_pin.sym} 3140 11800 0 0 {name=l9522 lab=BLB16}
N 3160 11760 3140 11760 {}
C {lab_pin.sym} 3140 11760 0 0 {name=l9523 lab=WL59}
N 3240 11840 3260 11840 {}
C {lab_pin.sym} 3260 11840 0 0 {name=l9524 lab=VDD}
N 3240 11760 3260 11760 {}
C {lab_pin.sym} 3260 11760 0 0 {name=l9525 lab=VSS}
C {bitcell_6t.sym} 3400 11800 0 0 {name=Xr59c17}
N 3360 11840 3340 11840 {}
C {lab_pin.sym} 3340 11840 0 0 {name=l9526 lab=BL17}
N 3360 11800 3340 11800 {}
C {lab_pin.sym} 3340 11800 0 0 {name=l9527 lab=BLB17}
N 3360 11760 3340 11760 {}
C {lab_pin.sym} 3340 11760 0 0 {name=l9528 lab=WL59}
N 3440 11840 3460 11840 {}
C {lab_pin.sym} 3460 11840 0 0 {name=l9529 lab=VDD}
N 3440 11760 3460 11760 {}
C {lab_pin.sym} 3460 11760 0 0 {name=l9530 lab=VSS}
C {bitcell_6t.sym} 3600 11800 0 0 {name=Xr59c18}
N 3560 11840 3540 11840 {}
C {lab_pin.sym} 3540 11840 0 0 {name=l9531 lab=BL18}
N 3560 11800 3540 11800 {}
C {lab_pin.sym} 3540 11800 0 0 {name=l9532 lab=BLB18}
N 3560 11760 3540 11760 {}
C {lab_pin.sym} 3540 11760 0 0 {name=l9533 lab=WL59}
N 3640 11840 3660 11840 {}
C {lab_pin.sym} 3660 11840 0 0 {name=l9534 lab=VDD}
N 3640 11760 3660 11760 {}
C {lab_pin.sym} 3660 11760 0 0 {name=l9535 lab=VSS}
C {bitcell_6t.sym} 3800 11800 0 0 {name=Xr59c19}
N 3760 11840 3740 11840 {}
C {lab_pin.sym} 3740 11840 0 0 {name=l9536 lab=BL19}
N 3760 11800 3740 11800 {}
C {lab_pin.sym} 3740 11800 0 0 {name=l9537 lab=BLB19}
N 3760 11760 3740 11760 {}
C {lab_pin.sym} 3740 11760 0 0 {name=l9538 lab=WL59}
N 3840 11840 3860 11840 {}
C {lab_pin.sym} 3860 11840 0 0 {name=l9539 lab=VDD}
N 3840 11760 3860 11760 {}
C {lab_pin.sym} 3860 11760 0 0 {name=l9540 lab=VSS}
C {bitcell_6t.sym} 4000 11800 0 0 {name=Xr59c20}
N 3960 11840 3940 11840 {}
C {lab_pin.sym} 3940 11840 0 0 {name=l9541 lab=BL20}
N 3960 11800 3940 11800 {}
C {lab_pin.sym} 3940 11800 0 0 {name=l9542 lab=BLB20}
N 3960 11760 3940 11760 {}
C {lab_pin.sym} 3940 11760 0 0 {name=l9543 lab=WL59}
N 4040 11840 4060 11840 {}
C {lab_pin.sym} 4060 11840 0 0 {name=l9544 lab=VDD}
N 4040 11760 4060 11760 {}
C {lab_pin.sym} 4060 11760 0 0 {name=l9545 lab=VSS}
C {bitcell_6t.sym} 4200 11800 0 0 {name=Xr59c21}
N 4160 11840 4140 11840 {}
C {lab_pin.sym} 4140 11840 0 0 {name=l9546 lab=BL21}
N 4160 11800 4140 11800 {}
C {lab_pin.sym} 4140 11800 0 0 {name=l9547 lab=BLB21}
N 4160 11760 4140 11760 {}
C {lab_pin.sym} 4140 11760 0 0 {name=l9548 lab=WL59}
N 4240 11840 4260 11840 {}
C {lab_pin.sym} 4260 11840 0 0 {name=l9549 lab=VDD}
N 4240 11760 4260 11760 {}
C {lab_pin.sym} 4260 11760 0 0 {name=l9550 lab=VSS}
C {bitcell_6t.sym} 4400 11800 0 0 {name=Xr59c22}
N 4360 11840 4340 11840 {}
C {lab_pin.sym} 4340 11840 0 0 {name=l9551 lab=BL22}
N 4360 11800 4340 11800 {}
C {lab_pin.sym} 4340 11800 0 0 {name=l9552 lab=BLB22}
N 4360 11760 4340 11760 {}
C {lab_pin.sym} 4340 11760 0 0 {name=l9553 lab=WL59}
N 4440 11840 4460 11840 {}
C {lab_pin.sym} 4460 11840 0 0 {name=l9554 lab=VDD}
N 4440 11760 4460 11760 {}
C {lab_pin.sym} 4460 11760 0 0 {name=l9555 lab=VSS}
C {bitcell_6t.sym} 4600 11800 0 0 {name=Xr59c23}
N 4560 11840 4540 11840 {}
C {lab_pin.sym} 4540 11840 0 0 {name=l9556 lab=BL23}
N 4560 11800 4540 11800 {}
C {lab_pin.sym} 4540 11800 0 0 {name=l9557 lab=BLB23}
N 4560 11760 4540 11760 {}
C {lab_pin.sym} 4540 11760 0 0 {name=l9558 lab=WL59}
N 4640 11840 4660 11840 {}
C {lab_pin.sym} 4660 11840 0 0 {name=l9559 lab=VDD}
N 4640 11760 4660 11760 {}
C {lab_pin.sym} 4660 11760 0 0 {name=l9560 lab=VSS}
C {bitcell_6t.sym} 4800 11800 0 0 {name=Xr59c24}
N 4760 11840 4740 11840 {}
C {lab_pin.sym} 4740 11840 0 0 {name=l9561 lab=BL24}
N 4760 11800 4740 11800 {}
C {lab_pin.sym} 4740 11800 0 0 {name=l9562 lab=BLB24}
N 4760 11760 4740 11760 {}
C {lab_pin.sym} 4740 11760 0 0 {name=l9563 lab=WL59}
N 4840 11840 4860 11840 {}
C {lab_pin.sym} 4860 11840 0 0 {name=l9564 lab=VDD}
N 4840 11760 4860 11760 {}
C {lab_pin.sym} 4860 11760 0 0 {name=l9565 lab=VSS}
C {bitcell_6t.sym} 5000 11800 0 0 {name=Xr59c25}
N 4960 11840 4940 11840 {}
C {lab_pin.sym} 4940 11840 0 0 {name=l9566 lab=BL25}
N 4960 11800 4940 11800 {}
C {lab_pin.sym} 4940 11800 0 0 {name=l9567 lab=BLB25}
N 4960 11760 4940 11760 {}
C {lab_pin.sym} 4940 11760 0 0 {name=l9568 lab=WL59}
N 5040 11840 5060 11840 {}
C {lab_pin.sym} 5060 11840 0 0 {name=l9569 lab=VDD}
N 5040 11760 5060 11760 {}
C {lab_pin.sym} 5060 11760 0 0 {name=l9570 lab=VSS}
C {bitcell_6t.sym} 5200 11800 0 0 {name=Xr59c26}
N 5160 11840 5140 11840 {}
C {lab_pin.sym} 5140 11840 0 0 {name=l9571 lab=BL26}
N 5160 11800 5140 11800 {}
C {lab_pin.sym} 5140 11800 0 0 {name=l9572 lab=BLB26}
N 5160 11760 5140 11760 {}
C {lab_pin.sym} 5140 11760 0 0 {name=l9573 lab=WL59}
N 5240 11840 5260 11840 {}
C {lab_pin.sym} 5260 11840 0 0 {name=l9574 lab=VDD}
N 5240 11760 5260 11760 {}
C {lab_pin.sym} 5260 11760 0 0 {name=l9575 lab=VSS}
C {bitcell_6t.sym} 5400 11800 0 0 {name=Xr59c27}
N 5360 11840 5340 11840 {}
C {lab_pin.sym} 5340 11840 0 0 {name=l9576 lab=BL27}
N 5360 11800 5340 11800 {}
C {lab_pin.sym} 5340 11800 0 0 {name=l9577 lab=BLB27}
N 5360 11760 5340 11760 {}
C {lab_pin.sym} 5340 11760 0 0 {name=l9578 lab=WL59}
N 5440 11840 5460 11840 {}
C {lab_pin.sym} 5460 11840 0 0 {name=l9579 lab=VDD}
N 5440 11760 5460 11760 {}
C {lab_pin.sym} 5460 11760 0 0 {name=l9580 lab=VSS}
C {bitcell_6t.sym} 5600 11800 0 0 {name=Xr59c28}
N 5560 11840 5540 11840 {}
C {lab_pin.sym} 5540 11840 0 0 {name=l9581 lab=BL28}
N 5560 11800 5540 11800 {}
C {lab_pin.sym} 5540 11800 0 0 {name=l9582 lab=BLB28}
N 5560 11760 5540 11760 {}
C {lab_pin.sym} 5540 11760 0 0 {name=l9583 lab=WL59}
N 5640 11840 5660 11840 {}
C {lab_pin.sym} 5660 11840 0 0 {name=l9584 lab=VDD}
N 5640 11760 5660 11760 {}
C {lab_pin.sym} 5660 11760 0 0 {name=l9585 lab=VSS}
C {bitcell_6t.sym} 5800 11800 0 0 {name=Xr59c29}
N 5760 11840 5740 11840 {}
C {lab_pin.sym} 5740 11840 0 0 {name=l9586 lab=BL29}
N 5760 11800 5740 11800 {}
C {lab_pin.sym} 5740 11800 0 0 {name=l9587 lab=BLB29}
N 5760 11760 5740 11760 {}
C {lab_pin.sym} 5740 11760 0 0 {name=l9588 lab=WL59}
N 5840 11840 5860 11840 {}
C {lab_pin.sym} 5860 11840 0 0 {name=l9589 lab=VDD}
N 5840 11760 5860 11760 {}
C {lab_pin.sym} 5860 11760 0 0 {name=l9590 lab=VSS}
C {bitcell_6t.sym} 6000 11800 0 0 {name=Xr59c30}
N 5960 11840 5940 11840 {}
C {lab_pin.sym} 5940 11840 0 0 {name=l9591 lab=BL30}
N 5960 11800 5940 11800 {}
C {lab_pin.sym} 5940 11800 0 0 {name=l9592 lab=BLB30}
N 5960 11760 5940 11760 {}
C {lab_pin.sym} 5940 11760 0 0 {name=l9593 lab=WL59}
N 6040 11840 6060 11840 {}
C {lab_pin.sym} 6060 11840 0 0 {name=l9594 lab=VDD}
N 6040 11760 6060 11760 {}
C {lab_pin.sym} 6060 11760 0 0 {name=l9595 lab=VSS}
C {bitcell_6t.sym} 6200 11800 0 0 {name=Xr59c31}
N 6160 11840 6140 11840 {}
C {lab_pin.sym} 6140 11840 0 0 {name=l9596 lab=BL31}
N 6160 11800 6140 11800 {}
C {lab_pin.sym} 6140 11800 0 0 {name=l9597 lab=BLB31}
N 6160 11760 6140 11760 {}
C {lab_pin.sym} 6140 11760 0 0 {name=l9598 lab=WL59}
N 6240 11840 6260 11840 {}
C {lab_pin.sym} 6260 11840 0 0 {name=l9599 lab=VDD}
N 6240 11760 6260 11760 {}
C {lab_pin.sym} 6260 11760 0 0 {name=l9600 lab=VSS}
C {bitcell_6t.sym} 0 12000 0 0 {name=Xr60c0}
N -40 12040 -60 12040 {}
C {lab_pin.sym} -60 12040 0 0 {name=l9601 lab=BL0}
N -40 12000 -60 12000 {}
C {lab_pin.sym} -60 12000 0 0 {name=l9602 lab=BLB0}
N -40 11960 -60 11960 {}
C {lab_pin.sym} -60 11960 0 0 {name=l9603 lab=WL60}
N 40 12040 60 12040 {}
C {lab_pin.sym} 60 12040 0 0 {name=l9604 lab=VDD}
N 40 11960 60 11960 {}
C {lab_pin.sym} 60 11960 0 0 {name=l9605 lab=VSS}
C {bitcell_6t.sym} 200 12000 0 0 {name=Xr60c1}
N 160 12040 140 12040 {}
C {lab_pin.sym} 140 12040 0 0 {name=l9606 lab=BL1}
N 160 12000 140 12000 {}
C {lab_pin.sym} 140 12000 0 0 {name=l9607 lab=BLB1}
N 160 11960 140 11960 {}
C {lab_pin.sym} 140 11960 0 0 {name=l9608 lab=WL60}
N 240 12040 260 12040 {}
C {lab_pin.sym} 260 12040 0 0 {name=l9609 lab=VDD}
N 240 11960 260 11960 {}
C {lab_pin.sym} 260 11960 0 0 {name=l9610 lab=VSS}
C {bitcell_6t.sym} 400 12000 0 0 {name=Xr60c2}
N 360 12040 340 12040 {}
C {lab_pin.sym} 340 12040 0 0 {name=l9611 lab=BL2}
N 360 12000 340 12000 {}
C {lab_pin.sym} 340 12000 0 0 {name=l9612 lab=BLB2}
N 360 11960 340 11960 {}
C {lab_pin.sym} 340 11960 0 0 {name=l9613 lab=WL60}
N 440 12040 460 12040 {}
C {lab_pin.sym} 460 12040 0 0 {name=l9614 lab=VDD}
N 440 11960 460 11960 {}
C {lab_pin.sym} 460 11960 0 0 {name=l9615 lab=VSS}
C {bitcell_6t.sym} 600 12000 0 0 {name=Xr60c3}
N 560 12040 540 12040 {}
C {lab_pin.sym} 540 12040 0 0 {name=l9616 lab=BL3}
N 560 12000 540 12000 {}
C {lab_pin.sym} 540 12000 0 0 {name=l9617 lab=BLB3}
N 560 11960 540 11960 {}
C {lab_pin.sym} 540 11960 0 0 {name=l9618 lab=WL60}
N 640 12040 660 12040 {}
C {lab_pin.sym} 660 12040 0 0 {name=l9619 lab=VDD}
N 640 11960 660 11960 {}
C {lab_pin.sym} 660 11960 0 0 {name=l9620 lab=VSS}
C {bitcell_6t.sym} 800 12000 0 0 {name=Xr60c4}
N 760 12040 740 12040 {}
C {lab_pin.sym} 740 12040 0 0 {name=l9621 lab=BL4}
N 760 12000 740 12000 {}
C {lab_pin.sym} 740 12000 0 0 {name=l9622 lab=BLB4}
N 760 11960 740 11960 {}
C {lab_pin.sym} 740 11960 0 0 {name=l9623 lab=WL60}
N 840 12040 860 12040 {}
C {lab_pin.sym} 860 12040 0 0 {name=l9624 lab=VDD}
N 840 11960 860 11960 {}
C {lab_pin.sym} 860 11960 0 0 {name=l9625 lab=VSS}
C {bitcell_6t.sym} 1000 12000 0 0 {name=Xr60c5}
N 960 12040 940 12040 {}
C {lab_pin.sym} 940 12040 0 0 {name=l9626 lab=BL5}
N 960 12000 940 12000 {}
C {lab_pin.sym} 940 12000 0 0 {name=l9627 lab=BLB5}
N 960 11960 940 11960 {}
C {lab_pin.sym} 940 11960 0 0 {name=l9628 lab=WL60}
N 1040 12040 1060 12040 {}
C {lab_pin.sym} 1060 12040 0 0 {name=l9629 lab=VDD}
N 1040 11960 1060 11960 {}
C {lab_pin.sym} 1060 11960 0 0 {name=l9630 lab=VSS}
C {bitcell_6t.sym} 1200 12000 0 0 {name=Xr60c6}
N 1160 12040 1140 12040 {}
C {lab_pin.sym} 1140 12040 0 0 {name=l9631 lab=BL6}
N 1160 12000 1140 12000 {}
C {lab_pin.sym} 1140 12000 0 0 {name=l9632 lab=BLB6}
N 1160 11960 1140 11960 {}
C {lab_pin.sym} 1140 11960 0 0 {name=l9633 lab=WL60}
N 1240 12040 1260 12040 {}
C {lab_pin.sym} 1260 12040 0 0 {name=l9634 lab=VDD}
N 1240 11960 1260 11960 {}
C {lab_pin.sym} 1260 11960 0 0 {name=l9635 lab=VSS}
C {bitcell_6t.sym} 1400 12000 0 0 {name=Xr60c7}
N 1360 12040 1340 12040 {}
C {lab_pin.sym} 1340 12040 0 0 {name=l9636 lab=BL7}
N 1360 12000 1340 12000 {}
C {lab_pin.sym} 1340 12000 0 0 {name=l9637 lab=BLB7}
N 1360 11960 1340 11960 {}
C {lab_pin.sym} 1340 11960 0 0 {name=l9638 lab=WL60}
N 1440 12040 1460 12040 {}
C {lab_pin.sym} 1460 12040 0 0 {name=l9639 lab=VDD}
N 1440 11960 1460 11960 {}
C {lab_pin.sym} 1460 11960 0 0 {name=l9640 lab=VSS}
C {bitcell_6t.sym} 1600 12000 0 0 {name=Xr60c8}
N 1560 12040 1540 12040 {}
C {lab_pin.sym} 1540 12040 0 0 {name=l9641 lab=BL8}
N 1560 12000 1540 12000 {}
C {lab_pin.sym} 1540 12000 0 0 {name=l9642 lab=BLB8}
N 1560 11960 1540 11960 {}
C {lab_pin.sym} 1540 11960 0 0 {name=l9643 lab=WL60}
N 1640 12040 1660 12040 {}
C {lab_pin.sym} 1660 12040 0 0 {name=l9644 lab=VDD}
N 1640 11960 1660 11960 {}
C {lab_pin.sym} 1660 11960 0 0 {name=l9645 lab=VSS}
C {bitcell_6t.sym} 1800 12000 0 0 {name=Xr60c9}
N 1760 12040 1740 12040 {}
C {lab_pin.sym} 1740 12040 0 0 {name=l9646 lab=BL9}
N 1760 12000 1740 12000 {}
C {lab_pin.sym} 1740 12000 0 0 {name=l9647 lab=BLB9}
N 1760 11960 1740 11960 {}
C {lab_pin.sym} 1740 11960 0 0 {name=l9648 lab=WL60}
N 1840 12040 1860 12040 {}
C {lab_pin.sym} 1860 12040 0 0 {name=l9649 lab=VDD}
N 1840 11960 1860 11960 {}
C {lab_pin.sym} 1860 11960 0 0 {name=l9650 lab=VSS}
C {bitcell_6t.sym} 2000 12000 0 0 {name=Xr60c10}
N 1960 12040 1940 12040 {}
C {lab_pin.sym} 1940 12040 0 0 {name=l9651 lab=BL10}
N 1960 12000 1940 12000 {}
C {lab_pin.sym} 1940 12000 0 0 {name=l9652 lab=BLB10}
N 1960 11960 1940 11960 {}
C {lab_pin.sym} 1940 11960 0 0 {name=l9653 lab=WL60}
N 2040 12040 2060 12040 {}
C {lab_pin.sym} 2060 12040 0 0 {name=l9654 lab=VDD}
N 2040 11960 2060 11960 {}
C {lab_pin.sym} 2060 11960 0 0 {name=l9655 lab=VSS}
C {bitcell_6t.sym} 2200 12000 0 0 {name=Xr60c11}
N 2160 12040 2140 12040 {}
C {lab_pin.sym} 2140 12040 0 0 {name=l9656 lab=BL11}
N 2160 12000 2140 12000 {}
C {lab_pin.sym} 2140 12000 0 0 {name=l9657 lab=BLB11}
N 2160 11960 2140 11960 {}
C {lab_pin.sym} 2140 11960 0 0 {name=l9658 lab=WL60}
N 2240 12040 2260 12040 {}
C {lab_pin.sym} 2260 12040 0 0 {name=l9659 lab=VDD}
N 2240 11960 2260 11960 {}
C {lab_pin.sym} 2260 11960 0 0 {name=l9660 lab=VSS}
C {bitcell_6t.sym} 2400 12000 0 0 {name=Xr60c12}
N 2360 12040 2340 12040 {}
C {lab_pin.sym} 2340 12040 0 0 {name=l9661 lab=BL12}
N 2360 12000 2340 12000 {}
C {lab_pin.sym} 2340 12000 0 0 {name=l9662 lab=BLB12}
N 2360 11960 2340 11960 {}
C {lab_pin.sym} 2340 11960 0 0 {name=l9663 lab=WL60}
N 2440 12040 2460 12040 {}
C {lab_pin.sym} 2460 12040 0 0 {name=l9664 lab=VDD}
N 2440 11960 2460 11960 {}
C {lab_pin.sym} 2460 11960 0 0 {name=l9665 lab=VSS}
C {bitcell_6t.sym} 2600 12000 0 0 {name=Xr60c13}
N 2560 12040 2540 12040 {}
C {lab_pin.sym} 2540 12040 0 0 {name=l9666 lab=BL13}
N 2560 12000 2540 12000 {}
C {lab_pin.sym} 2540 12000 0 0 {name=l9667 lab=BLB13}
N 2560 11960 2540 11960 {}
C {lab_pin.sym} 2540 11960 0 0 {name=l9668 lab=WL60}
N 2640 12040 2660 12040 {}
C {lab_pin.sym} 2660 12040 0 0 {name=l9669 lab=VDD}
N 2640 11960 2660 11960 {}
C {lab_pin.sym} 2660 11960 0 0 {name=l9670 lab=VSS}
C {bitcell_6t.sym} 2800 12000 0 0 {name=Xr60c14}
N 2760 12040 2740 12040 {}
C {lab_pin.sym} 2740 12040 0 0 {name=l9671 lab=BL14}
N 2760 12000 2740 12000 {}
C {lab_pin.sym} 2740 12000 0 0 {name=l9672 lab=BLB14}
N 2760 11960 2740 11960 {}
C {lab_pin.sym} 2740 11960 0 0 {name=l9673 lab=WL60}
N 2840 12040 2860 12040 {}
C {lab_pin.sym} 2860 12040 0 0 {name=l9674 lab=VDD}
N 2840 11960 2860 11960 {}
C {lab_pin.sym} 2860 11960 0 0 {name=l9675 lab=VSS}
C {bitcell_6t.sym} 3000 12000 0 0 {name=Xr60c15}
N 2960 12040 2940 12040 {}
C {lab_pin.sym} 2940 12040 0 0 {name=l9676 lab=BL15}
N 2960 12000 2940 12000 {}
C {lab_pin.sym} 2940 12000 0 0 {name=l9677 lab=BLB15}
N 2960 11960 2940 11960 {}
C {lab_pin.sym} 2940 11960 0 0 {name=l9678 lab=WL60}
N 3040 12040 3060 12040 {}
C {lab_pin.sym} 3060 12040 0 0 {name=l9679 lab=VDD}
N 3040 11960 3060 11960 {}
C {lab_pin.sym} 3060 11960 0 0 {name=l9680 lab=VSS}
C {bitcell_6t.sym} 3200 12000 0 0 {name=Xr60c16}
N 3160 12040 3140 12040 {}
C {lab_pin.sym} 3140 12040 0 0 {name=l9681 lab=BL16}
N 3160 12000 3140 12000 {}
C {lab_pin.sym} 3140 12000 0 0 {name=l9682 lab=BLB16}
N 3160 11960 3140 11960 {}
C {lab_pin.sym} 3140 11960 0 0 {name=l9683 lab=WL60}
N 3240 12040 3260 12040 {}
C {lab_pin.sym} 3260 12040 0 0 {name=l9684 lab=VDD}
N 3240 11960 3260 11960 {}
C {lab_pin.sym} 3260 11960 0 0 {name=l9685 lab=VSS}
C {bitcell_6t.sym} 3400 12000 0 0 {name=Xr60c17}
N 3360 12040 3340 12040 {}
C {lab_pin.sym} 3340 12040 0 0 {name=l9686 lab=BL17}
N 3360 12000 3340 12000 {}
C {lab_pin.sym} 3340 12000 0 0 {name=l9687 lab=BLB17}
N 3360 11960 3340 11960 {}
C {lab_pin.sym} 3340 11960 0 0 {name=l9688 lab=WL60}
N 3440 12040 3460 12040 {}
C {lab_pin.sym} 3460 12040 0 0 {name=l9689 lab=VDD}
N 3440 11960 3460 11960 {}
C {lab_pin.sym} 3460 11960 0 0 {name=l9690 lab=VSS}
C {bitcell_6t.sym} 3600 12000 0 0 {name=Xr60c18}
N 3560 12040 3540 12040 {}
C {lab_pin.sym} 3540 12040 0 0 {name=l9691 lab=BL18}
N 3560 12000 3540 12000 {}
C {lab_pin.sym} 3540 12000 0 0 {name=l9692 lab=BLB18}
N 3560 11960 3540 11960 {}
C {lab_pin.sym} 3540 11960 0 0 {name=l9693 lab=WL60}
N 3640 12040 3660 12040 {}
C {lab_pin.sym} 3660 12040 0 0 {name=l9694 lab=VDD}
N 3640 11960 3660 11960 {}
C {lab_pin.sym} 3660 11960 0 0 {name=l9695 lab=VSS}
C {bitcell_6t.sym} 3800 12000 0 0 {name=Xr60c19}
N 3760 12040 3740 12040 {}
C {lab_pin.sym} 3740 12040 0 0 {name=l9696 lab=BL19}
N 3760 12000 3740 12000 {}
C {lab_pin.sym} 3740 12000 0 0 {name=l9697 lab=BLB19}
N 3760 11960 3740 11960 {}
C {lab_pin.sym} 3740 11960 0 0 {name=l9698 lab=WL60}
N 3840 12040 3860 12040 {}
C {lab_pin.sym} 3860 12040 0 0 {name=l9699 lab=VDD}
N 3840 11960 3860 11960 {}
C {lab_pin.sym} 3860 11960 0 0 {name=l9700 lab=VSS}
C {bitcell_6t.sym} 4000 12000 0 0 {name=Xr60c20}
N 3960 12040 3940 12040 {}
C {lab_pin.sym} 3940 12040 0 0 {name=l9701 lab=BL20}
N 3960 12000 3940 12000 {}
C {lab_pin.sym} 3940 12000 0 0 {name=l9702 lab=BLB20}
N 3960 11960 3940 11960 {}
C {lab_pin.sym} 3940 11960 0 0 {name=l9703 lab=WL60}
N 4040 12040 4060 12040 {}
C {lab_pin.sym} 4060 12040 0 0 {name=l9704 lab=VDD}
N 4040 11960 4060 11960 {}
C {lab_pin.sym} 4060 11960 0 0 {name=l9705 lab=VSS}
C {bitcell_6t.sym} 4200 12000 0 0 {name=Xr60c21}
N 4160 12040 4140 12040 {}
C {lab_pin.sym} 4140 12040 0 0 {name=l9706 lab=BL21}
N 4160 12000 4140 12000 {}
C {lab_pin.sym} 4140 12000 0 0 {name=l9707 lab=BLB21}
N 4160 11960 4140 11960 {}
C {lab_pin.sym} 4140 11960 0 0 {name=l9708 lab=WL60}
N 4240 12040 4260 12040 {}
C {lab_pin.sym} 4260 12040 0 0 {name=l9709 lab=VDD}
N 4240 11960 4260 11960 {}
C {lab_pin.sym} 4260 11960 0 0 {name=l9710 lab=VSS}
C {bitcell_6t.sym} 4400 12000 0 0 {name=Xr60c22}
N 4360 12040 4340 12040 {}
C {lab_pin.sym} 4340 12040 0 0 {name=l9711 lab=BL22}
N 4360 12000 4340 12000 {}
C {lab_pin.sym} 4340 12000 0 0 {name=l9712 lab=BLB22}
N 4360 11960 4340 11960 {}
C {lab_pin.sym} 4340 11960 0 0 {name=l9713 lab=WL60}
N 4440 12040 4460 12040 {}
C {lab_pin.sym} 4460 12040 0 0 {name=l9714 lab=VDD}
N 4440 11960 4460 11960 {}
C {lab_pin.sym} 4460 11960 0 0 {name=l9715 lab=VSS}
C {bitcell_6t.sym} 4600 12000 0 0 {name=Xr60c23}
N 4560 12040 4540 12040 {}
C {lab_pin.sym} 4540 12040 0 0 {name=l9716 lab=BL23}
N 4560 12000 4540 12000 {}
C {lab_pin.sym} 4540 12000 0 0 {name=l9717 lab=BLB23}
N 4560 11960 4540 11960 {}
C {lab_pin.sym} 4540 11960 0 0 {name=l9718 lab=WL60}
N 4640 12040 4660 12040 {}
C {lab_pin.sym} 4660 12040 0 0 {name=l9719 lab=VDD}
N 4640 11960 4660 11960 {}
C {lab_pin.sym} 4660 11960 0 0 {name=l9720 lab=VSS}
C {bitcell_6t.sym} 4800 12000 0 0 {name=Xr60c24}
N 4760 12040 4740 12040 {}
C {lab_pin.sym} 4740 12040 0 0 {name=l9721 lab=BL24}
N 4760 12000 4740 12000 {}
C {lab_pin.sym} 4740 12000 0 0 {name=l9722 lab=BLB24}
N 4760 11960 4740 11960 {}
C {lab_pin.sym} 4740 11960 0 0 {name=l9723 lab=WL60}
N 4840 12040 4860 12040 {}
C {lab_pin.sym} 4860 12040 0 0 {name=l9724 lab=VDD}
N 4840 11960 4860 11960 {}
C {lab_pin.sym} 4860 11960 0 0 {name=l9725 lab=VSS}
C {bitcell_6t.sym} 5000 12000 0 0 {name=Xr60c25}
N 4960 12040 4940 12040 {}
C {lab_pin.sym} 4940 12040 0 0 {name=l9726 lab=BL25}
N 4960 12000 4940 12000 {}
C {lab_pin.sym} 4940 12000 0 0 {name=l9727 lab=BLB25}
N 4960 11960 4940 11960 {}
C {lab_pin.sym} 4940 11960 0 0 {name=l9728 lab=WL60}
N 5040 12040 5060 12040 {}
C {lab_pin.sym} 5060 12040 0 0 {name=l9729 lab=VDD}
N 5040 11960 5060 11960 {}
C {lab_pin.sym} 5060 11960 0 0 {name=l9730 lab=VSS}
C {bitcell_6t.sym} 5200 12000 0 0 {name=Xr60c26}
N 5160 12040 5140 12040 {}
C {lab_pin.sym} 5140 12040 0 0 {name=l9731 lab=BL26}
N 5160 12000 5140 12000 {}
C {lab_pin.sym} 5140 12000 0 0 {name=l9732 lab=BLB26}
N 5160 11960 5140 11960 {}
C {lab_pin.sym} 5140 11960 0 0 {name=l9733 lab=WL60}
N 5240 12040 5260 12040 {}
C {lab_pin.sym} 5260 12040 0 0 {name=l9734 lab=VDD}
N 5240 11960 5260 11960 {}
C {lab_pin.sym} 5260 11960 0 0 {name=l9735 lab=VSS}
C {bitcell_6t.sym} 5400 12000 0 0 {name=Xr60c27}
N 5360 12040 5340 12040 {}
C {lab_pin.sym} 5340 12040 0 0 {name=l9736 lab=BL27}
N 5360 12000 5340 12000 {}
C {lab_pin.sym} 5340 12000 0 0 {name=l9737 lab=BLB27}
N 5360 11960 5340 11960 {}
C {lab_pin.sym} 5340 11960 0 0 {name=l9738 lab=WL60}
N 5440 12040 5460 12040 {}
C {lab_pin.sym} 5460 12040 0 0 {name=l9739 lab=VDD}
N 5440 11960 5460 11960 {}
C {lab_pin.sym} 5460 11960 0 0 {name=l9740 lab=VSS}
C {bitcell_6t.sym} 5600 12000 0 0 {name=Xr60c28}
N 5560 12040 5540 12040 {}
C {lab_pin.sym} 5540 12040 0 0 {name=l9741 lab=BL28}
N 5560 12000 5540 12000 {}
C {lab_pin.sym} 5540 12000 0 0 {name=l9742 lab=BLB28}
N 5560 11960 5540 11960 {}
C {lab_pin.sym} 5540 11960 0 0 {name=l9743 lab=WL60}
N 5640 12040 5660 12040 {}
C {lab_pin.sym} 5660 12040 0 0 {name=l9744 lab=VDD}
N 5640 11960 5660 11960 {}
C {lab_pin.sym} 5660 11960 0 0 {name=l9745 lab=VSS}
C {bitcell_6t.sym} 5800 12000 0 0 {name=Xr60c29}
N 5760 12040 5740 12040 {}
C {lab_pin.sym} 5740 12040 0 0 {name=l9746 lab=BL29}
N 5760 12000 5740 12000 {}
C {lab_pin.sym} 5740 12000 0 0 {name=l9747 lab=BLB29}
N 5760 11960 5740 11960 {}
C {lab_pin.sym} 5740 11960 0 0 {name=l9748 lab=WL60}
N 5840 12040 5860 12040 {}
C {lab_pin.sym} 5860 12040 0 0 {name=l9749 lab=VDD}
N 5840 11960 5860 11960 {}
C {lab_pin.sym} 5860 11960 0 0 {name=l9750 lab=VSS}
C {bitcell_6t.sym} 6000 12000 0 0 {name=Xr60c30}
N 5960 12040 5940 12040 {}
C {lab_pin.sym} 5940 12040 0 0 {name=l9751 lab=BL30}
N 5960 12000 5940 12000 {}
C {lab_pin.sym} 5940 12000 0 0 {name=l9752 lab=BLB30}
N 5960 11960 5940 11960 {}
C {lab_pin.sym} 5940 11960 0 0 {name=l9753 lab=WL60}
N 6040 12040 6060 12040 {}
C {lab_pin.sym} 6060 12040 0 0 {name=l9754 lab=VDD}
N 6040 11960 6060 11960 {}
C {lab_pin.sym} 6060 11960 0 0 {name=l9755 lab=VSS}
C {bitcell_6t.sym} 6200 12000 0 0 {name=Xr60c31}
N 6160 12040 6140 12040 {}
C {lab_pin.sym} 6140 12040 0 0 {name=l9756 lab=BL31}
N 6160 12000 6140 12000 {}
C {lab_pin.sym} 6140 12000 0 0 {name=l9757 lab=BLB31}
N 6160 11960 6140 11960 {}
C {lab_pin.sym} 6140 11960 0 0 {name=l9758 lab=WL60}
N 6240 12040 6260 12040 {}
C {lab_pin.sym} 6260 12040 0 0 {name=l9759 lab=VDD}
N 6240 11960 6260 11960 {}
C {lab_pin.sym} 6260 11960 0 0 {name=l9760 lab=VSS}
C {bitcell_6t.sym} 0 12200 0 0 {name=Xr61c0}
N -40 12240 -60 12240 {}
C {lab_pin.sym} -60 12240 0 0 {name=l9761 lab=BL0}
N -40 12200 -60 12200 {}
C {lab_pin.sym} -60 12200 0 0 {name=l9762 lab=BLB0}
N -40 12160 -60 12160 {}
C {lab_pin.sym} -60 12160 0 0 {name=l9763 lab=WL61}
N 40 12240 60 12240 {}
C {lab_pin.sym} 60 12240 0 0 {name=l9764 lab=VDD}
N 40 12160 60 12160 {}
C {lab_pin.sym} 60 12160 0 0 {name=l9765 lab=VSS}
C {bitcell_6t.sym} 200 12200 0 0 {name=Xr61c1}
N 160 12240 140 12240 {}
C {lab_pin.sym} 140 12240 0 0 {name=l9766 lab=BL1}
N 160 12200 140 12200 {}
C {lab_pin.sym} 140 12200 0 0 {name=l9767 lab=BLB1}
N 160 12160 140 12160 {}
C {lab_pin.sym} 140 12160 0 0 {name=l9768 lab=WL61}
N 240 12240 260 12240 {}
C {lab_pin.sym} 260 12240 0 0 {name=l9769 lab=VDD}
N 240 12160 260 12160 {}
C {lab_pin.sym} 260 12160 0 0 {name=l9770 lab=VSS}
C {bitcell_6t.sym} 400 12200 0 0 {name=Xr61c2}
N 360 12240 340 12240 {}
C {lab_pin.sym} 340 12240 0 0 {name=l9771 lab=BL2}
N 360 12200 340 12200 {}
C {lab_pin.sym} 340 12200 0 0 {name=l9772 lab=BLB2}
N 360 12160 340 12160 {}
C {lab_pin.sym} 340 12160 0 0 {name=l9773 lab=WL61}
N 440 12240 460 12240 {}
C {lab_pin.sym} 460 12240 0 0 {name=l9774 lab=VDD}
N 440 12160 460 12160 {}
C {lab_pin.sym} 460 12160 0 0 {name=l9775 lab=VSS}
C {bitcell_6t.sym} 600 12200 0 0 {name=Xr61c3}
N 560 12240 540 12240 {}
C {lab_pin.sym} 540 12240 0 0 {name=l9776 lab=BL3}
N 560 12200 540 12200 {}
C {lab_pin.sym} 540 12200 0 0 {name=l9777 lab=BLB3}
N 560 12160 540 12160 {}
C {lab_pin.sym} 540 12160 0 0 {name=l9778 lab=WL61}
N 640 12240 660 12240 {}
C {lab_pin.sym} 660 12240 0 0 {name=l9779 lab=VDD}
N 640 12160 660 12160 {}
C {lab_pin.sym} 660 12160 0 0 {name=l9780 lab=VSS}
C {bitcell_6t.sym} 800 12200 0 0 {name=Xr61c4}
N 760 12240 740 12240 {}
C {lab_pin.sym} 740 12240 0 0 {name=l9781 lab=BL4}
N 760 12200 740 12200 {}
C {lab_pin.sym} 740 12200 0 0 {name=l9782 lab=BLB4}
N 760 12160 740 12160 {}
C {lab_pin.sym} 740 12160 0 0 {name=l9783 lab=WL61}
N 840 12240 860 12240 {}
C {lab_pin.sym} 860 12240 0 0 {name=l9784 lab=VDD}
N 840 12160 860 12160 {}
C {lab_pin.sym} 860 12160 0 0 {name=l9785 lab=VSS}
C {bitcell_6t.sym} 1000 12200 0 0 {name=Xr61c5}
N 960 12240 940 12240 {}
C {lab_pin.sym} 940 12240 0 0 {name=l9786 lab=BL5}
N 960 12200 940 12200 {}
C {lab_pin.sym} 940 12200 0 0 {name=l9787 lab=BLB5}
N 960 12160 940 12160 {}
C {lab_pin.sym} 940 12160 0 0 {name=l9788 lab=WL61}
N 1040 12240 1060 12240 {}
C {lab_pin.sym} 1060 12240 0 0 {name=l9789 lab=VDD}
N 1040 12160 1060 12160 {}
C {lab_pin.sym} 1060 12160 0 0 {name=l9790 lab=VSS}
C {bitcell_6t.sym} 1200 12200 0 0 {name=Xr61c6}
N 1160 12240 1140 12240 {}
C {lab_pin.sym} 1140 12240 0 0 {name=l9791 lab=BL6}
N 1160 12200 1140 12200 {}
C {lab_pin.sym} 1140 12200 0 0 {name=l9792 lab=BLB6}
N 1160 12160 1140 12160 {}
C {lab_pin.sym} 1140 12160 0 0 {name=l9793 lab=WL61}
N 1240 12240 1260 12240 {}
C {lab_pin.sym} 1260 12240 0 0 {name=l9794 lab=VDD}
N 1240 12160 1260 12160 {}
C {lab_pin.sym} 1260 12160 0 0 {name=l9795 lab=VSS}
C {bitcell_6t.sym} 1400 12200 0 0 {name=Xr61c7}
N 1360 12240 1340 12240 {}
C {lab_pin.sym} 1340 12240 0 0 {name=l9796 lab=BL7}
N 1360 12200 1340 12200 {}
C {lab_pin.sym} 1340 12200 0 0 {name=l9797 lab=BLB7}
N 1360 12160 1340 12160 {}
C {lab_pin.sym} 1340 12160 0 0 {name=l9798 lab=WL61}
N 1440 12240 1460 12240 {}
C {lab_pin.sym} 1460 12240 0 0 {name=l9799 lab=VDD}
N 1440 12160 1460 12160 {}
C {lab_pin.sym} 1460 12160 0 0 {name=l9800 lab=VSS}
C {bitcell_6t.sym} 1600 12200 0 0 {name=Xr61c8}
N 1560 12240 1540 12240 {}
C {lab_pin.sym} 1540 12240 0 0 {name=l9801 lab=BL8}
N 1560 12200 1540 12200 {}
C {lab_pin.sym} 1540 12200 0 0 {name=l9802 lab=BLB8}
N 1560 12160 1540 12160 {}
C {lab_pin.sym} 1540 12160 0 0 {name=l9803 lab=WL61}
N 1640 12240 1660 12240 {}
C {lab_pin.sym} 1660 12240 0 0 {name=l9804 lab=VDD}
N 1640 12160 1660 12160 {}
C {lab_pin.sym} 1660 12160 0 0 {name=l9805 lab=VSS}
C {bitcell_6t.sym} 1800 12200 0 0 {name=Xr61c9}
N 1760 12240 1740 12240 {}
C {lab_pin.sym} 1740 12240 0 0 {name=l9806 lab=BL9}
N 1760 12200 1740 12200 {}
C {lab_pin.sym} 1740 12200 0 0 {name=l9807 lab=BLB9}
N 1760 12160 1740 12160 {}
C {lab_pin.sym} 1740 12160 0 0 {name=l9808 lab=WL61}
N 1840 12240 1860 12240 {}
C {lab_pin.sym} 1860 12240 0 0 {name=l9809 lab=VDD}
N 1840 12160 1860 12160 {}
C {lab_pin.sym} 1860 12160 0 0 {name=l9810 lab=VSS}
C {bitcell_6t.sym} 2000 12200 0 0 {name=Xr61c10}
N 1960 12240 1940 12240 {}
C {lab_pin.sym} 1940 12240 0 0 {name=l9811 lab=BL10}
N 1960 12200 1940 12200 {}
C {lab_pin.sym} 1940 12200 0 0 {name=l9812 lab=BLB10}
N 1960 12160 1940 12160 {}
C {lab_pin.sym} 1940 12160 0 0 {name=l9813 lab=WL61}
N 2040 12240 2060 12240 {}
C {lab_pin.sym} 2060 12240 0 0 {name=l9814 lab=VDD}
N 2040 12160 2060 12160 {}
C {lab_pin.sym} 2060 12160 0 0 {name=l9815 lab=VSS}
C {bitcell_6t.sym} 2200 12200 0 0 {name=Xr61c11}
N 2160 12240 2140 12240 {}
C {lab_pin.sym} 2140 12240 0 0 {name=l9816 lab=BL11}
N 2160 12200 2140 12200 {}
C {lab_pin.sym} 2140 12200 0 0 {name=l9817 lab=BLB11}
N 2160 12160 2140 12160 {}
C {lab_pin.sym} 2140 12160 0 0 {name=l9818 lab=WL61}
N 2240 12240 2260 12240 {}
C {lab_pin.sym} 2260 12240 0 0 {name=l9819 lab=VDD}
N 2240 12160 2260 12160 {}
C {lab_pin.sym} 2260 12160 0 0 {name=l9820 lab=VSS}
C {bitcell_6t.sym} 2400 12200 0 0 {name=Xr61c12}
N 2360 12240 2340 12240 {}
C {lab_pin.sym} 2340 12240 0 0 {name=l9821 lab=BL12}
N 2360 12200 2340 12200 {}
C {lab_pin.sym} 2340 12200 0 0 {name=l9822 lab=BLB12}
N 2360 12160 2340 12160 {}
C {lab_pin.sym} 2340 12160 0 0 {name=l9823 lab=WL61}
N 2440 12240 2460 12240 {}
C {lab_pin.sym} 2460 12240 0 0 {name=l9824 lab=VDD}
N 2440 12160 2460 12160 {}
C {lab_pin.sym} 2460 12160 0 0 {name=l9825 lab=VSS}
C {bitcell_6t.sym} 2600 12200 0 0 {name=Xr61c13}
N 2560 12240 2540 12240 {}
C {lab_pin.sym} 2540 12240 0 0 {name=l9826 lab=BL13}
N 2560 12200 2540 12200 {}
C {lab_pin.sym} 2540 12200 0 0 {name=l9827 lab=BLB13}
N 2560 12160 2540 12160 {}
C {lab_pin.sym} 2540 12160 0 0 {name=l9828 lab=WL61}
N 2640 12240 2660 12240 {}
C {lab_pin.sym} 2660 12240 0 0 {name=l9829 lab=VDD}
N 2640 12160 2660 12160 {}
C {lab_pin.sym} 2660 12160 0 0 {name=l9830 lab=VSS}
C {bitcell_6t.sym} 2800 12200 0 0 {name=Xr61c14}
N 2760 12240 2740 12240 {}
C {lab_pin.sym} 2740 12240 0 0 {name=l9831 lab=BL14}
N 2760 12200 2740 12200 {}
C {lab_pin.sym} 2740 12200 0 0 {name=l9832 lab=BLB14}
N 2760 12160 2740 12160 {}
C {lab_pin.sym} 2740 12160 0 0 {name=l9833 lab=WL61}
N 2840 12240 2860 12240 {}
C {lab_pin.sym} 2860 12240 0 0 {name=l9834 lab=VDD}
N 2840 12160 2860 12160 {}
C {lab_pin.sym} 2860 12160 0 0 {name=l9835 lab=VSS}
C {bitcell_6t.sym} 3000 12200 0 0 {name=Xr61c15}
N 2960 12240 2940 12240 {}
C {lab_pin.sym} 2940 12240 0 0 {name=l9836 lab=BL15}
N 2960 12200 2940 12200 {}
C {lab_pin.sym} 2940 12200 0 0 {name=l9837 lab=BLB15}
N 2960 12160 2940 12160 {}
C {lab_pin.sym} 2940 12160 0 0 {name=l9838 lab=WL61}
N 3040 12240 3060 12240 {}
C {lab_pin.sym} 3060 12240 0 0 {name=l9839 lab=VDD}
N 3040 12160 3060 12160 {}
C {lab_pin.sym} 3060 12160 0 0 {name=l9840 lab=VSS}
C {bitcell_6t.sym} 3200 12200 0 0 {name=Xr61c16}
N 3160 12240 3140 12240 {}
C {lab_pin.sym} 3140 12240 0 0 {name=l9841 lab=BL16}
N 3160 12200 3140 12200 {}
C {lab_pin.sym} 3140 12200 0 0 {name=l9842 lab=BLB16}
N 3160 12160 3140 12160 {}
C {lab_pin.sym} 3140 12160 0 0 {name=l9843 lab=WL61}
N 3240 12240 3260 12240 {}
C {lab_pin.sym} 3260 12240 0 0 {name=l9844 lab=VDD}
N 3240 12160 3260 12160 {}
C {lab_pin.sym} 3260 12160 0 0 {name=l9845 lab=VSS}
C {bitcell_6t.sym} 3400 12200 0 0 {name=Xr61c17}
N 3360 12240 3340 12240 {}
C {lab_pin.sym} 3340 12240 0 0 {name=l9846 lab=BL17}
N 3360 12200 3340 12200 {}
C {lab_pin.sym} 3340 12200 0 0 {name=l9847 lab=BLB17}
N 3360 12160 3340 12160 {}
C {lab_pin.sym} 3340 12160 0 0 {name=l9848 lab=WL61}
N 3440 12240 3460 12240 {}
C {lab_pin.sym} 3460 12240 0 0 {name=l9849 lab=VDD}
N 3440 12160 3460 12160 {}
C {lab_pin.sym} 3460 12160 0 0 {name=l9850 lab=VSS}
C {bitcell_6t.sym} 3600 12200 0 0 {name=Xr61c18}
N 3560 12240 3540 12240 {}
C {lab_pin.sym} 3540 12240 0 0 {name=l9851 lab=BL18}
N 3560 12200 3540 12200 {}
C {lab_pin.sym} 3540 12200 0 0 {name=l9852 lab=BLB18}
N 3560 12160 3540 12160 {}
C {lab_pin.sym} 3540 12160 0 0 {name=l9853 lab=WL61}
N 3640 12240 3660 12240 {}
C {lab_pin.sym} 3660 12240 0 0 {name=l9854 lab=VDD}
N 3640 12160 3660 12160 {}
C {lab_pin.sym} 3660 12160 0 0 {name=l9855 lab=VSS}
C {bitcell_6t.sym} 3800 12200 0 0 {name=Xr61c19}
N 3760 12240 3740 12240 {}
C {lab_pin.sym} 3740 12240 0 0 {name=l9856 lab=BL19}
N 3760 12200 3740 12200 {}
C {lab_pin.sym} 3740 12200 0 0 {name=l9857 lab=BLB19}
N 3760 12160 3740 12160 {}
C {lab_pin.sym} 3740 12160 0 0 {name=l9858 lab=WL61}
N 3840 12240 3860 12240 {}
C {lab_pin.sym} 3860 12240 0 0 {name=l9859 lab=VDD}
N 3840 12160 3860 12160 {}
C {lab_pin.sym} 3860 12160 0 0 {name=l9860 lab=VSS}
C {bitcell_6t.sym} 4000 12200 0 0 {name=Xr61c20}
N 3960 12240 3940 12240 {}
C {lab_pin.sym} 3940 12240 0 0 {name=l9861 lab=BL20}
N 3960 12200 3940 12200 {}
C {lab_pin.sym} 3940 12200 0 0 {name=l9862 lab=BLB20}
N 3960 12160 3940 12160 {}
C {lab_pin.sym} 3940 12160 0 0 {name=l9863 lab=WL61}
N 4040 12240 4060 12240 {}
C {lab_pin.sym} 4060 12240 0 0 {name=l9864 lab=VDD}
N 4040 12160 4060 12160 {}
C {lab_pin.sym} 4060 12160 0 0 {name=l9865 lab=VSS}
C {bitcell_6t.sym} 4200 12200 0 0 {name=Xr61c21}
N 4160 12240 4140 12240 {}
C {lab_pin.sym} 4140 12240 0 0 {name=l9866 lab=BL21}
N 4160 12200 4140 12200 {}
C {lab_pin.sym} 4140 12200 0 0 {name=l9867 lab=BLB21}
N 4160 12160 4140 12160 {}
C {lab_pin.sym} 4140 12160 0 0 {name=l9868 lab=WL61}
N 4240 12240 4260 12240 {}
C {lab_pin.sym} 4260 12240 0 0 {name=l9869 lab=VDD}
N 4240 12160 4260 12160 {}
C {lab_pin.sym} 4260 12160 0 0 {name=l9870 lab=VSS}
C {bitcell_6t.sym} 4400 12200 0 0 {name=Xr61c22}
N 4360 12240 4340 12240 {}
C {lab_pin.sym} 4340 12240 0 0 {name=l9871 lab=BL22}
N 4360 12200 4340 12200 {}
C {lab_pin.sym} 4340 12200 0 0 {name=l9872 lab=BLB22}
N 4360 12160 4340 12160 {}
C {lab_pin.sym} 4340 12160 0 0 {name=l9873 lab=WL61}
N 4440 12240 4460 12240 {}
C {lab_pin.sym} 4460 12240 0 0 {name=l9874 lab=VDD}
N 4440 12160 4460 12160 {}
C {lab_pin.sym} 4460 12160 0 0 {name=l9875 lab=VSS}
C {bitcell_6t.sym} 4600 12200 0 0 {name=Xr61c23}
N 4560 12240 4540 12240 {}
C {lab_pin.sym} 4540 12240 0 0 {name=l9876 lab=BL23}
N 4560 12200 4540 12200 {}
C {lab_pin.sym} 4540 12200 0 0 {name=l9877 lab=BLB23}
N 4560 12160 4540 12160 {}
C {lab_pin.sym} 4540 12160 0 0 {name=l9878 lab=WL61}
N 4640 12240 4660 12240 {}
C {lab_pin.sym} 4660 12240 0 0 {name=l9879 lab=VDD}
N 4640 12160 4660 12160 {}
C {lab_pin.sym} 4660 12160 0 0 {name=l9880 lab=VSS}
C {bitcell_6t.sym} 4800 12200 0 0 {name=Xr61c24}
N 4760 12240 4740 12240 {}
C {lab_pin.sym} 4740 12240 0 0 {name=l9881 lab=BL24}
N 4760 12200 4740 12200 {}
C {lab_pin.sym} 4740 12200 0 0 {name=l9882 lab=BLB24}
N 4760 12160 4740 12160 {}
C {lab_pin.sym} 4740 12160 0 0 {name=l9883 lab=WL61}
N 4840 12240 4860 12240 {}
C {lab_pin.sym} 4860 12240 0 0 {name=l9884 lab=VDD}
N 4840 12160 4860 12160 {}
C {lab_pin.sym} 4860 12160 0 0 {name=l9885 lab=VSS}
C {bitcell_6t.sym} 5000 12200 0 0 {name=Xr61c25}
N 4960 12240 4940 12240 {}
C {lab_pin.sym} 4940 12240 0 0 {name=l9886 lab=BL25}
N 4960 12200 4940 12200 {}
C {lab_pin.sym} 4940 12200 0 0 {name=l9887 lab=BLB25}
N 4960 12160 4940 12160 {}
C {lab_pin.sym} 4940 12160 0 0 {name=l9888 lab=WL61}
N 5040 12240 5060 12240 {}
C {lab_pin.sym} 5060 12240 0 0 {name=l9889 lab=VDD}
N 5040 12160 5060 12160 {}
C {lab_pin.sym} 5060 12160 0 0 {name=l9890 lab=VSS}
C {bitcell_6t.sym} 5200 12200 0 0 {name=Xr61c26}
N 5160 12240 5140 12240 {}
C {lab_pin.sym} 5140 12240 0 0 {name=l9891 lab=BL26}
N 5160 12200 5140 12200 {}
C {lab_pin.sym} 5140 12200 0 0 {name=l9892 lab=BLB26}
N 5160 12160 5140 12160 {}
C {lab_pin.sym} 5140 12160 0 0 {name=l9893 lab=WL61}
N 5240 12240 5260 12240 {}
C {lab_pin.sym} 5260 12240 0 0 {name=l9894 lab=VDD}
N 5240 12160 5260 12160 {}
C {lab_pin.sym} 5260 12160 0 0 {name=l9895 lab=VSS}
C {bitcell_6t.sym} 5400 12200 0 0 {name=Xr61c27}
N 5360 12240 5340 12240 {}
C {lab_pin.sym} 5340 12240 0 0 {name=l9896 lab=BL27}
N 5360 12200 5340 12200 {}
C {lab_pin.sym} 5340 12200 0 0 {name=l9897 lab=BLB27}
N 5360 12160 5340 12160 {}
C {lab_pin.sym} 5340 12160 0 0 {name=l9898 lab=WL61}
N 5440 12240 5460 12240 {}
C {lab_pin.sym} 5460 12240 0 0 {name=l9899 lab=VDD}
N 5440 12160 5460 12160 {}
C {lab_pin.sym} 5460 12160 0 0 {name=l9900 lab=VSS}
C {bitcell_6t.sym} 5600 12200 0 0 {name=Xr61c28}
N 5560 12240 5540 12240 {}
C {lab_pin.sym} 5540 12240 0 0 {name=l9901 lab=BL28}
N 5560 12200 5540 12200 {}
C {lab_pin.sym} 5540 12200 0 0 {name=l9902 lab=BLB28}
N 5560 12160 5540 12160 {}
C {lab_pin.sym} 5540 12160 0 0 {name=l9903 lab=WL61}
N 5640 12240 5660 12240 {}
C {lab_pin.sym} 5660 12240 0 0 {name=l9904 lab=VDD}
N 5640 12160 5660 12160 {}
C {lab_pin.sym} 5660 12160 0 0 {name=l9905 lab=VSS}
C {bitcell_6t.sym} 5800 12200 0 0 {name=Xr61c29}
N 5760 12240 5740 12240 {}
C {lab_pin.sym} 5740 12240 0 0 {name=l9906 lab=BL29}
N 5760 12200 5740 12200 {}
C {lab_pin.sym} 5740 12200 0 0 {name=l9907 lab=BLB29}
N 5760 12160 5740 12160 {}
C {lab_pin.sym} 5740 12160 0 0 {name=l9908 lab=WL61}
N 5840 12240 5860 12240 {}
C {lab_pin.sym} 5860 12240 0 0 {name=l9909 lab=VDD}
N 5840 12160 5860 12160 {}
C {lab_pin.sym} 5860 12160 0 0 {name=l9910 lab=VSS}
C {bitcell_6t.sym} 6000 12200 0 0 {name=Xr61c30}
N 5960 12240 5940 12240 {}
C {lab_pin.sym} 5940 12240 0 0 {name=l9911 lab=BL30}
N 5960 12200 5940 12200 {}
C {lab_pin.sym} 5940 12200 0 0 {name=l9912 lab=BLB30}
N 5960 12160 5940 12160 {}
C {lab_pin.sym} 5940 12160 0 0 {name=l9913 lab=WL61}
N 6040 12240 6060 12240 {}
C {lab_pin.sym} 6060 12240 0 0 {name=l9914 lab=VDD}
N 6040 12160 6060 12160 {}
C {lab_pin.sym} 6060 12160 0 0 {name=l9915 lab=VSS}
C {bitcell_6t.sym} 6200 12200 0 0 {name=Xr61c31}
N 6160 12240 6140 12240 {}
C {lab_pin.sym} 6140 12240 0 0 {name=l9916 lab=BL31}
N 6160 12200 6140 12200 {}
C {lab_pin.sym} 6140 12200 0 0 {name=l9917 lab=BLB31}
N 6160 12160 6140 12160 {}
C {lab_pin.sym} 6140 12160 0 0 {name=l9918 lab=WL61}
N 6240 12240 6260 12240 {}
C {lab_pin.sym} 6260 12240 0 0 {name=l9919 lab=VDD}
N 6240 12160 6260 12160 {}
C {lab_pin.sym} 6260 12160 0 0 {name=l9920 lab=VSS}
C {bitcell_6t.sym} 0 12400 0 0 {name=Xr62c0}
N -40 12440 -60 12440 {}
C {lab_pin.sym} -60 12440 0 0 {name=l9921 lab=BL0}
N -40 12400 -60 12400 {}
C {lab_pin.sym} -60 12400 0 0 {name=l9922 lab=BLB0}
N -40 12360 -60 12360 {}
C {lab_pin.sym} -60 12360 0 0 {name=l9923 lab=WL62}
N 40 12440 60 12440 {}
C {lab_pin.sym} 60 12440 0 0 {name=l9924 lab=VDD}
N 40 12360 60 12360 {}
C {lab_pin.sym} 60 12360 0 0 {name=l9925 lab=VSS}
C {bitcell_6t.sym} 200 12400 0 0 {name=Xr62c1}
N 160 12440 140 12440 {}
C {lab_pin.sym} 140 12440 0 0 {name=l9926 lab=BL1}
N 160 12400 140 12400 {}
C {lab_pin.sym} 140 12400 0 0 {name=l9927 lab=BLB1}
N 160 12360 140 12360 {}
C {lab_pin.sym} 140 12360 0 0 {name=l9928 lab=WL62}
N 240 12440 260 12440 {}
C {lab_pin.sym} 260 12440 0 0 {name=l9929 lab=VDD}
N 240 12360 260 12360 {}
C {lab_pin.sym} 260 12360 0 0 {name=l9930 lab=VSS}
C {bitcell_6t.sym} 400 12400 0 0 {name=Xr62c2}
N 360 12440 340 12440 {}
C {lab_pin.sym} 340 12440 0 0 {name=l9931 lab=BL2}
N 360 12400 340 12400 {}
C {lab_pin.sym} 340 12400 0 0 {name=l9932 lab=BLB2}
N 360 12360 340 12360 {}
C {lab_pin.sym} 340 12360 0 0 {name=l9933 lab=WL62}
N 440 12440 460 12440 {}
C {lab_pin.sym} 460 12440 0 0 {name=l9934 lab=VDD}
N 440 12360 460 12360 {}
C {lab_pin.sym} 460 12360 0 0 {name=l9935 lab=VSS}
C {bitcell_6t.sym} 600 12400 0 0 {name=Xr62c3}
N 560 12440 540 12440 {}
C {lab_pin.sym} 540 12440 0 0 {name=l9936 lab=BL3}
N 560 12400 540 12400 {}
C {lab_pin.sym} 540 12400 0 0 {name=l9937 lab=BLB3}
N 560 12360 540 12360 {}
C {lab_pin.sym} 540 12360 0 0 {name=l9938 lab=WL62}
N 640 12440 660 12440 {}
C {lab_pin.sym} 660 12440 0 0 {name=l9939 lab=VDD}
N 640 12360 660 12360 {}
C {lab_pin.sym} 660 12360 0 0 {name=l9940 lab=VSS}
C {bitcell_6t.sym} 800 12400 0 0 {name=Xr62c4}
N 760 12440 740 12440 {}
C {lab_pin.sym} 740 12440 0 0 {name=l9941 lab=BL4}
N 760 12400 740 12400 {}
C {lab_pin.sym} 740 12400 0 0 {name=l9942 lab=BLB4}
N 760 12360 740 12360 {}
C {lab_pin.sym} 740 12360 0 0 {name=l9943 lab=WL62}
N 840 12440 860 12440 {}
C {lab_pin.sym} 860 12440 0 0 {name=l9944 lab=VDD}
N 840 12360 860 12360 {}
C {lab_pin.sym} 860 12360 0 0 {name=l9945 lab=VSS}
C {bitcell_6t.sym} 1000 12400 0 0 {name=Xr62c5}
N 960 12440 940 12440 {}
C {lab_pin.sym} 940 12440 0 0 {name=l9946 lab=BL5}
N 960 12400 940 12400 {}
C {lab_pin.sym} 940 12400 0 0 {name=l9947 lab=BLB5}
N 960 12360 940 12360 {}
C {lab_pin.sym} 940 12360 0 0 {name=l9948 lab=WL62}
N 1040 12440 1060 12440 {}
C {lab_pin.sym} 1060 12440 0 0 {name=l9949 lab=VDD}
N 1040 12360 1060 12360 {}
C {lab_pin.sym} 1060 12360 0 0 {name=l9950 lab=VSS}
C {bitcell_6t.sym} 1200 12400 0 0 {name=Xr62c6}
N 1160 12440 1140 12440 {}
C {lab_pin.sym} 1140 12440 0 0 {name=l9951 lab=BL6}
N 1160 12400 1140 12400 {}
C {lab_pin.sym} 1140 12400 0 0 {name=l9952 lab=BLB6}
N 1160 12360 1140 12360 {}
C {lab_pin.sym} 1140 12360 0 0 {name=l9953 lab=WL62}
N 1240 12440 1260 12440 {}
C {lab_pin.sym} 1260 12440 0 0 {name=l9954 lab=VDD}
N 1240 12360 1260 12360 {}
C {lab_pin.sym} 1260 12360 0 0 {name=l9955 lab=VSS}
C {bitcell_6t.sym} 1400 12400 0 0 {name=Xr62c7}
N 1360 12440 1340 12440 {}
C {lab_pin.sym} 1340 12440 0 0 {name=l9956 lab=BL7}
N 1360 12400 1340 12400 {}
C {lab_pin.sym} 1340 12400 0 0 {name=l9957 lab=BLB7}
N 1360 12360 1340 12360 {}
C {lab_pin.sym} 1340 12360 0 0 {name=l9958 lab=WL62}
N 1440 12440 1460 12440 {}
C {lab_pin.sym} 1460 12440 0 0 {name=l9959 lab=VDD}
N 1440 12360 1460 12360 {}
C {lab_pin.sym} 1460 12360 0 0 {name=l9960 lab=VSS}
C {bitcell_6t.sym} 1600 12400 0 0 {name=Xr62c8}
N 1560 12440 1540 12440 {}
C {lab_pin.sym} 1540 12440 0 0 {name=l9961 lab=BL8}
N 1560 12400 1540 12400 {}
C {lab_pin.sym} 1540 12400 0 0 {name=l9962 lab=BLB8}
N 1560 12360 1540 12360 {}
C {lab_pin.sym} 1540 12360 0 0 {name=l9963 lab=WL62}
N 1640 12440 1660 12440 {}
C {lab_pin.sym} 1660 12440 0 0 {name=l9964 lab=VDD}
N 1640 12360 1660 12360 {}
C {lab_pin.sym} 1660 12360 0 0 {name=l9965 lab=VSS}
C {bitcell_6t.sym} 1800 12400 0 0 {name=Xr62c9}
N 1760 12440 1740 12440 {}
C {lab_pin.sym} 1740 12440 0 0 {name=l9966 lab=BL9}
N 1760 12400 1740 12400 {}
C {lab_pin.sym} 1740 12400 0 0 {name=l9967 lab=BLB9}
N 1760 12360 1740 12360 {}
C {lab_pin.sym} 1740 12360 0 0 {name=l9968 lab=WL62}
N 1840 12440 1860 12440 {}
C {lab_pin.sym} 1860 12440 0 0 {name=l9969 lab=VDD}
N 1840 12360 1860 12360 {}
C {lab_pin.sym} 1860 12360 0 0 {name=l9970 lab=VSS}
C {bitcell_6t.sym} 2000 12400 0 0 {name=Xr62c10}
N 1960 12440 1940 12440 {}
C {lab_pin.sym} 1940 12440 0 0 {name=l9971 lab=BL10}
N 1960 12400 1940 12400 {}
C {lab_pin.sym} 1940 12400 0 0 {name=l9972 lab=BLB10}
N 1960 12360 1940 12360 {}
C {lab_pin.sym} 1940 12360 0 0 {name=l9973 lab=WL62}
N 2040 12440 2060 12440 {}
C {lab_pin.sym} 2060 12440 0 0 {name=l9974 lab=VDD}
N 2040 12360 2060 12360 {}
C {lab_pin.sym} 2060 12360 0 0 {name=l9975 lab=VSS}
C {bitcell_6t.sym} 2200 12400 0 0 {name=Xr62c11}
N 2160 12440 2140 12440 {}
C {lab_pin.sym} 2140 12440 0 0 {name=l9976 lab=BL11}
N 2160 12400 2140 12400 {}
C {lab_pin.sym} 2140 12400 0 0 {name=l9977 lab=BLB11}
N 2160 12360 2140 12360 {}
C {lab_pin.sym} 2140 12360 0 0 {name=l9978 lab=WL62}
N 2240 12440 2260 12440 {}
C {lab_pin.sym} 2260 12440 0 0 {name=l9979 lab=VDD}
N 2240 12360 2260 12360 {}
C {lab_pin.sym} 2260 12360 0 0 {name=l9980 lab=VSS}
C {bitcell_6t.sym} 2400 12400 0 0 {name=Xr62c12}
N 2360 12440 2340 12440 {}
C {lab_pin.sym} 2340 12440 0 0 {name=l9981 lab=BL12}
N 2360 12400 2340 12400 {}
C {lab_pin.sym} 2340 12400 0 0 {name=l9982 lab=BLB12}
N 2360 12360 2340 12360 {}
C {lab_pin.sym} 2340 12360 0 0 {name=l9983 lab=WL62}
N 2440 12440 2460 12440 {}
C {lab_pin.sym} 2460 12440 0 0 {name=l9984 lab=VDD}
N 2440 12360 2460 12360 {}
C {lab_pin.sym} 2460 12360 0 0 {name=l9985 lab=VSS}
C {bitcell_6t.sym} 2600 12400 0 0 {name=Xr62c13}
N 2560 12440 2540 12440 {}
C {lab_pin.sym} 2540 12440 0 0 {name=l9986 lab=BL13}
N 2560 12400 2540 12400 {}
C {lab_pin.sym} 2540 12400 0 0 {name=l9987 lab=BLB13}
N 2560 12360 2540 12360 {}
C {lab_pin.sym} 2540 12360 0 0 {name=l9988 lab=WL62}
N 2640 12440 2660 12440 {}
C {lab_pin.sym} 2660 12440 0 0 {name=l9989 lab=VDD}
N 2640 12360 2660 12360 {}
C {lab_pin.sym} 2660 12360 0 0 {name=l9990 lab=VSS}
C {bitcell_6t.sym} 2800 12400 0 0 {name=Xr62c14}
N 2760 12440 2740 12440 {}
C {lab_pin.sym} 2740 12440 0 0 {name=l9991 lab=BL14}
N 2760 12400 2740 12400 {}
C {lab_pin.sym} 2740 12400 0 0 {name=l9992 lab=BLB14}
N 2760 12360 2740 12360 {}
C {lab_pin.sym} 2740 12360 0 0 {name=l9993 lab=WL62}
N 2840 12440 2860 12440 {}
C {lab_pin.sym} 2860 12440 0 0 {name=l9994 lab=VDD}
N 2840 12360 2860 12360 {}
C {lab_pin.sym} 2860 12360 0 0 {name=l9995 lab=VSS}
C {bitcell_6t.sym} 3000 12400 0 0 {name=Xr62c15}
N 2960 12440 2940 12440 {}
C {lab_pin.sym} 2940 12440 0 0 {name=l9996 lab=BL15}
N 2960 12400 2940 12400 {}
C {lab_pin.sym} 2940 12400 0 0 {name=l9997 lab=BLB15}
N 2960 12360 2940 12360 {}
C {lab_pin.sym} 2940 12360 0 0 {name=l9998 lab=WL62}
N 3040 12440 3060 12440 {}
C {lab_pin.sym} 3060 12440 0 0 {name=l9999 lab=VDD}
N 3040 12360 3060 12360 {}
C {lab_pin.sym} 3060 12360 0 0 {name=l10000 lab=VSS}
C {bitcell_6t.sym} 3200 12400 0 0 {name=Xr62c16}
N 3160 12440 3140 12440 {}
C {lab_pin.sym} 3140 12440 0 0 {name=l10001 lab=BL16}
N 3160 12400 3140 12400 {}
C {lab_pin.sym} 3140 12400 0 0 {name=l10002 lab=BLB16}
N 3160 12360 3140 12360 {}
C {lab_pin.sym} 3140 12360 0 0 {name=l10003 lab=WL62}
N 3240 12440 3260 12440 {}
C {lab_pin.sym} 3260 12440 0 0 {name=l10004 lab=VDD}
N 3240 12360 3260 12360 {}
C {lab_pin.sym} 3260 12360 0 0 {name=l10005 lab=VSS}
C {bitcell_6t.sym} 3400 12400 0 0 {name=Xr62c17}
N 3360 12440 3340 12440 {}
C {lab_pin.sym} 3340 12440 0 0 {name=l10006 lab=BL17}
N 3360 12400 3340 12400 {}
C {lab_pin.sym} 3340 12400 0 0 {name=l10007 lab=BLB17}
N 3360 12360 3340 12360 {}
C {lab_pin.sym} 3340 12360 0 0 {name=l10008 lab=WL62}
N 3440 12440 3460 12440 {}
C {lab_pin.sym} 3460 12440 0 0 {name=l10009 lab=VDD}
N 3440 12360 3460 12360 {}
C {lab_pin.sym} 3460 12360 0 0 {name=l10010 lab=VSS}
C {bitcell_6t.sym} 3600 12400 0 0 {name=Xr62c18}
N 3560 12440 3540 12440 {}
C {lab_pin.sym} 3540 12440 0 0 {name=l10011 lab=BL18}
N 3560 12400 3540 12400 {}
C {lab_pin.sym} 3540 12400 0 0 {name=l10012 lab=BLB18}
N 3560 12360 3540 12360 {}
C {lab_pin.sym} 3540 12360 0 0 {name=l10013 lab=WL62}
N 3640 12440 3660 12440 {}
C {lab_pin.sym} 3660 12440 0 0 {name=l10014 lab=VDD}
N 3640 12360 3660 12360 {}
C {lab_pin.sym} 3660 12360 0 0 {name=l10015 lab=VSS}
C {bitcell_6t.sym} 3800 12400 0 0 {name=Xr62c19}
N 3760 12440 3740 12440 {}
C {lab_pin.sym} 3740 12440 0 0 {name=l10016 lab=BL19}
N 3760 12400 3740 12400 {}
C {lab_pin.sym} 3740 12400 0 0 {name=l10017 lab=BLB19}
N 3760 12360 3740 12360 {}
C {lab_pin.sym} 3740 12360 0 0 {name=l10018 lab=WL62}
N 3840 12440 3860 12440 {}
C {lab_pin.sym} 3860 12440 0 0 {name=l10019 lab=VDD}
N 3840 12360 3860 12360 {}
C {lab_pin.sym} 3860 12360 0 0 {name=l10020 lab=VSS}
C {bitcell_6t.sym} 4000 12400 0 0 {name=Xr62c20}
N 3960 12440 3940 12440 {}
C {lab_pin.sym} 3940 12440 0 0 {name=l10021 lab=BL20}
N 3960 12400 3940 12400 {}
C {lab_pin.sym} 3940 12400 0 0 {name=l10022 lab=BLB20}
N 3960 12360 3940 12360 {}
C {lab_pin.sym} 3940 12360 0 0 {name=l10023 lab=WL62}
N 4040 12440 4060 12440 {}
C {lab_pin.sym} 4060 12440 0 0 {name=l10024 lab=VDD}
N 4040 12360 4060 12360 {}
C {lab_pin.sym} 4060 12360 0 0 {name=l10025 lab=VSS}
C {bitcell_6t.sym} 4200 12400 0 0 {name=Xr62c21}
N 4160 12440 4140 12440 {}
C {lab_pin.sym} 4140 12440 0 0 {name=l10026 lab=BL21}
N 4160 12400 4140 12400 {}
C {lab_pin.sym} 4140 12400 0 0 {name=l10027 lab=BLB21}
N 4160 12360 4140 12360 {}
C {lab_pin.sym} 4140 12360 0 0 {name=l10028 lab=WL62}
N 4240 12440 4260 12440 {}
C {lab_pin.sym} 4260 12440 0 0 {name=l10029 lab=VDD}
N 4240 12360 4260 12360 {}
C {lab_pin.sym} 4260 12360 0 0 {name=l10030 lab=VSS}
C {bitcell_6t.sym} 4400 12400 0 0 {name=Xr62c22}
N 4360 12440 4340 12440 {}
C {lab_pin.sym} 4340 12440 0 0 {name=l10031 lab=BL22}
N 4360 12400 4340 12400 {}
C {lab_pin.sym} 4340 12400 0 0 {name=l10032 lab=BLB22}
N 4360 12360 4340 12360 {}
C {lab_pin.sym} 4340 12360 0 0 {name=l10033 lab=WL62}
N 4440 12440 4460 12440 {}
C {lab_pin.sym} 4460 12440 0 0 {name=l10034 lab=VDD}
N 4440 12360 4460 12360 {}
C {lab_pin.sym} 4460 12360 0 0 {name=l10035 lab=VSS}
C {bitcell_6t.sym} 4600 12400 0 0 {name=Xr62c23}
N 4560 12440 4540 12440 {}
C {lab_pin.sym} 4540 12440 0 0 {name=l10036 lab=BL23}
N 4560 12400 4540 12400 {}
C {lab_pin.sym} 4540 12400 0 0 {name=l10037 lab=BLB23}
N 4560 12360 4540 12360 {}
C {lab_pin.sym} 4540 12360 0 0 {name=l10038 lab=WL62}
N 4640 12440 4660 12440 {}
C {lab_pin.sym} 4660 12440 0 0 {name=l10039 lab=VDD}
N 4640 12360 4660 12360 {}
C {lab_pin.sym} 4660 12360 0 0 {name=l10040 lab=VSS}
C {bitcell_6t.sym} 4800 12400 0 0 {name=Xr62c24}
N 4760 12440 4740 12440 {}
C {lab_pin.sym} 4740 12440 0 0 {name=l10041 lab=BL24}
N 4760 12400 4740 12400 {}
C {lab_pin.sym} 4740 12400 0 0 {name=l10042 lab=BLB24}
N 4760 12360 4740 12360 {}
C {lab_pin.sym} 4740 12360 0 0 {name=l10043 lab=WL62}
N 4840 12440 4860 12440 {}
C {lab_pin.sym} 4860 12440 0 0 {name=l10044 lab=VDD}
N 4840 12360 4860 12360 {}
C {lab_pin.sym} 4860 12360 0 0 {name=l10045 lab=VSS}
C {bitcell_6t.sym} 5000 12400 0 0 {name=Xr62c25}
N 4960 12440 4940 12440 {}
C {lab_pin.sym} 4940 12440 0 0 {name=l10046 lab=BL25}
N 4960 12400 4940 12400 {}
C {lab_pin.sym} 4940 12400 0 0 {name=l10047 lab=BLB25}
N 4960 12360 4940 12360 {}
C {lab_pin.sym} 4940 12360 0 0 {name=l10048 lab=WL62}
N 5040 12440 5060 12440 {}
C {lab_pin.sym} 5060 12440 0 0 {name=l10049 lab=VDD}
N 5040 12360 5060 12360 {}
C {lab_pin.sym} 5060 12360 0 0 {name=l10050 lab=VSS}
C {bitcell_6t.sym} 5200 12400 0 0 {name=Xr62c26}
N 5160 12440 5140 12440 {}
C {lab_pin.sym} 5140 12440 0 0 {name=l10051 lab=BL26}
N 5160 12400 5140 12400 {}
C {lab_pin.sym} 5140 12400 0 0 {name=l10052 lab=BLB26}
N 5160 12360 5140 12360 {}
C {lab_pin.sym} 5140 12360 0 0 {name=l10053 lab=WL62}
N 5240 12440 5260 12440 {}
C {lab_pin.sym} 5260 12440 0 0 {name=l10054 lab=VDD}
N 5240 12360 5260 12360 {}
C {lab_pin.sym} 5260 12360 0 0 {name=l10055 lab=VSS}
C {bitcell_6t.sym} 5400 12400 0 0 {name=Xr62c27}
N 5360 12440 5340 12440 {}
C {lab_pin.sym} 5340 12440 0 0 {name=l10056 lab=BL27}
N 5360 12400 5340 12400 {}
C {lab_pin.sym} 5340 12400 0 0 {name=l10057 lab=BLB27}
N 5360 12360 5340 12360 {}
C {lab_pin.sym} 5340 12360 0 0 {name=l10058 lab=WL62}
N 5440 12440 5460 12440 {}
C {lab_pin.sym} 5460 12440 0 0 {name=l10059 lab=VDD}
N 5440 12360 5460 12360 {}
C {lab_pin.sym} 5460 12360 0 0 {name=l10060 lab=VSS}
C {bitcell_6t.sym} 5600 12400 0 0 {name=Xr62c28}
N 5560 12440 5540 12440 {}
C {lab_pin.sym} 5540 12440 0 0 {name=l10061 lab=BL28}
N 5560 12400 5540 12400 {}
C {lab_pin.sym} 5540 12400 0 0 {name=l10062 lab=BLB28}
N 5560 12360 5540 12360 {}
C {lab_pin.sym} 5540 12360 0 0 {name=l10063 lab=WL62}
N 5640 12440 5660 12440 {}
C {lab_pin.sym} 5660 12440 0 0 {name=l10064 lab=VDD}
N 5640 12360 5660 12360 {}
C {lab_pin.sym} 5660 12360 0 0 {name=l10065 lab=VSS}
C {bitcell_6t.sym} 5800 12400 0 0 {name=Xr62c29}
N 5760 12440 5740 12440 {}
C {lab_pin.sym} 5740 12440 0 0 {name=l10066 lab=BL29}
N 5760 12400 5740 12400 {}
C {lab_pin.sym} 5740 12400 0 0 {name=l10067 lab=BLB29}
N 5760 12360 5740 12360 {}
C {lab_pin.sym} 5740 12360 0 0 {name=l10068 lab=WL62}
N 5840 12440 5860 12440 {}
C {lab_pin.sym} 5860 12440 0 0 {name=l10069 lab=VDD}
N 5840 12360 5860 12360 {}
C {lab_pin.sym} 5860 12360 0 0 {name=l10070 lab=VSS}
C {bitcell_6t.sym} 6000 12400 0 0 {name=Xr62c30}
N 5960 12440 5940 12440 {}
C {lab_pin.sym} 5940 12440 0 0 {name=l10071 lab=BL30}
N 5960 12400 5940 12400 {}
C {lab_pin.sym} 5940 12400 0 0 {name=l10072 lab=BLB30}
N 5960 12360 5940 12360 {}
C {lab_pin.sym} 5940 12360 0 0 {name=l10073 lab=WL62}
N 6040 12440 6060 12440 {}
C {lab_pin.sym} 6060 12440 0 0 {name=l10074 lab=VDD}
N 6040 12360 6060 12360 {}
C {lab_pin.sym} 6060 12360 0 0 {name=l10075 lab=VSS}
C {bitcell_6t.sym} 6200 12400 0 0 {name=Xr62c31}
N 6160 12440 6140 12440 {}
C {lab_pin.sym} 6140 12440 0 0 {name=l10076 lab=BL31}
N 6160 12400 6140 12400 {}
C {lab_pin.sym} 6140 12400 0 0 {name=l10077 lab=BLB31}
N 6160 12360 6140 12360 {}
C {lab_pin.sym} 6140 12360 0 0 {name=l10078 lab=WL62}
N 6240 12440 6260 12440 {}
C {lab_pin.sym} 6260 12440 0 0 {name=l10079 lab=VDD}
N 6240 12360 6260 12360 {}
C {lab_pin.sym} 6260 12360 0 0 {name=l10080 lab=VSS}
C {bitcell_6t.sym} 0 12600 0 0 {name=Xr63c0}
N -40 12640 -60 12640 {}
C {lab_pin.sym} -60 12640 0 0 {name=l10081 lab=BL0}
N -40 12600 -60 12600 {}
C {lab_pin.sym} -60 12600 0 0 {name=l10082 lab=BLB0}
N -40 12560 -60 12560 {}
C {lab_pin.sym} -60 12560 0 0 {name=l10083 lab=WL63}
N 40 12640 60 12640 {}
C {lab_pin.sym} 60 12640 0 0 {name=l10084 lab=VDD}
N 40 12560 60 12560 {}
C {lab_pin.sym} 60 12560 0 0 {name=l10085 lab=VSS}
C {bitcell_6t.sym} 200 12600 0 0 {name=Xr63c1}
N 160 12640 140 12640 {}
C {lab_pin.sym} 140 12640 0 0 {name=l10086 lab=BL1}
N 160 12600 140 12600 {}
C {lab_pin.sym} 140 12600 0 0 {name=l10087 lab=BLB1}
N 160 12560 140 12560 {}
C {lab_pin.sym} 140 12560 0 0 {name=l10088 lab=WL63}
N 240 12640 260 12640 {}
C {lab_pin.sym} 260 12640 0 0 {name=l10089 lab=VDD}
N 240 12560 260 12560 {}
C {lab_pin.sym} 260 12560 0 0 {name=l10090 lab=VSS}
C {bitcell_6t.sym} 400 12600 0 0 {name=Xr63c2}
N 360 12640 340 12640 {}
C {lab_pin.sym} 340 12640 0 0 {name=l10091 lab=BL2}
N 360 12600 340 12600 {}
C {lab_pin.sym} 340 12600 0 0 {name=l10092 lab=BLB2}
N 360 12560 340 12560 {}
C {lab_pin.sym} 340 12560 0 0 {name=l10093 lab=WL63}
N 440 12640 460 12640 {}
C {lab_pin.sym} 460 12640 0 0 {name=l10094 lab=VDD}
N 440 12560 460 12560 {}
C {lab_pin.sym} 460 12560 0 0 {name=l10095 lab=VSS}
C {bitcell_6t.sym} 600 12600 0 0 {name=Xr63c3}
N 560 12640 540 12640 {}
C {lab_pin.sym} 540 12640 0 0 {name=l10096 lab=BL3}
N 560 12600 540 12600 {}
C {lab_pin.sym} 540 12600 0 0 {name=l10097 lab=BLB3}
N 560 12560 540 12560 {}
C {lab_pin.sym} 540 12560 0 0 {name=l10098 lab=WL63}
N 640 12640 660 12640 {}
C {lab_pin.sym} 660 12640 0 0 {name=l10099 lab=VDD}
N 640 12560 660 12560 {}
C {lab_pin.sym} 660 12560 0 0 {name=l10100 lab=VSS}
C {bitcell_6t.sym} 800 12600 0 0 {name=Xr63c4}
N 760 12640 740 12640 {}
C {lab_pin.sym} 740 12640 0 0 {name=l10101 lab=BL4}
N 760 12600 740 12600 {}
C {lab_pin.sym} 740 12600 0 0 {name=l10102 lab=BLB4}
N 760 12560 740 12560 {}
C {lab_pin.sym} 740 12560 0 0 {name=l10103 lab=WL63}
N 840 12640 860 12640 {}
C {lab_pin.sym} 860 12640 0 0 {name=l10104 lab=VDD}
N 840 12560 860 12560 {}
C {lab_pin.sym} 860 12560 0 0 {name=l10105 lab=VSS}
C {bitcell_6t.sym} 1000 12600 0 0 {name=Xr63c5}
N 960 12640 940 12640 {}
C {lab_pin.sym} 940 12640 0 0 {name=l10106 lab=BL5}
N 960 12600 940 12600 {}
C {lab_pin.sym} 940 12600 0 0 {name=l10107 lab=BLB5}
N 960 12560 940 12560 {}
C {lab_pin.sym} 940 12560 0 0 {name=l10108 lab=WL63}
N 1040 12640 1060 12640 {}
C {lab_pin.sym} 1060 12640 0 0 {name=l10109 lab=VDD}
N 1040 12560 1060 12560 {}
C {lab_pin.sym} 1060 12560 0 0 {name=l10110 lab=VSS}
C {bitcell_6t.sym} 1200 12600 0 0 {name=Xr63c6}
N 1160 12640 1140 12640 {}
C {lab_pin.sym} 1140 12640 0 0 {name=l10111 lab=BL6}
N 1160 12600 1140 12600 {}
C {lab_pin.sym} 1140 12600 0 0 {name=l10112 lab=BLB6}
N 1160 12560 1140 12560 {}
C {lab_pin.sym} 1140 12560 0 0 {name=l10113 lab=WL63}
N 1240 12640 1260 12640 {}
C {lab_pin.sym} 1260 12640 0 0 {name=l10114 lab=VDD}
N 1240 12560 1260 12560 {}
C {lab_pin.sym} 1260 12560 0 0 {name=l10115 lab=VSS}
C {bitcell_6t.sym} 1400 12600 0 0 {name=Xr63c7}
N 1360 12640 1340 12640 {}
C {lab_pin.sym} 1340 12640 0 0 {name=l10116 lab=BL7}
N 1360 12600 1340 12600 {}
C {lab_pin.sym} 1340 12600 0 0 {name=l10117 lab=BLB7}
N 1360 12560 1340 12560 {}
C {lab_pin.sym} 1340 12560 0 0 {name=l10118 lab=WL63}
N 1440 12640 1460 12640 {}
C {lab_pin.sym} 1460 12640 0 0 {name=l10119 lab=VDD}
N 1440 12560 1460 12560 {}
C {lab_pin.sym} 1460 12560 0 0 {name=l10120 lab=VSS}
C {bitcell_6t.sym} 1600 12600 0 0 {name=Xr63c8}
N 1560 12640 1540 12640 {}
C {lab_pin.sym} 1540 12640 0 0 {name=l10121 lab=BL8}
N 1560 12600 1540 12600 {}
C {lab_pin.sym} 1540 12600 0 0 {name=l10122 lab=BLB8}
N 1560 12560 1540 12560 {}
C {lab_pin.sym} 1540 12560 0 0 {name=l10123 lab=WL63}
N 1640 12640 1660 12640 {}
C {lab_pin.sym} 1660 12640 0 0 {name=l10124 lab=VDD}
N 1640 12560 1660 12560 {}
C {lab_pin.sym} 1660 12560 0 0 {name=l10125 lab=VSS}
C {bitcell_6t.sym} 1800 12600 0 0 {name=Xr63c9}
N 1760 12640 1740 12640 {}
C {lab_pin.sym} 1740 12640 0 0 {name=l10126 lab=BL9}
N 1760 12600 1740 12600 {}
C {lab_pin.sym} 1740 12600 0 0 {name=l10127 lab=BLB9}
N 1760 12560 1740 12560 {}
C {lab_pin.sym} 1740 12560 0 0 {name=l10128 lab=WL63}
N 1840 12640 1860 12640 {}
C {lab_pin.sym} 1860 12640 0 0 {name=l10129 lab=VDD}
N 1840 12560 1860 12560 {}
C {lab_pin.sym} 1860 12560 0 0 {name=l10130 lab=VSS}
C {bitcell_6t.sym} 2000 12600 0 0 {name=Xr63c10}
N 1960 12640 1940 12640 {}
C {lab_pin.sym} 1940 12640 0 0 {name=l10131 lab=BL10}
N 1960 12600 1940 12600 {}
C {lab_pin.sym} 1940 12600 0 0 {name=l10132 lab=BLB10}
N 1960 12560 1940 12560 {}
C {lab_pin.sym} 1940 12560 0 0 {name=l10133 lab=WL63}
N 2040 12640 2060 12640 {}
C {lab_pin.sym} 2060 12640 0 0 {name=l10134 lab=VDD}
N 2040 12560 2060 12560 {}
C {lab_pin.sym} 2060 12560 0 0 {name=l10135 lab=VSS}
C {bitcell_6t.sym} 2200 12600 0 0 {name=Xr63c11}
N 2160 12640 2140 12640 {}
C {lab_pin.sym} 2140 12640 0 0 {name=l10136 lab=BL11}
N 2160 12600 2140 12600 {}
C {lab_pin.sym} 2140 12600 0 0 {name=l10137 lab=BLB11}
N 2160 12560 2140 12560 {}
C {lab_pin.sym} 2140 12560 0 0 {name=l10138 lab=WL63}
N 2240 12640 2260 12640 {}
C {lab_pin.sym} 2260 12640 0 0 {name=l10139 lab=VDD}
N 2240 12560 2260 12560 {}
C {lab_pin.sym} 2260 12560 0 0 {name=l10140 lab=VSS}
C {bitcell_6t.sym} 2400 12600 0 0 {name=Xr63c12}
N 2360 12640 2340 12640 {}
C {lab_pin.sym} 2340 12640 0 0 {name=l10141 lab=BL12}
N 2360 12600 2340 12600 {}
C {lab_pin.sym} 2340 12600 0 0 {name=l10142 lab=BLB12}
N 2360 12560 2340 12560 {}
C {lab_pin.sym} 2340 12560 0 0 {name=l10143 lab=WL63}
N 2440 12640 2460 12640 {}
C {lab_pin.sym} 2460 12640 0 0 {name=l10144 lab=VDD}
N 2440 12560 2460 12560 {}
C {lab_pin.sym} 2460 12560 0 0 {name=l10145 lab=VSS}
C {bitcell_6t.sym} 2600 12600 0 0 {name=Xr63c13}
N 2560 12640 2540 12640 {}
C {lab_pin.sym} 2540 12640 0 0 {name=l10146 lab=BL13}
N 2560 12600 2540 12600 {}
C {lab_pin.sym} 2540 12600 0 0 {name=l10147 lab=BLB13}
N 2560 12560 2540 12560 {}
C {lab_pin.sym} 2540 12560 0 0 {name=l10148 lab=WL63}
N 2640 12640 2660 12640 {}
C {lab_pin.sym} 2660 12640 0 0 {name=l10149 lab=VDD}
N 2640 12560 2660 12560 {}
C {lab_pin.sym} 2660 12560 0 0 {name=l10150 lab=VSS}
C {bitcell_6t.sym} 2800 12600 0 0 {name=Xr63c14}
N 2760 12640 2740 12640 {}
C {lab_pin.sym} 2740 12640 0 0 {name=l10151 lab=BL14}
N 2760 12600 2740 12600 {}
C {lab_pin.sym} 2740 12600 0 0 {name=l10152 lab=BLB14}
N 2760 12560 2740 12560 {}
C {lab_pin.sym} 2740 12560 0 0 {name=l10153 lab=WL63}
N 2840 12640 2860 12640 {}
C {lab_pin.sym} 2860 12640 0 0 {name=l10154 lab=VDD}
N 2840 12560 2860 12560 {}
C {lab_pin.sym} 2860 12560 0 0 {name=l10155 lab=VSS}
C {bitcell_6t.sym} 3000 12600 0 0 {name=Xr63c15}
N 2960 12640 2940 12640 {}
C {lab_pin.sym} 2940 12640 0 0 {name=l10156 lab=BL15}
N 2960 12600 2940 12600 {}
C {lab_pin.sym} 2940 12600 0 0 {name=l10157 lab=BLB15}
N 2960 12560 2940 12560 {}
C {lab_pin.sym} 2940 12560 0 0 {name=l10158 lab=WL63}
N 3040 12640 3060 12640 {}
C {lab_pin.sym} 3060 12640 0 0 {name=l10159 lab=VDD}
N 3040 12560 3060 12560 {}
C {lab_pin.sym} 3060 12560 0 0 {name=l10160 lab=VSS}
C {bitcell_6t.sym} 3200 12600 0 0 {name=Xr63c16}
N 3160 12640 3140 12640 {}
C {lab_pin.sym} 3140 12640 0 0 {name=l10161 lab=BL16}
N 3160 12600 3140 12600 {}
C {lab_pin.sym} 3140 12600 0 0 {name=l10162 lab=BLB16}
N 3160 12560 3140 12560 {}
C {lab_pin.sym} 3140 12560 0 0 {name=l10163 lab=WL63}
N 3240 12640 3260 12640 {}
C {lab_pin.sym} 3260 12640 0 0 {name=l10164 lab=VDD}
N 3240 12560 3260 12560 {}
C {lab_pin.sym} 3260 12560 0 0 {name=l10165 lab=VSS}
C {bitcell_6t.sym} 3400 12600 0 0 {name=Xr63c17}
N 3360 12640 3340 12640 {}
C {lab_pin.sym} 3340 12640 0 0 {name=l10166 lab=BL17}
N 3360 12600 3340 12600 {}
C {lab_pin.sym} 3340 12600 0 0 {name=l10167 lab=BLB17}
N 3360 12560 3340 12560 {}
C {lab_pin.sym} 3340 12560 0 0 {name=l10168 lab=WL63}
N 3440 12640 3460 12640 {}
C {lab_pin.sym} 3460 12640 0 0 {name=l10169 lab=VDD}
N 3440 12560 3460 12560 {}
C {lab_pin.sym} 3460 12560 0 0 {name=l10170 lab=VSS}
C {bitcell_6t.sym} 3600 12600 0 0 {name=Xr63c18}
N 3560 12640 3540 12640 {}
C {lab_pin.sym} 3540 12640 0 0 {name=l10171 lab=BL18}
N 3560 12600 3540 12600 {}
C {lab_pin.sym} 3540 12600 0 0 {name=l10172 lab=BLB18}
N 3560 12560 3540 12560 {}
C {lab_pin.sym} 3540 12560 0 0 {name=l10173 lab=WL63}
N 3640 12640 3660 12640 {}
C {lab_pin.sym} 3660 12640 0 0 {name=l10174 lab=VDD}
N 3640 12560 3660 12560 {}
C {lab_pin.sym} 3660 12560 0 0 {name=l10175 lab=VSS}
C {bitcell_6t.sym} 3800 12600 0 0 {name=Xr63c19}
N 3760 12640 3740 12640 {}
C {lab_pin.sym} 3740 12640 0 0 {name=l10176 lab=BL19}
N 3760 12600 3740 12600 {}
C {lab_pin.sym} 3740 12600 0 0 {name=l10177 lab=BLB19}
N 3760 12560 3740 12560 {}
C {lab_pin.sym} 3740 12560 0 0 {name=l10178 lab=WL63}
N 3840 12640 3860 12640 {}
C {lab_pin.sym} 3860 12640 0 0 {name=l10179 lab=VDD}
N 3840 12560 3860 12560 {}
C {lab_pin.sym} 3860 12560 0 0 {name=l10180 lab=VSS}
C {bitcell_6t.sym} 4000 12600 0 0 {name=Xr63c20}
N 3960 12640 3940 12640 {}
C {lab_pin.sym} 3940 12640 0 0 {name=l10181 lab=BL20}
N 3960 12600 3940 12600 {}
C {lab_pin.sym} 3940 12600 0 0 {name=l10182 lab=BLB20}
N 3960 12560 3940 12560 {}
C {lab_pin.sym} 3940 12560 0 0 {name=l10183 lab=WL63}
N 4040 12640 4060 12640 {}
C {lab_pin.sym} 4060 12640 0 0 {name=l10184 lab=VDD}
N 4040 12560 4060 12560 {}
C {lab_pin.sym} 4060 12560 0 0 {name=l10185 lab=VSS}
C {bitcell_6t.sym} 4200 12600 0 0 {name=Xr63c21}
N 4160 12640 4140 12640 {}
C {lab_pin.sym} 4140 12640 0 0 {name=l10186 lab=BL21}
N 4160 12600 4140 12600 {}
C {lab_pin.sym} 4140 12600 0 0 {name=l10187 lab=BLB21}
N 4160 12560 4140 12560 {}
C {lab_pin.sym} 4140 12560 0 0 {name=l10188 lab=WL63}
N 4240 12640 4260 12640 {}
C {lab_pin.sym} 4260 12640 0 0 {name=l10189 lab=VDD}
N 4240 12560 4260 12560 {}
C {lab_pin.sym} 4260 12560 0 0 {name=l10190 lab=VSS}
C {bitcell_6t.sym} 4400 12600 0 0 {name=Xr63c22}
N 4360 12640 4340 12640 {}
C {lab_pin.sym} 4340 12640 0 0 {name=l10191 lab=BL22}
N 4360 12600 4340 12600 {}
C {lab_pin.sym} 4340 12600 0 0 {name=l10192 lab=BLB22}
N 4360 12560 4340 12560 {}
C {lab_pin.sym} 4340 12560 0 0 {name=l10193 lab=WL63}
N 4440 12640 4460 12640 {}
C {lab_pin.sym} 4460 12640 0 0 {name=l10194 lab=VDD}
N 4440 12560 4460 12560 {}
C {lab_pin.sym} 4460 12560 0 0 {name=l10195 lab=VSS}
C {bitcell_6t.sym} 4600 12600 0 0 {name=Xr63c23}
N 4560 12640 4540 12640 {}
C {lab_pin.sym} 4540 12640 0 0 {name=l10196 lab=BL23}
N 4560 12600 4540 12600 {}
C {lab_pin.sym} 4540 12600 0 0 {name=l10197 lab=BLB23}
N 4560 12560 4540 12560 {}
C {lab_pin.sym} 4540 12560 0 0 {name=l10198 lab=WL63}
N 4640 12640 4660 12640 {}
C {lab_pin.sym} 4660 12640 0 0 {name=l10199 lab=VDD}
N 4640 12560 4660 12560 {}
C {lab_pin.sym} 4660 12560 0 0 {name=l10200 lab=VSS}
C {bitcell_6t.sym} 4800 12600 0 0 {name=Xr63c24}
N 4760 12640 4740 12640 {}
C {lab_pin.sym} 4740 12640 0 0 {name=l10201 lab=BL24}
N 4760 12600 4740 12600 {}
C {lab_pin.sym} 4740 12600 0 0 {name=l10202 lab=BLB24}
N 4760 12560 4740 12560 {}
C {lab_pin.sym} 4740 12560 0 0 {name=l10203 lab=WL63}
N 4840 12640 4860 12640 {}
C {lab_pin.sym} 4860 12640 0 0 {name=l10204 lab=VDD}
N 4840 12560 4860 12560 {}
C {lab_pin.sym} 4860 12560 0 0 {name=l10205 lab=VSS}
C {bitcell_6t.sym} 5000 12600 0 0 {name=Xr63c25}
N 4960 12640 4940 12640 {}
C {lab_pin.sym} 4940 12640 0 0 {name=l10206 lab=BL25}
N 4960 12600 4940 12600 {}
C {lab_pin.sym} 4940 12600 0 0 {name=l10207 lab=BLB25}
N 4960 12560 4940 12560 {}
C {lab_pin.sym} 4940 12560 0 0 {name=l10208 lab=WL63}
N 5040 12640 5060 12640 {}
C {lab_pin.sym} 5060 12640 0 0 {name=l10209 lab=VDD}
N 5040 12560 5060 12560 {}
C {lab_pin.sym} 5060 12560 0 0 {name=l10210 lab=VSS}
C {bitcell_6t.sym} 5200 12600 0 0 {name=Xr63c26}
N 5160 12640 5140 12640 {}
C {lab_pin.sym} 5140 12640 0 0 {name=l10211 lab=BL26}
N 5160 12600 5140 12600 {}
C {lab_pin.sym} 5140 12600 0 0 {name=l10212 lab=BLB26}
N 5160 12560 5140 12560 {}
C {lab_pin.sym} 5140 12560 0 0 {name=l10213 lab=WL63}
N 5240 12640 5260 12640 {}
C {lab_pin.sym} 5260 12640 0 0 {name=l10214 lab=VDD}
N 5240 12560 5260 12560 {}
C {lab_pin.sym} 5260 12560 0 0 {name=l10215 lab=VSS}
C {bitcell_6t.sym} 5400 12600 0 0 {name=Xr63c27}
N 5360 12640 5340 12640 {}
C {lab_pin.sym} 5340 12640 0 0 {name=l10216 lab=BL27}
N 5360 12600 5340 12600 {}
C {lab_pin.sym} 5340 12600 0 0 {name=l10217 lab=BLB27}
N 5360 12560 5340 12560 {}
C {lab_pin.sym} 5340 12560 0 0 {name=l10218 lab=WL63}
N 5440 12640 5460 12640 {}
C {lab_pin.sym} 5460 12640 0 0 {name=l10219 lab=VDD}
N 5440 12560 5460 12560 {}
C {lab_pin.sym} 5460 12560 0 0 {name=l10220 lab=VSS}
C {bitcell_6t.sym} 5600 12600 0 0 {name=Xr63c28}
N 5560 12640 5540 12640 {}
C {lab_pin.sym} 5540 12640 0 0 {name=l10221 lab=BL28}
N 5560 12600 5540 12600 {}
C {lab_pin.sym} 5540 12600 0 0 {name=l10222 lab=BLB28}
N 5560 12560 5540 12560 {}
C {lab_pin.sym} 5540 12560 0 0 {name=l10223 lab=WL63}
N 5640 12640 5660 12640 {}
C {lab_pin.sym} 5660 12640 0 0 {name=l10224 lab=VDD}
N 5640 12560 5660 12560 {}
C {lab_pin.sym} 5660 12560 0 0 {name=l10225 lab=VSS}
C {bitcell_6t.sym} 5800 12600 0 0 {name=Xr63c29}
N 5760 12640 5740 12640 {}
C {lab_pin.sym} 5740 12640 0 0 {name=l10226 lab=BL29}
N 5760 12600 5740 12600 {}
C {lab_pin.sym} 5740 12600 0 0 {name=l10227 lab=BLB29}
N 5760 12560 5740 12560 {}
C {lab_pin.sym} 5740 12560 0 0 {name=l10228 lab=WL63}
N 5840 12640 5860 12640 {}
C {lab_pin.sym} 5860 12640 0 0 {name=l10229 lab=VDD}
N 5840 12560 5860 12560 {}
C {lab_pin.sym} 5860 12560 0 0 {name=l10230 lab=VSS}
C {bitcell_6t.sym} 6000 12600 0 0 {name=Xr63c30}
N 5960 12640 5940 12640 {}
C {lab_pin.sym} 5940 12640 0 0 {name=l10231 lab=BL30}
N 5960 12600 5940 12600 {}
C {lab_pin.sym} 5940 12600 0 0 {name=l10232 lab=BLB30}
N 5960 12560 5940 12560 {}
C {lab_pin.sym} 5940 12560 0 0 {name=l10233 lab=WL63}
N 6040 12640 6060 12640 {}
C {lab_pin.sym} 6060 12640 0 0 {name=l10234 lab=VDD}
N 6040 12560 6060 12560 {}
C {lab_pin.sym} 6060 12560 0 0 {name=l10235 lab=VSS}
C {bitcell_6t.sym} 6200 12600 0 0 {name=Xr63c31}
N 6160 12640 6140 12640 {}
C {lab_pin.sym} 6140 12640 0 0 {name=l10236 lab=BL31}
N 6160 12600 6140 12600 {}
C {lab_pin.sym} 6140 12600 0 0 {name=l10237 lab=BLB31}
N 6160 12560 6140 12560 {}
C {lab_pin.sym} 6140 12560 0 0 {name=l10238 lab=WL63}
N 6240 12640 6260 12640 {}
C {lab_pin.sym} 6260 12640 0 0 {name=l10239 lab=VDD}
N 6240 12560 6260 12560 {}
C {lab_pin.sym} 6260 12560 0 0 {name=l10240 lab=VSS}
C {bitcell_6t.sym} 0 12800 0 0 {name=Xr64c0}
N -40 12840 -60 12840 {}
C {lab_pin.sym} -60 12840 0 0 {name=l10241 lab=BL0}
N -40 12800 -60 12800 {}
C {lab_pin.sym} -60 12800 0 0 {name=l10242 lab=BLB0}
N -40 12760 -60 12760 {}
C {lab_pin.sym} -60 12760 0 0 {name=l10243 lab=WL64}
N 40 12840 60 12840 {}
C {lab_pin.sym} 60 12840 0 0 {name=l10244 lab=VDD}
N 40 12760 60 12760 {}
C {lab_pin.sym} 60 12760 0 0 {name=l10245 lab=VSS}
C {bitcell_6t.sym} 200 12800 0 0 {name=Xr64c1}
N 160 12840 140 12840 {}
C {lab_pin.sym} 140 12840 0 0 {name=l10246 lab=BL1}
N 160 12800 140 12800 {}
C {lab_pin.sym} 140 12800 0 0 {name=l10247 lab=BLB1}
N 160 12760 140 12760 {}
C {lab_pin.sym} 140 12760 0 0 {name=l10248 lab=WL64}
N 240 12840 260 12840 {}
C {lab_pin.sym} 260 12840 0 0 {name=l10249 lab=VDD}
N 240 12760 260 12760 {}
C {lab_pin.sym} 260 12760 0 0 {name=l10250 lab=VSS}
C {bitcell_6t.sym} 400 12800 0 0 {name=Xr64c2}
N 360 12840 340 12840 {}
C {lab_pin.sym} 340 12840 0 0 {name=l10251 lab=BL2}
N 360 12800 340 12800 {}
C {lab_pin.sym} 340 12800 0 0 {name=l10252 lab=BLB2}
N 360 12760 340 12760 {}
C {lab_pin.sym} 340 12760 0 0 {name=l10253 lab=WL64}
N 440 12840 460 12840 {}
C {lab_pin.sym} 460 12840 0 0 {name=l10254 lab=VDD}
N 440 12760 460 12760 {}
C {lab_pin.sym} 460 12760 0 0 {name=l10255 lab=VSS}
C {bitcell_6t.sym} 600 12800 0 0 {name=Xr64c3}
N 560 12840 540 12840 {}
C {lab_pin.sym} 540 12840 0 0 {name=l10256 lab=BL3}
N 560 12800 540 12800 {}
C {lab_pin.sym} 540 12800 0 0 {name=l10257 lab=BLB3}
N 560 12760 540 12760 {}
C {lab_pin.sym} 540 12760 0 0 {name=l10258 lab=WL64}
N 640 12840 660 12840 {}
C {lab_pin.sym} 660 12840 0 0 {name=l10259 lab=VDD}
N 640 12760 660 12760 {}
C {lab_pin.sym} 660 12760 0 0 {name=l10260 lab=VSS}
C {bitcell_6t.sym} 800 12800 0 0 {name=Xr64c4}
N 760 12840 740 12840 {}
C {lab_pin.sym} 740 12840 0 0 {name=l10261 lab=BL4}
N 760 12800 740 12800 {}
C {lab_pin.sym} 740 12800 0 0 {name=l10262 lab=BLB4}
N 760 12760 740 12760 {}
C {lab_pin.sym} 740 12760 0 0 {name=l10263 lab=WL64}
N 840 12840 860 12840 {}
C {lab_pin.sym} 860 12840 0 0 {name=l10264 lab=VDD}
N 840 12760 860 12760 {}
C {lab_pin.sym} 860 12760 0 0 {name=l10265 lab=VSS}
C {bitcell_6t.sym} 1000 12800 0 0 {name=Xr64c5}
N 960 12840 940 12840 {}
C {lab_pin.sym} 940 12840 0 0 {name=l10266 lab=BL5}
N 960 12800 940 12800 {}
C {lab_pin.sym} 940 12800 0 0 {name=l10267 lab=BLB5}
N 960 12760 940 12760 {}
C {lab_pin.sym} 940 12760 0 0 {name=l10268 lab=WL64}
N 1040 12840 1060 12840 {}
C {lab_pin.sym} 1060 12840 0 0 {name=l10269 lab=VDD}
N 1040 12760 1060 12760 {}
C {lab_pin.sym} 1060 12760 0 0 {name=l10270 lab=VSS}
C {bitcell_6t.sym} 1200 12800 0 0 {name=Xr64c6}
N 1160 12840 1140 12840 {}
C {lab_pin.sym} 1140 12840 0 0 {name=l10271 lab=BL6}
N 1160 12800 1140 12800 {}
C {lab_pin.sym} 1140 12800 0 0 {name=l10272 lab=BLB6}
N 1160 12760 1140 12760 {}
C {lab_pin.sym} 1140 12760 0 0 {name=l10273 lab=WL64}
N 1240 12840 1260 12840 {}
C {lab_pin.sym} 1260 12840 0 0 {name=l10274 lab=VDD}
N 1240 12760 1260 12760 {}
C {lab_pin.sym} 1260 12760 0 0 {name=l10275 lab=VSS}
C {bitcell_6t.sym} 1400 12800 0 0 {name=Xr64c7}
N 1360 12840 1340 12840 {}
C {lab_pin.sym} 1340 12840 0 0 {name=l10276 lab=BL7}
N 1360 12800 1340 12800 {}
C {lab_pin.sym} 1340 12800 0 0 {name=l10277 lab=BLB7}
N 1360 12760 1340 12760 {}
C {lab_pin.sym} 1340 12760 0 0 {name=l10278 lab=WL64}
N 1440 12840 1460 12840 {}
C {lab_pin.sym} 1460 12840 0 0 {name=l10279 lab=VDD}
N 1440 12760 1460 12760 {}
C {lab_pin.sym} 1460 12760 0 0 {name=l10280 lab=VSS}
C {bitcell_6t.sym} 1600 12800 0 0 {name=Xr64c8}
N 1560 12840 1540 12840 {}
C {lab_pin.sym} 1540 12840 0 0 {name=l10281 lab=BL8}
N 1560 12800 1540 12800 {}
C {lab_pin.sym} 1540 12800 0 0 {name=l10282 lab=BLB8}
N 1560 12760 1540 12760 {}
C {lab_pin.sym} 1540 12760 0 0 {name=l10283 lab=WL64}
N 1640 12840 1660 12840 {}
C {lab_pin.sym} 1660 12840 0 0 {name=l10284 lab=VDD}
N 1640 12760 1660 12760 {}
C {lab_pin.sym} 1660 12760 0 0 {name=l10285 lab=VSS}
C {bitcell_6t.sym} 1800 12800 0 0 {name=Xr64c9}
N 1760 12840 1740 12840 {}
C {lab_pin.sym} 1740 12840 0 0 {name=l10286 lab=BL9}
N 1760 12800 1740 12800 {}
C {lab_pin.sym} 1740 12800 0 0 {name=l10287 lab=BLB9}
N 1760 12760 1740 12760 {}
C {lab_pin.sym} 1740 12760 0 0 {name=l10288 lab=WL64}
N 1840 12840 1860 12840 {}
C {lab_pin.sym} 1860 12840 0 0 {name=l10289 lab=VDD}
N 1840 12760 1860 12760 {}
C {lab_pin.sym} 1860 12760 0 0 {name=l10290 lab=VSS}
C {bitcell_6t.sym} 2000 12800 0 0 {name=Xr64c10}
N 1960 12840 1940 12840 {}
C {lab_pin.sym} 1940 12840 0 0 {name=l10291 lab=BL10}
N 1960 12800 1940 12800 {}
C {lab_pin.sym} 1940 12800 0 0 {name=l10292 lab=BLB10}
N 1960 12760 1940 12760 {}
C {lab_pin.sym} 1940 12760 0 0 {name=l10293 lab=WL64}
N 2040 12840 2060 12840 {}
C {lab_pin.sym} 2060 12840 0 0 {name=l10294 lab=VDD}
N 2040 12760 2060 12760 {}
C {lab_pin.sym} 2060 12760 0 0 {name=l10295 lab=VSS}
C {bitcell_6t.sym} 2200 12800 0 0 {name=Xr64c11}
N 2160 12840 2140 12840 {}
C {lab_pin.sym} 2140 12840 0 0 {name=l10296 lab=BL11}
N 2160 12800 2140 12800 {}
C {lab_pin.sym} 2140 12800 0 0 {name=l10297 lab=BLB11}
N 2160 12760 2140 12760 {}
C {lab_pin.sym} 2140 12760 0 0 {name=l10298 lab=WL64}
N 2240 12840 2260 12840 {}
C {lab_pin.sym} 2260 12840 0 0 {name=l10299 lab=VDD}
N 2240 12760 2260 12760 {}
C {lab_pin.sym} 2260 12760 0 0 {name=l10300 lab=VSS}
C {bitcell_6t.sym} 2400 12800 0 0 {name=Xr64c12}
N 2360 12840 2340 12840 {}
C {lab_pin.sym} 2340 12840 0 0 {name=l10301 lab=BL12}
N 2360 12800 2340 12800 {}
C {lab_pin.sym} 2340 12800 0 0 {name=l10302 lab=BLB12}
N 2360 12760 2340 12760 {}
C {lab_pin.sym} 2340 12760 0 0 {name=l10303 lab=WL64}
N 2440 12840 2460 12840 {}
C {lab_pin.sym} 2460 12840 0 0 {name=l10304 lab=VDD}
N 2440 12760 2460 12760 {}
C {lab_pin.sym} 2460 12760 0 0 {name=l10305 lab=VSS}
C {bitcell_6t.sym} 2600 12800 0 0 {name=Xr64c13}
N 2560 12840 2540 12840 {}
C {lab_pin.sym} 2540 12840 0 0 {name=l10306 lab=BL13}
N 2560 12800 2540 12800 {}
C {lab_pin.sym} 2540 12800 0 0 {name=l10307 lab=BLB13}
N 2560 12760 2540 12760 {}
C {lab_pin.sym} 2540 12760 0 0 {name=l10308 lab=WL64}
N 2640 12840 2660 12840 {}
C {lab_pin.sym} 2660 12840 0 0 {name=l10309 lab=VDD}
N 2640 12760 2660 12760 {}
C {lab_pin.sym} 2660 12760 0 0 {name=l10310 lab=VSS}
C {bitcell_6t.sym} 2800 12800 0 0 {name=Xr64c14}
N 2760 12840 2740 12840 {}
C {lab_pin.sym} 2740 12840 0 0 {name=l10311 lab=BL14}
N 2760 12800 2740 12800 {}
C {lab_pin.sym} 2740 12800 0 0 {name=l10312 lab=BLB14}
N 2760 12760 2740 12760 {}
C {lab_pin.sym} 2740 12760 0 0 {name=l10313 lab=WL64}
N 2840 12840 2860 12840 {}
C {lab_pin.sym} 2860 12840 0 0 {name=l10314 lab=VDD}
N 2840 12760 2860 12760 {}
C {lab_pin.sym} 2860 12760 0 0 {name=l10315 lab=VSS}
C {bitcell_6t.sym} 3000 12800 0 0 {name=Xr64c15}
N 2960 12840 2940 12840 {}
C {lab_pin.sym} 2940 12840 0 0 {name=l10316 lab=BL15}
N 2960 12800 2940 12800 {}
C {lab_pin.sym} 2940 12800 0 0 {name=l10317 lab=BLB15}
N 2960 12760 2940 12760 {}
C {lab_pin.sym} 2940 12760 0 0 {name=l10318 lab=WL64}
N 3040 12840 3060 12840 {}
C {lab_pin.sym} 3060 12840 0 0 {name=l10319 lab=VDD}
N 3040 12760 3060 12760 {}
C {lab_pin.sym} 3060 12760 0 0 {name=l10320 lab=VSS}
C {bitcell_6t.sym} 3200 12800 0 0 {name=Xr64c16}
N 3160 12840 3140 12840 {}
C {lab_pin.sym} 3140 12840 0 0 {name=l10321 lab=BL16}
N 3160 12800 3140 12800 {}
C {lab_pin.sym} 3140 12800 0 0 {name=l10322 lab=BLB16}
N 3160 12760 3140 12760 {}
C {lab_pin.sym} 3140 12760 0 0 {name=l10323 lab=WL64}
N 3240 12840 3260 12840 {}
C {lab_pin.sym} 3260 12840 0 0 {name=l10324 lab=VDD}
N 3240 12760 3260 12760 {}
C {lab_pin.sym} 3260 12760 0 0 {name=l10325 lab=VSS}
C {bitcell_6t.sym} 3400 12800 0 0 {name=Xr64c17}
N 3360 12840 3340 12840 {}
C {lab_pin.sym} 3340 12840 0 0 {name=l10326 lab=BL17}
N 3360 12800 3340 12800 {}
C {lab_pin.sym} 3340 12800 0 0 {name=l10327 lab=BLB17}
N 3360 12760 3340 12760 {}
C {lab_pin.sym} 3340 12760 0 0 {name=l10328 lab=WL64}
N 3440 12840 3460 12840 {}
C {lab_pin.sym} 3460 12840 0 0 {name=l10329 lab=VDD}
N 3440 12760 3460 12760 {}
C {lab_pin.sym} 3460 12760 0 0 {name=l10330 lab=VSS}
C {bitcell_6t.sym} 3600 12800 0 0 {name=Xr64c18}
N 3560 12840 3540 12840 {}
C {lab_pin.sym} 3540 12840 0 0 {name=l10331 lab=BL18}
N 3560 12800 3540 12800 {}
C {lab_pin.sym} 3540 12800 0 0 {name=l10332 lab=BLB18}
N 3560 12760 3540 12760 {}
C {lab_pin.sym} 3540 12760 0 0 {name=l10333 lab=WL64}
N 3640 12840 3660 12840 {}
C {lab_pin.sym} 3660 12840 0 0 {name=l10334 lab=VDD}
N 3640 12760 3660 12760 {}
C {lab_pin.sym} 3660 12760 0 0 {name=l10335 lab=VSS}
C {bitcell_6t.sym} 3800 12800 0 0 {name=Xr64c19}
N 3760 12840 3740 12840 {}
C {lab_pin.sym} 3740 12840 0 0 {name=l10336 lab=BL19}
N 3760 12800 3740 12800 {}
C {lab_pin.sym} 3740 12800 0 0 {name=l10337 lab=BLB19}
N 3760 12760 3740 12760 {}
C {lab_pin.sym} 3740 12760 0 0 {name=l10338 lab=WL64}
N 3840 12840 3860 12840 {}
C {lab_pin.sym} 3860 12840 0 0 {name=l10339 lab=VDD}
N 3840 12760 3860 12760 {}
C {lab_pin.sym} 3860 12760 0 0 {name=l10340 lab=VSS}
C {bitcell_6t.sym} 4000 12800 0 0 {name=Xr64c20}
N 3960 12840 3940 12840 {}
C {lab_pin.sym} 3940 12840 0 0 {name=l10341 lab=BL20}
N 3960 12800 3940 12800 {}
C {lab_pin.sym} 3940 12800 0 0 {name=l10342 lab=BLB20}
N 3960 12760 3940 12760 {}
C {lab_pin.sym} 3940 12760 0 0 {name=l10343 lab=WL64}
N 4040 12840 4060 12840 {}
C {lab_pin.sym} 4060 12840 0 0 {name=l10344 lab=VDD}
N 4040 12760 4060 12760 {}
C {lab_pin.sym} 4060 12760 0 0 {name=l10345 lab=VSS}
C {bitcell_6t.sym} 4200 12800 0 0 {name=Xr64c21}
N 4160 12840 4140 12840 {}
C {lab_pin.sym} 4140 12840 0 0 {name=l10346 lab=BL21}
N 4160 12800 4140 12800 {}
C {lab_pin.sym} 4140 12800 0 0 {name=l10347 lab=BLB21}
N 4160 12760 4140 12760 {}
C {lab_pin.sym} 4140 12760 0 0 {name=l10348 lab=WL64}
N 4240 12840 4260 12840 {}
C {lab_pin.sym} 4260 12840 0 0 {name=l10349 lab=VDD}
N 4240 12760 4260 12760 {}
C {lab_pin.sym} 4260 12760 0 0 {name=l10350 lab=VSS}
C {bitcell_6t.sym} 4400 12800 0 0 {name=Xr64c22}
N 4360 12840 4340 12840 {}
C {lab_pin.sym} 4340 12840 0 0 {name=l10351 lab=BL22}
N 4360 12800 4340 12800 {}
C {lab_pin.sym} 4340 12800 0 0 {name=l10352 lab=BLB22}
N 4360 12760 4340 12760 {}
C {lab_pin.sym} 4340 12760 0 0 {name=l10353 lab=WL64}
N 4440 12840 4460 12840 {}
C {lab_pin.sym} 4460 12840 0 0 {name=l10354 lab=VDD}
N 4440 12760 4460 12760 {}
C {lab_pin.sym} 4460 12760 0 0 {name=l10355 lab=VSS}
C {bitcell_6t.sym} 4600 12800 0 0 {name=Xr64c23}
N 4560 12840 4540 12840 {}
C {lab_pin.sym} 4540 12840 0 0 {name=l10356 lab=BL23}
N 4560 12800 4540 12800 {}
C {lab_pin.sym} 4540 12800 0 0 {name=l10357 lab=BLB23}
N 4560 12760 4540 12760 {}
C {lab_pin.sym} 4540 12760 0 0 {name=l10358 lab=WL64}
N 4640 12840 4660 12840 {}
C {lab_pin.sym} 4660 12840 0 0 {name=l10359 lab=VDD}
N 4640 12760 4660 12760 {}
C {lab_pin.sym} 4660 12760 0 0 {name=l10360 lab=VSS}
C {bitcell_6t.sym} 4800 12800 0 0 {name=Xr64c24}
N 4760 12840 4740 12840 {}
C {lab_pin.sym} 4740 12840 0 0 {name=l10361 lab=BL24}
N 4760 12800 4740 12800 {}
C {lab_pin.sym} 4740 12800 0 0 {name=l10362 lab=BLB24}
N 4760 12760 4740 12760 {}
C {lab_pin.sym} 4740 12760 0 0 {name=l10363 lab=WL64}
N 4840 12840 4860 12840 {}
C {lab_pin.sym} 4860 12840 0 0 {name=l10364 lab=VDD}
N 4840 12760 4860 12760 {}
C {lab_pin.sym} 4860 12760 0 0 {name=l10365 lab=VSS}
C {bitcell_6t.sym} 5000 12800 0 0 {name=Xr64c25}
N 4960 12840 4940 12840 {}
C {lab_pin.sym} 4940 12840 0 0 {name=l10366 lab=BL25}
N 4960 12800 4940 12800 {}
C {lab_pin.sym} 4940 12800 0 0 {name=l10367 lab=BLB25}
N 4960 12760 4940 12760 {}
C {lab_pin.sym} 4940 12760 0 0 {name=l10368 lab=WL64}
N 5040 12840 5060 12840 {}
C {lab_pin.sym} 5060 12840 0 0 {name=l10369 lab=VDD}
N 5040 12760 5060 12760 {}
C {lab_pin.sym} 5060 12760 0 0 {name=l10370 lab=VSS}
C {bitcell_6t.sym} 5200 12800 0 0 {name=Xr64c26}
N 5160 12840 5140 12840 {}
C {lab_pin.sym} 5140 12840 0 0 {name=l10371 lab=BL26}
N 5160 12800 5140 12800 {}
C {lab_pin.sym} 5140 12800 0 0 {name=l10372 lab=BLB26}
N 5160 12760 5140 12760 {}
C {lab_pin.sym} 5140 12760 0 0 {name=l10373 lab=WL64}
N 5240 12840 5260 12840 {}
C {lab_pin.sym} 5260 12840 0 0 {name=l10374 lab=VDD}
N 5240 12760 5260 12760 {}
C {lab_pin.sym} 5260 12760 0 0 {name=l10375 lab=VSS}
C {bitcell_6t.sym} 5400 12800 0 0 {name=Xr64c27}
N 5360 12840 5340 12840 {}
C {lab_pin.sym} 5340 12840 0 0 {name=l10376 lab=BL27}
N 5360 12800 5340 12800 {}
C {lab_pin.sym} 5340 12800 0 0 {name=l10377 lab=BLB27}
N 5360 12760 5340 12760 {}
C {lab_pin.sym} 5340 12760 0 0 {name=l10378 lab=WL64}
N 5440 12840 5460 12840 {}
C {lab_pin.sym} 5460 12840 0 0 {name=l10379 lab=VDD}
N 5440 12760 5460 12760 {}
C {lab_pin.sym} 5460 12760 0 0 {name=l10380 lab=VSS}
C {bitcell_6t.sym} 5600 12800 0 0 {name=Xr64c28}
N 5560 12840 5540 12840 {}
C {lab_pin.sym} 5540 12840 0 0 {name=l10381 lab=BL28}
N 5560 12800 5540 12800 {}
C {lab_pin.sym} 5540 12800 0 0 {name=l10382 lab=BLB28}
N 5560 12760 5540 12760 {}
C {lab_pin.sym} 5540 12760 0 0 {name=l10383 lab=WL64}
N 5640 12840 5660 12840 {}
C {lab_pin.sym} 5660 12840 0 0 {name=l10384 lab=VDD}
N 5640 12760 5660 12760 {}
C {lab_pin.sym} 5660 12760 0 0 {name=l10385 lab=VSS}
C {bitcell_6t.sym} 5800 12800 0 0 {name=Xr64c29}
N 5760 12840 5740 12840 {}
C {lab_pin.sym} 5740 12840 0 0 {name=l10386 lab=BL29}
N 5760 12800 5740 12800 {}
C {lab_pin.sym} 5740 12800 0 0 {name=l10387 lab=BLB29}
N 5760 12760 5740 12760 {}
C {lab_pin.sym} 5740 12760 0 0 {name=l10388 lab=WL64}
N 5840 12840 5860 12840 {}
C {lab_pin.sym} 5860 12840 0 0 {name=l10389 lab=VDD}
N 5840 12760 5860 12760 {}
C {lab_pin.sym} 5860 12760 0 0 {name=l10390 lab=VSS}
C {bitcell_6t.sym} 6000 12800 0 0 {name=Xr64c30}
N 5960 12840 5940 12840 {}
C {lab_pin.sym} 5940 12840 0 0 {name=l10391 lab=BL30}
N 5960 12800 5940 12800 {}
C {lab_pin.sym} 5940 12800 0 0 {name=l10392 lab=BLB30}
N 5960 12760 5940 12760 {}
C {lab_pin.sym} 5940 12760 0 0 {name=l10393 lab=WL64}
N 6040 12840 6060 12840 {}
C {lab_pin.sym} 6060 12840 0 0 {name=l10394 lab=VDD}
N 6040 12760 6060 12760 {}
C {lab_pin.sym} 6060 12760 0 0 {name=l10395 lab=VSS}
C {bitcell_6t.sym} 6200 12800 0 0 {name=Xr64c31}
N 6160 12840 6140 12840 {}
C {lab_pin.sym} 6140 12840 0 0 {name=l10396 lab=BL31}
N 6160 12800 6140 12800 {}
C {lab_pin.sym} 6140 12800 0 0 {name=l10397 lab=BLB31}
N 6160 12760 6140 12760 {}
C {lab_pin.sym} 6140 12760 0 0 {name=l10398 lab=WL64}
N 6240 12840 6260 12840 {}
C {lab_pin.sym} 6260 12840 0 0 {name=l10399 lab=VDD}
N 6240 12760 6260 12760 {}
C {lab_pin.sym} 6260 12760 0 0 {name=l10400 lab=VSS}
C {bitcell_6t.sym} 0 13000 0 0 {name=Xr65c0}
N -40 13040 -60 13040 {}
C {lab_pin.sym} -60 13040 0 0 {name=l10401 lab=BL0}
N -40 13000 -60 13000 {}
C {lab_pin.sym} -60 13000 0 0 {name=l10402 lab=BLB0}
N -40 12960 -60 12960 {}
C {lab_pin.sym} -60 12960 0 0 {name=l10403 lab=WL65}
N 40 13040 60 13040 {}
C {lab_pin.sym} 60 13040 0 0 {name=l10404 lab=VDD}
N 40 12960 60 12960 {}
C {lab_pin.sym} 60 12960 0 0 {name=l10405 lab=VSS}
C {bitcell_6t.sym} 200 13000 0 0 {name=Xr65c1}
N 160 13040 140 13040 {}
C {lab_pin.sym} 140 13040 0 0 {name=l10406 lab=BL1}
N 160 13000 140 13000 {}
C {lab_pin.sym} 140 13000 0 0 {name=l10407 lab=BLB1}
N 160 12960 140 12960 {}
C {lab_pin.sym} 140 12960 0 0 {name=l10408 lab=WL65}
N 240 13040 260 13040 {}
C {lab_pin.sym} 260 13040 0 0 {name=l10409 lab=VDD}
N 240 12960 260 12960 {}
C {lab_pin.sym} 260 12960 0 0 {name=l10410 lab=VSS}
C {bitcell_6t.sym} 400 13000 0 0 {name=Xr65c2}
N 360 13040 340 13040 {}
C {lab_pin.sym} 340 13040 0 0 {name=l10411 lab=BL2}
N 360 13000 340 13000 {}
C {lab_pin.sym} 340 13000 0 0 {name=l10412 lab=BLB2}
N 360 12960 340 12960 {}
C {lab_pin.sym} 340 12960 0 0 {name=l10413 lab=WL65}
N 440 13040 460 13040 {}
C {lab_pin.sym} 460 13040 0 0 {name=l10414 lab=VDD}
N 440 12960 460 12960 {}
C {lab_pin.sym} 460 12960 0 0 {name=l10415 lab=VSS}
C {bitcell_6t.sym} 600 13000 0 0 {name=Xr65c3}
N 560 13040 540 13040 {}
C {lab_pin.sym} 540 13040 0 0 {name=l10416 lab=BL3}
N 560 13000 540 13000 {}
C {lab_pin.sym} 540 13000 0 0 {name=l10417 lab=BLB3}
N 560 12960 540 12960 {}
C {lab_pin.sym} 540 12960 0 0 {name=l10418 lab=WL65}
N 640 13040 660 13040 {}
C {lab_pin.sym} 660 13040 0 0 {name=l10419 lab=VDD}
N 640 12960 660 12960 {}
C {lab_pin.sym} 660 12960 0 0 {name=l10420 lab=VSS}
C {bitcell_6t.sym} 800 13000 0 0 {name=Xr65c4}
N 760 13040 740 13040 {}
C {lab_pin.sym} 740 13040 0 0 {name=l10421 lab=BL4}
N 760 13000 740 13000 {}
C {lab_pin.sym} 740 13000 0 0 {name=l10422 lab=BLB4}
N 760 12960 740 12960 {}
C {lab_pin.sym} 740 12960 0 0 {name=l10423 lab=WL65}
N 840 13040 860 13040 {}
C {lab_pin.sym} 860 13040 0 0 {name=l10424 lab=VDD}
N 840 12960 860 12960 {}
C {lab_pin.sym} 860 12960 0 0 {name=l10425 lab=VSS}
C {bitcell_6t.sym} 1000 13000 0 0 {name=Xr65c5}
N 960 13040 940 13040 {}
C {lab_pin.sym} 940 13040 0 0 {name=l10426 lab=BL5}
N 960 13000 940 13000 {}
C {lab_pin.sym} 940 13000 0 0 {name=l10427 lab=BLB5}
N 960 12960 940 12960 {}
C {lab_pin.sym} 940 12960 0 0 {name=l10428 lab=WL65}
N 1040 13040 1060 13040 {}
C {lab_pin.sym} 1060 13040 0 0 {name=l10429 lab=VDD}
N 1040 12960 1060 12960 {}
C {lab_pin.sym} 1060 12960 0 0 {name=l10430 lab=VSS}
C {bitcell_6t.sym} 1200 13000 0 0 {name=Xr65c6}
N 1160 13040 1140 13040 {}
C {lab_pin.sym} 1140 13040 0 0 {name=l10431 lab=BL6}
N 1160 13000 1140 13000 {}
C {lab_pin.sym} 1140 13000 0 0 {name=l10432 lab=BLB6}
N 1160 12960 1140 12960 {}
C {lab_pin.sym} 1140 12960 0 0 {name=l10433 lab=WL65}
N 1240 13040 1260 13040 {}
C {lab_pin.sym} 1260 13040 0 0 {name=l10434 lab=VDD}
N 1240 12960 1260 12960 {}
C {lab_pin.sym} 1260 12960 0 0 {name=l10435 lab=VSS}
C {bitcell_6t.sym} 1400 13000 0 0 {name=Xr65c7}
N 1360 13040 1340 13040 {}
C {lab_pin.sym} 1340 13040 0 0 {name=l10436 lab=BL7}
N 1360 13000 1340 13000 {}
C {lab_pin.sym} 1340 13000 0 0 {name=l10437 lab=BLB7}
N 1360 12960 1340 12960 {}
C {lab_pin.sym} 1340 12960 0 0 {name=l10438 lab=WL65}
N 1440 13040 1460 13040 {}
C {lab_pin.sym} 1460 13040 0 0 {name=l10439 lab=VDD}
N 1440 12960 1460 12960 {}
C {lab_pin.sym} 1460 12960 0 0 {name=l10440 lab=VSS}
C {bitcell_6t.sym} 1600 13000 0 0 {name=Xr65c8}
N 1560 13040 1540 13040 {}
C {lab_pin.sym} 1540 13040 0 0 {name=l10441 lab=BL8}
N 1560 13000 1540 13000 {}
C {lab_pin.sym} 1540 13000 0 0 {name=l10442 lab=BLB8}
N 1560 12960 1540 12960 {}
C {lab_pin.sym} 1540 12960 0 0 {name=l10443 lab=WL65}
N 1640 13040 1660 13040 {}
C {lab_pin.sym} 1660 13040 0 0 {name=l10444 lab=VDD}
N 1640 12960 1660 12960 {}
C {lab_pin.sym} 1660 12960 0 0 {name=l10445 lab=VSS}
C {bitcell_6t.sym} 1800 13000 0 0 {name=Xr65c9}
N 1760 13040 1740 13040 {}
C {lab_pin.sym} 1740 13040 0 0 {name=l10446 lab=BL9}
N 1760 13000 1740 13000 {}
C {lab_pin.sym} 1740 13000 0 0 {name=l10447 lab=BLB9}
N 1760 12960 1740 12960 {}
C {lab_pin.sym} 1740 12960 0 0 {name=l10448 lab=WL65}
N 1840 13040 1860 13040 {}
C {lab_pin.sym} 1860 13040 0 0 {name=l10449 lab=VDD}
N 1840 12960 1860 12960 {}
C {lab_pin.sym} 1860 12960 0 0 {name=l10450 lab=VSS}
C {bitcell_6t.sym} 2000 13000 0 0 {name=Xr65c10}
N 1960 13040 1940 13040 {}
C {lab_pin.sym} 1940 13040 0 0 {name=l10451 lab=BL10}
N 1960 13000 1940 13000 {}
C {lab_pin.sym} 1940 13000 0 0 {name=l10452 lab=BLB10}
N 1960 12960 1940 12960 {}
C {lab_pin.sym} 1940 12960 0 0 {name=l10453 lab=WL65}
N 2040 13040 2060 13040 {}
C {lab_pin.sym} 2060 13040 0 0 {name=l10454 lab=VDD}
N 2040 12960 2060 12960 {}
C {lab_pin.sym} 2060 12960 0 0 {name=l10455 lab=VSS}
C {bitcell_6t.sym} 2200 13000 0 0 {name=Xr65c11}
N 2160 13040 2140 13040 {}
C {lab_pin.sym} 2140 13040 0 0 {name=l10456 lab=BL11}
N 2160 13000 2140 13000 {}
C {lab_pin.sym} 2140 13000 0 0 {name=l10457 lab=BLB11}
N 2160 12960 2140 12960 {}
C {lab_pin.sym} 2140 12960 0 0 {name=l10458 lab=WL65}
N 2240 13040 2260 13040 {}
C {lab_pin.sym} 2260 13040 0 0 {name=l10459 lab=VDD}
N 2240 12960 2260 12960 {}
C {lab_pin.sym} 2260 12960 0 0 {name=l10460 lab=VSS}
C {bitcell_6t.sym} 2400 13000 0 0 {name=Xr65c12}
N 2360 13040 2340 13040 {}
C {lab_pin.sym} 2340 13040 0 0 {name=l10461 lab=BL12}
N 2360 13000 2340 13000 {}
C {lab_pin.sym} 2340 13000 0 0 {name=l10462 lab=BLB12}
N 2360 12960 2340 12960 {}
C {lab_pin.sym} 2340 12960 0 0 {name=l10463 lab=WL65}
N 2440 13040 2460 13040 {}
C {lab_pin.sym} 2460 13040 0 0 {name=l10464 lab=VDD}
N 2440 12960 2460 12960 {}
C {lab_pin.sym} 2460 12960 0 0 {name=l10465 lab=VSS}
C {bitcell_6t.sym} 2600 13000 0 0 {name=Xr65c13}
N 2560 13040 2540 13040 {}
C {lab_pin.sym} 2540 13040 0 0 {name=l10466 lab=BL13}
N 2560 13000 2540 13000 {}
C {lab_pin.sym} 2540 13000 0 0 {name=l10467 lab=BLB13}
N 2560 12960 2540 12960 {}
C {lab_pin.sym} 2540 12960 0 0 {name=l10468 lab=WL65}
N 2640 13040 2660 13040 {}
C {lab_pin.sym} 2660 13040 0 0 {name=l10469 lab=VDD}
N 2640 12960 2660 12960 {}
C {lab_pin.sym} 2660 12960 0 0 {name=l10470 lab=VSS}
C {bitcell_6t.sym} 2800 13000 0 0 {name=Xr65c14}
N 2760 13040 2740 13040 {}
C {lab_pin.sym} 2740 13040 0 0 {name=l10471 lab=BL14}
N 2760 13000 2740 13000 {}
C {lab_pin.sym} 2740 13000 0 0 {name=l10472 lab=BLB14}
N 2760 12960 2740 12960 {}
C {lab_pin.sym} 2740 12960 0 0 {name=l10473 lab=WL65}
N 2840 13040 2860 13040 {}
C {lab_pin.sym} 2860 13040 0 0 {name=l10474 lab=VDD}
N 2840 12960 2860 12960 {}
C {lab_pin.sym} 2860 12960 0 0 {name=l10475 lab=VSS}
C {bitcell_6t.sym} 3000 13000 0 0 {name=Xr65c15}
N 2960 13040 2940 13040 {}
C {lab_pin.sym} 2940 13040 0 0 {name=l10476 lab=BL15}
N 2960 13000 2940 13000 {}
C {lab_pin.sym} 2940 13000 0 0 {name=l10477 lab=BLB15}
N 2960 12960 2940 12960 {}
C {lab_pin.sym} 2940 12960 0 0 {name=l10478 lab=WL65}
N 3040 13040 3060 13040 {}
C {lab_pin.sym} 3060 13040 0 0 {name=l10479 lab=VDD}
N 3040 12960 3060 12960 {}
C {lab_pin.sym} 3060 12960 0 0 {name=l10480 lab=VSS}
C {bitcell_6t.sym} 3200 13000 0 0 {name=Xr65c16}
N 3160 13040 3140 13040 {}
C {lab_pin.sym} 3140 13040 0 0 {name=l10481 lab=BL16}
N 3160 13000 3140 13000 {}
C {lab_pin.sym} 3140 13000 0 0 {name=l10482 lab=BLB16}
N 3160 12960 3140 12960 {}
C {lab_pin.sym} 3140 12960 0 0 {name=l10483 lab=WL65}
N 3240 13040 3260 13040 {}
C {lab_pin.sym} 3260 13040 0 0 {name=l10484 lab=VDD}
N 3240 12960 3260 12960 {}
C {lab_pin.sym} 3260 12960 0 0 {name=l10485 lab=VSS}
C {bitcell_6t.sym} 3400 13000 0 0 {name=Xr65c17}
N 3360 13040 3340 13040 {}
C {lab_pin.sym} 3340 13040 0 0 {name=l10486 lab=BL17}
N 3360 13000 3340 13000 {}
C {lab_pin.sym} 3340 13000 0 0 {name=l10487 lab=BLB17}
N 3360 12960 3340 12960 {}
C {lab_pin.sym} 3340 12960 0 0 {name=l10488 lab=WL65}
N 3440 13040 3460 13040 {}
C {lab_pin.sym} 3460 13040 0 0 {name=l10489 lab=VDD}
N 3440 12960 3460 12960 {}
C {lab_pin.sym} 3460 12960 0 0 {name=l10490 lab=VSS}
C {bitcell_6t.sym} 3600 13000 0 0 {name=Xr65c18}
N 3560 13040 3540 13040 {}
C {lab_pin.sym} 3540 13040 0 0 {name=l10491 lab=BL18}
N 3560 13000 3540 13000 {}
C {lab_pin.sym} 3540 13000 0 0 {name=l10492 lab=BLB18}
N 3560 12960 3540 12960 {}
C {lab_pin.sym} 3540 12960 0 0 {name=l10493 lab=WL65}
N 3640 13040 3660 13040 {}
C {lab_pin.sym} 3660 13040 0 0 {name=l10494 lab=VDD}
N 3640 12960 3660 12960 {}
C {lab_pin.sym} 3660 12960 0 0 {name=l10495 lab=VSS}
C {bitcell_6t.sym} 3800 13000 0 0 {name=Xr65c19}
N 3760 13040 3740 13040 {}
C {lab_pin.sym} 3740 13040 0 0 {name=l10496 lab=BL19}
N 3760 13000 3740 13000 {}
C {lab_pin.sym} 3740 13000 0 0 {name=l10497 lab=BLB19}
N 3760 12960 3740 12960 {}
C {lab_pin.sym} 3740 12960 0 0 {name=l10498 lab=WL65}
N 3840 13040 3860 13040 {}
C {lab_pin.sym} 3860 13040 0 0 {name=l10499 lab=VDD}
N 3840 12960 3860 12960 {}
C {lab_pin.sym} 3860 12960 0 0 {name=l10500 lab=VSS}
C {bitcell_6t.sym} 4000 13000 0 0 {name=Xr65c20}
N 3960 13040 3940 13040 {}
C {lab_pin.sym} 3940 13040 0 0 {name=l10501 lab=BL20}
N 3960 13000 3940 13000 {}
C {lab_pin.sym} 3940 13000 0 0 {name=l10502 lab=BLB20}
N 3960 12960 3940 12960 {}
C {lab_pin.sym} 3940 12960 0 0 {name=l10503 lab=WL65}
N 4040 13040 4060 13040 {}
C {lab_pin.sym} 4060 13040 0 0 {name=l10504 lab=VDD}
N 4040 12960 4060 12960 {}
C {lab_pin.sym} 4060 12960 0 0 {name=l10505 lab=VSS}
C {bitcell_6t.sym} 4200 13000 0 0 {name=Xr65c21}
N 4160 13040 4140 13040 {}
C {lab_pin.sym} 4140 13040 0 0 {name=l10506 lab=BL21}
N 4160 13000 4140 13000 {}
C {lab_pin.sym} 4140 13000 0 0 {name=l10507 lab=BLB21}
N 4160 12960 4140 12960 {}
C {lab_pin.sym} 4140 12960 0 0 {name=l10508 lab=WL65}
N 4240 13040 4260 13040 {}
C {lab_pin.sym} 4260 13040 0 0 {name=l10509 lab=VDD}
N 4240 12960 4260 12960 {}
C {lab_pin.sym} 4260 12960 0 0 {name=l10510 lab=VSS}
C {bitcell_6t.sym} 4400 13000 0 0 {name=Xr65c22}
N 4360 13040 4340 13040 {}
C {lab_pin.sym} 4340 13040 0 0 {name=l10511 lab=BL22}
N 4360 13000 4340 13000 {}
C {lab_pin.sym} 4340 13000 0 0 {name=l10512 lab=BLB22}
N 4360 12960 4340 12960 {}
C {lab_pin.sym} 4340 12960 0 0 {name=l10513 lab=WL65}
N 4440 13040 4460 13040 {}
C {lab_pin.sym} 4460 13040 0 0 {name=l10514 lab=VDD}
N 4440 12960 4460 12960 {}
C {lab_pin.sym} 4460 12960 0 0 {name=l10515 lab=VSS}
C {bitcell_6t.sym} 4600 13000 0 0 {name=Xr65c23}
N 4560 13040 4540 13040 {}
C {lab_pin.sym} 4540 13040 0 0 {name=l10516 lab=BL23}
N 4560 13000 4540 13000 {}
C {lab_pin.sym} 4540 13000 0 0 {name=l10517 lab=BLB23}
N 4560 12960 4540 12960 {}
C {lab_pin.sym} 4540 12960 0 0 {name=l10518 lab=WL65}
N 4640 13040 4660 13040 {}
C {lab_pin.sym} 4660 13040 0 0 {name=l10519 lab=VDD}
N 4640 12960 4660 12960 {}
C {lab_pin.sym} 4660 12960 0 0 {name=l10520 lab=VSS}
C {bitcell_6t.sym} 4800 13000 0 0 {name=Xr65c24}
N 4760 13040 4740 13040 {}
C {lab_pin.sym} 4740 13040 0 0 {name=l10521 lab=BL24}
N 4760 13000 4740 13000 {}
C {lab_pin.sym} 4740 13000 0 0 {name=l10522 lab=BLB24}
N 4760 12960 4740 12960 {}
C {lab_pin.sym} 4740 12960 0 0 {name=l10523 lab=WL65}
N 4840 13040 4860 13040 {}
C {lab_pin.sym} 4860 13040 0 0 {name=l10524 lab=VDD}
N 4840 12960 4860 12960 {}
C {lab_pin.sym} 4860 12960 0 0 {name=l10525 lab=VSS}
C {bitcell_6t.sym} 5000 13000 0 0 {name=Xr65c25}
N 4960 13040 4940 13040 {}
C {lab_pin.sym} 4940 13040 0 0 {name=l10526 lab=BL25}
N 4960 13000 4940 13000 {}
C {lab_pin.sym} 4940 13000 0 0 {name=l10527 lab=BLB25}
N 4960 12960 4940 12960 {}
C {lab_pin.sym} 4940 12960 0 0 {name=l10528 lab=WL65}
N 5040 13040 5060 13040 {}
C {lab_pin.sym} 5060 13040 0 0 {name=l10529 lab=VDD}
N 5040 12960 5060 12960 {}
C {lab_pin.sym} 5060 12960 0 0 {name=l10530 lab=VSS}
C {bitcell_6t.sym} 5200 13000 0 0 {name=Xr65c26}
N 5160 13040 5140 13040 {}
C {lab_pin.sym} 5140 13040 0 0 {name=l10531 lab=BL26}
N 5160 13000 5140 13000 {}
C {lab_pin.sym} 5140 13000 0 0 {name=l10532 lab=BLB26}
N 5160 12960 5140 12960 {}
C {lab_pin.sym} 5140 12960 0 0 {name=l10533 lab=WL65}
N 5240 13040 5260 13040 {}
C {lab_pin.sym} 5260 13040 0 0 {name=l10534 lab=VDD}
N 5240 12960 5260 12960 {}
C {lab_pin.sym} 5260 12960 0 0 {name=l10535 lab=VSS}
C {bitcell_6t.sym} 5400 13000 0 0 {name=Xr65c27}
N 5360 13040 5340 13040 {}
C {lab_pin.sym} 5340 13040 0 0 {name=l10536 lab=BL27}
N 5360 13000 5340 13000 {}
C {lab_pin.sym} 5340 13000 0 0 {name=l10537 lab=BLB27}
N 5360 12960 5340 12960 {}
C {lab_pin.sym} 5340 12960 0 0 {name=l10538 lab=WL65}
N 5440 13040 5460 13040 {}
C {lab_pin.sym} 5460 13040 0 0 {name=l10539 lab=VDD}
N 5440 12960 5460 12960 {}
C {lab_pin.sym} 5460 12960 0 0 {name=l10540 lab=VSS}
C {bitcell_6t.sym} 5600 13000 0 0 {name=Xr65c28}
N 5560 13040 5540 13040 {}
C {lab_pin.sym} 5540 13040 0 0 {name=l10541 lab=BL28}
N 5560 13000 5540 13000 {}
C {lab_pin.sym} 5540 13000 0 0 {name=l10542 lab=BLB28}
N 5560 12960 5540 12960 {}
C {lab_pin.sym} 5540 12960 0 0 {name=l10543 lab=WL65}
N 5640 13040 5660 13040 {}
C {lab_pin.sym} 5660 13040 0 0 {name=l10544 lab=VDD}
N 5640 12960 5660 12960 {}
C {lab_pin.sym} 5660 12960 0 0 {name=l10545 lab=VSS}
C {bitcell_6t.sym} 5800 13000 0 0 {name=Xr65c29}
N 5760 13040 5740 13040 {}
C {lab_pin.sym} 5740 13040 0 0 {name=l10546 lab=BL29}
N 5760 13000 5740 13000 {}
C {lab_pin.sym} 5740 13000 0 0 {name=l10547 lab=BLB29}
N 5760 12960 5740 12960 {}
C {lab_pin.sym} 5740 12960 0 0 {name=l10548 lab=WL65}
N 5840 13040 5860 13040 {}
C {lab_pin.sym} 5860 13040 0 0 {name=l10549 lab=VDD}
N 5840 12960 5860 12960 {}
C {lab_pin.sym} 5860 12960 0 0 {name=l10550 lab=VSS}
C {bitcell_6t.sym} 6000 13000 0 0 {name=Xr65c30}
N 5960 13040 5940 13040 {}
C {lab_pin.sym} 5940 13040 0 0 {name=l10551 lab=BL30}
N 5960 13000 5940 13000 {}
C {lab_pin.sym} 5940 13000 0 0 {name=l10552 lab=BLB30}
N 5960 12960 5940 12960 {}
C {lab_pin.sym} 5940 12960 0 0 {name=l10553 lab=WL65}
N 6040 13040 6060 13040 {}
C {lab_pin.sym} 6060 13040 0 0 {name=l10554 lab=VDD}
N 6040 12960 6060 12960 {}
C {lab_pin.sym} 6060 12960 0 0 {name=l10555 lab=VSS}
C {bitcell_6t.sym} 6200 13000 0 0 {name=Xr65c31}
N 6160 13040 6140 13040 {}
C {lab_pin.sym} 6140 13040 0 0 {name=l10556 lab=BL31}
N 6160 13000 6140 13000 {}
C {lab_pin.sym} 6140 13000 0 0 {name=l10557 lab=BLB31}
N 6160 12960 6140 12960 {}
C {lab_pin.sym} 6140 12960 0 0 {name=l10558 lab=WL65}
N 6240 13040 6260 13040 {}
C {lab_pin.sym} 6260 13040 0 0 {name=l10559 lab=VDD}
N 6240 12960 6260 12960 {}
C {lab_pin.sym} 6260 12960 0 0 {name=l10560 lab=VSS}
C {bitcell_6t.sym} 0 13200 0 0 {name=Xr66c0}
N -40 13240 -60 13240 {}
C {lab_pin.sym} -60 13240 0 0 {name=l10561 lab=BL0}
N -40 13200 -60 13200 {}
C {lab_pin.sym} -60 13200 0 0 {name=l10562 lab=BLB0}
N -40 13160 -60 13160 {}
C {lab_pin.sym} -60 13160 0 0 {name=l10563 lab=WL66}
N 40 13240 60 13240 {}
C {lab_pin.sym} 60 13240 0 0 {name=l10564 lab=VDD}
N 40 13160 60 13160 {}
C {lab_pin.sym} 60 13160 0 0 {name=l10565 lab=VSS}
C {bitcell_6t.sym} 200 13200 0 0 {name=Xr66c1}
N 160 13240 140 13240 {}
C {lab_pin.sym} 140 13240 0 0 {name=l10566 lab=BL1}
N 160 13200 140 13200 {}
C {lab_pin.sym} 140 13200 0 0 {name=l10567 lab=BLB1}
N 160 13160 140 13160 {}
C {lab_pin.sym} 140 13160 0 0 {name=l10568 lab=WL66}
N 240 13240 260 13240 {}
C {lab_pin.sym} 260 13240 0 0 {name=l10569 lab=VDD}
N 240 13160 260 13160 {}
C {lab_pin.sym} 260 13160 0 0 {name=l10570 lab=VSS}
C {bitcell_6t.sym} 400 13200 0 0 {name=Xr66c2}
N 360 13240 340 13240 {}
C {lab_pin.sym} 340 13240 0 0 {name=l10571 lab=BL2}
N 360 13200 340 13200 {}
C {lab_pin.sym} 340 13200 0 0 {name=l10572 lab=BLB2}
N 360 13160 340 13160 {}
C {lab_pin.sym} 340 13160 0 0 {name=l10573 lab=WL66}
N 440 13240 460 13240 {}
C {lab_pin.sym} 460 13240 0 0 {name=l10574 lab=VDD}
N 440 13160 460 13160 {}
C {lab_pin.sym} 460 13160 0 0 {name=l10575 lab=VSS}
C {bitcell_6t.sym} 600 13200 0 0 {name=Xr66c3}
N 560 13240 540 13240 {}
C {lab_pin.sym} 540 13240 0 0 {name=l10576 lab=BL3}
N 560 13200 540 13200 {}
C {lab_pin.sym} 540 13200 0 0 {name=l10577 lab=BLB3}
N 560 13160 540 13160 {}
C {lab_pin.sym} 540 13160 0 0 {name=l10578 lab=WL66}
N 640 13240 660 13240 {}
C {lab_pin.sym} 660 13240 0 0 {name=l10579 lab=VDD}
N 640 13160 660 13160 {}
C {lab_pin.sym} 660 13160 0 0 {name=l10580 lab=VSS}
C {bitcell_6t.sym} 800 13200 0 0 {name=Xr66c4}
N 760 13240 740 13240 {}
C {lab_pin.sym} 740 13240 0 0 {name=l10581 lab=BL4}
N 760 13200 740 13200 {}
C {lab_pin.sym} 740 13200 0 0 {name=l10582 lab=BLB4}
N 760 13160 740 13160 {}
C {lab_pin.sym} 740 13160 0 0 {name=l10583 lab=WL66}
N 840 13240 860 13240 {}
C {lab_pin.sym} 860 13240 0 0 {name=l10584 lab=VDD}
N 840 13160 860 13160 {}
C {lab_pin.sym} 860 13160 0 0 {name=l10585 lab=VSS}
C {bitcell_6t.sym} 1000 13200 0 0 {name=Xr66c5}
N 960 13240 940 13240 {}
C {lab_pin.sym} 940 13240 0 0 {name=l10586 lab=BL5}
N 960 13200 940 13200 {}
C {lab_pin.sym} 940 13200 0 0 {name=l10587 lab=BLB5}
N 960 13160 940 13160 {}
C {lab_pin.sym} 940 13160 0 0 {name=l10588 lab=WL66}
N 1040 13240 1060 13240 {}
C {lab_pin.sym} 1060 13240 0 0 {name=l10589 lab=VDD}
N 1040 13160 1060 13160 {}
C {lab_pin.sym} 1060 13160 0 0 {name=l10590 lab=VSS}
C {bitcell_6t.sym} 1200 13200 0 0 {name=Xr66c6}
N 1160 13240 1140 13240 {}
C {lab_pin.sym} 1140 13240 0 0 {name=l10591 lab=BL6}
N 1160 13200 1140 13200 {}
C {lab_pin.sym} 1140 13200 0 0 {name=l10592 lab=BLB6}
N 1160 13160 1140 13160 {}
C {lab_pin.sym} 1140 13160 0 0 {name=l10593 lab=WL66}
N 1240 13240 1260 13240 {}
C {lab_pin.sym} 1260 13240 0 0 {name=l10594 lab=VDD}
N 1240 13160 1260 13160 {}
C {lab_pin.sym} 1260 13160 0 0 {name=l10595 lab=VSS}
C {bitcell_6t.sym} 1400 13200 0 0 {name=Xr66c7}
N 1360 13240 1340 13240 {}
C {lab_pin.sym} 1340 13240 0 0 {name=l10596 lab=BL7}
N 1360 13200 1340 13200 {}
C {lab_pin.sym} 1340 13200 0 0 {name=l10597 lab=BLB7}
N 1360 13160 1340 13160 {}
C {lab_pin.sym} 1340 13160 0 0 {name=l10598 lab=WL66}
N 1440 13240 1460 13240 {}
C {lab_pin.sym} 1460 13240 0 0 {name=l10599 lab=VDD}
N 1440 13160 1460 13160 {}
C {lab_pin.sym} 1460 13160 0 0 {name=l10600 lab=VSS}
C {bitcell_6t.sym} 1600 13200 0 0 {name=Xr66c8}
N 1560 13240 1540 13240 {}
C {lab_pin.sym} 1540 13240 0 0 {name=l10601 lab=BL8}
N 1560 13200 1540 13200 {}
C {lab_pin.sym} 1540 13200 0 0 {name=l10602 lab=BLB8}
N 1560 13160 1540 13160 {}
C {lab_pin.sym} 1540 13160 0 0 {name=l10603 lab=WL66}
N 1640 13240 1660 13240 {}
C {lab_pin.sym} 1660 13240 0 0 {name=l10604 lab=VDD}
N 1640 13160 1660 13160 {}
C {lab_pin.sym} 1660 13160 0 0 {name=l10605 lab=VSS}
C {bitcell_6t.sym} 1800 13200 0 0 {name=Xr66c9}
N 1760 13240 1740 13240 {}
C {lab_pin.sym} 1740 13240 0 0 {name=l10606 lab=BL9}
N 1760 13200 1740 13200 {}
C {lab_pin.sym} 1740 13200 0 0 {name=l10607 lab=BLB9}
N 1760 13160 1740 13160 {}
C {lab_pin.sym} 1740 13160 0 0 {name=l10608 lab=WL66}
N 1840 13240 1860 13240 {}
C {lab_pin.sym} 1860 13240 0 0 {name=l10609 lab=VDD}
N 1840 13160 1860 13160 {}
C {lab_pin.sym} 1860 13160 0 0 {name=l10610 lab=VSS}
C {bitcell_6t.sym} 2000 13200 0 0 {name=Xr66c10}
N 1960 13240 1940 13240 {}
C {lab_pin.sym} 1940 13240 0 0 {name=l10611 lab=BL10}
N 1960 13200 1940 13200 {}
C {lab_pin.sym} 1940 13200 0 0 {name=l10612 lab=BLB10}
N 1960 13160 1940 13160 {}
C {lab_pin.sym} 1940 13160 0 0 {name=l10613 lab=WL66}
N 2040 13240 2060 13240 {}
C {lab_pin.sym} 2060 13240 0 0 {name=l10614 lab=VDD}
N 2040 13160 2060 13160 {}
C {lab_pin.sym} 2060 13160 0 0 {name=l10615 lab=VSS}
C {bitcell_6t.sym} 2200 13200 0 0 {name=Xr66c11}
N 2160 13240 2140 13240 {}
C {lab_pin.sym} 2140 13240 0 0 {name=l10616 lab=BL11}
N 2160 13200 2140 13200 {}
C {lab_pin.sym} 2140 13200 0 0 {name=l10617 lab=BLB11}
N 2160 13160 2140 13160 {}
C {lab_pin.sym} 2140 13160 0 0 {name=l10618 lab=WL66}
N 2240 13240 2260 13240 {}
C {lab_pin.sym} 2260 13240 0 0 {name=l10619 lab=VDD}
N 2240 13160 2260 13160 {}
C {lab_pin.sym} 2260 13160 0 0 {name=l10620 lab=VSS}
C {bitcell_6t.sym} 2400 13200 0 0 {name=Xr66c12}
N 2360 13240 2340 13240 {}
C {lab_pin.sym} 2340 13240 0 0 {name=l10621 lab=BL12}
N 2360 13200 2340 13200 {}
C {lab_pin.sym} 2340 13200 0 0 {name=l10622 lab=BLB12}
N 2360 13160 2340 13160 {}
C {lab_pin.sym} 2340 13160 0 0 {name=l10623 lab=WL66}
N 2440 13240 2460 13240 {}
C {lab_pin.sym} 2460 13240 0 0 {name=l10624 lab=VDD}
N 2440 13160 2460 13160 {}
C {lab_pin.sym} 2460 13160 0 0 {name=l10625 lab=VSS}
C {bitcell_6t.sym} 2600 13200 0 0 {name=Xr66c13}
N 2560 13240 2540 13240 {}
C {lab_pin.sym} 2540 13240 0 0 {name=l10626 lab=BL13}
N 2560 13200 2540 13200 {}
C {lab_pin.sym} 2540 13200 0 0 {name=l10627 lab=BLB13}
N 2560 13160 2540 13160 {}
C {lab_pin.sym} 2540 13160 0 0 {name=l10628 lab=WL66}
N 2640 13240 2660 13240 {}
C {lab_pin.sym} 2660 13240 0 0 {name=l10629 lab=VDD}
N 2640 13160 2660 13160 {}
C {lab_pin.sym} 2660 13160 0 0 {name=l10630 lab=VSS}
C {bitcell_6t.sym} 2800 13200 0 0 {name=Xr66c14}
N 2760 13240 2740 13240 {}
C {lab_pin.sym} 2740 13240 0 0 {name=l10631 lab=BL14}
N 2760 13200 2740 13200 {}
C {lab_pin.sym} 2740 13200 0 0 {name=l10632 lab=BLB14}
N 2760 13160 2740 13160 {}
C {lab_pin.sym} 2740 13160 0 0 {name=l10633 lab=WL66}
N 2840 13240 2860 13240 {}
C {lab_pin.sym} 2860 13240 0 0 {name=l10634 lab=VDD}
N 2840 13160 2860 13160 {}
C {lab_pin.sym} 2860 13160 0 0 {name=l10635 lab=VSS}
C {bitcell_6t.sym} 3000 13200 0 0 {name=Xr66c15}
N 2960 13240 2940 13240 {}
C {lab_pin.sym} 2940 13240 0 0 {name=l10636 lab=BL15}
N 2960 13200 2940 13200 {}
C {lab_pin.sym} 2940 13200 0 0 {name=l10637 lab=BLB15}
N 2960 13160 2940 13160 {}
C {lab_pin.sym} 2940 13160 0 0 {name=l10638 lab=WL66}
N 3040 13240 3060 13240 {}
C {lab_pin.sym} 3060 13240 0 0 {name=l10639 lab=VDD}
N 3040 13160 3060 13160 {}
C {lab_pin.sym} 3060 13160 0 0 {name=l10640 lab=VSS}
C {bitcell_6t.sym} 3200 13200 0 0 {name=Xr66c16}
N 3160 13240 3140 13240 {}
C {lab_pin.sym} 3140 13240 0 0 {name=l10641 lab=BL16}
N 3160 13200 3140 13200 {}
C {lab_pin.sym} 3140 13200 0 0 {name=l10642 lab=BLB16}
N 3160 13160 3140 13160 {}
C {lab_pin.sym} 3140 13160 0 0 {name=l10643 lab=WL66}
N 3240 13240 3260 13240 {}
C {lab_pin.sym} 3260 13240 0 0 {name=l10644 lab=VDD}
N 3240 13160 3260 13160 {}
C {lab_pin.sym} 3260 13160 0 0 {name=l10645 lab=VSS}
C {bitcell_6t.sym} 3400 13200 0 0 {name=Xr66c17}
N 3360 13240 3340 13240 {}
C {lab_pin.sym} 3340 13240 0 0 {name=l10646 lab=BL17}
N 3360 13200 3340 13200 {}
C {lab_pin.sym} 3340 13200 0 0 {name=l10647 lab=BLB17}
N 3360 13160 3340 13160 {}
C {lab_pin.sym} 3340 13160 0 0 {name=l10648 lab=WL66}
N 3440 13240 3460 13240 {}
C {lab_pin.sym} 3460 13240 0 0 {name=l10649 lab=VDD}
N 3440 13160 3460 13160 {}
C {lab_pin.sym} 3460 13160 0 0 {name=l10650 lab=VSS}
C {bitcell_6t.sym} 3600 13200 0 0 {name=Xr66c18}
N 3560 13240 3540 13240 {}
C {lab_pin.sym} 3540 13240 0 0 {name=l10651 lab=BL18}
N 3560 13200 3540 13200 {}
C {lab_pin.sym} 3540 13200 0 0 {name=l10652 lab=BLB18}
N 3560 13160 3540 13160 {}
C {lab_pin.sym} 3540 13160 0 0 {name=l10653 lab=WL66}
N 3640 13240 3660 13240 {}
C {lab_pin.sym} 3660 13240 0 0 {name=l10654 lab=VDD}
N 3640 13160 3660 13160 {}
C {lab_pin.sym} 3660 13160 0 0 {name=l10655 lab=VSS}
C {bitcell_6t.sym} 3800 13200 0 0 {name=Xr66c19}
N 3760 13240 3740 13240 {}
C {lab_pin.sym} 3740 13240 0 0 {name=l10656 lab=BL19}
N 3760 13200 3740 13200 {}
C {lab_pin.sym} 3740 13200 0 0 {name=l10657 lab=BLB19}
N 3760 13160 3740 13160 {}
C {lab_pin.sym} 3740 13160 0 0 {name=l10658 lab=WL66}
N 3840 13240 3860 13240 {}
C {lab_pin.sym} 3860 13240 0 0 {name=l10659 lab=VDD}
N 3840 13160 3860 13160 {}
C {lab_pin.sym} 3860 13160 0 0 {name=l10660 lab=VSS}
C {bitcell_6t.sym} 4000 13200 0 0 {name=Xr66c20}
N 3960 13240 3940 13240 {}
C {lab_pin.sym} 3940 13240 0 0 {name=l10661 lab=BL20}
N 3960 13200 3940 13200 {}
C {lab_pin.sym} 3940 13200 0 0 {name=l10662 lab=BLB20}
N 3960 13160 3940 13160 {}
C {lab_pin.sym} 3940 13160 0 0 {name=l10663 lab=WL66}
N 4040 13240 4060 13240 {}
C {lab_pin.sym} 4060 13240 0 0 {name=l10664 lab=VDD}
N 4040 13160 4060 13160 {}
C {lab_pin.sym} 4060 13160 0 0 {name=l10665 lab=VSS}
C {bitcell_6t.sym} 4200 13200 0 0 {name=Xr66c21}
N 4160 13240 4140 13240 {}
C {lab_pin.sym} 4140 13240 0 0 {name=l10666 lab=BL21}
N 4160 13200 4140 13200 {}
C {lab_pin.sym} 4140 13200 0 0 {name=l10667 lab=BLB21}
N 4160 13160 4140 13160 {}
C {lab_pin.sym} 4140 13160 0 0 {name=l10668 lab=WL66}
N 4240 13240 4260 13240 {}
C {lab_pin.sym} 4260 13240 0 0 {name=l10669 lab=VDD}
N 4240 13160 4260 13160 {}
C {lab_pin.sym} 4260 13160 0 0 {name=l10670 lab=VSS}
C {bitcell_6t.sym} 4400 13200 0 0 {name=Xr66c22}
N 4360 13240 4340 13240 {}
C {lab_pin.sym} 4340 13240 0 0 {name=l10671 lab=BL22}
N 4360 13200 4340 13200 {}
C {lab_pin.sym} 4340 13200 0 0 {name=l10672 lab=BLB22}
N 4360 13160 4340 13160 {}
C {lab_pin.sym} 4340 13160 0 0 {name=l10673 lab=WL66}
N 4440 13240 4460 13240 {}
C {lab_pin.sym} 4460 13240 0 0 {name=l10674 lab=VDD}
N 4440 13160 4460 13160 {}
C {lab_pin.sym} 4460 13160 0 0 {name=l10675 lab=VSS}
C {bitcell_6t.sym} 4600 13200 0 0 {name=Xr66c23}
N 4560 13240 4540 13240 {}
C {lab_pin.sym} 4540 13240 0 0 {name=l10676 lab=BL23}
N 4560 13200 4540 13200 {}
C {lab_pin.sym} 4540 13200 0 0 {name=l10677 lab=BLB23}
N 4560 13160 4540 13160 {}
C {lab_pin.sym} 4540 13160 0 0 {name=l10678 lab=WL66}
N 4640 13240 4660 13240 {}
C {lab_pin.sym} 4660 13240 0 0 {name=l10679 lab=VDD}
N 4640 13160 4660 13160 {}
C {lab_pin.sym} 4660 13160 0 0 {name=l10680 lab=VSS}
C {bitcell_6t.sym} 4800 13200 0 0 {name=Xr66c24}
N 4760 13240 4740 13240 {}
C {lab_pin.sym} 4740 13240 0 0 {name=l10681 lab=BL24}
N 4760 13200 4740 13200 {}
C {lab_pin.sym} 4740 13200 0 0 {name=l10682 lab=BLB24}
N 4760 13160 4740 13160 {}
C {lab_pin.sym} 4740 13160 0 0 {name=l10683 lab=WL66}
N 4840 13240 4860 13240 {}
C {lab_pin.sym} 4860 13240 0 0 {name=l10684 lab=VDD}
N 4840 13160 4860 13160 {}
C {lab_pin.sym} 4860 13160 0 0 {name=l10685 lab=VSS}
C {bitcell_6t.sym} 5000 13200 0 0 {name=Xr66c25}
N 4960 13240 4940 13240 {}
C {lab_pin.sym} 4940 13240 0 0 {name=l10686 lab=BL25}
N 4960 13200 4940 13200 {}
C {lab_pin.sym} 4940 13200 0 0 {name=l10687 lab=BLB25}
N 4960 13160 4940 13160 {}
C {lab_pin.sym} 4940 13160 0 0 {name=l10688 lab=WL66}
N 5040 13240 5060 13240 {}
C {lab_pin.sym} 5060 13240 0 0 {name=l10689 lab=VDD}
N 5040 13160 5060 13160 {}
C {lab_pin.sym} 5060 13160 0 0 {name=l10690 lab=VSS}
C {bitcell_6t.sym} 5200 13200 0 0 {name=Xr66c26}
N 5160 13240 5140 13240 {}
C {lab_pin.sym} 5140 13240 0 0 {name=l10691 lab=BL26}
N 5160 13200 5140 13200 {}
C {lab_pin.sym} 5140 13200 0 0 {name=l10692 lab=BLB26}
N 5160 13160 5140 13160 {}
C {lab_pin.sym} 5140 13160 0 0 {name=l10693 lab=WL66}
N 5240 13240 5260 13240 {}
C {lab_pin.sym} 5260 13240 0 0 {name=l10694 lab=VDD}
N 5240 13160 5260 13160 {}
C {lab_pin.sym} 5260 13160 0 0 {name=l10695 lab=VSS}
C {bitcell_6t.sym} 5400 13200 0 0 {name=Xr66c27}
N 5360 13240 5340 13240 {}
C {lab_pin.sym} 5340 13240 0 0 {name=l10696 lab=BL27}
N 5360 13200 5340 13200 {}
C {lab_pin.sym} 5340 13200 0 0 {name=l10697 lab=BLB27}
N 5360 13160 5340 13160 {}
C {lab_pin.sym} 5340 13160 0 0 {name=l10698 lab=WL66}
N 5440 13240 5460 13240 {}
C {lab_pin.sym} 5460 13240 0 0 {name=l10699 lab=VDD}
N 5440 13160 5460 13160 {}
C {lab_pin.sym} 5460 13160 0 0 {name=l10700 lab=VSS}
C {bitcell_6t.sym} 5600 13200 0 0 {name=Xr66c28}
N 5560 13240 5540 13240 {}
C {lab_pin.sym} 5540 13240 0 0 {name=l10701 lab=BL28}
N 5560 13200 5540 13200 {}
C {lab_pin.sym} 5540 13200 0 0 {name=l10702 lab=BLB28}
N 5560 13160 5540 13160 {}
C {lab_pin.sym} 5540 13160 0 0 {name=l10703 lab=WL66}
N 5640 13240 5660 13240 {}
C {lab_pin.sym} 5660 13240 0 0 {name=l10704 lab=VDD}
N 5640 13160 5660 13160 {}
C {lab_pin.sym} 5660 13160 0 0 {name=l10705 lab=VSS}
C {bitcell_6t.sym} 5800 13200 0 0 {name=Xr66c29}
N 5760 13240 5740 13240 {}
C {lab_pin.sym} 5740 13240 0 0 {name=l10706 lab=BL29}
N 5760 13200 5740 13200 {}
C {lab_pin.sym} 5740 13200 0 0 {name=l10707 lab=BLB29}
N 5760 13160 5740 13160 {}
C {lab_pin.sym} 5740 13160 0 0 {name=l10708 lab=WL66}
N 5840 13240 5860 13240 {}
C {lab_pin.sym} 5860 13240 0 0 {name=l10709 lab=VDD}
N 5840 13160 5860 13160 {}
C {lab_pin.sym} 5860 13160 0 0 {name=l10710 lab=VSS}
C {bitcell_6t.sym} 6000 13200 0 0 {name=Xr66c30}
N 5960 13240 5940 13240 {}
C {lab_pin.sym} 5940 13240 0 0 {name=l10711 lab=BL30}
N 5960 13200 5940 13200 {}
C {lab_pin.sym} 5940 13200 0 0 {name=l10712 lab=BLB30}
N 5960 13160 5940 13160 {}
C {lab_pin.sym} 5940 13160 0 0 {name=l10713 lab=WL66}
N 6040 13240 6060 13240 {}
C {lab_pin.sym} 6060 13240 0 0 {name=l10714 lab=VDD}
N 6040 13160 6060 13160 {}
C {lab_pin.sym} 6060 13160 0 0 {name=l10715 lab=VSS}
C {bitcell_6t.sym} 6200 13200 0 0 {name=Xr66c31}
N 6160 13240 6140 13240 {}
C {lab_pin.sym} 6140 13240 0 0 {name=l10716 lab=BL31}
N 6160 13200 6140 13200 {}
C {lab_pin.sym} 6140 13200 0 0 {name=l10717 lab=BLB31}
N 6160 13160 6140 13160 {}
C {lab_pin.sym} 6140 13160 0 0 {name=l10718 lab=WL66}
N 6240 13240 6260 13240 {}
C {lab_pin.sym} 6260 13240 0 0 {name=l10719 lab=VDD}
N 6240 13160 6260 13160 {}
C {lab_pin.sym} 6260 13160 0 0 {name=l10720 lab=VSS}
C {bitcell_6t.sym} 0 13400 0 0 {name=Xr67c0}
N -40 13440 -60 13440 {}
C {lab_pin.sym} -60 13440 0 0 {name=l10721 lab=BL0}
N -40 13400 -60 13400 {}
C {lab_pin.sym} -60 13400 0 0 {name=l10722 lab=BLB0}
N -40 13360 -60 13360 {}
C {lab_pin.sym} -60 13360 0 0 {name=l10723 lab=WL67}
N 40 13440 60 13440 {}
C {lab_pin.sym} 60 13440 0 0 {name=l10724 lab=VDD}
N 40 13360 60 13360 {}
C {lab_pin.sym} 60 13360 0 0 {name=l10725 lab=VSS}
C {bitcell_6t.sym} 200 13400 0 0 {name=Xr67c1}
N 160 13440 140 13440 {}
C {lab_pin.sym} 140 13440 0 0 {name=l10726 lab=BL1}
N 160 13400 140 13400 {}
C {lab_pin.sym} 140 13400 0 0 {name=l10727 lab=BLB1}
N 160 13360 140 13360 {}
C {lab_pin.sym} 140 13360 0 0 {name=l10728 lab=WL67}
N 240 13440 260 13440 {}
C {lab_pin.sym} 260 13440 0 0 {name=l10729 lab=VDD}
N 240 13360 260 13360 {}
C {lab_pin.sym} 260 13360 0 0 {name=l10730 lab=VSS}
C {bitcell_6t.sym} 400 13400 0 0 {name=Xr67c2}
N 360 13440 340 13440 {}
C {lab_pin.sym} 340 13440 0 0 {name=l10731 lab=BL2}
N 360 13400 340 13400 {}
C {lab_pin.sym} 340 13400 0 0 {name=l10732 lab=BLB2}
N 360 13360 340 13360 {}
C {lab_pin.sym} 340 13360 0 0 {name=l10733 lab=WL67}
N 440 13440 460 13440 {}
C {lab_pin.sym} 460 13440 0 0 {name=l10734 lab=VDD}
N 440 13360 460 13360 {}
C {lab_pin.sym} 460 13360 0 0 {name=l10735 lab=VSS}
C {bitcell_6t.sym} 600 13400 0 0 {name=Xr67c3}
N 560 13440 540 13440 {}
C {lab_pin.sym} 540 13440 0 0 {name=l10736 lab=BL3}
N 560 13400 540 13400 {}
C {lab_pin.sym} 540 13400 0 0 {name=l10737 lab=BLB3}
N 560 13360 540 13360 {}
C {lab_pin.sym} 540 13360 0 0 {name=l10738 lab=WL67}
N 640 13440 660 13440 {}
C {lab_pin.sym} 660 13440 0 0 {name=l10739 lab=VDD}
N 640 13360 660 13360 {}
C {lab_pin.sym} 660 13360 0 0 {name=l10740 lab=VSS}
C {bitcell_6t.sym} 800 13400 0 0 {name=Xr67c4}
N 760 13440 740 13440 {}
C {lab_pin.sym} 740 13440 0 0 {name=l10741 lab=BL4}
N 760 13400 740 13400 {}
C {lab_pin.sym} 740 13400 0 0 {name=l10742 lab=BLB4}
N 760 13360 740 13360 {}
C {lab_pin.sym} 740 13360 0 0 {name=l10743 lab=WL67}
N 840 13440 860 13440 {}
C {lab_pin.sym} 860 13440 0 0 {name=l10744 lab=VDD}
N 840 13360 860 13360 {}
C {lab_pin.sym} 860 13360 0 0 {name=l10745 lab=VSS}
C {bitcell_6t.sym} 1000 13400 0 0 {name=Xr67c5}
N 960 13440 940 13440 {}
C {lab_pin.sym} 940 13440 0 0 {name=l10746 lab=BL5}
N 960 13400 940 13400 {}
C {lab_pin.sym} 940 13400 0 0 {name=l10747 lab=BLB5}
N 960 13360 940 13360 {}
C {lab_pin.sym} 940 13360 0 0 {name=l10748 lab=WL67}
N 1040 13440 1060 13440 {}
C {lab_pin.sym} 1060 13440 0 0 {name=l10749 lab=VDD}
N 1040 13360 1060 13360 {}
C {lab_pin.sym} 1060 13360 0 0 {name=l10750 lab=VSS}
C {bitcell_6t.sym} 1200 13400 0 0 {name=Xr67c6}
N 1160 13440 1140 13440 {}
C {lab_pin.sym} 1140 13440 0 0 {name=l10751 lab=BL6}
N 1160 13400 1140 13400 {}
C {lab_pin.sym} 1140 13400 0 0 {name=l10752 lab=BLB6}
N 1160 13360 1140 13360 {}
C {lab_pin.sym} 1140 13360 0 0 {name=l10753 lab=WL67}
N 1240 13440 1260 13440 {}
C {lab_pin.sym} 1260 13440 0 0 {name=l10754 lab=VDD}
N 1240 13360 1260 13360 {}
C {lab_pin.sym} 1260 13360 0 0 {name=l10755 lab=VSS}
C {bitcell_6t.sym} 1400 13400 0 0 {name=Xr67c7}
N 1360 13440 1340 13440 {}
C {lab_pin.sym} 1340 13440 0 0 {name=l10756 lab=BL7}
N 1360 13400 1340 13400 {}
C {lab_pin.sym} 1340 13400 0 0 {name=l10757 lab=BLB7}
N 1360 13360 1340 13360 {}
C {lab_pin.sym} 1340 13360 0 0 {name=l10758 lab=WL67}
N 1440 13440 1460 13440 {}
C {lab_pin.sym} 1460 13440 0 0 {name=l10759 lab=VDD}
N 1440 13360 1460 13360 {}
C {lab_pin.sym} 1460 13360 0 0 {name=l10760 lab=VSS}
C {bitcell_6t.sym} 1600 13400 0 0 {name=Xr67c8}
N 1560 13440 1540 13440 {}
C {lab_pin.sym} 1540 13440 0 0 {name=l10761 lab=BL8}
N 1560 13400 1540 13400 {}
C {lab_pin.sym} 1540 13400 0 0 {name=l10762 lab=BLB8}
N 1560 13360 1540 13360 {}
C {lab_pin.sym} 1540 13360 0 0 {name=l10763 lab=WL67}
N 1640 13440 1660 13440 {}
C {lab_pin.sym} 1660 13440 0 0 {name=l10764 lab=VDD}
N 1640 13360 1660 13360 {}
C {lab_pin.sym} 1660 13360 0 0 {name=l10765 lab=VSS}
C {bitcell_6t.sym} 1800 13400 0 0 {name=Xr67c9}
N 1760 13440 1740 13440 {}
C {lab_pin.sym} 1740 13440 0 0 {name=l10766 lab=BL9}
N 1760 13400 1740 13400 {}
C {lab_pin.sym} 1740 13400 0 0 {name=l10767 lab=BLB9}
N 1760 13360 1740 13360 {}
C {lab_pin.sym} 1740 13360 0 0 {name=l10768 lab=WL67}
N 1840 13440 1860 13440 {}
C {lab_pin.sym} 1860 13440 0 0 {name=l10769 lab=VDD}
N 1840 13360 1860 13360 {}
C {lab_pin.sym} 1860 13360 0 0 {name=l10770 lab=VSS}
C {bitcell_6t.sym} 2000 13400 0 0 {name=Xr67c10}
N 1960 13440 1940 13440 {}
C {lab_pin.sym} 1940 13440 0 0 {name=l10771 lab=BL10}
N 1960 13400 1940 13400 {}
C {lab_pin.sym} 1940 13400 0 0 {name=l10772 lab=BLB10}
N 1960 13360 1940 13360 {}
C {lab_pin.sym} 1940 13360 0 0 {name=l10773 lab=WL67}
N 2040 13440 2060 13440 {}
C {lab_pin.sym} 2060 13440 0 0 {name=l10774 lab=VDD}
N 2040 13360 2060 13360 {}
C {lab_pin.sym} 2060 13360 0 0 {name=l10775 lab=VSS}
C {bitcell_6t.sym} 2200 13400 0 0 {name=Xr67c11}
N 2160 13440 2140 13440 {}
C {lab_pin.sym} 2140 13440 0 0 {name=l10776 lab=BL11}
N 2160 13400 2140 13400 {}
C {lab_pin.sym} 2140 13400 0 0 {name=l10777 lab=BLB11}
N 2160 13360 2140 13360 {}
C {lab_pin.sym} 2140 13360 0 0 {name=l10778 lab=WL67}
N 2240 13440 2260 13440 {}
C {lab_pin.sym} 2260 13440 0 0 {name=l10779 lab=VDD}
N 2240 13360 2260 13360 {}
C {lab_pin.sym} 2260 13360 0 0 {name=l10780 lab=VSS}
C {bitcell_6t.sym} 2400 13400 0 0 {name=Xr67c12}
N 2360 13440 2340 13440 {}
C {lab_pin.sym} 2340 13440 0 0 {name=l10781 lab=BL12}
N 2360 13400 2340 13400 {}
C {lab_pin.sym} 2340 13400 0 0 {name=l10782 lab=BLB12}
N 2360 13360 2340 13360 {}
C {lab_pin.sym} 2340 13360 0 0 {name=l10783 lab=WL67}
N 2440 13440 2460 13440 {}
C {lab_pin.sym} 2460 13440 0 0 {name=l10784 lab=VDD}
N 2440 13360 2460 13360 {}
C {lab_pin.sym} 2460 13360 0 0 {name=l10785 lab=VSS}
C {bitcell_6t.sym} 2600 13400 0 0 {name=Xr67c13}
N 2560 13440 2540 13440 {}
C {lab_pin.sym} 2540 13440 0 0 {name=l10786 lab=BL13}
N 2560 13400 2540 13400 {}
C {lab_pin.sym} 2540 13400 0 0 {name=l10787 lab=BLB13}
N 2560 13360 2540 13360 {}
C {lab_pin.sym} 2540 13360 0 0 {name=l10788 lab=WL67}
N 2640 13440 2660 13440 {}
C {lab_pin.sym} 2660 13440 0 0 {name=l10789 lab=VDD}
N 2640 13360 2660 13360 {}
C {lab_pin.sym} 2660 13360 0 0 {name=l10790 lab=VSS}
C {bitcell_6t.sym} 2800 13400 0 0 {name=Xr67c14}
N 2760 13440 2740 13440 {}
C {lab_pin.sym} 2740 13440 0 0 {name=l10791 lab=BL14}
N 2760 13400 2740 13400 {}
C {lab_pin.sym} 2740 13400 0 0 {name=l10792 lab=BLB14}
N 2760 13360 2740 13360 {}
C {lab_pin.sym} 2740 13360 0 0 {name=l10793 lab=WL67}
N 2840 13440 2860 13440 {}
C {lab_pin.sym} 2860 13440 0 0 {name=l10794 lab=VDD}
N 2840 13360 2860 13360 {}
C {lab_pin.sym} 2860 13360 0 0 {name=l10795 lab=VSS}
C {bitcell_6t.sym} 3000 13400 0 0 {name=Xr67c15}
N 2960 13440 2940 13440 {}
C {lab_pin.sym} 2940 13440 0 0 {name=l10796 lab=BL15}
N 2960 13400 2940 13400 {}
C {lab_pin.sym} 2940 13400 0 0 {name=l10797 lab=BLB15}
N 2960 13360 2940 13360 {}
C {lab_pin.sym} 2940 13360 0 0 {name=l10798 lab=WL67}
N 3040 13440 3060 13440 {}
C {lab_pin.sym} 3060 13440 0 0 {name=l10799 lab=VDD}
N 3040 13360 3060 13360 {}
C {lab_pin.sym} 3060 13360 0 0 {name=l10800 lab=VSS}
C {bitcell_6t.sym} 3200 13400 0 0 {name=Xr67c16}
N 3160 13440 3140 13440 {}
C {lab_pin.sym} 3140 13440 0 0 {name=l10801 lab=BL16}
N 3160 13400 3140 13400 {}
C {lab_pin.sym} 3140 13400 0 0 {name=l10802 lab=BLB16}
N 3160 13360 3140 13360 {}
C {lab_pin.sym} 3140 13360 0 0 {name=l10803 lab=WL67}
N 3240 13440 3260 13440 {}
C {lab_pin.sym} 3260 13440 0 0 {name=l10804 lab=VDD}
N 3240 13360 3260 13360 {}
C {lab_pin.sym} 3260 13360 0 0 {name=l10805 lab=VSS}
C {bitcell_6t.sym} 3400 13400 0 0 {name=Xr67c17}
N 3360 13440 3340 13440 {}
C {lab_pin.sym} 3340 13440 0 0 {name=l10806 lab=BL17}
N 3360 13400 3340 13400 {}
C {lab_pin.sym} 3340 13400 0 0 {name=l10807 lab=BLB17}
N 3360 13360 3340 13360 {}
C {lab_pin.sym} 3340 13360 0 0 {name=l10808 lab=WL67}
N 3440 13440 3460 13440 {}
C {lab_pin.sym} 3460 13440 0 0 {name=l10809 lab=VDD}
N 3440 13360 3460 13360 {}
C {lab_pin.sym} 3460 13360 0 0 {name=l10810 lab=VSS}
C {bitcell_6t.sym} 3600 13400 0 0 {name=Xr67c18}
N 3560 13440 3540 13440 {}
C {lab_pin.sym} 3540 13440 0 0 {name=l10811 lab=BL18}
N 3560 13400 3540 13400 {}
C {lab_pin.sym} 3540 13400 0 0 {name=l10812 lab=BLB18}
N 3560 13360 3540 13360 {}
C {lab_pin.sym} 3540 13360 0 0 {name=l10813 lab=WL67}
N 3640 13440 3660 13440 {}
C {lab_pin.sym} 3660 13440 0 0 {name=l10814 lab=VDD}
N 3640 13360 3660 13360 {}
C {lab_pin.sym} 3660 13360 0 0 {name=l10815 lab=VSS}
C {bitcell_6t.sym} 3800 13400 0 0 {name=Xr67c19}
N 3760 13440 3740 13440 {}
C {lab_pin.sym} 3740 13440 0 0 {name=l10816 lab=BL19}
N 3760 13400 3740 13400 {}
C {lab_pin.sym} 3740 13400 0 0 {name=l10817 lab=BLB19}
N 3760 13360 3740 13360 {}
C {lab_pin.sym} 3740 13360 0 0 {name=l10818 lab=WL67}
N 3840 13440 3860 13440 {}
C {lab_pin.sym} 3860 13440 0 0 {name=l10819 lab=VDD}
N 3840 13360 3860 13360 {}
C {lab_pin.sym} 3860 13360 0 0 {name=l10820 lab=VSS}
C {bitcell_6t.sym} 4000 13400 0 0 {name=Xr67c20}
N 3960 13440 3940 13440 {}
C {lab_pin.sym} 3940 13440 0 0 {name=l10821 lab=BL20}
N 3960 13400 3940 13400 {}
C {lab_pin.sym} 3940 13400 0 0 {name=l10822 lab=BLB20}
N 3960 13360 3940 13360 {}
C {lab_pin.sym} 3940 13360 0 0 {name=l10823 lab=WL67}
N 4040 13440 4060 13440 {}
C {lab_pin.sym} 4060 13440 0 0 {name=l10824 lab=VDD}
N 4040 13360 4060 13360 {}
C {lab_pin.sym} 4060 13360 0 0 {name=l10825 lab=VSS}
C {bitcell_6t.sym} 4200 13400 0 0 {name=Xr67c21}
N 4160 13440 4140 13440 {}
C {lab_pin.sym} 4140 13440 0 0 {name=l10826 lab=BL21}
N 4160 13400 4140 13400 {}
C {lab_pin.sym} 4140 13400 0 0 {name=l10827 lab=BLB21}
N 4160 13360 4140 13360 {}
C {lab_pin.sym} 4140 13360 0 0 {name=l10828 lab=WL67}
N 4240 13440 4260 13440 {}
C {lab_pin.sym} 4260 13440 0 0 {name=l10829 lab=VDD}
N 4240 13360 4260 13360 {}
C {lab_pin.sym} 4260 13360 0 0 {name=l10830 lab=VSS}
C {bitcell_6t.sym} 4400 13400 0 0 {name=Xr67c22}
N 4360 13440 4340 13440 {}
C {lab_pin.sym} 4340 13440 0 0 {name=l10831 lab=BL22}
N 4360 13400 4340 13400 {}
C {lab_pin.sym} 4340 13400 0 0 {name=l10832 lab=BLB22}
N 4360 13360 4340 13360 {}
C {lab_pin.sym} 4340 13360 0 0 {name=l10833 lab=WL67}
N 4440 13440 4460 13440 {}
C {lab_pin.sym} 4460 13440 0 0 {name=l10834 lab=VDD}
N 4440 13360 4460 13360 {}
C {lab_pin.sym} 4460 13360 0 0 {name=l10835 lab=VSS}
C {bitcell_6t.sym} 4600 13400 0 0 {name=Xr67c23}
N 4560 13440 4540 13440 {}
C {lab_pin.sym} 4540 13440 0 0 {name=l10836 lab=BL23}
N 4560 13400 4540 13400 {}
C {lab_pin.sym} 4540 13400 0 0 {name=l10837 lab=BLB23}
N 4560 13360 4540 13360 {}
C {lab_pin.sym} 4540 13360 0 0 {name=l10838 lab=WL67}
N 4640 13440 4660 13440 {}
C {lab_pin.sym} 4660 13440 0 0 {name=l10839 lab=VDD}
N 4640 13360 4660 13360 {}
C {lab_pin.sym} 4660 13360 0 0 {name=l10840 lab=VSS}
C {bitcell_6t.sym} 4800 13400 0 0 {name=Xr67c24}
N 4760 13440 4740 13440 {}
C {lab_pin.sym} 4740 13440 0 0 {name=l10841 lab=BL24}
N 4760 13400 4740 13400 {}
C {lab_pin.sym} 4740 13400 0 0 {name=l10842 lab=BLB24}
N 4760 13360 4740 13360 {}
C {lab_pin.sym} 4740 13360 0 0 {name=l10843 lab=WL67}
N 4840 13440 4860 13440 {}
C {lab_pin.sym} 4860 13440 0 0 {name=l10844 lab=VDD}
N 4840 13360 4860 13360 {}
C {lab_pin.sym} 4860 13360 0 0 {name=l10845 lab=VSS}
C {bitcell_6t.sym} 5000 13400 0 0 {name=Xr67c25}
N 4960 13440 4940 13440 {}
C {lab_pin.sym} 4940 13440 0 0 {name=l10846 lab=BL25}
N 4960 13400 4940 13400 {}
C {lab_pin.sym} 4940 13400 0 0 {name=l10847 lab=BLB25}
N 4960 13360 4940 13360 {}
C {lab_pin.sym} 4940 13360 0 0 {name=l10848 lab=WL67}
N 5040 13440 5060 13440 {}
C {lab_pin.sym} 5060 13440 0 0 {name=l10849 lab=VDD}
N 5040 13360 5060 13360 {}
C {lab_pin.sym} 5060 13360 0 0 {name=l10850 lab=VSS}
C {bitcell_6t.sym} 5200 13400 0 0 {name=Xr67c26}
N 5160 13440 5140 13440 {}
C {lab_pin.sym} 5140 13440 0 0 {name=l10851 lab=BL26}
N 5160 13400 5140 13400 {}
C {lab_pin.sym} 5140 13400 0 0 {name=l10852 lab=BLB26}
N 5160 13360 5140 13360 {}
C {lab_pin.sym} 5140 13360 0 0 {name=l10853 lab=WL67}
N 5240 13440 5260 13440 {}
C {lab_pin.sym} 5260 13440 0 0 {name=l10854 lab=VDD}
N 5240 13360 5260 13360 {}
C {lab_pin.sym} 5260 13360 0 0 {name=l10855 lab=VSS}
C {bitcell_6t.sym} 5400 13400 0 0 {name=Xr67c27}
N 5360 13440 5340 13440 {}
C {lab_pin.sym} 5340 13440 0 0 {name=l10856 lab=BL27}
N 5360 13400 5340 13400 {}
C {lab_pin.sym} 5340 13400 0 0 {name=l10857 lab=BLB27}
N 5360 13360 5340 13360 {}
C {lab_pin.sym} 5340 13360 0 0 {name=l10858 lab=WL67}
N 5440 13440 5460 13440 {}
C {lab_pin.sym} 5460 13440 0 0 {name=l10859 lab=VDD}
N 5440 13360 5460 13360 {}
C {lab_pin.sym} 5460 13360 0 0 {name=l10860 lab=VSS}
C {bitcell_6t.sym} 5600 13400 0 0 {name=Xr67c28}
N 5560 13440 5540 13440 {}
C {lab_pin.sym} 5540 13440 0 0 {name=l10861 lab=BL28}
N 5560 13400 5540 13400 {}
C {lab_pin.sym} 5540 13400 0 0 {name=l10862 lab=BLB28}
N 5560 13360 5540 13360 {}
C {lab_pin.sym} 5540 13360 0 0 {name=l10863 lab=WL67}
N 5640 13440 5660 13440 {}
C {lab_pin.sym} 5660 13440 0 0 {name=l10864 lab=VDD}
N 5640 13360 5660 13360 {}
C {lab_pin.sym} 5660 13360 0 0 {name=l10865 lab=VSS}
C {bitcell_6t.sym} 5800 13400 0 0 {name=Xr67c29}
N 5760 13440 5740 13440 {}
C {lab_pin.sym} 5740 13440 0 0 {name=l10866 lab=BL29}
N 5760 13400 5740 13400 {}
C {lab_pin.sym} 5740 13400 0 0 {name=l10867 lab=BLB29}
N 5760 13360 5740 13360 {}
C {lab_pin.sym} 5740 13360 0 0 {name=l10868 lab=WL67}
N 5840 13440 5860 13440 {}
C {lab_pin.sym} 5860 13440 0 0 {name=l10869 lab=VDD}
N 5840 13360 5860 13360 {}
C {lab_pin.sym} 5860 13360 0 0 {name=l10870 lab=VSS}
C {bitcell_6t.sym} 6000 13400 0 0 {name=Xr67c30}
N 5960 13440 5940 13440 {}
C {lab_pin.sym} 5940 13440 0 0 {name=l10871 lab=BL30}
N 5960 13400 5940 13400 {}
C {lab_pin.sym} 5940 13400 0 0 {name=l10872 lab=BLB30}
N 5960 13360 5940 13360 {}
C {lab_pin.sym} 5940 13360 0 0 {name=l10873 lab=WL67}
N 6040 13440 6060 13440 {}
C {lab_pin.sym} 6060 13440 0 0 {name=l10874 lab=VDD}
N 6040 13360 6060 13360 {}
C {lab_pin.sym} 6060 13360 0 0 {name=l10875 lab=VSS}
C {bitcell_6t.sym} 6200 13400 0 0 {name=Xr67c31}
N 6160 13440 6140 13440 {}
C {lab_pin.sym} 6140 13440 0 0 {name=l10876 lab=BL31}
N 6160 13400 6140 13400 {}
C {lab_pin.sym} 6140 13400 0 0 {name=l10877 lab=BLB31}
N 6160 13360 6140 13360 {}
C {lab_pin.sym} 6140 13360 0 0 {name=l10878 lab=WL67}
N 6240 13440 6260 13440 {}
C {lab_pin.sym} 6260 13440 0 0 {name=l10879 lab=VDD}
N 6240 13360 6260 13360 {}
C {lab_pin.sym} 6260 13360 0 0 {name=l10880 lab=VSS}
C {bitcell_6t.sym} 0 13600 0 0 {name=Xr68c0}
N -40 13640 -60 13640 {}
C {lab_pin.sym} -60 13640 0 0 {name=l10881 lab=BL0}
N -40 13600 -60 13600 {}
C {lab_pin.sym} -60 13600 0 0 {name=l10882 lab=BLB0}
N -40 13560 -60 13560 {}
C {lab_pin.sym} -60 13560 0 0 {name=l10883 lab=WL68}
N 40 13640 60 13640 {}
C {lab_pin.sym} 60 13640 0 0 {name=l10884 lab=VDD}
N 40 13560 60 13560 {}
C {lab_pin.sym} 60 13560 0 0 {name=l10885 lab=VSS}
C {bitcell_6t.sym} 200 13600 0 0 {name=Xr68c1}
N 160 13640 140 13640 {}
C {lab_pin.sym} 140 13640 0 0 {name=l10886 lab=BL1}
N 160 13600 140 13600 {}
C {lab_pin.sym} 140 13600 0 0 {name=l10887 lab=BLB1}
N 160 13560 140 13560 {}
C {lab_pin.sym} 140 13560 0 0 {name=l10888 lab=WL68}
N 240 13640 260 13640 {}
C {lab_pin.sym} 260 13640 0 0 {name=l10889 lab=VDD}
N 240 13560 260 13560 {}
C {lab_pin.sym} 260 13560 0 0 {name=l10890 lab=VSS}
C {bitcell_6t.sym} 400 13600 0 0 {name=Xr68c2}
N 360 13640 340 13640 {}
C {lab_pin.sym} 340 13640 0 0 {name=l10891 lab=BL2}
N 360 13600 340 13600 {}
C {lab_pin.sym} 340 13600 0 0 {name=l10892 lab=BLB2}
N 360 13560 340 13560 {}
C {lab_pin.sym} 340 13560 0 0 {name=l10893 lab=WL68}
N 440 13640 460 13640 {}
C {lab_pin.sym} 460 13640 0 0 {name=l10894 lab=VDD}
N 440 13560 460 13560 {}
C {lab_pin.sym} 460 13560 0 0 {name=l10895 lab=VSS}
C {bitcell_6t.sym} 600 13600 0 0 {name=Xr68c3}
N 560 13640 540 13640 {}
C {lab_pin.sym} 540 13640 0 0 {name=l10896 lab=BL3}
N 560 13600 540 13600 {}
C {lab_pin.sym} 540 13600 0 0 {name=l10897 lab=BLB3}
N 560 13560 540 13560 {}
C {lab_pin.sym} 540 13560 0 0 {name=l10898 lab=WL68}
N 640 13640 660 13640 {}
C {lab_pin.sym} 660 13640 0 0 {name=l10899 lab=VDD}
N 640 13560 660 13560 {}
C {lab_pin.sym} 660 13560 0 0 {name=l10900 lab=VSS}
C {bitcell_6t.sym} 800 13600 0 0 {name=Xr68c4}
N 760 13640 740 13640 {}
C {lab_pin.sym} 740 13640 0 0 {name=l10901 lab=BL4}
N 760 13600 740 13600 {}
C {lab_pin.sym} 740 13600 0 0 {name=l10902 lab=BLB4}
N 760 13560 740 13560 {}
C {lab_pin.sym} 740 13560 0 0 {name=l10903 lab=WL68}
N 840 13640 860 13640 {}
C {lab_pin.sym} 860 13640 0 0 {name=l10904 lab=VDD}
N 840 13560 860 13560 {}
C {lab_pin.sym} 860 13560 0 0 {name=l10905 lab=VSS}
C {bitcell_6t.sym} 1000 13600 0 0 {name=Xr68c5}
N 960 13640 940 13640 {}
C {lab_pin.sym} 940 13640 0 0 {name=l10906 lab=BL5}
N 960 13600 940 13600 {}
C {lab_pin.sym} 940 13600 0 0 {name=l10907 lab=BLB5}
N 960 13560 940 13560 {}
C {lab_pin.sym} 940 13560 0 0 {name=l10908 lab=WL68}
N 1040 13640 1060 13640 {}
C {lab_pin.sym} 1060 13640 0 0 {name=l10909 lab=VDD}
N 1040 13560 1060 13560 {}
C {lab_pin.sym} 1060 13560 0 0 {name=l10910 lab=VSS}
C {bitcell_6t.sym} 1200 13600 0 0 {name=Xr68c6}
N 1160 13640 1140 13640 {}
C {lab_pin.sym} 1140 13640 0 0 {name=l10911 lab=BL6}
N 1160 13600 1140 13600 {}
C {lab_pin.sym} 1140 13600 0 0 {name=l10912 lab=BLB6}
N 1160 13560 1140 13560 {}
C {lab_pin.sym} 1140 13560 0 0 {name=l10913 lab=WL68}
N 1240 13640 1260 13640 {}
C {lab_pin.sym} 1260 13640 0 0 {name=l10914 lab=VDD}
N 1240 13560 1260 13560 {}
C {lab_pin.sym} 1260 13560 0 0 {name=l10915 lab=VSS}
C {bitcell_6t.sym} 1400 13600 0 0 {name=Xr68c7}
N 1360 13640 1340 13640 {}
C {lab_pin.sym} 1340 13640 0 0 {name=l10916 lab=BL7}
N 1360 13600 1340 13600 {}
C {lab_pin.sym} 1340 13600 0 0 {name=l10917 lab=BLB7}
N 1360 13560 1340 13560 {}
C {lab_pin.sym} 1340 13560 0 0 {name=l10918 lab=WL68}
N 1440 13640 1460 13640 {}
C {lab_pin.sym} 1460 13640 0 0 {name=l10919 lab=VDD}
N 1440 13560 1460 13560 {}
C {lab_pin.sym} 1460 13560 0 0 {name=l10920 lab=VSS}
C {bitcell_6t.sym} 1600 13600 0 0 {name=Xr68c8}
N 1560 13640 1540 13640 {}
C {lab_pin.sym} 1540 13640 0 0 {name=l10921 lab=BL8}
N 1560 13600 1540 13600 {}
C {lab_pin.sym} 1540 13600 0 0 {name=l10922 lab=BLB8}
N 1560 13560 1540 13560 {}
C {lab_pin.sym} 1540 13560 0 0 {name=l10923 lab=WL68}
N 1640 13640 1660 13640 {}
C {lab_pin.sym} 1660 13640 0 0 {name=l10924 lab=VDD}
N 1640 13560 1660 13560 {}
C {lab_pin.sym} 1660 13560 0 0 {name=l10925 lab=VSS}
C {bitcell_6t.sym} 1800 13600 0 0 {name=Xr68c9}
N 1760 13640 1740 13640 {}
C {lab_pin.sym} 1740 13640 0 0 {name=l10926 lab=BL9}
N 1760 13600 1740 13600 {}
C {lab_pin.sym} 1740 13600 0 0 {name=l10927 lab=BLB9}
N 1760 13560 1740 13560 {}
C {lab_pin.sym} 1740 13560 0 0 {name=l10928 lab=WL68}
N 1840 13640 1860 13640 {}
C {lab_pin.sym} 1860 13640 0 0 {name=l10929 lab=VDD}
N 1840 13560 1860 13560 {}
C {lab_pin.sym} 1860 13560 0 0 {name=l10930 lab=VSS}
C {bitcell_6t.sym} 2000 13600 0 0 {name=Xr68c10}
N 1960 13640 1940 13640 {}
C {lab_pin.sym} 1940 13640 0 0 {name=l10931 lab=BL10}
N 1960 13600 1940 13600 {}
C {lab_pin.sym} 1940 13600 0 0 {name=l10932 lab=BLB10}
N 1960 13560 1940 13560 {}
C {lab_pin.sym} 1940 13560 0 0 {name=l10933 lab=WL68}
N 2040 13640 2060 13640 {}
C {lab_pin.sym} 2060 13640 0 0 {name=l10934 lab=VDD}
N 2040 13560 2060 13560 {}
C {lab_pin.sym} 2060 13560 0 0 {name=l10935 lab=VSS}
C {bitcell_6t.sym} 2200 13600 0 0 {name=Xr68c11}
N 2160 13640 2140 13640 {}
C {lab_pin.sym} 2140 13640 0 0 {name=l10936 lab=BL11}
N 2160 13600 2140 13600 {}
C {lab_pin.sym} 2140 13600 0 0 {name=l10937 lab=BLB11}
N 2160 13560 2140 13560 {}
C {lab_pin.sym} 2140 13560 0 0 {name=l10938 lab=WL68}
N 2240 13640 2260 13640 {}
C {lab_pin.sym} 2260 13640 0 0 {name=l10939 lab=VDD}
N 2240 13560 2260 13560 {}
C {lab_pin.sym} 2260 13560 0 0 {name=l10940 lab=VSS}
C {bitcell_6t.sym} 2400 13600 0 0 {name=Xr68c12}
N 2360 13640 2340 13640 {}
C {lab_pin.sym} 2340 13640 0 0 {name=l10941 lab=BL12}
N 2360 13600 2340 13600 {}
C {lab_pin.sym} 2340 13600 0 0 {name=l10942 lab=BLB12}
N 2360 13560 2340 13560 {}
C {lab_pin.sym} 2340 13560 0 0 {name=l10943 lab=WL68}
N 2440 13640 2460 13640 {}
C {lab_pin.sym} 2460 13640 0 0 {name=l10944 lab=VDD}
N 2440 13560 2460 13560 {}
C {lab_pin.sym} 2460 13560 0 0 {name=l10945 lab=VSS}
C {bitcell_6t.sym} 2600 13600 0 0 {name=Xr68c13}
N 2560 13640 2540 13640 {}
C {lab_pin.sym} 2540 13640 0 0 {name=l10946 lab=BL13}
N 2560 13600 2540 13600 {}
C {lab_pin.sym} 2540 13600 0 0 {name=l10947 lab=BLB13}
N 2560 13560 2540 13560 {}
C {lab_pin.sym} 2540 13560 0 0 {name=l10948 lab=WL68}
N 2640 13640 2660 13640 {}
C {lab_pin.sym} 2660 13640 0 0 {name=l10949 lab=VDD}
N 2640 13560 2660 13560 {}
C {lab_pin.sym} 2660 13560 0 0 {name=l10950 lab=VSS}
C {bitcell_6t.sym} 2800 13600 0 0 {name=Xr68c14}
N 2760 13640 2740 13640 {}
C {lab_pin.sym} 2740 13640 0 0 {name=l10951 lab=BL14}
N 2760 13600 2740 13600 {}
C {lab_pin.sym} 2740 13600 0 0 {name=l10952 lab=BLB14}
N 2760 13560 2740 13560 {}
C {lab_pin.sym} 2740 13560 0 0 {name=l10953 lab=WL68}
N 2840 13640 2860 13640 {}
C {lab_pin.sym} 2860 13640 0 0 {name=l10954 lab=VDD}
N 2840 13560 2860 13560 {}
C {lab_pin.sym} 2860 13560 0 0 {name=l10955 lab=VSS}
C {bitcell_6t.sym} 3000 13600 0 0 {name=Xr68c15}
N 2960 13640 2940 13640 {}
C {lab_pin.sym} 2940 13640 0 0 {name=l10956 lab=BL15}
N 2960 13600 2940 13600 {}
C {lab_pin.sym} 2940 13600 0 0 {name=l10957 lab=BLB15}
N 2960 13560 2940 13560 {}
C {lab_pin.sym} 2940 13560 0 0 {name=l10958 lab=WL68}
N 3040 13640 3060 13640 {}
C {lab_pin.sym} 3060 13640 0 0 {name=l10959 lab=VDD}
N 3040 13560 3060 13560 {}
C {lab_pin.sym} 3060 13560 0 0 {name=l10960 lab=VSS}
C {bitcell_6t.sym} 3200 13600 0 0 {name=Xr68c16}
N 3160 13640 3140 13640 {}
C {lab_pin.sym} 3140 13640 0 0 {name=l10961 lab=BL16}
N 3160 13600 3140 13600 {}
C {lab_pin.sym} 3140 13600 0 0 {name=l10962 lab=BLB16}
N 3160 13560 3140 13560 {}
C {lab_pin.sym} 3140 13560 0 0 {name=l10963 lab=WL68}
N 3240 13640 3260 13640 {}
C {lab_pin.sym} 3260 13640 0 0 {name=l10964 lab=VDD}
N 3240 13560 3260 13560 {}
C {lab_pin.sym} 3260 13560 0 0 {name=l10965 lab=VSS}
C {bitcell_6t.sym} 3400 13600 0 0 {name=Xr68c17}
N 3360 13640 3340 13640 {}
C {lab_pin.sym} 3340 13640 0 0 {name=l10966 lab=BL17}
N 3360 13600 3340 13600 {}
C {lab_pin.sym} 3340 13600 0 0 {name=l10967 lab=BLB17}
N 3360 13560 3340 13560 {}
C {lab_pin.sym} 3340 13560 0 0 {name=l10968 lab=WL68}
N 3440 13640 3460 13640 {}
C {lab_pin.sym} 3460 13640 0 0 {name=l10969 lab=VDD}
N 3440 13560 3460 13560 {}
C {lab_pin.sym} 3460 13560 0 0 {name=l10970 lab=VSS}
C {bitcell_6t.sym} 3600 13600 0 0 {name=Xr68c18}
N 3560 13640 3540 13640 {}
C {lab_pin.sym} 3540 13640 0 0 {name=l10971 lab=BL18}
N 3560 13600 3540 13600 {}
C {lab_pin.sym} 3540 13600 0 0 {name=l10972 lab=BLB18}
N 3560 13560 3540 13560 {}
C {lab_pin.sym} 3540 13560 0 0 {name=l10973 lab=WL68}
N 3640 13640 3660 13640 {}
C {lab_pin.sym} 3660 13640 0 0 {name=l10974 lab=VDD}
N 3640 13560 3660 13560 {}
C {lab_pin.sym} 3660 13560 0 0 {name=l10975 lab=VSS}
C {bitcell_6t.sym} 3800 13600 0 0 {name=Xr68c19}
N 3760 13640 3740 13640 {}
C {lab_pin.sym} 3740 13640 0 0 {name=l10976 lab=BL19}
N 3760 13600 3740 13600 {}
C {lab_pin.sym} 3740 13600 0 0 {name=l10977 lab=BLB19}
N 3760 13560 3740 13560 {}
C {lab_pin.sym} 3740 13560 0 0 {name=l10978 lab=WL68}
N 3840 13640 3860 13640 {}
C {lab_pin.sym} 3860 13640 0 0 {name=l10979 lab=VDD}
N 3840 13560 3860 13560 {}
C {lab_pin.sym} 3860 13560 0 0 {name=l10980 lab=VSS}
C {bitcell_6t.sym} 4000 13600 0 0 {name=Xr68c20}
N 3960 13640 3940 13640 {}
C {lab_pin.sym} 3940 13640 0 0 {name=l10981 lab=BL20}
N 3960 13600 3940 13600 {}
C {lab_pin.sym} 3940 13600 0 0 {name=l10982 lab=BLB20}
N 3960 13560 3940 13560 {}
C {lab_pin.sym} 3940 13560 0 0 {name=l10983 lab=WL68}
N 4040 13640 4060 13640 {}
C {lab_pin.sym} 4060 13640 0 0 {name=l10984 lab=VDD}
N 4040 13560 4060 13560 {}
C {lab_pin.sym} 4060 13560 0 0 {name=l10985 lab=VSS}
C {bitcell_6t.sym} 4200 13600 0 0 {name=Xr68c21}
N 4160 13640 4140 13640 {}
C {lab_pin.sym} 4140 13640 0 0 {name=l10986 lab=BL21}
N 4160 13600 4140 13600 {}
C {lab_pin.sym} 4140 13600 0 0 {name=l10987 lab=BLB21}
N 4160 13560 4140 13560 {}
C {lab_pin.sym} 4140 13560 0 0 {name=l10988 lab=WL68}
N 4240 13640 4260 13640 {}
C {lab_pin.sym} 4260 13640 0 0 {name=l10989 lab=VDD}
N 4240 13560 4260 13560 {}
C {lab_pin.sym} 4260 13560 0 0 {name=l10990 lab=VSS}
C {bitcell_6t.sym} 4400 13600 0 0 {name=Xr68c22}
N 4360 13640 4340 13640 {}
C {lab_pin.sym} 4340 13640 0 0 {name=l10991 lab=BL22}
N 4360 13600 4340 13600 {}
C {lab_pin.sym} 4340 13600 0 0 {name=l10992 lab=BLB22}
N 4360 13560 4340 13560 {}
C {lab_pin.sym} 4340 13560 0 0 {name=l10993 lab=WL68}
N 4440 13640 4460 13640 {}
C {lab_pin.sym} 4460 13640 0 0 {name=l10994 lab=VDD}
N 4440 13560 4460 13560 {}
C {lab_pin.sym} 4460 13560 0 0 {name=l10995 lab=VSS}
C {bitcell_6t.sym} 4600 13600 0 0 {name=Xr68c23}
N 4560 13640 4540 13640 {}
C {lab_pin.sym} 4540 13640 0 0 {name=l10996 lab=BL23}
N 4560 13600 4540 13600 {}
C {lab_pin.sym} 4540 13600 0 0 {name=l10997 lab=BLB23}
N 4560 13560 4540 13560 {}
C {lab_pin.sym} 4540 13560 0 0 {name=l10998 lab=WL68}
N 4640 13640 4660 13640 {}
C {lab_pin.sym} 4660 13640 0 0 {name=l10999 lab=VDD}
N 4640 13560 4660 13560 {}
C {lab_pin.sym} 4660 13560 0 0 {name=l11000 lab=VSS}
C {bitcell_6t.sym} 4800 13600 0 0 {name=Xr68c24}
N 4760 13640 4740 13640 {}
C {lab_pin.sym} 4740 13640 0 0 {name=l11001 lab=BL24}
N 4760 13600 4740 13600 {}
C {lab_pin.sym} 4740 13600 0 0 {name=l11002 lab=BLB24}
N 4760 13560 4740 13560 {}
C {lab_pin.sym} 4740 13560 0 0 {name=l11003 lab=WL68}
N 4840 13640 4860 13640 {}
C {lab_pin.sym} 4860 13640 0 0 {name=l11004 lab=VDD}
N 4840 13560 4860 13560 {}
C {lab_pin.sym} 4860 13560 0 0 {name=l11005 lab=VSS}
C {bitcell_6t.sym} 5000 13600 0 0 {name=Xr68c25}
N 4960 13640 4940 13640 {}
C {lab_pin.sym} 4940 13640 0 0 {name=l11006 lab=BL25}
N 4960 13600 4940 13600 {}
C {lab_pin.sym} 4940 13600 0 0 {name=l11007 lab=BLB25}
N 4960 13560 4940 13560 {}
C {lab_pin.sym} 4940 13560 0 0 {name=l11008 lab=WL68}
N 5040 13640 5060 13640 {}
C {lab_pin.sym} 5060 13640 0 0 {name=l11009 lab=VDD}
N 5040 13560 5060 13560 {}
C {lab_pin.sym} 5060 13560 0 0 {name=l11010 lab=VSS}
C {bitcell_6t.sym} 5200 13600 0 0 {name=Xr68c26}
N 5160 13640 5140 13640 {}
C {lab_pin.sym} 5140 13640 0 0 {name=l11011 lab=BL26}
N 5160 13600 5140 13600 {}
C {lab_pin.sym} 5140 13600 0 0 {name=l11012 lab=BLB26}
N 5160 13560 5140 13560 {}
C {lab_pin.sym} 5140 13560 0 0 {name=l11013 lab=WL68}
N 5240 13640 5260 13640 {}
C {lab_pin.sym} 5260 13640 0 0 {name=l11014 lab=VDD}
N 5240 13560 5260 13560 {}
C {lab_pin.sym} 5260 13560 0 0 {name=l11015 lab=VSS}
C {bitcell_6t.sym} 5400 13600 0 0 {name=Xr68c27}
N 5360 13640 5340 13640 {}
C {lab_pin.sym} 5340 13640 0 0 {name=l11016 lab=BL27}
N 5360 13600 5340 13600 {}
C {lab_pin.sym} 5340 13600 0 0 {name=l11017 lab=BLB27}
N 5360 13560 5340 13560 {}
C {lab_pin.sym} 5340 13560 0 0 {name=l11018 lab=WL68}
N 5440 13640 5460 13640 {}
C {lab_pin.sym} 5460 13640 0 0 {name=l11019 lab=VDD}
N 5440 13560 5460 13560 {}
C {lab_pin.sym} 5460 13560 0 0 {name=l11020 lab=VSS}
C {bitcell_6t.sym} 5600 13600 0 0 {name=Xr68c28}
N 5560 13640 5540 13640 {}
C {lab_pin.sym} 5540 13640 0 0 {name=l11021 lab=BL28}
N 5560 13600 5540 13600 {}
C {lab_pin.sym} 5540 13600 0 0 {name=l11022 lab=BLB28}
N 5560 13560 5540 13560 {}
C {lab_pin.sym} 5540 13560 0 0 {name=l11023 lab=WL68}
N 5640 13640 5660 13640 {}
C {lab_pin.sym} 5660 13640 0 0 {name=l11024 lab=VDD}
N 5640 13560 5660 13560 {}
C {lab_pin.sym} 5660 13560 0 0 {name=l11025 lab=VSS}
C {bitcell_6t.sym} 5800 13600 0 0 {name=Xr68c29}
N 5760 13640 5740 13640 {}
C {lab_pin.sym} 5740 13640 0 0 {name=l11026 lab=BL29}
N 5760 13600 5740 13600 {}
C {lab_pin.sym} 5740 13600 0 0 {name=l11027 lab=BLB29}
N 5760 13560 5740 13560 {}
C {lab_pin.sym} 5740 13560 0 0 {name=l11028 lab=WL68}
N 5840 13640 5860 13640 {}
C {lab_pin.sym} 5860 13640 0 0 {name=l11029 lab=VDD}
N 5840 13560 5860 13560 {}
C {lab_pin.sym} 5860 13560 0 0 {name=l11030 lab=VSS}
C {bitcell_6t.sym} 6000 13600 0 0 {name=Xr68c30}
N 5960 13640 5940 13640 {}
C {lab_pin.sym} 5940 13640 0 0 {name=l11031 lab=BL30}
N 5960 13600 5940 13600 {}
C {lab_pin.sym} 5940 13600 0 0 {name=l11032 lab=BLB30}
N 5960 13560 5940 13560 {}
C {lab_pin.sym} 5940 13560 0 0 {name=l11033 lab=WL68}
N 6040 13640 6060 13640 {}
C {lab_pin.sym} 6060 13640 0 0 {name=l11034 lab=VDD}
N 6040 13560 6060 13560 {}
C {lab_pin.sym} 6060 13560 0 0 {name=l11035 lab=VSS}
C {bitcell_6t.sym} 6200 13600 0 0 {name=Xr68c31}
N 6160 13640 6140 13640 {}
C {lab_pin.sym} 6140 13640 0 0 {name=l11036 lab=BL31}
N 6160 13600 6140 13600 {}
C {lab_pin.sym} 6140 13600 0 0 {name=l11037 lab=BLB31}
N 6160 13560 6140 13560 {}
C {lab_pin.sym} 6140 13560 0 0 {name=l11038 lab=WL68}
N 6240 13640 6260 13640 {}
C {lab_pin.sym} 6260 13640 0 0 {name=l11039 lab=VDD}
N 6240 13560 6260 13560 {}
C {lab_pin.sym} 6260 13560 0 0 {name=l11040 lab=VSS}
C {bitcell_6t.sym} 0 13800 0 0 {name=Xr69c0}
N -40 13840 -60 13840 {}
C {lab_pin.sym} -60 13840 0 0 {name=l11041 lab=BL0}
N -40 13800 -60 13800 {}
C {lab_pin.sym} -60 13800 0 0 {name=l11042 lab=BLB0}
N -40 13760 -60 13760 {}
C {lab_pin.sym} -60 13760 0 0 {name=l11043 lab=WL69}
N 40 13840 60 13840 {}
C {lab_pin.sym} 60 13840 0 0 {name=l11044 lab=VDD}
N 40 13760 60 13760 {}
C {lab_pin.sym} 60 13760 0 0 {name=l11045 lab=VSS}
C {bitcell_6t.sym} 200 13800 0 0 {name=Xr69c1}
N 160 13840 140 13840 {}
C {lab_pin.sym} 140 13840 0 0 {name=l11046 lab=BL1}
N 160 13800 140 13800 {}
C {lab_pin.sym} 140 13800 0 0 {name=l11047 lab=BLB1}
N 160 13760 140 13760 {}
C {lab_pin.sym} 140 13760 0 0 {name=l11048 lab=WL69}
N 240 13840 260 13840 {}
C {lab_pin.sym} 260 13840 0 0 {name=l11049 lab=VDD}
N 240 13760 260 13760 {}
C {lab_pin.sym} 260 13760 0 0 {name=l11050 lab=VSS}
C {bitcell_6t.sym} 400 13800 0 0 {name=Xr69c2}
N 360 13840 340 13840 {}
C {lab_pin.sym} 340 13840 0 0 {name=l11051 lab=BL2}
N 360 13800 340 13800 {}
C {lab_pin.sym} 340 13800 0 0 {name=l11052 lab=BLB2}
N 360 13760 340 13760 {}
C {lab_pin.sym} 340 13760 0 0 {name=l11053 lab=WL69}
N 440 13840 460 13840 {}
C {lab_pin.sym} 460 13840 0 0 {name=l11054 lab=VDD}
N 440 13760 460 13760 {}
C {lab_pin.sym} 460 13760 0 0 {name=l11055 lab=VSS}
C {bitcell_6t.sym} 600 13800 0 0 {name=Xr69c3}
N 560 13840 540 13840 {}
C {lab_pin.sym} 540 13840 0 0 {name=l11056 lab=BL3}
N 560 13800 540 13800 {}
C {lab_pin.sym} 540 13800 0 0 {name=l11057 lab=BLB3}
N 560 13760 540 13760 {}
C {lab_pin.sym} 540 13760 0 0 {name=l11058 lab=WL69}
N 640 13840 660 13840 {}
C {lab_pin.sym} 660 13840 0 0 {name=l11059 lab=VDD}
N 640 13760 660 13760 {}
C {lab_pin.sym} 660 13760 0 0 {name=l11060 lab=VSS}
C {bitcell_6t.sym} 800 13800 0 0 {name=Xr69c4}
N 760 13840 740 13840 {}
C {lab_pin.sym} 740 13840 0 0 {name=l11061 lab=BL4}
N 760 13800 740 13800 {}
C {lab_pin.sym} 740 13800 0 0 {name=l11062 lab=BLB4}
N 760 13760 740 13760 {}
C {lab_pin.sym} 740 13760 0 0 {name=l11063 lab=WL69}
N 840 13840 860 13840 {}
C {lab_pin.sym} 860 13840 0 0 {name=l11064 lab=VDD}
N 840 13760 860 13760 {}
C {lab_pin.sym} 860 13760 0 0 {name=l11065 lab=VSS}
C {bitcell_6t.sym} 1000 13800 0 0 {name=Xr69c5}
N 960 13840 940 13840 {}
C {lab_pin.sym} 940 13840 0 0 {name=l11066 lab=BL5}
N 960 13800 940 13800 {}
C {lab_pin.sym} 940 13800 0 0 {name=l11067 lab=BLB5}
N 960 13760 940 13760 {}
C {lab_pin.sym} 940 13760 0 0 {name=l11068 lab=WL69}
N 1040 13840 1060 13840 {}
C {lab_pin.sym} 1060 13840 0 0 {name=l11069 lab=VDD}
N 1040 13760 1060 13760 {}
C {lab_pin.sym} 1060 13760 0 0 {name=l11070 lab=VSS}
C {bitcell_6t.sym} 1200 13800 0 0 {name=Xr69c6}
N 1160 13840 1140 13840 {}
C {lab_pin.sym} 1140 13840 0 0 {name=l11071 lab=BL6}
N 1160 13800 1140 13800 {}
C {lab_pin.sym} 1140 13800 0 0 {name=l11072 lab=BLB6}
N 1160 13760 1140 13760 {}
C {lab_pin.sym} 1140 13760 0 0 {name=l11073 lab=WL69}
N 1240 13840 1260 13840 {}
C {lab_pin.sym} 1260 13840 0 0 {name=l11074 lab=VDD}
N 1240 13760 1260 13760 {}
C {lab_pin.sym} 1260 13760 0 0 {name=l11075 lab=VSS}
C {bitcell_6t.sym} 1400 13800 0 0 {name=Xr69c7}
N 1360 13840 1340 13840 {}
C {lab_pin.sym} 1340 13840 0 0 {name=l11076 lab=BL7}
N 1360 13800 1340 13800 {}
C {lab_pin.sym} 1340 13800 0 0 {name=l11077 lab=BLB7}
N 1360 13760 1340 13760 {}
C {lab_pin.sym} 1340 13760 0 0 {name=l11078 lab=WL69}
N 1440 13840 1460 13840 {}
C {lab_pin.sym} 1460 13840 0 0 {name=l11079 lab=VDD}
N 1440 13760 1460 13760 {}
C {lab_pin.sym} 1460 13760 0 0 {name=l11080 lab=VSS}
C {bitcell_6t.sym} 1600 13800 0 0 {name=Xr69c8}
N 1560 13840 1540 13840 {}
C {lab_pin.sym} 1540 13840 0 0 {name=l11081 lab=BL8}
N 1560 13800 1540 13800 {}
C {lab_pin.sym} 1540 13800 0 0 {name=l11082 lab=BLB8}
N 1560 13760 1540 13760 {}
C {lab_pin.sym} 1540 13760 0 0 {name=l11083 lab=WL69}
N 1640 13840 1660 13840 {}
C {lab_pin.sym} 1660 13840 0 0 {name=l11084 lab=VDD}
N 1640 13760 1660 13760 {}
C {lab_pin.sym} 1660 13760 0 0 {name=l11085 lab=VSS}
C {bitcell_6t.sym} 1800 13800 0 0 {name=Xr69c9}
N 1760 13840 1740 13840 {}
C {lab_pin.sym} 1740 13840 0 0 {name=l11086 lab=BL9}
N 1760 13800 1740 13800 {}
C {lab_pin.sym} 1740 13800 0 0 {name=l11087 lab=BLB9}
N 1760 13760 1740 13760 {}
C {lab_pin.sym} 1740 13760 0 0 {name=l11088 lab=WL69}
N 1840 13840 1860 13840 {}
C {lab_pin.sym} 1860 13840 0 0 {name=l11089 lab=VDD}
N 1840 13760 1860 13760 {}
C {lab_pin.sym} 1860 13760 0 0 {name=l11090 lab=VSS}
C {bitcell_6t.sym} 2000 13800 0 0 {name=Xr69c10}
N 1960 13840 1940 13840 {}
C {lab_pin.sym} 1940 13840 0 0 {name=l11091 lab=BL10}
N 1960 13800 1940 13800 {}
C {lab_pin.sym} 1940 13800 0 0 {name=l11092 lab=BLB10}
N 1960 13760 1940 13760 {}
C {lab_pin.sym} 1940 13760 0 0 {name=l11093 lab=WL69}
N 2040 13840 2060 13840 {}
C {lab_pin.sym} 2060 13840 0 0 {name=l11094 lab=VDD}
N 2040 13760 2060 13760 {}
C {lab_pin.sym} 2060 13760 0 0 {name=l11095 lab=VSS}
C {bitcell_6t.sym} 2200 13800 0 0 {name=Xr69c11}
N 2160 13840 2140 13840 {}
C {lab_pin.sym} 2140 13840 0 0 {name=l11096 lab=BL11}
N 2160 13800 2140 13800 {}
C {lab_pin.sym} 2140 13800 0 0 {name=l11097 lab=BLB11}
N 2160 13760 2140 13760 {}
C {lab_pin.sym} 2140 13760 0 0 {name=l11098 lab=WL69}
N 2240 13840 2260 13840 {}
C {lab_pin.sym} 2260 13840 0 0 {name=l11099 lab=VDD}
N 2240 13760 2260 13760 {}
C {lab_pin.sym} 2260 13760 0 0 {name=l11100 lab=VSS}
C {bitcell_6t.sym} 2400 13800 0 0 {name=Xr69c12}
N 2360 13840 2340 13840 {}
C {lab_pin.sym} 2340 13840 0 0 {name=l11101 lab=BL12}
N 2360 13800 2340 13800 {}
C {lab_pin.sym} 2340 13800 0 0 {name=l11102 lab=BLB12}
N 2360 13760 2340 13760 {}
C {lab_pin.sym} 2340 13760 0 0 {name=l11103 lab=WL69}
N 2440 13840 2460 13840 {}
C {lab_pin.sym} 2460 13840 0 0 {name=l11104 lab=VDD}
N 2440 13760 2460 13760 {}
C {lab_pin.sym} 2460 13760 0 0 {name=l11105 lab=VSS}
C {bitcell_6t.sym} 2600 13800 0 0 {name=Xr69c13}
N 2560 13840 2540 13840 {}
C {lab_pin.sym} 2540 13840 0 0 {name=l11106 lab=BL13}
N 2560 13800 2540 13800 {}
C {lab_pin.sym} 2540 13800 0 0 {name=l11107 lab=BLB13}
N 2560 13760 2540 13760 {}
C {lab_pin.sym} 2540 13760 0 0 {name=l11108 lab=WL69}
N 2640 13840 2660 13840 {}
C {lab_pin.sym} 2660 13840 0 0 {name=l11109 lab=VDD}
N 2640 13760 2660 13760 {}
C {lab_pin.sym} 2660 13760 0 0 {name=l11110 lab=VSS}
C {bitcell_6t.sym} 2800 13800 0 0 {name=Xr69c14}
N 2760 13840 2740 13840 {}
C {lab_pin.sym} 2740 13840 0 0 {name=l11111 lab=BL14}
N 2760 13800 2740 13800 {}
C {lab_pin.sym} 2740 13800 0 0 {name=l11112 lab=BLB14}
N 2760 13760 2740 13760 {}
C {lab_pin.sym} 2740 13760 0 0 {name=l11113 lab=WL69}
N 2840 13840 2860 13840 {}
C {lab_pin.sym} 2860 13840 0 0 {name=l11114 lab=VDD}
N 2840 13760 2860 13760 {}
C {lab_pin.sym} 2860 13760 0 0 {name=l11115 lab=VSS}
C {bitcell_6t.sym} 3000 13800 0 0 {name=Xr69c15}
N 2960 13840 2940 13840 {}
C {lab_pin.sym} 2940 13840 0 0 {name=l11116 lab=BL15}
N 2960 13800 2940 13800 {}
C {lab_pin.sym} 2940 13800 0 0 {name=l11117 lab=BLB15}
N 2960 13760 2940 13760 {}
C {lab_pin.sym} 2940 13760 0 0 {name=l11118 lab=WL69}
N 3040 13840 3060 13840 {}
C {lab_pin.sym} 3060 13840 0 0 {name=l11119 lab=VDD}
N 3040 13760 3060 13760 {}
C {lab_pin.sym} 3060 13760 0 0 {name=l11120 lab=VSS}
C {bitcell_6t.sym} 3200 13800 0 0 {name=Xr69c16}
N 3160 13840 3140 13840 {}
C {lab_pin.sym} 3140 13840 0 0 {name=l11121 lab=BL16}
N 3160 13800 3140 13800 {}
C {lab_pin.sym} 3140 13800 0 0 {name=l11122 lab=BLB16}
N 3160 13760 3140 13760 {}
C {lab_pin.sym} 3140 13760 0 0 {name=l11123 lab=WL69}
N 3240 13840 3260 13840 {}
C {lab_pin.sym} 3260 13840 0 0 {name=l11124 lab=VDD}
N 3240 13760 3260 13760 {}
C {lab_pin.sym} 3260 13760 0 0 {name=l11125 lab=VSS}
C {bitcell_6t.sym} 3400 13800 0 0 {name=Xr69c17}
N 3360 13840 3340 13840 {}
C {lab_pin.sym} 3340 13840 0 0 {name=l11126 lab=BL17}
N 3360 13800 3340 13800 {}
C {lab_pin.sym} 3340 13800 0 0 {name=l11127 lab=BLB17}
N 3360 13760 3340 13760 {}
C {lab_pin.sym} 3340 13760 0 0 {name=l11128 lab=WL69}
N 3440 13840 3460 13840 {}
C {lab_pin.sym} 3460 13840 0 0 {name=l11129 lab=VDD}
N 3440 13760 3460 13760 {}
C {lab_pin.sym} 3460 13760 0 0 {name=l11130 lab=VSS}
C {bitcell_6t.sym} 3600 13800 0 0 {name=Xr69c18}
N 3560 13840 3540 13840 {}
C {lab_pin.sym} 3540 13840 0 0 {name=l11131 lab=BL18}
N 3560 13800 3540 13800 {}
C {lab_pin.sym} 3540 13800 0 0 {name=l11132 lab=BLB18}
N 3560 13760 3540 13760 {}
C {lab_pin.sym} 3540 13760 0 0 {name=l11133 lab=WL69}
N 3640 13840 3660 13840 {}
C {lab_pin.sym} 3660 13840 0 0 {name=l11134 lab=VDD}
N 3640 13760 3660 13760 {}
C {lab_pin.sym} 3660 13760 0 0 {name=l11135 lab=VSS}
C {bitcell_6t.sym} 3800 13800 0 0 {name=Xr69c19}
N 3760 13840 3740 13840 {}
C {lab_pin.sym} 3740 13840 0 0 {name=l11136 lab=BL19}
N 3760 13800 3740 13800 {}
C {lab_pin.sym} 3740 13800 0 0 {name=l11137 lab=BLB19}
N 3760 13760 3740 13760 {}
C {lab_pin.sym} 3740 13760 0 0 {name=l11138 lab=WL69}
N 3840 13840 3860 13840 {}
C {lab_pin.sym} 3860 13840 0 0 {name=l11139 lab=VDD}
N 3840 13760 3860 13760 {}
C {lab_pin.sym} 3860 13760 0 0 {name=l11140 lab=VSS}
C {bitcell_6t.sym} 4000 13800 0 0 {name=Xr69c20}
N 3960 13840 3940 13840 {}
C {lab_pin.sym} 3940 13840 0 0 {name=l11141 lab=BL20}
N 3960 13800 3940 13800 {}
C {lab_pin.sym} 3940 13800 0 0 {name=l11142 lab=BLB20}
N 3960 13760 3940 13760 {}
C {lab_pin.sym} 3940 13760 0 0 {name=l11143 lab=WL69}
N 4040 13840 4060 13840 {}
C {lab_pin.sym} 4060 13840 0 0 {name=l11144 lab=VDD}
N 4040 13760 4060 13760 {}
C {lab_pin.sym} 4060 13760 0 0 {name=l11145 lab=VSS}
C {bitcell_6t.sym} 4200 13800 0 0 {name=Xr69c21}
N 4160 13840 4140 13840 {}
C {lab_pin.sym} 4140 13840 0 0 {name=l11146 lab=BL21}
N 4160 13800 4140 13800 {}
C {lab_pin.sym} 4140 13800 0 0 {name=l11147 lab=BLB21}
N 4160 13760 4140 13760 {}
C {lab_pin.sym} 4140 13760 0 0 {name=l11148 lab=WL69}
N 4240 13840 4260 13840 {}
C {lab_pin.sym} 4260 13840 0 0 {name=l11149 lab=VDD}
N 4240 13760 4260 13760 {}
C {lab_pin.sym} 4260 13760 0 0 {name=l11150 lab=VSS}
C {bitcell_6t.sym} 4400 13800 0 0 {name=Xr69c22}
N 4360 13840 4340 13840 {}
C {lab_pin.sym} 4340 13840 0 0 {name=l11151 lab=BL22}
N 4360 13800 4340 13800 {}
C {lab_pin.sym} 4340 13800 0 0 {name=l11152 lab=BLB22}
N 4360 13760 4340 13760 {}
C {lab_pin.sym} 4340 13760 0 0 {name=l11153 lab=WL69}
N 4440 13840 4460 13840 {}
C {lab_pin.sym} 4460 13840 0 0 {name=l11154 lab=VDD}
N 4440 13760 4460 13760 {}
C {lab_pin.sym} 4460 13760 0 0 {name=l11155 lab=VSS}
C {bitcell_6t.sym} 4600 13800 0 0 {name=Xr69c23}
N 4560 13840 4540 13840 {}
C {lab_pin.sym} 4540 13840 0 0 {name=l11156 lab=BL23}
N 4560 13800 4540 13800 {}
C {lab_pin.sym} 4540 13800 0 0 {name=l11157 lab=BLB23}
N 4560 13760 4540 13760 {}
C {lab_pin.sym} 4540 13760 0 0 {name=l11158 lab=WL69}
N 4640 13840 4660 13840 {}
C {lab_pin.sym} 4660 13840 0 0 {name=l11159 lab=VDD}
N 4640 13760 4660 13760 {}
C {lab_pin.sym} 4660 13760 0 0 {name=l11160 lab=VSS}
C {bitcell_6t.sym} 4800 13800 0 0 {name=Xr69c24}
N 4760 13840 4740 13840 {}
C {lab_pin.sym} 4740 13840 0 0 {name=l11161 lab=BL24}
N 4760 13800 4740 13800 {}
C {lab_pin.sym} 4740 13800 0 0 {name=l11162 lab=BLB24}
N 4760 13760 4740 13760 {}
C {lab_pin.sym} 4740 13760 0 0 {name=l11163 lab=WL69}
N 4840 13840 4860 13840 {}
C {lab_pin.sym} 4860 13840 0 0 {name=l11164 lab=VDD}
N 4840 13760 4860 13760 {}
C {lab_pin.sym} 4860 13760 0 0 {name=l11165 lab=VSS}
C {bitcell_6t.sym} 5000 13800 0 0 {name=Xr69c25}
N 4960 13840 4940 13840 {}
C {lab_pin.sym} 4940 13840 0 0 {name=l11166 lab=BL25}
N 4960 13800 4940 13800 {}
C {lab_pin.sym} 4940 13800 0 0 {name=l11167 lab=BLB25}
N 4960 13760 4940 13760 {}
C {lab_pin.sym} 4940 13760 0 0 {name=l11168 lab=WL69}
N 5040 13840 5060 13840 {}
C {lab_pin.sym} 5060 13840 0 0 {name=l11169 lab=VDD}
N 5040 13760 5060 13760 {}
C {lab_pin.sym} 5060 13760 0 0 {name=l11170 lab=VSS}
C {bitcell_6t.sym} 5200 13800 0 0 {name=Xr69c26}
N 5160 13840 5140 13840 {}
C {lab_pin.sym} 5140 13840 0 0 {name=l11171 lab=BL26}
N 5160 13800 5140 13800 {}
C {lab_pin.sym} 5140 13800 0 0 {name=l11172 lab=BLB26}
N 5160 13760 5140 13760 {}
C {lab_pin.sym} 5140 13760 0 0 {name=l11173 lab=WL69}
N 5240 13840 5260 13840 {}
C {lab_pin.sym} 5260 13840 0 0 {name=l11174 lab=VDD}
N 5240 13760 5260 13760 {}
C {lab_pin.sym} 5260 13760 0 0 {name=l11175 lab=VSS}
C {bitcell_6t.sym} 5400 13800 0 0 {name=Xr69c27}
N 5360 13840 5340 13840 {}
C {lab_pin.sym} 5340 13840 0 0 {name=l11176 lab=BL27}
N 5360 13800 5340 13800 {}
C {lab_pin.sym} 5340 13800 0 0 {name=l11177 lab=BLB27}
N 5360 13760 5340 13760 {}
C {lab_pin.sym} 5340 13760 0 0 {name=l11178 lab=WL69}
N 5440 13840 5460 13840 {}
C {lab_pin.sym} 5460 13840 0 0 {name=l11179 lab=VDD}
N 5440 13760 5460 13760 {}
C {lab_pin.sym} 5460 13760 0 0 {name=l11180 lab=VSS}
C {bitcell_6t.sym} 5600 13800 0 0 {name=Xr69c28}
N 5560 13840 5540 13840 {}
C {lab_pin.sym} 5540 13840 0 0 {name=l11181 lab=BL28}
N 5560 13800 5540 13800 {}
C {lab_pin.sym} 5540 13800 0 0 {name=l11182 lab=BLB28}
N 5560 13760 5540 13760 {}
C {lab_pin.sym} 5540 13760 0 0 {name=l11183 lab=WL69}
N 5640 13840 5660 13840 {}
C {lab_pin.sym} 5660 13840 0 0 {name=l11184 lab=VDD}
N 5640 13760 5660 13760 {}
C {lab_pin.sym} 5660 13760 0 0 {name=l11185 lab=VSS}
C {bitcell_6t.sym} 5800 13800 0 0 {name=Xr69c29}
N 5760 13840 5740 13840 {}
C {lab_pin.sym} 5740 13840 0 0 {name=l11186 lab=BL29}
N 5760 13800 5740 13800 {}
C {lab_pin.sym} 5740 13800 0 0 {name=l11187 lab=BLB29}
N 5760 13760 5740 13760 {}
C {lab_pin.sym} 5740 13760 0 0 {name=l11188 lab=WL69}
N 5840 13840 5860 13840 {}
C {lab_pin.sym} 5860 13840 0 0 {name=l11189 lab=VDD}
N 5840 13760 5860 13760 {}
C {lab_pin.sym} 5860 13760 0 0 {name=l11190 lab=VSS}
C {bitcell_6t.sym} 6000 13800 0 0 {name=Xr69c30}
N 5960 13840 5940 13840 {}
C {lab_pin.sym} 5940 13840 0 0 {name=l11191 lab=BL30}
N 5960 13800 5940 13800 {}
C {lab_pin.sym} 5940 13800 0 0 {name=l11192 lab=BLB30}
N 5960 13760 5940 13760 {}
C {lab_pin.sym} 5940 13760 0 0 {name=l11193 lab=WL69}
N 6040 13840 6060 13840 {}
C {lab_pin.sym} 6060 13840 0 0 {name=l11194 lab=VDD}
N 6040 13760 6060 13760 {}
C {lab_pin.sym} 6060 13760 0 0 {name=l11195 lab=VSS}
C {bitcell_6t.sym} 6200 13800 0 0 {name=Xr69c31}
N 6160 13840 6140 13840 {}
C {lab_pin.sym} 6140 13840 0 0 {name=l11196 lab=BL31}
N 6160 13800 6140 13800 {}
C {lab_pin.sym} 6140 13800 0 0 {name=l11197 lab=BLB31}
N 6160 13760 6140 13760 {}
C {lab_pin.sym} 6140 13760 0 0 {name=l11198 lab=WL69}
N 6240 13840 6260 13840 {}
C {lab_pin.sym} 6260 13840 0 0 {name=l11199 lab=VDD}
N 6240 13760 6260 13760 {}
C {lab_pin.sym} 6260 13760 0 0 {name=l11200 lab=VSS}
C {bitcell_6t.sym} 0 14000 0 0 {name=Xr70c0}
N -40 14040 -60 14040 {}
C {lab_pin.sym} -60 14040 0 0 {name=l11201 lab=BL0}
N -40 14000 -60 14000 {}
C {lab_pin.sym} -60 14000 0 0 {name=l11202 lab=BLB0}
N -40 13960 -60 13960 {}
C {lab_pin.sym} -60 13960 0 0 {name=l11203 lab=WL70}
N 40 14040 60 14040 {}
C {lab_pin.sym} 60 14040 0 0 {name=l11204 lab=VDD}
N 40 13960 60 13960 {}
C {lab_pin.sym} 60 13960 0 0 {name=l11205 lab=VSS}
C {bitcell_6t.sym} 200 14000 0 0 {name=Xr70c1}
N 160 14040 140 14040 {}
C {lab_pin.sym} 140 14040 0 0 {name=l11206 lab=BL1}
N 160 14000 140 14000 {}
C {lab_pin.sym} 140 14000 0 0 {name=l11207 lab=BLB1}
N 160 13960 140 13960 {}
C {lab_pin.sym} 140 13960 0 0 {name=l11208 lab=WL70}
N 240 14040 260 14040 {}
C {lab_pin.sym} 260 14040 0 0 {name=l11209 lab=VDD}
N 240 13960 260 13960 {}
C {lab_pin.sym} 260 13960 0 0 {name=l11210 lab=VSS}
C {bitcell_6t.sym} 400 14000 0 0 {name=Xr70c2}
N 360 14040 340 14040 {}
C {lab_pin.sym} 340 14040 0 0 {name=l11211 lab=BL2}
N 360 14000 340 14000 {}
C {lab_pin.sym} 340 14000 0 0 {name=l11212 lab=BLB2}
N 360 13960 340 13960 {}
C {lab_pin.sym} 340 13960 0 0 {name=l11213 lab=WL70}
N 440 14040 460 14040 {}
C {lab_pin.sym} 460 14040 0 0 {name=l11214 lab=VDD}
N 440 13960 460 13960 {}
C {lab_pin.sym} 460 13960 0 0 {name=l11215 lab=VSS}
C {bitcell_6t.sym} 600 14000 0 0 {name=Xr70c3}
N 560 14040 540 14040 {}
C {lab_pin.sym} 540 14040 0 0 {name=l11216 lab=BL3}
N 560 14000 540 14000 {}
C {lab_pin.sym} 540 14000 0 0 {name=l11217 lab=BLB3}
N 560 13960 540 13960 {}
C {lab_pin.sym} 540 13960 0 0 {name=l11218 lab=WL70}
N 640 14040 660 14040 {}
C {lab_pin.sym} 660 14040 0 0 {name=l11219 lab=VDD}
N 640 13960 660 13960 {}
C {lab_pin.sym} 660 13960 0 0 {name=l11220 lab=VSS}
C {bitcell_6t.sym} 800 14000 0 0 {name=Xr70c4}
N 760 14040 740 14040 {}
C {lab_pin.sym} 740 14040 0 0 {name=l11221 lab=BL4}
N 760 14000 740 14000 {}
C {lab_pin.sym} 740 14000 0 0 {name=l11222 lab=BLB4}
N 760 13960 740 13960 {}
C {lab_pin.sym} 740 13960 0 0 {name=l11223 lab=WL70}
N 840 14040 860 14040 {}
C {lab_pin.sym} 860 14040 0 0 {name=l11224 lab=VDD}
N 840 13960 860 13960 {}
C {lab_pin.sym} 860 13960 0 0 {name=l11225 lab=VSS}
C {bitcell_6t.sym} 1000 14000 0 0 {name=Xr70c5}
N 960 14040 940 14040 {}
C {lab_pin.sym} 940 14040 0 0 {name=l11226 lab=BL5}
N 960 14000 940 14000 {}
C {lab_pin.sym} 940 14000 0 0 {name=l11227 lab=BLB5}
N 960 13960 940 13960 {}
C {lab_pin.sym} 940 13960 0 0 {name=l11228 lab=WL70}
N 1040 14040 1060 14040 {}
C {lab_pin.sym} 1060 14040 0 0 {name=l11229 lab=VDD}
N 1040 13960 1060 13960 {}
C {lab_pin.sym} 1060 13960 0 0 {name=l11230 lab=VSS}
C {bitcell_6t.sym} 1200 14000 0 0 {name=Xr70c6}
N 1160 14040 1140 14040 {}
C {lab_pin.sym} 1140 14040 0 0 {name=l11231 lab=BL6}
N 1160 14000 1140 14000 {}
C {lab_pin.sym} 1140 14000 0 0 {name=l11232 lab=BLB6}
N 1160 13960 1140 13960 {}
C {lab_pin.sym} 1140 13960 0 0 {name=l11233 lab=WL70}
N 1240 14040 1260 14040 {}
C {lab_pin.sym} 1260 14040 0 0 {name=l11234 lab=VDD}
N 1240 13960 1260 13960 {}
C {lab_pin.sym} 1260 13960 0 0 {name=l11235 lab=VSS}
C {bitcell_6t.sym} 1400 14000 0 0 {name=Xr70c7}
N 1360 14040 1340 14040 {}
C {lab_pin.sym} 1340 14040 0 0 {name=l11236 lab=BL7}
N 1360 14000 1340 14000 {}
C {lab_pin.sym} 1340 14000 0 0 {name=l11237 lab=BLB7}
N 1360 13960 1340 13960 {}
C {lab_pin.sym} 1340 13960 0 0 {name=l11238 lab=WL70}
N 1440 14040 1460 14040 {}
C {lab_pin.sym} 1460 14040 0 0 {name=l11239 lab=VDD}
N 1440 13960 1460 13960 {}
C {lab_pin.sym} 1460 13960 0 0 {name=l11240 lab=VSS}
C {bitcell_6t.sym} 1600 14000 0 0 {name=Xr70c8}
N 1560 14040 1540 14040 {}
C {lab_pin.sym} 1540 14040 0 0 {name=l11241 lab=BL8}
N 1560 14000 1540 14000 {}
C {lab_pin.sym} 1540 14000 0 0 {name=l11242 lab=BLB8}
N 1560 13960 1540 13960 {}
C {lab_pin.sym} 1540 13960 0 0 {name=l11243 lab=WL70}
N 1640 14040 1660 14040 {}
C {lab_pin.sym} 1660 14040 0 0 {name=l11244 lab=VDD}
N 1640 13960 1660 13960 {}
C {lab_pin.sym} 1660 13960 0 0 {name=l11245 lab=VSS}
C {bitcell_6t.sym} 1800 14000 0 0 {name=Xr70c9}
N 1760 14040 1740 14040 {}
C {lab_pin.sym} 1740 14040 0 0 {name=l11246 lab=BL9}
N 1760 14000 1740 14000 {}
C {lab_pin.sym} 1740 14000 0 0 {name=l11247 lab=BLB9}
N 1760 13960 1740 13960 {}
C {lab_pin.sym} 1740 13960 0 0 {name=l11248 lab=WL70}
N 1840 14040 1860 14040 {}
C {lab_pin.sym} 1860 14040 0 0 {name=l11249 lab=VDD}
N 1840 13960 1860 13960 {}
C {lab_pin.sym} 1860 13960 0 0 {name=l11250 lab=VSS}
C {bitcell_6t.sym} 2000 14000 0 0 {name=Xr70c10}
N 1960 14040 1940 14040 {}
C {lab_pin.sym} 1940 14040 0 0 {name=l11251 lab=BL10}
N 1960 14000 1940 14000 {}
C {lab_pin.sym} 1940 14000 0 0 {name=l11252 lab=BLB10}
N 1960 13960 1940 13960 {}
C {lab_pin.sym} 1940 13960 0 0 {name=l11253 lab=WL70}
N 2040 14040 2060 14040 {}
C {lab_pin.sym} 2060 14040 0 0 {name=l11254 lab=VDD}
N 2040 13960 2060 13960 {}
C {lab_pin.sym} 2060 13960 0 0 {name=l11255 lab=VSS}
C {bitcell_6t.sym} 2200 14000 0 0 {name=Xr70c11}
N 2160 14040 2140 14040 {}
C {lab_pin.sym} 2140 14040 0 0 {name=l11256 lab=BL11}
N 2160 14000 2140 14000 {}
C {lab_pin.sym} 2140 14000 0 0 {name=l11257 lab=BLB11}
N 2160 13960 2140 13960 {}
C {lab_pin.sym} 2140 13960 0 0 {name=l11258 lab=WL70}
N 2240 14040 2260 14040 {}
C {lab_pin.sym} 2260 14040 0 0 {name=l11259 lab=VDD}
N 2240 13960 2260 13960 {}
C {lab_pin.sym} 2260 13960 0 0 {name=l11260 lab=VSS}
C {bitcell_6t.sym} 2400 14000 0 0 {name=Xr70c12}
N 2360 14040 2340 14040 {}
C {lab_pin.sym} 2340 14040 0 0 {name=l11261 lab=BL12}
N 2360 14000 2340 14000 {}
C {lab_pin.sym} 2340 14000 0 0 {name=l11262 lab=BLB12}
N 2360 13960 2340 13960 {}
C {lab_pin.sym} 2340 13960 0 0 {name=l11263 lab=WL70}
N 2440 14040 2460 14040 {}
C {lab_pin.sym} 2460 14040 0 0 {name=l11264 lab=VDD}
N 2440 13960 2460 13960 {}
C {lab_pin.sym} 2460 13960 0 0 {name=l11265 lab=VSS}
C {bitcell_6t.sym} 2600 14000 0 0 {name=Xr70c13}
N 2560 14040 2540 14040 {}
C {lab_pin.sym} 2540 14040 0 0 {name=l11266 lab=BL13}
N 2560 14000 2540 14000 {}
C {lab_pin.sym} 2540 14000 0 0 {name=l11267 lab=BLB13}
N 2560 13960 2540 13960 {}
C {lab_pin.sym} 2540 13960 0 0 {name=l11268 lab=WL70}
N 2640 14040 2660 14040 {}
C {lab_pin.sym} 2660 14040 0 0 {name=l11269 lab=VDD}
N 2640 13960 2660 13960 {}
C {lab_pin.sym} 2660 13960 0 0 {name=l11270 lab=VSS}
C {bitcell_6t.sym} 2800 14000 0 0 {name=Xr70c14}
N 2760 14040 2740 14040 {}
C {lab_pin.sym} 2740 14040 0 0 {name=l11271 lab=BL14}
N 2760 14000 2740 14000 {}
C {lab_pin.sym} 2740 14000 0 0 {name=l11272 lab=BLB14}
N 2760 13960 2740 13960 {}
C {lab_pin.sym} 2740 13960 0 0 {name=l11273 lab=WL70}
N 2840 14040 2860 14040 {}
C {lab_pin.sym} 2860 14040 0 0 {name=l11274 lab=VDD}
N 2840 13960 2860 13960 {}
C {lab_pin.sym} 2860 13960 0 0 {name=l11275 lab=VSS}
C {bitcell_6t.sym} 3000 14000 0 0 {name=Xr70c15}
N 2960 14040 2940 14040 {}
C {lab_pin.sym} 2940 14040 0 0 {name=l11276 lab=BL15}
N 2960 14000 2940 14000 {}
C {lab_pin.sym} 2940 14000 0 0 {name=l11277 lab=BLB15}
N 2960 13960 2940 13960 {}
C {lab_pin.sym} 2940 13960 0 0 {name=l11278 lab=WL70}
N 3040 14040 3060 14040 {}
C {lab_pin.sym} 3060 14040 0 0 {name=l11279 lab=VDD}
N 3040 13960 3060 13960 {}
C {lab_pin.sym} 3060 13960 0 0 {name=l11280 lab=VSS}
C {bitcell_6t.sym} 3200 14000 0 0 {name=Xr70c16}
N 3160 14040 3140 14040 {}
C {lab_pin.sym} 3140 14040 0 0 {name=l11281 lab=BL16}
N 3160 14000 3140 14000 {}
C {lab_pin.sym} 3140 14000 0 0 {name=l11282 lab=BLB16}
N 3160 13960 3140 13960 {}
C {lab_pin.sym} 3140 13960 0 0 {name=l11283 lab=WL70}
N 3240 14040 3260 14040 {}
C {lab_pin.sym} 3260 14040 0 0 {name=l11284 lab=VDD}
N 3240 13960 3260 13960 {}
C {lab_pin.sym} 3260 13960 0 0 {name=l11285 lab=VSS}
C {bitcell_6t.sym} 3400 14000 0 0 {name=Xr70c17}
N 3360 14040 3340 14040 {}
C {lab_pin.sym} 3340 14040 0 0 {name=l11286 lab=BL17}
N 3360 14000 3340 14000 {}
C {lab_pin.sym} 3340 14000 0 0 {name=l11287 lab=BLB17}
N 3360 13960 3340 13960 {}
C {lab_pin.sym} 3340 13960 0 0 {name=l11288 lab=WL70}
N 3440 14040 3460 14040 {}
C {lab_pin.sym} 3460 14040 0 0 {name=l11289 lab=VDD}
N 3440 13960 3460 13960 {}
C {lab_pin.sym} 3460 13960 0 0 {name=l11290 lab=VSS}
C {bitcell_6t.sym} 3600 14000 0 0 {name=Xr70c18}
N 3560 14040 3540 14040 {}
C {lab_pin.sym} 3540 14040 0 0 {name=l11291 lab=BL18}
N 3560 14000 3540 14000 {}
C {lab_pin.sym} 3540 14000 0 0 {name=l11292 lab=BLB18}
N 3560 13960 3540 13960 {}
C {lab_pin.sym} 3540 13960 0 0 {name=l11293 lab=WL70}
N 3640 14040 3660 14040 {}
C {lab_pin.sym} 3660 14040 0 0 {name=l11294 lab=VDD}
N 3640 13960 3660 13960 {}
C {lab_pin.sym} 3660 13960 0 0 {name=l11295 lab=VSS}
C {bitcell_6t.sym} 3800 14000 0 0 {name=Xr70c19}
N 3760 14040 3740 14040 {}
C {lab_pin.sym} 3740 14040 0 0 {name=l11296 lab=BL19}
N 3760 14000 3740 14000 {}
C {lab_pin.sym} 3740 14000 0 0 {name=l11297 lab=BLB19}
N 3760 13960 3740 13960 {}
C {lab_pin.sym} 3740 13960 0 0 {name=l11298 lab=WL70}
N 3840 14040 3860 14040 {}
C {lab_pin.sym} 3860 14040 0 0 {name=l11299 lab=VDD}
N 3840 13960 3860 13960 {}
C {lab_pin.sym} 3860 13960 0 0 {name=l11300 lab=VSS}
C {bitcell_6t.sym} 4000 14000 0 0 {name=Xr70c20}
N 3960 14040 3940 14040 {}
C {lab_pin.sym} 3940 14040 0 0 {name=l11301 lab=BL20}
N 3960 14000 3940 14000 {}
C {lab_pin.sym} 3940 14000 0 0 {name=l11302 lab=BLB20}
N 3960 13960 3940 13960 {}
C {lab_pin.sym} 3940 13960 0 0 {name=l11303 lab=WL70}
N 4040 14040 4060 14040 {}
C {lab_pin.sym} 4060 14040 0 0 {name=l11304 lab=VDD}
N 4040 13960 4060 13960 {}
C {lab_pin.sym} 4060 13960 0 0 {name=l11305 lab=VSS}
C {bitcell_6t.sym} 4200 14000 0 0 {name=Xr70c21}
N 4160 14040 4140 14040 {}
C {lab_pin.sym} 4140 14040 0 0 {name=l11306 lab=BL21}
N 4160 14000 4140 14000 {}
C {lab_pin.sym} 4140 14000 0 0 {name=l11307 lab=BLB21}
N 4160 13960 4140 13960 {}
C {lab_pin.sym} 4140 13960 0 0 {name=l11308 lab=WL70}
N 4240 14040 4260 14040 {}
C {lab_pin.sym} 4260 14040 0 0 {name=l11309 lab=VDD}
N 4240 13960 4260 13960 {}
C {lab_pin.sym} 4260 13960 0 0 {name=l11310 lab=VSS}
C {bitcell_6t.sym} 4400 14000 0 0 {name=Xr70c22}
N 4360 14040 4340 14040 {}
C {lab_pin.sym} 4340 14040 0 0 {name=l11311 lab=BL22}
N 4360 14000 4340 14000 {}
C {lab_pin.sym} 4340 14000 0 0 {name=l11312 lab=BLB22}
N 4360 13960 4340 13960 {}
C {lab_pin.sym} 4340 13960 0 0 {name=l11313 lab=WL70}
N 4440 14040 4460 14040 {}
C {lab_pin.sym} 4460 14040 0 0 {name=l11314 lab=VDD}
N 4440 13960 4460 13960 {}
C {lab_pin.sym} 4460 13960 0 0 {name=l11315 lab=VSS}
C {bitcell_6t.sym} 4600 14000 0 0 {name=Xr70c23}
N 4560 14040 4540 14040 {}
C {lab_pin.sym} 4540 14040 0 0 {name=l11316 lab=BL23}
N 4560 14000 4540 14000 {}
C {lab_pin.sym} 4540 14000 0 0 {name=l11317 lab=BLB23}
N 4560 13960 4540 13960 {}
C {lab_pin.sym} 4540 13960 0 0 {name=l11318 lab=WL70}
N 4640 14040 4660 14040 {}
C {lab_pin.sym} 4660 14040 0 0 {name=l11319 lab=VDD}
N 4640 13960 4660 13960 {}
C {lab_pin.sym} 4660 13960 0 0 {name=l11320 lab=VSS}
C {bitcell_6t.sym} 4800 14000 0 0 {name=Xr70c24}
N 4760 14040 4740 14040 {}
C {lab_pin.sym} 4740 14040 0 0 {name=l11321 lab=BL24}
N 4760 14000 4740 14000 {}
C {lab_pin.sym} 4740 14000 0 0 {name=l11322 lab=BLB24}
N 4760 13960 4740 13960 {}
C {lab_pin.sym} 4740 13960 0 0 {name=l11323 lab=WL70}
N 4840 14040 4860 14040 {}
C {lab_pin.sym} 4860 14040 0 0 {name=l11324 lab=VDD}
N 4840 13960 4860 13960 {}
C {lab_pin.sym} 4860 13960 0 0 {name=l11325 lab=VSS}
C {bitcell_6t.sym} 5000 14000 0 0 {name=Xr70c25}
N 4960 14040 4940 14040 {}
C {lab_pin.sym} 4940 14040 0 0 {name=l11326 lab=BL25}
N 4960 14000 4940 14000 {}
C {lab_pin.sym} 4940 14000 0 0 {name=l11327 lab=BLB25}
N 4960 13960 4940 13960 {}
C {lab_pin.sym} 4940 13960 0 0 {name=l11328 lab=WL70}
N 5040 14040 5060 14040 {}
C {lab_pin.sym} 5060 14040 0 0 {name=l11329 lab=VDD}
N 5040 13960 5060 13960 {}
C {lab_pin.sym} 5060 13960 0 0 {name=l11330 lab=VSS}
C {bitcell_6t.sym} 5200 14000 0 0 {name=Xr70c26}
N 5160 14040 5140 14040 {}
C {lab_pin.sym} 5140 14040 0 0 {name=l11331 lab=BL26}
N 5160 14000 5140 14000 {}
C {lab_pin.sym} 5140 14000 0 0 {name=l11332 lab=BLB26}
N 5160 13960 5140 13960 {}
C {lab_pin.sym} 5140 13960 0 0 {name=l11333 lab=WL70}
N 5240 14040 5260 14040 {}
C {lab_pin.sym} 5260 14040 0 0 {name=l11334 lab=VDD}
N 5240 13960 5260 13960 {}
C {lab_pin.sym} 5260 13960 0 0 {name=l11335 lab=VSS}
C {bitcell_6t.sym} 5400 14000 0 0 {name=Xr70c27}
N 5360 14040 5340 14040 {}
C {lab_pin.sym} 5340 14040 0 0 {name=l11336 lab=BL27}
N 5360 14000 5340 14000 {}
C {lab_pin.sym} 5340 14000 0 0 {name=l11337 lab=BLB27}
N 5360 13960 5340 13960 {}
C {lab_pin.sym} 5340 13960 0 0 {name=l11338 lab=WL70}
N 5440 14040 5460 14040 {}
C {lab_pin.sym} 5460 14040 0 0 {name=l11339 lab=VDD}
N 5440 13960 5460 13960 {}
C {lab_pin.sym} 5460 13960 0 0 {name=l11340 lab=VSS}
C {bitcell_6t.sym} 5600 14000 0 0 {name=Xr70c28}
N 5560 14040 5540 14040 {}
C {lab_pin.sym} 5540 14040 0 0 {name=l11341 lab=BL28}
N 5560 14000 5540 14000 {}
C {lab_pin.sym} 5540 14000 0 0 {name=l11342 lab=BLB28}
N 5560 13960 5540 13960 {}
C {lab_pin.sym} 5540 13960 0 0 {name=l11343 lab=WL70}
N 5640 14040 5660 14040 {}
C {lab_pin.sym} 5660 14040 0 0 {name=l11344 lab=VDD}
N 5640 13960 5660 13960 {}
C {lab_pin.sym} 5660 13960 0 0 {name=l11345 lab=VSS}
C {bitcell_6t.sym} 5800 14000 0 0 {name=Xr70c29}
N 5760 14040 5740 14040 {}
C {lab_pin.sym} 5740 14040 0 0 {name=l11346 lab=BL29}
N 5760 14000 5740 14000 {}
C {lab_pin.sym} 5740 14000 0 0 {name=l11347 lab=BLB29}
N 5760 13960 5740 13960 {}
C {lab_pin.sym} 5740 13960 0 0 {name=l11348 lab=WL70}
N 5840 14040 5860 14040 {}
C {lab_pin.sym} 5860 14040 0 0 {name=l11349 lab=VDD}
N 5840 13960 5860 13960 {}
C {lab_pin.sym} 5860 13960 0 0 {name=l11350 lab=VSS}
C {bitcell_6t.sym} 6000 14000 0 0 {name=Xr70c30}
N 5960 14040 5940 14040 {}
C {lab_pin.sym} 5940 14040 0 0 {name=l11351 lab=BL30}
N 5960 14000 5940 14000 {}
C {lab_pin.sym} 5940 14000 0 0 {name=l11352 lab=BLB30}
N 5960 13960 5940 13960 {}
C {lab_pin.sym} 5940 13960 0 0 {name=l11353 lab=WL70}
N 6040 14040 6060 14040 {}
C {lab_pin.sym} 6060 14040 0 0 {name=l11354 lab=VDD}
N 6040 13960 6060 13960 {}
C {lab_pin.sym} 6060 13960 0 0 {name=l11355 lab=VSS}
C {bitcell_6t.sym} 6200 14000 0 0 {name=Xr70c31}
N 6160 14040 6140 14040 {}
C {lab_pin.sym} 6140 14040 0 0 {name=l11356 lab=BL31}
N 6160 14000 6140 14000 {}
C {lab_pin.sym} 6140 14000 0 0 {name=l11357 lab=BLB31}
N 6160 13960 6140 13960 {}
C {lab_pin.sym} 6140 13960 0 0 {name=l11358 lab=WL70}
N 6240 14040 6260 14040 {}
C {lab_pin.sym} 6260 14040 0 0 {name=l11359 lab=VDD}
N 6240 13960 6260 13960 {}
C {lab_pin.sym} 6260 13960 0 0 {name=l11360 lab=VSS}
C {bitcell_6t.sym} 0 14200 0 0 {name=Xr71c0}
N -40 14240 -60 14240 {}
C {lab_pin.sym} -60 14240 0 0 {name=l11361 lab=BL0}
N -40 14200 -60 14200 {}
C {lab_pin.sym} -60 14200 0 0 {name=l11362 lab=BLB0}
N -40 14160 -60 14160 {}
C {lab_pin.sym} -60 14160 0 0 {name=l11363 lab=WL71}
N 40 14240 60 14240 {}
C {lab_pin.sym} 60 14240 0 0 {name=l11364 lab=VDD}
N 40 14160 60 14160 {}
C {lab_pin.sym} 60 14160 0 0 {name=l11365 lab=VSS}
C {bitcell_6t.sym} 200 14200 0 0 {name=Xr71c1}
N 160 14240 140 14240 {}
C {lab_pin.sym} 140 14240 0 0 {name=l11366 lab=BL1}
N 160 14200 140 14200 {}
C {lab_pin.sym} 140 14200 0 0 {name=l11367 lab=BLB1}
N 160 14160 140 14160 {}
C {lab_pin.sym} 140 14160 0 0 {name=l11368 lab=WL71}
N 240 14240 260 14240 {}
C {lab_pin.sym} 260 14240 0 0 {name=l11369 lab=VDD}
N 240 14160 260 14160 {}
C {lab_pin.sym} 260 14160 0 0 {name=l11370 lab=VSS}
C {bitcell_6t.sym} 400 14200 0 0 {name=Xr71c2}
N 360 14240 340 14240 {}
C {lab_pin.sym} 340 14240 0 0 {name=l11371 lab=BL2}
N 360 14200 340 14200 {}
C {lab_pin.sym} 340 14200 0 0 {name=l11372 lab=BLB2}
N 360 14160 340 14160 {}
C {lab_pin.sym} 340 14160 0 0 {name=l11373 lab=WL71}
N 440 14240 460 14240 {}
C {lab_pin.sym} 460 14240 0 0 {name=l11374 lab=VDD}
N 440 14160 460 14160 {}
C {lab_pin.sym} 460 14160 0 0 {name=l11375 lab=VSS}
C {bitcell_6t.sym} 600 14200 0 0 {name=Xr71c3}
N 560 14240 540 14240 {}
C {lab_pin.sym} 540 14240 0 0 {name=l11376 lab=BL3}
N 560 14200 540 14200 {}
C {lab_pin.sym} 540 14200 0 0 {name=l11377 lab=BLB3}
N 560 14160 540 14160 {}
C {lab_pin.sym} 540 14160 0 0 {name=l11378 lab=WL71}
N 640 14240 660 14240 {}
C {lab_pin.sym} 660 14240 0 0 {name=l11379 lab=VDD}
N 640 14160 660 14160 {}
C {lab_pin.sym} 660 14160 0 0 {name=l11380 lab=VSS}
C {bitcell_6t.sym} 800 14200 0 0 {name=Xr71c4}
N 760 14240 740 14240 {}
C {lab_pin.sym} 740 14240 0 0 {name=l11381 lab=BL4}
N 760 14200 740 14200 {}
C {lab_pin.sym} 740 14200 0 0 {name=l11382 lab=BLB4}
N 760 14160 740 14160 {}
C {lab_pin.sym} 740 14160 0 0 {name=l11383 lab=WL71}
N 840 14240 860 14240 {}
C {lab_pin.sym} 860 14240 0 0 {name=l11384 lab=VDD}
N 840 14160 860 14160 {}
C {lab_pin.sym} 860 14160 0 0 {name=l11385 lab=VSS}
C {bitcell_6t.sym} 1000 14200 0 0 {name=Xr71c5}
N 960 14240 940 14240 {}
C {lab_pin.sym} 940 14240 0 0 {name=l11386 lab=BL5}
N 960 14200 940 14200 {}
C {lab_pin.sym} 940 14200 0 0 {name=l11387 lab=BLB5}
N 960 14160 940 14160 {}
C {lab_pin.sym} 940 14160 0 0 {name=l11388 lab=WL71}
N 1040 14240 1060 14240 {}
C {lab_pin.sym} 1060 14240 0 0 {name=l11389 lab=VDD}
N 1040 14160 1060 14160 {}
C {lab_pin.sym} 1060 14160 0 0 {name=l11390 lab=VSS}
C {bitcell_6t.sym} 1200 14200 0 0 {name=Xr71c6}
N 1160 14240 1140 14240 {}
C {lab_pin.sym} 1140 14240 0 0 {name=l11391 lab=BL6}
N 1160 14200 1140 14200 {}
C {lab_pin.sym} 1140 14200 0 0 {name=l11392 lab=BLB6}
N 1160 14160 1140 14160 {}
C {lab_pin.sym} 1140 14160 0 0 {name=l11393 lab=WL71}
N 1240 14240 1260 14240 {}
C {lab_pin.sym} 1260 14240 0 0 {name=l11394 lab=VDD}
N 1240 14160 1260 14160 {}
C {lab_pin.sym} 1260 14160 0 0 {name=l11395 lab=VSS}
C {bitcell_6t.sym} 1400 14200 0 0 {name=Xr71c7}
N 1360 14240 1340 14240 {}
C {lab_pin.sym} 1340 14240 0 0 {name=l11396 lab=BL7}
N 1360 14200 1340 14200 {}
C {lab_pin.sym} 1340 14200 0 0 {name=l11397 lab=BLB7}
N 1360 14160 1340 14160 {}
C {lab_pin.sym} 1340 14160 0 0 {name=l11398 lab=WL71}
N 1440 14240 1460 14240 {}
C {lab_pin.sym} 1460 14240 0 0 {name=l11399 lab=VDD}
N 1440 14160 1460 14160 {}
C {lab_pin.sym} 1460 14160 0 0 {name=l11400 lab=VSS}
C {bitcell_6t.sym} 1600 14200 0 0 {name=Xr71c8}
N 1560 14240 1540 14240 {}
C {lab_pin.sym} 1540 14240 0 0 {name=l11401 lab=BL8}
N 1560 14200 1540 14200 {}
C {lab_pin.sym} 1540 14200 0 0 {name=l11402 lab=BLB8}
N 1560 14160 1540 14160 {}
C {lab_pin.sym} 1540 14160 0 0 {name=l11403 lab=WL71}
N 1640 14240 1660 14240 {}
C {lab_pin.sym} 1660 14240 0 0 {name=l11404 lab=VDD}
N 1640 14160 1660 14160 {}
C {lab_pin.sym} 1660 14160 0 0 {name=l11405 lab=VSS}
C {bitcell_6t.sym} 1800 14200 0 0 {name=Xr71c9}
N 1760 14240 1740 14240 {}
C {lab_pin.sym} 1740 14240 0 0 {name=l11406 lab=BL9}
N 1760 14200 1740 14200 {}
C {lab_pin.sym} 1740 14200 0 0 {name=l11407 lab=BLB9}
N 1760 14160 1740 14160 {}
C {lab_pin.sym} 1740 14160 0 0 {name=l11408 lab=WL71}
N 1840 14240 1860 14240 {}
C {lab_pin.sym} 1860 14240 0 0 {name=l11409 lab=VDD}
N 1840 14160 1860 14160 {}
C {lab_pin.sym} 1860 14160 0 0 {name=l11410 lab=VSS}
C {bitcell_6t.sym} 2000 14200 0 0 {name=Xr71c10}
N 1960 14240 1940 14240 {}
C {lab_pin.sym} 1940 14240 0 0 {name=l11411 lab=BL10}
N 1960 14200 1940 14200 {}
C {lab_pin.sym} 1940 14200 0 0 {name=l11412 lab=BLB10}
N 1960 14160 1940 14160 {}
C {lab_pin.sym} 1940 14160 0 0 {name=l11413 lab=WL71}
N 2040 14240 2060 14240 {}
C {lab_pin.sym} 2060 14240 0 0 {name=l11414 lab=VDD}
N 2040 14160 2060 14160 {}
C {lab_pin.sym} 2060 14160 0 0 {name=l11415 lab=VSS}
C {bitcell_6t.sym} 2200 14200 0 0 {name=Xr71c11}
N 2160 14240 2140 14240 {}
C {lab_pin.sym} 2140 14240 0 0 {name=l11416 lab=BL11}
N 2160 14200 2140 14200 {}
C {lab_pin.sym} 2140 14200 0 0 {name=l11417 lab=BLB11}
N 2160 14160 2140 14160 {}
C {lab_pin.sym} 2140 14160 0 0 {name=l11418 lab=WL71}
N 2240 14240 2260 14240 {}
C {lab_pin.sym} 2260 14240 0 0 {name=l11419 lab=VDD}
N 2240 14160 2260 14160 {}
C {lab_pin.sym} 2260 14160 0 0 {name=l11420 lab=VSS}
C {bitcell_6t.sym} 2400 14200 0 0 {name=Xr71c12}
N 2360 14240 2340 14240 {}
C {lab_pin.sym} 2340 14240 0 0 {name=l11421 lab=BL12}
N 2360 14200 2340 14200 {}
C {lab_pin.sym} 2340 14200 0 0 {name=l11422 lab=BLB12}
N 2360 14160 2340 14160 {}
C {lab_pin.sym} 2340 14160 0 0 {name=l11423 lab=WL71}
N 2440 14240 2460 14240 {}
C {lab_pin.sym} 2460 14240 0 0 {name=l11424 lab=VDD}
N 2440 14160 2460 14160 {}
C {lab_pin.sym} 2460 14160 0 0 {name=l11425 lab=VSS}
C {bitcell_6t.sym} 2600 14200 0 0 {name=Xr71c13}
N 2560 14240 2540 14240 {}
C {lab_pin.sym} 2540 14240 0 0 {name=l11426 lab=BL13}
N 2560 14200 2540 14200 {}
C {lab_pin.sym} 2540 14200 0 0 {name=l11427 lab=BLB13}
N 2560 14160 2540 14160 {}
C {lab_pin.sym} 2540 14160 0 0 {name=l11428 lab=WL71}
N 2640 14240 2660 14240 {}
C {lab_pin.sym} 2660 14240 0 0 {name=l11429 lab=VDD}
N 2640 14160 2660 14160 {}
C {lab_pin.sym} 2660 14160 0 0 {name=l11430 lab=VSS}
C {bitcell_6t.sym} 2800 14200 0 0 {name=Xr71c14}
N 2760 14240 2740 14240 {}
C {lab_pin.sym} 2740 14240 0 0 {name=l11431 lab=BL14}
N 2760 14200 2740 14200 {}
C {lab_pin.sym} 2740 14200 0 0 {name=l11432 lab=BLB14}
N 2760 14160 2740 14160 {}
C {lab_pin.sym} 2740 14160 0 0 {name=l11433 lab=WL71}
N 2840 14240 2860 14240 {}
C {lab_pin.sym} 2860 14240 0 0 {name=l11434 lab=VDD}
N 2840 14160 2860 14160 {}
C {lab_pin.sym} 2860 14160 0 0 {name=l11435 lab=VSS}
C {bitcell_6t.sym} 3000 14200 0 0 {name=Xr71c15}
N 2960 14240 2940 14240 {}
C {lab_pin.sym} 2940 14240 0 0 {name=l11436 lab=BL15}
N 2960 14200 2940 14200 {}
C {lab_pin.sym} 2940 14200 0 0 {name=l11437 lab=BLB15}
N 2960 14160 2940 14160 {}
C {lab_pin.sym} 2940 14160 0 0 {name=l11438 lab=WL71}
N 3040 14240 3060 14240 {}
C {lab_pin.sym} 3060 14240 0 0 {name=l11439 lab=VDD}
N 3040 14160 3060 14160 {}
C {lab_pin.sym} 3060 14160 0 0 {name=l11440 lab=VSS}
C {bitcell_6t.sym} 3200 14200 0 0 {name=Xr71c16}
N 3160 14240 3140 14240 {}
C {lab_pin.sym} 3140 14240 0 0 {name=l11441 lab=BL16}
N 3160 14200 3140 14200 {}
C {lab_pin.sym} 3140 14200 0 0 {name=l11442 lab=BLB16}
N 3160 14160 3140 14160 {}
C {lab_pin.sym} 3140 14160 0 0 {name=l11443 lab=WL71}
N 3240 14240 3260 14240 {}
C {lab_pin.sym} 3260 14240 0 0 {name=l11444 lab=VDD}
N 3240 14160 3260 14160 {}
C {lab_pin.sym} 3260 14160 0 0 {name=l11445 lab=VSS}
C {bitcell_6t.sym} 3400 14200 0 0 {name=Xr71c17}
N 3360 14240 3340 14240 {}
C {lab_pin.sym} 3340 14240 0 0 {name=l11446 lab=BL17}
N 3360 14200 3340 14200 {}
C {lab_pin.sym} 3340 14200 0 0 {name=l11447 lab=BLB17}
N 3360 14160 3340 14160 {}
C {lab_pin.sym} 3340 14160 0 0 {name=l11448 lab=WL71}
N 3440 14240 3460 14240 {}
C {lab_pin.sym} 3460 14240 0 0 {name=l11449 lab=VDD}
N 3440 14160 3460 14160 {}
C {lab_pin.sym} 3460 14160 0 0 {name=l11450 lab=VSS}
C {bitcell_6t.sym} 3600 14200 0 0 {name=Xr71c18}
N 3560 14240 3540 14240 {}
C {lab_pin.sym} 3540 14240 0 0 {name=l11451 lab=BL18}
N 3560 14200 3540 14200 {}
C {lab_pin.sym} 3540 14200 0 0 {name=l11452 lab=BLB18}
N 3560 14160 3540 14160 {}
C {lab_pin.sym} 3540 14160 0 0 {name=l11453 lab=WL71}
N 3640 14240 3660 14240 {}
C {lab_pin.sym} 3660 14240 0 0 {name=l11454 lab=VDD}
N 3640 14160 3660 14160 {}
C {lab_pin.sym} 3660 14160 0 0 {name=l11455 lab=VSS}
C {bitcell_6t.sym} 3800 14200 0 0 {name=Xr71c19}
N 3760 14240 3740 14240 {}
C {lab_pin.sym} 3740 14240 0 0 {name=l11456 lab=BL19}
N 3760 14200 3740 14200 {}
C {lab_pin.sym} 3740 14200 0 0 {name=l11457 lab=BLB19}
N 3760 14160 3740 14160 {}
C {lab_pin.sym} 3740 14160 0 0 {name=l11458 lab=WL71}
N 3840 14240 3860 14240 {}
C {lab_pin.sym} 3860 14240 0 0 {name=l11459 lab=VDD}
N 3840 14160 3860 14160 {}
C {lab_pin.sym} 3860 14160 0 0 {name=l11460 lab=VSS}
C {bitcell_6t.sym} 4000 14200 0 0 {name=Xr71c20}
N 3960 14240 3940 14240 {}
C {lab_pin.sym} 3940 14240 0 0 {name=l11461 lab=BL20}
N 3960 14200 3940 14200 {}
C {lab_pin.sym} 3940 14200 0 0 {name=l11462 lab=BLB20}
N 3960 14160 3940 14160 {}
C {lab_pin.sym} 3940 14160 0 0 {name=l11463 lab=WL71}
N 4040 14240 4060 14240 {}
C {lab_pin.sym} 4060 14240 0 0 {name=l11464 lab=VDD}
N 4040 14160 4060 14160 {}
C {lab_pin.sym} 4060 14160 0 0 {name=l11465 lab=VSS}
C {bitcell_6t.sym} 4200 14200 0 0 {name=Xr71c21}
N 4160 14240 4140 14240 {}
C {lab_pin.sym} 4140 14240 0 0 {name=l11466 lab=BL21}
N 4160 14200 4140 14200 {}
C {lab_pin.sym} 4140 14200 0 0 {name=l11467 lab=BLB21}
N 4160 14160 4140 14160 {}
C {lab_pin.sym} 4140 14160 0 0 {name=l11468 lab=WL71}
N 4240 14240 4260 14240 {}
C {lab_pin.sym} 4260 14240 0 0 {name=l11469 lab=VDD}
N 4240 14160 4260 14160 {}
C {lab_pin.sym} 4260 14160 0 0 {name=l11470 lab=VSS}
C {bitcell_6t.sym} 4400 14200 0 0 {name=Xr71c22}
N 4360 14240 4340 14240 {}
C {lab_pin.sym} 4340 14240 0 0 {name=l11471 lab=BL22}
N 4360 14200 4340 14200 {}
C {lab_pin.sym} 4340 14200 0 0 {name=l11472 lab=BLB22}
N 4360 14160 4340 14160 {}
C {lab_pin.sym} 4340 14160 0 0 {name=l11473 lab=WL71}
N 4440 14240 4460 14240 {}
C {lab_pin.sym} 4460 14240 0 0 {name=l11474 lab=VDD}
N 4440 14160 4460 14160 {}
C {lab_pin.sym} 4460 14160 0 0 {name=l11475 lab=VSS}
C {bitcell_6t.sym} 4600 14200 0 0 {name=Xr71c23}
N 4560 14240 4540 14240 {}
C {lab_pin.sym} 4540 14240 0 0 {name=l11476 lab=BL23}
N 4560 14200 4540 14200 {}
C {lab_pin.sym} 4540 14200 0 0 {name=l11477 lab=BLB23}
N 4560 14160 4540 14160 {}
C {lab_pin.sym} 4540 14160 0 0 {name=l11478 lab=WL71}
N 4640 14240 4660 14240 {}
C {lab_pin.sym} 4660 14240 0 0 {name=l11479 lab=VDD}
N 4640 14160 4660 14160 {}
C {lab_pin.sym} 4660 14160 0 0 {name=l11480 lab=VSS}
C {bitcell_6t.sym} 4800 14200 0 0 {name=Xr71c24}
N 4760 14240 4740 14240 {}
C {lab_pin.sym} 4740 14240 0 0 {name=l11481 lab=BL24}
N 4760 14200 4740 14200 {}
C {lab_pin.sym} 4740 14200 0 0 {name=l11482 lab=BLB24}
N 4760 14160 4740 14160 {}
C {lab_pin.sym} 4740 14160 0 0 {name=l11483 lab=WL71}
N 4840 14240 4860 14240 {}
C {lab_pin.sym} 4860 14240 0 0 {name=l11484 lab=VDD}
N 4840 14160 4860 14160 {}
C {lab_pin.sym} 4860 14160 0 0 {name=l11485 lab=VSS}
C {bitcell_6t.sym} 5000 14200 0 0 {name=Xr71c25}
N 4960 14240 4940 14240 {}
C {lab_pin.sym} 4940 14240 0 0 {name=l11486 lab=BL25}
N 4960 14200 4940 14200 {}
C {lab_pin.sym} 4940 14200 0 0 {name=l11487 lab=BLB25}
N 4960 14160 4940 14160 {}
C {lab_pin.sym} 4940 14160 0 0 {name=l11488 lab=WL71}
N 5040 14240 5060 14240 {}
C {lab_pin.sym} 5060 14240 0 0 {name=l11489 lab=VDD}
N 5040 14160 5060 14160 {}
C {lab_pin.sym} 5060 14160 0 0 {name=l11490 lab=VSS}
C {bitcell_6t.sym} 5200 14200 0 0 {name=Xr71c26}
N 5160 14240 5140 14240 {}
C {lab_pin.sym} 5140 14240 0 0 {name=l11491 lab=BL26}
N 5160 14200 5140 14200 {}
C {lab_pin.sym} 5140 14200 0 0 {name=l11492 lab=BLB26}
N 5160 14160 5140 14160 {}
C {lab_pin.sym} 5140 14160 0 0 {name=l11493 lab=WL71}
N 5240 14240 5260 14240 {}
C {lab_pin.sym} 5260 14240 0 0 {name=l11494 lab=VDD}
N 5240 14160 5260 14160 {}
C {lab_pin.sym} 5260 14160 0 0 {name=l11495 lab=VSS}
C {bitcell_6t.sym} 5400 14200 0 0 {name=Xr71c27}
N 5360 14240 5340 14240 {}
C {lab_pin.sym} 5340 14240 0 0 {name=l11496 lab=BL27}
N 5360 14200 5340 14200 {}
C {lab_pin.sym} 5340 14200 0 0 {name=l11497 lab=BLB27}
N 5360 14160 5340 14160 {}
C {lab_pin.sym} 5340 14160 0 0 {name=l11498 lab=WL71}
N 5440 14240 5460 14240 {}
C {lab_pin.sym} 5460 14240 0 0 {name=l11499 lab=VDD}
N 5440 14160 5460 14160 {}
C {lab_pin.sym} 5460 14160 0 0 {name=l11500 lab=VSS}
C {bitcell_6t.sym} 5600 14200 0 0 {name=Xr71c28}
N 5560 14240 5540 14240 {}
C {lab_pin.sym} 5540 14240 0 0 {name=l11501 lab=BL28}
N 5560 14200 5540 14200 {}
C {lab_pin.sym} 5540 14200 0 0 {name=l11502 lab=BLB28}
N 5560 14160 5540 14160 {}
C {lab_pin.sym} 5540 14160 0 0 {name=l11503 lab=WL71}
N 5640 14240 5660 14240 {}
C {lab_pin.sym} 5660 14240 0 0 {name=l11504 lab=VDD}
N 5640 14160 5660 14160 {}
C {lab_pin.sym} 5660 14160 0 0 {name=l11505 lab=VSS}
C {bitcell_6t.sym} 5800 14200 0 0 {name=Xr71c29}
N 5760 14240 5740 14240 {}
C {lab_pin.sym} 5740 14240 0 0 {name=l11506 lab=BL29}
N 5760 14200 5740 14200 {}
C {lab_pin.sym} 5740 14200 0 0 {name=l11507 lab=BLB29}
N 5760 14160 5740 14160 {}
C {lab_pin.sym} 5740 14160 0 0 {name=l11508 lab=WL71}
N 5840 14240 5860 14240 {}
C {lab_pin.sym} 5860 14240 0 0 {name=l11509 lab=VDD}
N 5840 14160 5860 14160 {}
C {lab_pin.sym} 5860 14160 0 0 {name=l11510 lab=VSS}
C {bitcell_6t.sym} 6000 14200 0 0 {name=Xr71c30}
N 5960 14240 5940 14240 {}
C {lab_pin.sym} 5940 14240 0 0 {name=l11511 lab=BL30}
N 5960 14200 5940 14200 {}
C {lab_pin.sym} 5940 14200 0 0 {name=l11512 lab=BLB30}
N 5960 14160 5940 14160 {}
C {lab_pin.sym} 5940 14160 0 0 {name=l11513 lab=WL71}
N 6040 14240 6060 14240 {}
C {lab_pin.sym} 6060 14240 0 0 {name=l11514 lab=VDD}
N 6040 14160 6060 14160 {}
C {lab_pin.sym} 6060 14160 0 0 {name=l11515 lab=VSS}
C {bitcell_6t.sym} 6200 14200 0 0 {name=Xr71c31}
N 6160 14240 6140 14240 {}
C {lab_pin.sym} 6140 14240 0 0 {name=l11516 lab=BL31}
N 6160 14200 6140 14200 {}
C {lab_pin.sym} 6140 14200 0 0 {name=l11517 lab=BLB31}
N 6160 14160 6140 14160 {}
C {lab_pin.sym} 6140 14160 0 0 {name=l11518 lab=WL71}
N 6240 14240 6260 14240 {}
C {lab_pin.sym} 6260 14240 0 0 {name=l11519 lab=VDD}
N 6240 14160 6260 14160 {}
C {lab_pin.sym} 6260 14160 0 0 {name=l11520 lab=VSS}
C {bitcell_6t.sym} 0 14400 0 0 {name=Xr72c0}
N -40 14440 -60 14440 {}
C {lab_pin.sym} -60 14440 0 0 {name=l11521 lab=BL0}
N -40 14400 -60 14400 {}
C {lab_pin.sym} -60 14400 0 0 {name=l11522 lab=BLB0}
N -40 14360 -60 14360 {}
C {lab_pin.sym} -60 14360 0 0 {name=l11523 lab=WL72}
N 40 14440 60 14440 {}
C {lab_pin.sym} 60 14440 0 0 {name=l11524 lab=VDD}
N 40 14360 60 14360 {}
C {lab_pin.sym} 60 14360 0 0 {name=l11525 lab=VSS}
C {bitcell_6t.sym} 200 14400 0 0 {name=Xr72c1}
N 160 14440 140 14440 {}
C {lab_pin.sym} 140 14440 0 0 {name=l11526 lab=BL1}
N 160 14400 140 14400 {}
C {lab_pin.sym} 140 14400 0 0 {name=l11527 lab=BLB1}
N 160 14360 140 14360 {}
C {lab_pin.sym} 140 14360 0 0 {name=l11528 lab=WL72}
N 240 14440 260 14440 {}
C {lab_pin.sym} 260 14440 0 0 {name=l11529 lab=VDD}
N 240 14360 260 14360 {}
C {lab_pin.sym} 260 14360 0 0 {name=l11530 lab=VSS}
C {bitcell_6t.sym} 400 14400 0 0 {name=Xr72c2}
N 360 14440 340 14440 {}
C {lab_pin.sym} 340 14440 0 0 {name=l11531 lab=BL2}
N 360 14400 340 14400 {}
C {lab_pin.sym} 340 14400 0 0 {name=l11532 lab=BLB2}
N 360 14360 340 14360 {}
C {lab_pin.sym} 340 14360 0 0 {name=l11533 lab=WL72}
N 440 14440 460 14440 {}
C {lab_pin.sym} 460 14440 0 0 {name=l11534 lab=VDD}
N 440 14360 460 14360 {}
C {lab_pin.sym} 460 14360 0 0 {name=l11535 lab=VSS}
C {bitcell_6t.sym} 600 14400 0 0 {name=Xr72c3}
N 560 14440 540 14440 {}
C {lab_pin.sym} 540 14440 0 0 {name=l11536 lab=BL3}
N 560 14400 540 14400 {}
C {lab_pin.sym} 540 14400 0 0 {name=l11537 lab=BLB3}
N 560 14360 540 14360 {}
C {lab_pin.sym} 540 14360 0 0 {name=l11538 lab=WL72}
N 640 14440 660 14440 {}
C {lab_pin.sym} 660 14440 0 0 {name=l11539 lab=VDD}
N 640 14360 660 14360 {}
C {lab_pin.sym} 660 14360 0 0 {name=l11540 lab=VSS}
C {bitcell_6t.sym} 800 14400 0 0 {name=Xr72c4}
N 760 14440 740 14440 {}
C {lab_pin.sym} 740 14440 0 0 {name=l11541 lab=BL4}
N 760 14400 740 14400 {}
C {lab_pin.sym} 740 14400 0 0 {name=l11542 lab=BLB4}
N 760 14360 740 14360 {}
C {lab_pin.sym} 740 14360 0 0 {name=l11543 lab=WL72}
N 840 14440 860 14440 {}
C {lab_pin.sym} 860 14440 0 0 {name=l11544 lab=VDD}
N 840 14360 860 14360 {}
C {lab_pin.sym} 860 14360 0 0 {name=l11545 lab=VSS}
C {bitcell_6t.sym} 1000 14400 0 0 {name=Xr72c5}
N 960 14440 940 14440 {}
C {lab_pin.sym} 940 14440 0 0 {name=l11546 lab=BL5}
N 960 14400 940 14400 {}
C {lab_pin.sym} 940 14400 0 0 {name=l11547 lab=BLB5}
N 960 14360 940 14360 {}
C {lab_pin.sym} 940 14360 0 0 {name=l11548 lab=WL72}
N 1040 14440 1060 14440 {}
C {lab_pin.sym} 1060 14440 0 0 {name=l11549 lab=VDD}
N 1040 14360 1060 14360 {}
C {lab_pin.sym} 1060 14360 0 0 {name=l11550 lab=VSS}
C {bitcell_6t.sym} 1200 14400 0 0 {name=Xr72c6}
N 1160 14440 1140 14440 {}
C {lab_pin.sym} 1140 14440 0 0 {name=l11551 lab=BL6}
N 1160 14400 1140 14400 {}
C {lab_pin.sym} 1140 14400 0 0 {name=l11552 lab=BLB6}
N 1160 14360 1140 14360 {}
C {lab_pin.sym} 1140 14360 0 0 {name=l11553 lab=WL72}
N 1240 14440 1260 14440 {}
C {lab_pin.sym} 1260 14440 0 0 {name=l11554 lab=VDD}
N 1240 14360 1260 14360 {}
C {lab_pin.sym} 1260 14360 0 0 {name=l11555 lab=VSS}
C {bitcell_6t.sym} 1400 14400 0 0 {name=Xr72c7}
N 1360 14440 1340 14440 {}
C {lab_pin.sym} 1340 14440 0 0 {name=l11556 lab=BL7}
N 1360 14400 1340 14400 {}
C {lab_pin.sym} 1340 14400 0 0 {name=l11557 lab=BLB7}
N 1360 14360 1340 14360 {}
C {lab_pin.sym} 1340 14360 0 0 {name=l11558 lab=WL72}
N 1440 14440 1460 14440 {}
C {lab_pin.sym} 1460 14440 0 0 {name=l11559 lab=VDD}
N 1440 14360 1460 14360 {}
C {lab_pin.sym} 1460 14360 0 0 {name=l11560 lab=VSS}
C {bitcell_6t.sym} 1600 14400 0 0 {name=Xr72c8}
N 1560 14440 1540 14440 {}
C {lab_pin.sym} 1540 14440 0 0 {name=l11561 lab=BL8}
N 1560 14400 1540 14400 {}
C {lab_pin.sym} 1540 14400 0 0 {name=l11562 lab=BLB8}
N 1560 14360 1540 14360 {}
C {lab_pin.sym} 1540 14360 0 0 {name=l11563 lab=WL72}
N 1640 14440 1660 14440 {}
C {lab_pin.sym} 1660 14440 0 0 {name=l11564 lab=VDD}
N 1640 14360 1660 14360 {}
C {lab_pin.sym} 1660 14360 0 0 {name=l11565 lab=VSS}
C {bitcell_6t.sym} 1800 14400 0 0 {name=Xr72c9}
N 1760 14440 1740 14440 {}
C {lab_pin.sym} 1740 14440 0 0 {name=l11566 lab=BL9}
N 1760 14400 1740 14400 {}
C {lab_pin.sym} 1740 14400 0 0 {name=l11567 lab=BLB9}
N 1760 14360 1740 14360 {}
C {lab_pin.sym} 1740 14360 0 0 {name=l11568 lab=WL72}
N 1840 14440 1860 14440 {}
C {lab_pin.sym} 1860 14440 0 0 {name=l11569 lab=VDD}
N 1840 14360 1860 14360 {}
C {lab_pin.sym} 1860 14360 0 0 {name=l11570 lab=VSS}
C {bitcell_6t.sym} 2000 14400 0 0 {name=Xr72c10}
N 1960 14440 1940 14440 {}
C {lab_pin.sym} 1940 14440 0 0 {name=l11571 lab=BL10}
N 1960 14400 1940 14400 {}
C {lab_pin.sym} 1940 14400 0 0 {name=l11572 lab=BLB10}
N 1960 14360 1940 14360 {}
C {lab_pin.sym} 1940 14360 0 0 {name=l11573 lab=WL72}
N 2040 14440 2060 14440 {}
C {lab_pin.sym} 2060 14440 0 0 {name=l11574 lab=VDD}
N 2040 14360 2060 14360 {}
C {lab_pin.sym} 2060 14360 0 0 {name=l11575 lab=VSS}
C {bitcell_6t.sym} 2200 14400 0 0 {name=Xr72c11}
N 2160 14440 2140 14440 {}
C {lab_pin.sym} 2140 14440 0 0 {name=l11576 lab=BL11}
N 2160 14400 2140 14400 {}
C {lab_pin.sym} 2140 14400 0 0 {name=l11577 lab=BLB11}
N 2160 14360 2140 14360 {}
C {lab_pin.sym} 2140 14360 0 0 {name=l11578 lab=WL72}
N 2240 14440 2260 14440 {}
C {lab_pin.sym} 2260 14440 0 0 {name=l11579 lab=VDD}
N 2240 14360 2260 14360 {}
C {lab_pin.sym} 2260 14360 0 0 {name=l11580 lab=VSS}
C {bitcell_6t.sym} 2400 14400 0 0 {name=Xr72c12}
N 2360 14440 2340 14440 {}
C {lab_pin.sym} 2340 14440 0 0 {name=l11581 lab=BL12}
N 2360 14400 2340 14400 {}
C {lab_pin.sym} 2340 14400 0 0 {name=l11582 lab=BLB12}
N 2360 14360 2340 14360 {}
C {lab_pin.sym} 2340 14360 0 0 {name=l11583 lab=WL72}
N 2440 14440 2460 14440 {}
C {lab_pin.sym} 2460 14440 0 0 {name=l11584 lab=VDD}
N 2440 14360 2460 14360 {}
C {lab_pin.sym} 2460 14360 0 0 {name=l11585 lab=VSS}
C {bitcell_6t.sym} 2600 14400 0 0 {name=Xr72c13}
N 2560 14440 2540 14440 {}
C {lab_pin.sym} 2540 14440 0 0 {name=l11586 lab=BL13}
N 2560 14400 2540 14400 {}
C {lab_pin.sym} 2540 14400 0 0 {name=l11587 lab=BLB13}
N 2560 14360 2540 14360 {}
C {lab_pin.sym} 2540 14360 0 0 {name=l11588 lab=WL72}
N 2640 14440 2660 14440 {}
C {lab_pin.sym} 2660 14440 0 0 {name=l11589 lab=VDD}
N 2640 14360 2660 14360 {}
C {lab_pin.sym} 2660 14360 0 0 {name=l11590 lab=VSS}
C {bitcell_6t.sym} 2800 14400 0 0 {name=Xr72c14}
N 2760 14440 2740 14440 {}
C {lab_pin.sym} 2740 14440 0 0 {name=l11591 lab=BL14}
N 2760 14400 2740 14400 {}
C {lab_pin.sym} 2740 14400 0 0 {name=l11592 lab=BLB14}
N 2760 14360 2740 14360 {}
C {lab_pin.sym} 2740 14360 0 0 {name=l11593 lab=WL72}
N 2840 14440 2860 14440 {}
C {lab_pin.sym} 2860 14440 0 0 {name=l11594 lab=VDD}
N 2840 14360 2860 14360 {}
C {lab_pin.sym} 2860 14360 0 0 {name=l11595 lab=VSS}
C {bitcell_6t.sym} 3000 14400 0 0 {name=Xr72c15}
N 2960 14440 2940 14440 {}
C {lab_pin.sym} 2940 14440 0 0 {name=l11596 lab=BL15}
N 2960 14400 2940 14400 {}
C {lab_pin.sym} 2940 14400 0 0 {name=l11597 lab=BLB15}
N 2960 14360 2940 14360 {}
C {lab_pin.sym} 2940 14360 0 0 {name=l11598 lab=WL72}
N 3040 14440 3060 14440 {}
C {lab_pin.sym} 3060 14440 0 0 {name=l11599 lab=VDD}
N 3040 14360 3060 14360 {}
C {lab_pin.sym} 3060 14360 0 0 {name=l11600 lab=VSS}
C {bitcell_6t.sym} 3200 14400 0 0 {name=Xr72c16}
N 3160 14440 3140 14440 {}
C {lab_pin.sym} 3140 14440 0 0 {name=l11601 lab=BL16}
N 3160 14400 3140 14400 {}
C {lab_pin.sym} 3140 14400 0 0 {name=l11602 lab=BLB16}
N 3160 14360 3140 14360 {}
C {lab_pin.sym} 3140 14360 0 0 {name=l11603 lab=WL72}
N 3240 14440 3260 14440 {}
C {lab_pin.sym} 3260 14440 0 0 {name=l11604 lab=VDD}
N 3240 14360 3260 14360 {}
C {lab_pin.sym} 3260 14360 0 0 {name=l11605 lab=VSS}
C {bitcell_6t.sym} 3400 14400 0 0 {name=Xr72c17}
N 3360 14440 3340 14440 {}
C {lab_pin.sym} 3340 14440 0 0 {name=l11606 lab=BL17}
N 3360 14400 3340 14400 {}
C {lab_pin.sym} 3340 14400 0 0 {name=l11607 lab=BLB17}
N 3360 14360 3340 14360 {}
C {lab_pin.sym} 3340 14360 0 0 {name=l11608 lab=WL72}
N 3440 14440 3460 14440 {}
C {lab_pin.sym} 3460 14440 0 0 {name=l11609 lab=VDD}
N 3440 14360 3460 14360 {}
C {lab_pin.sym} 3460 14360 0 0 {name=l11610 lab=VSS}
C {bitcell_6t.sym} 3600 14400 0 0 {name=Xr72c18}
N 3560 14440 3540 14440 {}
C {lab_pin.sym} 3540 14440 0 0 {name=l11611 lab=BL18}
N 3560 14400 3540 14400 {}
C {lab_pin.sym} 3540 14400 0 0 {name=l11612 lab=BLB18}
N 3560 14360 3540 14360 {}
C {lab_pin.sym} 3540 14360 0 0 {name=l11613 lab=WL72}
N 3640 14440 3660 14440 {}
C {lab_pin.sym} 3660 14440 0 0 {name=l11614 lab=VDD}
N 3640 14360 3660 14360 {}
C {lab_pin.sym} 3660 14360 0 0 {name=l11615 lab=VSS}
C {bitcell_6t.sym} 3800 14400 0 0 {name=Xr72c19}
N 3760 14440 3740 14440 {}
C {lab_pin.sym} 3740 14440 0 0 {name=l11616 lab=BL19}
N 3760 14400 3740 14400 {}
C {lab_pin.sym} 3740 14400 0 0 {name=l11617 lab=BLB19}
N 3760 14360 3740 14360 {}
C {lab_pin.sym} 3740 14360 0 0 {name=l11618 lab=WL72}
N 3840 14440 3860 14440 {}
C {lab_pin.sym} 3860 14440 0 0 {name=l11619 lab=VDD}
N 3840 14360 3860 14360 {}
C {lab_pin.sym} 3860 14360 0 0 {name=l11620 lab=VSS}
C {bitcell_6t.sym} 4000 14400 0 0 {name=Xr72c20}
N 3960 14440 3940 14440 {}
C {lab_pin.sym} 3940 14440 0 0 {name=l11621 lab=BL20}
N 3960 14400 3940 14400 {}
C {lab_pin.sym} 3940 14400 0 0 {name=l11622 lab=BLB20}
N 3960 14360 3940 14360 {}
C {lab_pin.sym} 3940 14360 0 0 {name=l11623 lab=WL72}
N 4040 14440 4060 14440 {}
C {lab_pin.sym} 4060 14440 0 0 {name=l11624 lab=VDD}
N 4040 14360 4060 14360 {}
C {lab_pin.sym} 4060 14360 0 0 {name=l11625 lab=VSS}
C {bitcell_6t.sym} 4200 14400 0 0 {name=Xr72c21}
N 4160 14440 4140 14440 {}
C {lab_pin.sym} 4140 14440 0 0 {name=l11626 lab=BL21}
N 4160 14400 4140 14400 {}
C {lab_pin.sym} 4140 14400 0 0 {name=l11627 lab=BLB21}
N 4160 14360 4140 14360 {}
C {lab_pin.sym} 4140 14360 0 0 {name=l11628 lab=WL72}
N 4240 14440 4260 14440 {}
C {lab_pin.sym} 4260 14440 0 0 {name=l11629 lab=VDD}
N 4240 14360 4260 14360 {}
C {lab_pin.sym} 4260 14360 0 0 {name=l11630 lab=VSS}
C {bitcell_6t.sym} 4400 14400 0 0 {name=Xr72c22}
N 4360 14440 4340 14440 {}
C {lab_pin.sym} 4340 14440 0 0 {name=l11631 lab=BL22}
N 4360 14400 4340 14400 {}
C {lab_pin.sym} 4340 14400 0 0 {name=l11632 lab=BLB22}
N 4360 14360 4340 14360 {}
C {lab_pin.sym} 4340 14360 0 0 {name=l11633 lab=WL72}
N 4440 14440 4460 14440 {}
C {lab_pin.sym} 4460 14440 0 0 {name=l11634 lab=VDD}
N 4440 14360 4460 14360 {}
C {lab_pin.sym} 4460 14360 0 0 {name=l11635 lab=VSS}
C {bitcell_6t.sym} 4600 14400 0 0 {name=Xr72c23}
N 4560 14440 4540 14440 {}
C {lab_pin.sym} 4540 14440 0 0 {name=l11636 lab=BL23}
N 4560 14400 4540 14400 {}
C {lab_pin.sym} 4540 14400 0 0 {name=l11637 lab=BLB23}
N 4560 14360 4540 14360 {}
C {lab_pin.sym} 4540 14360 0 0 {name=l11638 lab=WL72}
N 4640 14440 4660 14440 {}
C {lab_pin.sym} 4660 14440 0 0 {name=l11639 lab=VDD}
N 4640 14360 4660 14360 {}
C {lab_pin.sym} 4660 14360 0 0 {name=l11640 lab=VSS}
C {bitcell_6t.sym} 4800 14400 0 0 {name=Xr72c24}
N 4760 14440 4740 14440 {}
C {lab_pin.sym} 4740 14440 0 0 {name=l11641 lab=BL24}
N 4760 14400 4740 14400 {}
C {lab_pin.sym} 4740 14400 0 0 {name=l11642 lab=BLB24}
N 4760 14360 4740 14360 {}
C {lab_pin.sym} 4740 14360 0 0 {name=l11643 lab=WL72}
N 4840 14440 4860 14440 {}
C {lab_pin.sym} 4860 14440 0 0 {name=l11644 lab=VDD}
N 4840 14360 4860 14360 {}
C {lab_pin.sym} 4860 14360 0 0 {name=l11645 lab=VSS}
C {bitcell_6t.sym} 5000 14400 0 0 {name=Xr72c25}
N 4960 14440 4940 14440 {}
C {lab_pin.sym} 4940 14440 0 0 {name=l11646 lab=BL25}
N 4960 14400 4940 14400 {}
C {lab_pin.sym} 4940 14400 0 0 {name=l11647 lab=BLB25}
N 4960 14360 4940 14360 {}
C {lab_pin.sym} 4940 14360 0 0 {name=l11648 lab=WL72}
N 5040 14440 5060 14440 {}
C {lab_pin.sym} 5060 14440 0 0 {name=l11649 lab=VDD}
N 5040 14360 5060 14360 {}
C {lab_pin.sym} 5060 14360 0 0 {name=l11650 lab=VSS}
C {bitcell_6t.sym} 5200 14400 0 0 {name=Xr72c26}
N 5160 14440 5140 14440 {}
C {lab_pin.sym} 5140 14440 0 0 {name=l11651 lab=BL26}
N 5160 14400 5140 14400 {}
C {lab_pin.sym} 5140 14400 0 0 {name=l11652 lab=BLB26}
N 5160 14360 5140 14360 {}
C {lab_pin.sym} 5140 14360 0 0 {name=l11653 lab=WL72}
N 5240 14440 5260 14440 {}
C {lab_pin.sym} 5260 14440 0 0 {name=l11654 lab=VDD}
N 5240 14360 5260 14360 {}
C {lab_pin.sym} 5260 14360 0 0 {name=l11655 lab=VSS}
C {bitcell_6t.sym} 5400 14400 0 0 {name=Xr72c27}
N 5360 14440 5340 14440 {}
C {lab_pin.sym} 5340 14440 0 0 {name=l11656 lab=BL27}
N 5360 14400 5340 14400 {}
C {lab_pin.sym} 5340 14400 0 0 {name=l11657 lab=BLB27}
N 5360 14360 5340 14360 {}
C {lab_pin.sym} 5340 14360 0 0 {name=l11658 lab=WL72}
N 5440 14440 5460 14440 {}
C {lab_pin.sym} 5460 14440 0 0 {name=l11659 lab=VDD}
N 5440 14360 5460 14360 {}
C {lab_pin.sym} 5460 14360 0 0 {name=l11660 lab=VSS}
C {bitcell_6t.sym} 5600 14400 0 0 {name=Xr72c28}
N 5560 14440 5540 14440 {}
C {lab_pin.sym} 5540 14440 0 0 {name=l11661 lab=BL28}
N 5560 14400 5540 14400 {}
C {lab_pin.sym} 5540 14400 0 0 {name=l11662 lab=BLB28}
N 5560 14360 5540 14360 {}
C {lab_pin.sym} 5540 14360 0 0 {name=l11663 lab=WL72}
N 5640 14440 5660 14440 {}
C {lab_pin.sym} 5660 14440 0 0 {name=l11664 lab=VDD}
N 5640 14360 5660 14360 {}
C {lab_pin.sym} 5660 14360 0 0 {name=l11665 lab=VSS}
C {bitcell_6t.sym} 5800 14400 0 0 {name=Xr72c29}
N 5760 14440 5740 14440 {}
C {lab_pin.sym} 5740 14440 0 0 {name=l11666 lab=BL29}
N 5760 14400 5740 14400 {}
C {lab_pin.sym} 5740 14400 0 0 {name=l11667 lab=BLB29}
N 5760 14360 5740 14360 {}
C {lab_pin.sym} 5740 14360 0 0 {name=l11668 lab=WL72}
N 5840 14440 5860 14440 {}
C {lab_pin.sym} 5860 14440 0 0 {name=l11669 lab=VDD}
N 5840 14360 5860 14360 {}
C {lab_pin.sym} 5860 14360 0 0 {name=l11670 lab=VSS}
C {bitcell_6t.sym} 6000 14400 0 0 {name=Xr72c30}
N 5960 14440 5940 14440 {}
C {lab_pin.sym} 5940 14440 0 0 {name=l11671 lab=BL30}
N 5960 14400 5940 14400 {}
C {lab_pin.sym} 5940 14400 0 0 {name=l11672 lab=BLB30}
N 5960 14360 5940 14360 {}
C {lab_pin.sym} 5940 14360 0 0 {name=l11673 lab=WL72}
N 6040 14440 6060 14440 {}
C {lab_pin.sym} 6060 14440 0 0 {name=l11674 lab=VDD}
N 6040 14360 6060 14360 {}
C {lab_pin.sym} 6060 14360 0 0 {name=l11675 lab=VSS}
C {bitcell_6t.sym} 6200 14400 0 0 {name=Xr72c31}
N 6160 14440 6140 14440 {}
C {lab_pin.sym} 6140 14440 0 0 {name=l11676 lab=BL31}
N 6160 14400 6140 14400 {}
C {lab_pin.sym} 6140 14400 0 0 {name=l11677 lab=BLB31}
N 6160 14360 6140 14360 {}
C {lab_pin.sym} 6140 14360 0 0 {name=l11678 lab=WL72}
N 6240 14440 6260 14440 {}
C {lab_pin.sym} 6260 14440 0 0 {name=l11679 lab=VDD}
N 6240 14360 6260 14360 {}
C {lab_pin.sym} 6260 14360 0 0 {name=l11680 lab=VSS}
C {bitcell_6t.sym} 0 14600 0 0 {name=Xr73c0}
N -40 14640 -60 14640 {}
C {lab_pin.sym} -60 14640 0 0 {name=l11681 lab=BL0}
N -40 14600 -60 14600 {}
C {lab_pin.sym} -60 14600 0 0 {name=l11682 lab=BLB0}
N -40 14560 -60 14560 {}
C {lab_pin.sym} -60 14560 0 0 {name=l11683 lab=WL73}
N 40 14640 60 14640 {}
C {lab_pin.sym} 60 14640 0 0 {name=l11684 lab=VDD}
N 40 14560 60 14560 {}
C {lab_pin.sym} 60 14560 0 0 {name=l11685 lab=VSS}
C {bitcell_6t.sym} 200 14600 0 0 {name=Xr73c1}
N 160 14640 140 14640 {}
C {lab_pin.sym} 140 14640 0 0 {name=l11686 lab=BL1}
N 160 14600 140 14600 {}
C {lab_pin.sym} 140 14600 0 0 {name=l11687 lab=BLB1}
N 160 14560 140 14560 {}
C {lab_pin.sym} 140 14560 0 0 {name=l11688 lab=WL73}
N 240 14640 260 14640 {}
C {lab_pin.sym} 260 14640 0 0 {name=l11689 lab=VDD}
N 240 14560 260 14560 {}
C {lab_pin.sym} 260 14560 0 0 {name=l11690 lab=VSS}
C {bitcell_6t.sym} 400 14600 0 0 {name=Xr73c2}
N 360 14640 340 14640 {}
C {lab_pin.sym} 340 14640 0 0 {name=l11691 lab=BL2}
N 360 14600 340 14600 {}
C {lab_pin.sym} 340 14600 0 0 {name=l11692 lab=BLB2}
N 360 14560 340 14560 {}
C {lab_pin.sym} 340 14560 0 0 {name=l11693 lab=WL73}
N 440 14640 460 14640 {}
C {lab_pin.sym} 460 14640 0 0 {name=l11694 lab=VDD}
N 440 14560 460 14560 {}
C {lab_pin.sym} 460 14560 0 0 {name=l11695 lab=VSS}
C {bitcell_6t.sym} 600 14600 0 0 {name=Xr73c3}
N 560 14640 540 14640 {}
C {lab_pin.sym} 540 14640 0 0 {name=l11696 lab=BL3}
N 560 14600 540 14600 {}
C {lab_pin.sym} 540 14600 0 0 {name=l11697 lab=BLB3}
N 560 14560 540 14560 {}
C {lab_pin.sym} 540 14560 0 0 {name=l11698 lab=WL73}
N 640 14640 660 14640 {}
C {lab_pin.sym} 660 14640 0 0 {name=l11699 lab=VDD}
N 640 14560 660 14560 {}
C {lab_pin.sym} 660 14560 0 0 {name=l11700 lab=VSS}
C {bitcell_6t.sym} 800 14600 0 0 {name=Xr73c4}
N 760 14640 740 14640 {}
C {lab_pin.sym} 740 14640 0 0 {name=l11701 lab=BL4}
N 760 14600 740 14600 {}
C {lab_pin.sym} 740 14600 0 0 {name=l11702 lab=BLB4}
N 760 14560 740 14560 {}
C {lab_pin.sym} 740 14560 0 0 {name=l11703 lab=WL73}
N 840 14640 860 14640 {}
C {lab_pin.sym} 860 14640 0 0 {name=l11704 lab=VDD}
N 840 14560 860 14560 {}
C {lab_pin.sym} 860 14560 0 0 {name=l11705 lab=VSS}
C {bitcell_6t.sym} 1000 14600 0 0 {name=Xr73c5}
N 960 14640 940 14640 {}
C {lab_pin.sym} 940 14640 0 0 {name=l11706 lab=BL5}
N 960 14600 940 14600 {}
C {lab_pin.sym} 940 14600 0 0 {name=l11707 lab=BLB5}
N 960 14560 940 14560 {}
C {lab_pin.sym} 940 14560 0 0 {name=l11708 lab=WL73}
N 1040 14640 1060 14640 {}
C {lab_pin.sym} 1060 14640 0 0 {name=l11709 lab=VDD}
N 1040 14560 1060 14560 {}
C {lab_pin.sym} 1060 14560 0 0 {name=l11710 lab=VSS}
C {bitcell_6t.sym} 1200 14600 0 0 {name=Xr73c6}
N 1160 14640 1140 14640 {}
C {lab_pin.sym} 1140 14640 0 0 {name=l11711 lab=BL6}
N 1160 14600 1140 14600 {}
C {lab_pin.sym} 1140 14600 0 0 {name=l11712 lab=BLB6}
N 1160 14560 1140 14560 {}
C {lab_pin.sym} 1140 14560 0 0 {name=l11713 lab=WL73}
N 1240 14640 1260 14640 {}
C {lab_pin.sym} 1260 14640 0 0 {name=l11714 lab=VDD}
N 1240 14560 1260 14560 {}
C {lab_pin.sym} 1260 14560 0 0 {name=l11715 lab=VSS}
C {bitcell_6t.sym} 1400 14600 0 0 {name=Xr73c7}
N 1360 14640 1340 14640 {}
C {lab_pin.sym} 1340 14640 0 0 {name=l11716 lab=BL7}
N 1360 14600 1340 14600 {}
C {lab_pin.sym} 1340 14600 0 0 {name=l11717 lab=BLB7}
N 1360 14560 1340 14560 {}
C {lab_pin.sym} 1340 14560 0 0 {name=l11718 lab=WL73}
N 1440 14640 1460 14640 {}
C {lab_pin.sym} 1460 14640 0 0 {name=l11719 lab=VDD}
N 1440 14560 1460 14560 {}
C {lab_pin.sym} 1460 14560 0 0 {name=l11720 lab=VSS}
C {bitcell_6t.sym} 1600 14600 0 0 {name=Xr73c8}
N 1560 14640 1540 14640 {}
C {lab_pin.sym} 1540 14640 0 0 {name=l11721 lab=BL8}
N 1560 14600 1540 14600 {}
C {lab_pin.sym} 1540 14600 0 0 {name=l11722 lab=BLB8}
N 1560 14560 1540 14560 {}
C {lab_pin.sym} 1540 14560 0 0 {name=l11723 lab=WL73}
N 1640 14640 1660 14640 {}
C {lab_pin.sym} 1660 14640 0 0 {name=l11724 lab=VDD}
N 1640 14560 1660 14560 {}
C {lab_pin.sym} 1660 14560 0 0 {name=l11725 lab=VSS}
C {bitcell_6t.sym} 1800 14600 0 0 {name=Xr73c9}
N 1760 14640 1740 14640 {}
C {lab_pin.sym} 1740 14640 0 0 {name=l11726 lab=BL9}
N 1760 14600 1740 14600 {}
C {lab_pin.sym} 1740 14600 0 0 {name=l11727 lab=BLB9}
N 1760 14560 1740 14560 {}
C {lab_pin.sym} 1740 14560 0 0 {name=l11728 lab=WL73}
N 1840 14640 1860 14640 {}
C {lab_pin.sym} 1860 14640 0 0 {name=l11729 lab=VDD}
N 1840 14560 1860 14560 {}
C {lab_pin.sym} 1860 14560 0 0 {name=l11730 lab=VSS}
C {bitcell_6t.sym} 2000 14600 0 0 {name=Xr73c10}
N 1960 14640 1940 14640 {}
C {lab_pin.sym} 1940 14640 0 0 {name=l11731 lab=BL10}
N 1960 14600 1940 14600 {}
C {lab_pin.sym} 1940 14600 0 0 {name=l11732 lab=BLB10}
N 1960 14560 1940 14560 {}
C {lab_pin.sym} 1940 14560 0 0 {name=l11733 lab=WL73}
N 2040 14640 2060 14640 {}
C {lab_pin.sym} 2060 14640 0 0 {name=l11734 lab=VDD}
N 2040 14560 2060 14560 {}
C {lab_pin.sym} 2060 14560 0 0 {name=l11735 lab=VSS}
C {bitcell_6t.sym} 2200 14600 0 0 {name=Xr73c11}
N 2160 14640 2140 14640 {}
C {lab_pin.sym} 2140 14640 0 0 {name=l11736 lab=BL11}
N 2160 14600 2140 14600 {}
C {lab_pin.sym} 2140 14600 0 0 {name=l11737 lab=BLB11}
N 2160 14560 2140 14560 {}
C {lab_pin.sym} 2140 14560 0 0 {name=l11738 lab=WL73}
N 2240 14640 2260 14640 {}
C {lab_pin.sym} 2260 14640 0 0 {name=l11739 lab=VDD}
N 2240 14560 2260 14560 {}
C {lab_pin.sym} 2260 14560 0 0 {name=l11740 lab=VSS}
C {bitcell_6t.sym} 2400 14600 0 0 {name=Xr73c12}
N 2360 14640 2340 14640 {}
C {lab_pin.sym} 2340 14640 0 0 {name=l11741 lab=BL12}
N 2360 14600 2340 14600 {}
C {lab_pin.sym} 2340 14600 0 0 {name=l11742 lab=BLB12}
N 2360 14560 2340 14560 {}
C {lab_pin.sym} 2340 14560 0 0 {name=l11743 lab=WL73}
N 2440 14640 2460 14640 {}
C {lab_pin.sym} 2460 14640 0 0 {name=l11744 lab=VDD}
N 2440 14560 2460 14560 {}
C {lab_pin.sym} 2460 14560 0 0 {name=l11745 lab=VSS}
C {bitcell_6t.sym} 2600 14600 0 0 {name=Xr73c13}
N 2560 14640 2540 14640 {}
C {lab_pin.sym} 2540 14640 0 0 {name=l11746 lab=BL13}
N 2560 14600 2540 14600 {}
C {lab_pin.sym} 2540 14600 0 0 {name=l11747 lab=BLB13}
N 2560 14560 2540 14560 {}
C {lab_pin.sym} 2540 14560 0 0 {name=l11748 lab=WL73}
N 2640 14640 2660 14640 {}
C {lab_pin.sym} 2660 14640 0 0 {name=l11749 lab=VDD}
N 2640 14560 2660 14560 {}
C {lab_pin.sym} 2660 14560 0 0 {name=l11750 lab=VSS}
C {bitcell_6t.sym} 2800 14600 0 0 {name=Xr73c14}
N 2760 14640 2740 14640 {}
C {lab_pin.sym} 2740 14640 0 0 {name=l11751 lab=BL14}
N 2760 14600 2740 14600 {}
C {lab_pin.sym} 2740 14600 0 0 {name=l11752 lab=BLB14}
N 2760 14560 2740 14560 {}
C {lab_pin.sym} 2740 14560 0 0 {name=l11753 lab=WL73}
N 2840 14640 2860 14640 {}
C {lab_pin.sym} 2860 14640 0 0 {name=l11754 lab=VDD}
N 2840 14560 2860 14560 {}
C {lab_pin.sym} 2860 14560 0 0 {name=l11755 lab=VSS}
C {bitcell_6t.sym} 3000 14600 0 0 {name=Xr73c15}
N 2960 14640 2940 14640 {}
C {lab_pin.sym} 2940 14640 0 0 {name=l11756 lab=BL15}
N 2960 14600 2940 14600 {}
C {lab_pin.sym} 2940 14600 0 0 {name=l11757 lab=BLB15}
N 2960 14560 2940 14560 {}
C {lab_pin.sym} 2940 14560 0 0 {name=l11758 lab=WL73}
N 3040 14640 3060 14640 {}
C {lab_pin.sym} 3060 14640 0 0 {name=l11759 lab=VDD}
N 3040 14560 3060 14560 {}
C {lab_pin.sym} 3060 14560 0 0 {name=l11760 lab=VSS}
C {bitcell_6t.sym} 3200 14600 0 0 {name=Xr73c16}
N 3160 14640 3140 14640 {}
C {lab_pin.sym} 3140 14640 0 0 {name=l11761 lab=BL16}
N 3160 14600 3140 14600 {}
C {lab_pin.sym} 3140 14600 0 0 {name=l11762 lab=BLB16}
N 3160 14560 3140 14560 {}
C {lab_pin.sym} 3140 14560 0 0 {name=l11763 lab=WL73}
N 3240 14640 3260 14640 {}
C {lab_pin.sym} 3260 14640 0 0 {name=l11764 lab=VDD}
N 3240 14560 3260 14560 {}
C {lab_pin.sym} 3260 14560 0 0 {name=l11765 lab=VSS}
C {bitcell_6t.sym} 3400 14600 0 0 {name=Xr73c17}
N 3360 14640 3340 14640 {}
C {lab_pin.sym} 3340 14640 0 0 {name=l11766 lab=BL17}
N 3360 14600 3340 14600 {}
C {lab_pin.sym} 3340 14600 0 0 {name=l11767 lab=BLB17}
N 3360 14560 3340 14560 {}
C {lab_pin.sym} 3340 14560 0 0 {name=l11768 lab=WL73}
N 3440 14640 3460 14640 {}
C {lab_pin.sym} 3460 14640 0 0 {name=l11769 lab=VDD}
N 3440 14560 3460 14560 {}
C {lab_pin.sym} 3460 14560 0 0 {name=l11770 lab=VSS}
C {bitcell_6t.sym} 3600 14600 0 0 {name=Xr73c18}
N 3560 14640 3540 14640 {}
C {lab_pin.sym} 3540 14640 0 0 {name=l11771 lab=BL18}
N 3560 14600 3540 14600 {}
C {lab_pin.sym} 3540 14600 0 0 {name=l11772 lab=BLB18}
N 3560 14560 3540 14560 {}
C {lab_pin.sym} 3540 14560 0 0 {name=l11773 lab=WL73}
N 3640 14640 3660 14640 {}
C {lab_pin.sym} 3660 14640 0 0 {name=l11774 lab=VDD}
N 3640 14560 3660 14560 {}
C {lab_pin.sym} 3660 14560 0 0 {name=l11775 lab=VSS}
C {bitcell_6t.sym} 3800 14600 0 0 {name=Xr73c19}
N 3760 14640 3740 14640 {}
C {lab_pin.sym} 3740 14640 0 0 {name=l11776 lab=BL19}
N 3760 14600 3740 14600 {}
C {lab_pin.sym} 3740 14600 0 0 {name=l11777 lab=BLB19}
N 3760 14560 3740 14560 {}
C {lab_pin.sym} 3740 14560 0 0 {name=l11778 lab=WL73}
N 3840 14640 3860 14640 {}
C {lab_pin.sym} 3860 14640 0 0 {name=l11779 lab=VDD}
N 3840 14560 3860 14560 {}
C {lab_pin.sym} 3860 14560 0 0 {name=l11780 lab=VSS}
C {bitcell_6t.sym} 4000 14600 0 0 {name=Xr73c20}
N 3960 14640 3940 14640 {}
C {lab_pin.sym} 3940 14640 0 0 {name=l11781 lab=BL20}
N 3960 14600 3940 14600 {}
C {lab_pin.sym} 3940 14600 0 0 {name=l11782 lab=BLB20}
N 3960 14560 3940 14560 {}
C {lab_pin.sym} 3940 14560 0 0 {name=l11783 lab=WL73}
N 4040 14640 4060 14640 {}
C {lab_pin.sym} 4060 14640 0 0 {name=l11784 lab=VDD}
N 4040 14560 4060 14560 {}
C {lab_pin.sym} 4060 14560 0 0 {name=l11785 lab=VSS}
C {bitcell_6t.sym} 4200 14600 0 0 {name=Xr73c21}
N 4160 14640 4140 14640 {}
C {lab_pin.sym} 4140 14640 0 0 {name=l11786 lab=BL21}
N 4160 14600 4140 14600 {}
C {lab_pin.sym} 4140 14600 0 0 {name=l11787 lab=BLB21}
N 4160 14560 4140 14560 {}
C {lab_pin.sym} 4140 14560 0 0 {name=l11788 lab=WL73}
N 4240 14640 4260 14640 {}
C {lab_pin.sym} 4260 14640 0 0 {name=l11789 lab=VDD}
N 4240 14560 4260 14560 {}
C {lab_pin.sym} 4260 14560 0 0 {name=l11790 lab=VSS}
C {bitcell_6t.sym} 4400 14600 0 0 {name=Xr73c22}
N 4360 14640 4340 14640 {}
C {lab_pin.sym} 4340 14640 0 0 {name=l11791 lab=BL22}
N 4360 14600 4340 14600 {}
C {lab_pin.sym} 4340 14600 0 0 {name=l11792 lab=BLB22}
N 4360 14560 4340 14560 {}
C {lab_pin.sym} 4340 14560 0 0 {name=l11793 lab=WL73}
N 4440 14640 4460 14640 {}
C {lab_pin.sym} 4460 14640 0 0 {name=l11794 lab=VDD}
N 4440 14560 4460 14560 {}
C {lab_pin.sym} 4460 14560 0 0 {name=l11795 lab=VSS}
C {bitcell_6t.sym} 4600 14600 0 0 {name=Xr73c23}
N 4560 14640 4540 14640 {}
C {lab_pin.sym} 4540 14640 0 0 {name=l11796 lab=BL23}
N 4560 14600 4540 14600 {}
C {lab_pin.sym} 4540 14600 0 0 {name=l11797 lab=BLB23}
N 4560 14560 4540 14560 {}
C {lab_pin.sym} 4540 14560 0 0 {name=l11798 lab=WL73}
N 4640 14640 4660 14640 {}
C {lab_pin.sym} 4660 14640 0 0 {name=l11799 lab=VDD}
N 4640 14560 4660 14560 {}
C {lab_pin.sym} 4660 14560 0 0 {name=l11800 lab=VSS}
C {bitcell_6t.sym} 4800 14600 0 0 {name=Xr73c24}
N 4760 14640 4740 14640 {}
C {lab_pin.sym} 4740 14640 0 0 {name=l11801 lab=BL24}
N 4760 14600 4740 14600 {}
C {lab_pin.sym} 4740 14600 0 0 {name=l11802 lab=BLB24}
N 4760 14560 4740 14560 {}
C {lab_pin.sym} 4740 14560 0 0 {name=l11803 lab=WL73}
N 4840 14640 4860 14640 {}
C {lab_pin.sym} 4860 14640 0 0 {name=l11804 lab=VDD}
N 4840 14560 4860 14560 {}
C {lab_pin.sym} 4860 14560 0 0 {name=l11805 lab=VSS}
C {bitcell_6t.sym} 5000 14600 0 0 {name=Xr73c25}
N 4960 14640 4940 14640 {}
C {lab_pin.sym} 4940 14640 0 0 {name=l11806 lab=BL25}
N 4960 14600 4940 14600 {}
C {lab_pin.sym} 4940 14600 0 0 {name=l11807 lab=BLB25}
N 4960 14560 4940 14560 {}
C {lab_pin.sym} 4940 14560 0 0 {name=l11808 lab=WL73}
N 5040 14640 5060 14640 {}
C {lab_pin.sym} 5060 14640 0 0 {name=l11809 lab=VDD}
N 5040 14560 5060 14560 {}
C {lab_pin.sym} 5060 14560 0 0 {name=l11810 lab=VSS}
C {bitcell_6t.sym} 5200 14600 0 0 {name=Xr73c26}
N 5160 14640 5140 14640 {}
C {lab_pin.sym} 5140 14640 0 0 {name=l11811 lab=BL26}
N 5160 14600 5140 14600 {}
C {lab_pin.sym} 5140 14600 0 0 {name=l11812 lab=BLB26}
N 5160 14560 5140 14560 {}
C {lab_pin.sym} 5140 14560 0 0 {name=l11813 lab=WL73}
N 5240 14640 5260 14640 {}
C {lab_pin.sym} 5260 14640 0 0 {name=l11814 lab=VDD}
N 5240 14560 5260 14560 {}
C {lab_pin.sym} 5260 14560 0 0 {name=l11815 lab=VSS}
C {bitcell_6t.sym} 5400 14600 0 0 {name=Xr73c27}
N 5360 14640 5340 14640 {}
C {lab_pin.sym} 5340 14640 0 0 {name=l11816 lab=BL27}
N 5360 14600 5340 14600 {}
C {lab_pin.sym} 5340 14600 0 0 {name=l11817 lab=BLB27}
N 5360 14560 5340 14560 {}
C {lab_pin.sym} 5340 14560 0 0 {name=l11818 lab=WL73}
N 5440 14640 5460 14640 {}
C {lab_pin.sym} 5460 14640 0 0 {name=l11819 lab=VDD}
N 5440 14560 5460 14560 {}
C {lab_pin.sym} 5460 14560 0 0 {name=l11820 lab=VSS}
C {bitcell_6t.sym} 5600 14600 0 0 {name=Xr73c28}
N 5560 14640 5540 14640 {}
C {lab_pin.sym} 5540 14640 0 0 {name=l11821 lab=BL28}
N 5560 14600 5540 14600 {}
C {lab_pin.sym} 5540 14600 0 0 {name=l11822 lab=BLB28}
N 5560 14560 5540 14560 {}
C {lab_pin.sym} 5540 14560 0 0 {name=l11823 lab=WL73}
N 5640 14640 5660 14640 {}
C {lab_pin.sym} 5660 14640 0 0 {name=l11824 lab=VDD}
N 5640 14560 5660 14560 {}
C {lab_pin.sym} 5660 14560 0 0 {name=l11825 lab=VSS}
C {bitcell_6t.sym} 5800 14600 0 0 {name=Xr73c29}
N 5760 14640 5740 14640 {}
C {lab_pin.sym} 5740 14640 0 0 {name=l11826 lab=BL29}
N 5760 14600 5740 14600 {}
C {lab_pin.sym} 5740 14600 0 0 {name=l11827 lab=BLB29}
N 5760 14560 5740 14560 {}
C {lab_pin.sym} 5740 14560 0 0 {name=l11828 lab=WL73}
N 5840 14640 5860 14640 {}
C {lab_pin.sym} 5860 14640 0 0 {name=l11829 lab=VDD}
N 5840 14560 5860 14560 {}
C {lab_pin.sym} 5860 14560 0 0 {name=l11830 lab=VSS}
C {bitcell_6t.sym} 6000 14600 0 0 {name=Xr73c30}
N 5960 14640 5940 14640 {}
C {lab_pin.sym} 5940 14640 0 0 {name=l11831 lab=BL30}
N 5960 14600 5940 14600 {}
C {lab_pin.sym} 5940 14600 0 0 {name=l11832 lab=BLB30}
N 5960 14560 5940 14560 {}
C {lab_pin.sym} 5940 14560 0 0 {name=l11833 lab=WL73}
N 6040 14640 6060 14640 {}
C {lab_pin.sym} 6060 14640 0 0 {name=l11834 lab=VDD}
N 6040 14560 6060 14560 {}
C {lab_pin.sym} 6060 14560 0 0 {name=l11835 lab=VSS}
C {bitcell_6t.sym} 6200 14600 0 0 {name=Xr73c31}
N 6160 14640 6140 14640 {}
C {lab_pin.sym} 6140 14640 0 0 {name=l11836 lab=BL31}
N 6160 14600 6140 14600 {}
C {lab_pin.sym} 6140 14600 0 0 {name=l11837 lab=BLB31}
N 6160 14560 6140 14560 {}
C {lab_pin.sym} 6140 14560 0 0 {name=l11838 lab=WL73}
N 6240 14640 6260 14640 {}
C {lab_pin.sym} 6260 14640 0 0 {name=l11839 lab=VDD}
N 6240 14560 6260 14560 {}
C {lab_pin.sym} 6260 14560 0 0 {name=l11840 lab=VSS}
C {bitcell_6t.sym} 0 14800 0 0 {name=Xr74c0}
N -40 14840 -60 14840 {}
C {lab_pin.sym} -60 14840 0 0 {name=l11841 lab=BL0}
N -40 14800 -60 14800 {}
C {lab_pin.sym} -60 14800 0 0 {name=l11842 lab=BLB0}
N -40 14760 -60 14760 {}
C {lab_pin.sym} -60 14760 0 0 {name=l11843 lab=WL74}
N 40 14840 60 14840 {}
C {lab_pin.sym} 60 14840 0 0 {name=l11844 lab=VDD}
N 40 14760 60 14760 {}
C {lab_pin.sym} 60 14760 0 0 {name=l11845 lab=VSS}
C {bitcell_6t.sym} 200 14800 0 0 {name=Xr74c1}
N 160 14840 140 14840 {}
C {lab_pin.sym} 140 14840 0 0 {name=l11846 lab=BL1}
N 160 14800 140 14800 {}
C {lab_pin.sym} 140 14800 0 0 {name=l11847 lab=BLB1}
N 160 14760 140 14760 {}
C {lab_pin.sym} 140 14760 0 0 {name=l11848 lab=WL74}
N 240 14840 260 14840 {}
C {lab_pin.sym} 260 14840 0 0 {name=l11849 lab=VDD}
N 240 14760 260 14760 {}
C {lab_pin.sym} 260 14760 0 0 {name=l11850 lab=VSS}
C {bitcell_6t.sym} 400 14800 0 0 {name=Xr74c2}
N 360 14840 340 14840 {}
C {lab_pin.sym} 340 14840 0 0 {name=l11851 lab=BL2}
N 360 14800 340 14800 {}
C {lab_pin.sym} 340 14800 0 0 {name=l11852 lab=BLB2}
N 360 14760 340 14760 {}
C {lab_pin.sym} 340 14760 0 0 {name=l11853 lab=WL74}
N 440 14840 460 14840 {}
C {lab_pin.sym} 460 14840 0 0 {name=l11854 lab=VDD}
N 440 14760 460 14760 {}
C {lab_pin.sym} 460 14760 0 0 {name=l11855 lab=VSS}
C {bitcell_6t.sym} 600 14800 0 0 {name=Xr74c3}
N 560 14840 540 14840 {}
C {lab_pin.sym} 540 14840 0 0 {name=l11856 lab=BL3}
N 560 14800 540 14800 {}
C {lab_pin.sym} 540 14800 0 0 {name=l11857 lab=BLB3}
N 560 14760 540 14760 {}
C {lab_pin.sym} 540 14760 0 0 {name=l11858 lab=WL74}
N 640 14840 660 14840 {}
C {lab_pin.sym} 660 14840 0 0 {name=l11859 lab=VDD}
N 640 14760 660 14760 {}
C {lab_pin.sym} 660 14760 0 0 {name=l11860 lab=VSS}
C {bitcell_6t.sym} 800 14800 0 0 {name=Xr74c4}
N 760 14840 740 14840 {}
C {lab_pin.sym} 740 14840 0 0 {name=l11861 lab=BL4}
N 760 14800 740 14800 {}
C {lab_pin.sym} 740 14800 0 0 {name=l11862 lab=BLB4}
N 760 14760 740 14760 {}
C {lab_pin.sym} 740 14760 0 0 {name=l11863 lab=WL74}
N 840 14840 860 14840 {}
C {lab_pin.sym} 860 14840 0 0 {name=l11864 lab=VDD}
N 840 14760 860 14760 {}
C {lab_pin.sym} 860 14760 0 0 {name=l11865 lab=VSS}
C {bitcell_6t.sym} 1000 14800 0 0 {name=Xr74c5}
N 960 14840 940 14840 {}
C {lab_pin.sym} 940 14840 0 0 {name=l11866 lab=BL5}
N 960 14800 940 14800 {}
C {lab_pin.sym} 940 14800 0 0 {name=l11867 lab=BLB5}
N 960 14760 940 14760 {}
C {lab_pin.sym} 940 14760 0 0 {name=l11868 lab=WL74}
N 1040 14840 1060 14840 {}
C {lab_pin.sym} 1060 14840 0 0 {name=l11869 lab=VDD}
N 1040 14760 1060 14760 {}
C {lab_pin.sym} 1060 14760 0 0 {name=l11870 lab=VSS}
C {bitcell_6t.sym} 1200 14800 0 0 {name=Xr74c6}
N 1160 14840 1140 14840 {}
C {lab_pin.sym} 1140 14840 0 0 {name=l11871 lab=BL6}
N 1160 14800 1140 14800 {}
C {lab_pin.sym} 1140 14800 0 0 {name=l11872 lab=BLB6}
N 1160 14760 1140 14760 {}
C {lab_pin.sym} 1140 14760 0 0 {name=l11873 lab=WL74}
N 1240 14840 1260 14840 {}
C {lab_pin.sym} 1260 14840 0 0 {name=l11874 lab=VDD}
N 1240 14760 1260 14760 {}
C {lab_pin.sym} 1260 14760 0 0 {name=l11875 lab=VSS}
C {bitcell_6t.sym} 1400 14800 0 0 {name=Xr74c7}
N 1360 14840 1340 14840 {}
C {lab_pin.sym} 1340 14840 0 0 {name=l11876 lab=BL7}
N 1360 14800 1340 14800 {}
C {lab_pin.sym} 1340 14800 0 0 {name=l11877 lab=BLB7}
N 1360 14760 1340 14760 {}
C {lab_pin.sym} 1340 14760 0 0 {name=l11878 lab=WL74}
N 1440 14840 1460 14840 {}
C {lab_pin.sym} 1460 14840 0 0 {name=l11879 lab=VDD}
N 1440 14760 1460 14760 {}
C {lab_pin.sym} 1460 14760 0 0 {name=l11880 lab=VSS}
C {bitcell_6t.sym} 1600 14800 0 0 {name=Xr74c8}
N 1560 14840 1540 14840 {}
C {lab_pin.sym} 1540 14840 0 0 {name=l11881 lab=BL8}
N 1560 14800 1540 14800 {}
C {lab_pin.sym} 1540 14800 0 0 {name=l11882 lab=BLB8}
N 1560 14760 1540 14760 {}
C {lab_pin.sym} 1540 14760 0 0 {name=l11883 lab=WL74}
N 1640 14840 1660 14840 {}
C {lab_pin.sym} 1660 14840 0 0 {name=l11884 lab=VDD}
N 1640 14760 1660 14760 {}
C {lab_pin.sym} 1660 14760 0 0 {name=l11885 lab=VSS}
C {bitcell_6t.sym} 1800 14800 0 0 {name=Xr74c9}
N 1760 14840 1740 14840 {}
C {lab_pin.sym} 1740 14840 0 0 {name=l11886 lab=BL9}
N 1760 14800 1740 14800 {}
C {lab_pin.sym} 1740 14800 0 0 {name=l11887 lab=BLB9}
N 1760 14760 1740 14760 {}
C {lab_pin.sym} 1740 14760 0 0 {name=l11888 lab=WL74}
N 1840 14840 1860 14840 {}
C {lab_pin.sym} 1860 14840 0 0 {name=l11889 lab=VDD}
N 1840 14760 1860 14760 {}
C {lab_pin.sym} 1860 14760 0 0 {name=l11890 lab=VSS}
C {bitcell_6t.sym} 2000 14800 0 0 {name=Xr74c10}
N 1960 14840 1940 14840 {}
C {lab_pin.sym} 1940 14840 0 0 {name=l11891 lab=BL10}
N 1960 14800 1940 14800 {}
C {lab_pin.sym} 1940 14800 0 0 {name=l11892 lab=BLB10}
N 1960 14760 1940 14760 {}
C {lab_pin.sym} 1940 14760 0 0 {name=l11893 lab=WL74}
N 2040 14840 2060 14840 {}
C {lab_pin.sym} 2060 14840 0 0 {name=l11894 lab=VDD}
N 2040 14760 2060 14760 {}
C {lab_pin.sym} 2060 14760 0 0 {name=l11895 lab=VSS}
C {bitcell_6t.sym} 2200 14800 0 0 {name=Xr74c11}
N 2160 14840 2140 14840 {}
C {lab_pin.sym} 2140 14840 0 0 {name=l11896 lab=BL11}
N 2160 14800 2140 14800 {}
C {lab_pin.sym} 2140 14800 0 0 {name=l11897 lab=BLB11}
N 2160 14760 2140 14760 {}
C {lab_pin.sym} 2140 14760 0 0 {name=l11898 lab=WL74}
N 2240 14840 2260 14840 {}
C {lab_pin.sym} 2260 14840 0 0 {name=l11899 lab=VDD}
N 2240 14760 2260 14760 {}
C {lab_pin.sym} 2260 14760 0 0 {name=l11900 lab=VSS}
C {bitcell_6t.sym} 2400 14800 0 0 {name=Xr74c12}
N 2360 14840 2340 14840 {}
C {lab_pin.sym} 2340 14840 0 0 {name=l11901 lab=BL12}
N 2360 14800 2340 14800 {}
C {lab_pin.sym} 2340 14800 0 0 {name=l11902 lab=BLB12}
N 2360 14760 2340 14760 {}
C {lab_pin.sym} 2340 14760 0 0 {name=l11903 lab=WL74}
N 2440 14840 2460 14840 {}
C {lab_pin.sym} 2460 14840 0 0 {name=l11904 lab=VDD}
N 2440 14760 2460 14760 {}
C {lab_pin.sym} 2460 14760 0 0 {name=l11905 lab=VSS}
C {bitcell_6t.sym} 2600 14800 0 0 {name=Xr74c13}
N 2560 14840 2540 14840 {}
C {lab_pin.sym} 2540 14840 0 0 {name=l11906 lab=BL13}
N 2560 14800 2540 14800 {}
C {lab_pin.sym} 2540 14800 0 0 {name=l11907 lab=BLB13}
N 2560 14760 2540 14760 {}
C {lab_pin.sym} 2540 14760 0 0 {name=l11908 lab=WL74}
N 2640 14840 2660 14840 {}
C {lab_pin.sym} 2660 14840 0 0 {name=l11909 lab=VDD}
N 2640 14760 2660 14760 {}
C {lab_pin.sym} 2660 14760 0 0 {name=l11910 lab=VSS}
C {bitcell_6t.sym} 2800 14800 0 0 {name=Xr74c14}
N 2760 14840 2740 14840 {}
C {lab_pin.sym} 2740 14840 0 0 {name=l11911 lab=BL14}
N 2760 14800 2740 14800 {}
C {lab_pin.sym} 2740 14800 0 0 {name=l11912 lab=BLB14}
N 2760 14760 2740 14760 {}
C {lab_pin.sym} 2740 14760 0 0 {name=l11913 lab=WL74}
N 2840 14840 2860 14840 {}
C {lab_pin.sym} 2860 14840 0 0 {name=l11914 lab=VDD}
N 2840 14760 2860 14760 {}
C {lab_pin.sym} 2860 14760 0 0 {name=l11915 lab=VSS}
C {bitcell_6t.sym} 3000 14800 0 0 {name=Xr74c15}
N 2960 14840 2940 14840 {}
C {lab_pin.sym} 2940 14840 0 0 {name=l11916 lab=BL15}
N 2960 14800 2940 14800 {}
C {lab_pin.sym} 2940 14800 0 0 {name=l11917 lab=BLB15}
N 2960 14760 2940 14760 {}
C {lab_pin.sym} 2940 14760 0 0 {name=l11918 lab=WL74}
N 3040 14840 3060 14840 {}
C {lab_pin.sym} 3060 14840 0 0 {name=l11919 lab=VDD}
N 3040 14760 3060 14760 {}
C {lab_pin.sym} 3060 14760 0 0 {name=l11920 lab=VSS}
C {bitcell_6t.sym} 3200 14800 0 0 {name=Xr74c16}
N 3160 14840 3140 14840 {}
C {lab_pin.sym} 3140 14840 0 0 {name=l11921 lab=BL16}
N 3160 14800 3140 14800 {}
C {lab_pin.sym} 3140 14800 0 0 {name=l11922 lab=BLB16}
N 3160 14760 3140 14760 {}
C {lab_pin.sym} 3140 14760 0 0 {name=l11923 lab=WL74}
N 3240 14840 3260 14840 {}
C {lab_pin.sym} 3260 14840 0 0 {name=l11924 lab=VDD}
N 3240 14760 3260 14760 {}
C {lab_pin.sym} 3260 14760 0 0 {name=l11925 lab=VSS}
C {bitcell_6t.sym} 3400 14800 0 0 {name=Xr74c17}
N 3360 14840 3340 14840 {}
C {lab_pin.sym} 3340 14840 0 0 {name=l11926 lab=BL17}
N 3360 14800 3340 14800 {}
C {lab_pin.sym} 3340 14800 0 0 {name=l11927 lab=BLB17}
N 3360 14760 3340 14760 {}
C {lab_pin.sym} 3340 14760 0 0 {name=l11928 lab=WL74}
N 3440 14840 3460 14840 {}
C {lab_pin.sym} 3460 14840 0 0 {name=l11929 lab=VDD}
N 3440 14760 3460 14760 {}
C {lab_pin.sym} 3460 14760 0 0 {name=l11930 lab=VSS}
C {bitcell_6t.sym} 3600 14800 0 0 {name=Xr74c18}
N 3560 14840 3540 14840 {}
C {lab_pin.sym} 3540 14840 0 0 {name=l11931 lab=BL18}
N 3560 14800 3540 14800 {}
C {lab_pin.sym} 3540 14800 0 0 {name=l11932 lab=BLB18}
N 3560 14760 3540 14760 {}
C {lab_pin.sym} 3540 14760 0 0 {name=l11933 lab=WL74}
N 3640 14840 3660 14840 {}
C {lab_pin.sym} 3660 14840 0 0 {name=l11934 lab=VDD}
N 3640 14760 3660 14760 {}
C {lab_pin.sym} 3660 14760 0 0 {name=l11935 lab=VSS}
C {bitcell_6t.sym} 3800 14800 0 0 {name=Xr74c19}
N 3760 14840 3740 14840 {}
C {lab_pin.sym} 3740 14840 0 0 {name=l11936 lab=BL19}
N 3760 14800 3740 14800 {}
C {lab_pin.sym} 3740 14800 0 0 {name=l11937 lab=BLB19}
N 3760 14760 3740 14760 {}
C {lab_pin.sym} 3740 14760 0 0 {name=l11938 lab=WL74}
N 3840 14840 3860 14840 {}
C {lab_pin.sym} 3860 14840 0 0 {name=l11939 lab=VDD}
N 3840 14760 3860 14760 {}
C {lab_pin.sym} 3860 14760 0 0 {name=l11940 lab=VSS}
C {bitcell_6t.sym} 4000 14800 0 0 {name=Xr74c20}
N 3960 14840 3940 14840 {}
C {lab_pin.sym} 3940 14840 0 0 {name=l11941 lab=BL20}
N 3960 14800 3940 14800 {}
C {lab_pin.sym} 3940 14800 0 0 {name=l11942 lab=BLB20}
N 3960 14760 3940 14760 {}
C {lab_pin.sym} 3940 14760 0 0 {name=l11943 lab=WL74}
N 4040 14840 4060 14840 {}
C {lab_pin.sym} 4060 14840 0 0 {name=l11944 lab=VDD}
N 4040 14760 4060 14760 {}
C {lab_pin.sym} 4060 14760 0 0 {name=l11945 lab=VSS}
C {bitcell_6t.sym} 4200 14800 0 0 {name=Xr74c21}
N 4160 14840 4140 14840 {}
C {lab_pin.sym} 4140 14840 0 0 {name=l11946 lab=BL21}
N 4160 14800 4140 14800 {}
C {lab_pin.sym} 4140 14800 0 0 {name=l11947 lab=BLB21}
N 4160 14760 4140 14760 {}
C {lab_pin.sym} 4140 14760 0 0 {name=l11948 lab=WL74}
N 4240 14840 4260 14840 {}
C {lab_pin.sym} 4260 14840 0 0 {name=l11949 lab=VDD}
N 4240 14760 4260 14760 {}
C {lab_pin.sym} 4260 14760 0 0 {name=l11950 lab=VSS}
C {bitcell_6t.sym} 4400 14800 0 0 {name=Xr74c22}
N 4360 14840 4340 14840 {}
C {lab_pin.sym} 4340 14840 0 0 {name=l11951 lab=BL22}
N 4360 14800 4340 14800 {}
C {lab_pin.sym} 4340 14800 0 0 {name=l11952 lab=BLB22}
N 4360 14760 4340 14760 {}
C {lab_pin.sym} 4340 14760 0 0 {name=l11953 lab=WL74}
N 4440 14840 4460 14840 {}
C {lab_pin.sym} 4460 14840 0 0 {name=l11954 lab=VDD}
N 4440 14760 4460 14760 {}
C {lab_pin.sym} 4460 14760 0 0 {name=l11955 lab=VSS}
C {bitcell_6t.sym} 4600 14800 0 0 {name=Xr74c23}
N 4560 14840 4540 14840 {}
C {lab_pin.sym} 4540 14840 0 0 {name=l11956 lab=BL23}
N 4560 14800 4540 14800 {}
C {lab_pin.sym} 4540 14800 0 0 {name=l11957 lab=BLB23}
N 4560 14760 4540 14760 {}
C {lab_pin.sym} 4540 14760 0 0 {name=l11958 lab=WL74}
N 4640 14840 4660 14840 {}
C {lab_pin.sym} 4660 14840 0 0 {name=l11959 lab=VDD}
N 4640 14760 4660 14760 {}
C {lab_pin.sym} 4660 14760 0 0 {name=l11960 lab=VSS}
C {bitcell_6t.sym} 4800 14800 0 0 {name=Xr74c24}
N 4760 14840 4740 14840 {}
C {lab_pin.sym} 4740 14840 0 0 {name=l11961 lab=BL24}
N 4760 14800 4740 14800 {}
C {lab_pin.sym} 4740 14800 0 0 {name=l11962 lab=BLB24}
N 4760 14760 4740 14760 {}
C {lab_pin.sym} 4740 14760 0 0 {name=l11963 lab=WL74}
N 4840 14840 4860 14840 {}
C {lab_pin.sym} 4860 14840 0 0 {name=l11964 lab=VDD}
N 4840 14760 4860 14760 {}
C {lab_pin.sym} 4860 14760 0 0 {name=l11965 lab=VSS}
C {bitcell_6t.sym} 5000 14800 0 0 {name=Xr74c25}
N 4960 14840 4940 14840 {}
C {lab_pin.sym} 4940 14840 0 0 {name=l11966 lab=BL25}
N 4960 14800 4940 14800 {}
C {lab_pin.sym} 4940 14800 0 0 {name=l11967 lab=BLB25}
N 4960 14760 4940 14760 {}
C {lab_pin.sym} 4940 14760 0 0 {name=l11968 lab=WL74}
N 5040 14840 5060 14840 {}
C {lab_pin.sym} 5060 14840 0 0 {name=l11969 lab=VDD}
N 5040 14760 5060 14760 {}
C {lab_pin.sym} 5060 14760 0 0 {name=l11970 lab=VSS}
C {bitcell_6t.sym} 5200 14800 0 0 {name=Xr74c26}
N 5160 14840 5140 14840 {}
C {lab_pin.sym} 5140 14840 0 0 {name=l11971 lab=BL26}
N 5160 14800 5140 14800 {}
C {lab_pin.sym} 5140 14800 0 0 {name=l11972 lab=BLB26}
N 5160 14760 5140 14760 {}
C {lab_pin.sym} 5140 14760 0 0 {name=l11973 lab=WL74}
N 5240 14840 5260 14840 {}
C {lab_pin.sym} 5260 14840 0 0 {name=l11974 lab=VDD}
N 5240 14760 5260 14760 {}
C {lab_pin.sym} 5260 14760 0 0 {name=l11975 lab=VSS}
C {bitcell_6t.sym} 5400 14800 0 0 {name=Xr74c27}
N 5360 14840 5340 14840 {}
C {lab_pin.sym} 5340 14840 0 0 {name=l11976 lab=BL27}
N 5360 14800 5340 14800 {}
C {lab_pin.sym} 5340 14800 0 0 {name=l11977 lab=BLB27}
N 5360 14760 5340 14760 {}
C {lab_pin.sym} 5340 14760 0 0 {name=l11978 lab=WL74}
N 5440 14840 5460 14840 {}
C {lab_pin.sym} 5460 14840 0 0 {name=l11979 lab=VDD}
N 5440 14760 5460 14760 {}
C {lab_pin.sym} 5460 14760 0 0 {name=l11980 lab=VSS}
C {bitcell_6t.sym} 5600 14800 0 0 {name=Xr74c28}
N 5560 14840 5540 14840 {}
C {lab_pin.sym} 5540 14840 0 0 {name=l11981 lab=BL28}
N 5560 14800 5540 14800 {}
C {lab_pin.sym} 5540 14800 0 0 {name=l11982 lab=BLB28}
N 5560 14760 5540 14760 {}
C {lab_pin.sym} 5540 14760 0 0 {name=l11983 lab=WL74}
N 5640 14840 5660 14840 {}
C {lab_pin.sym} 5660 14840 0 0 {name=l11984 lab=VDD}
N 5640 14760 5660 14760 {}
C {lab_pin.sym} 5660 14760 0 0 {name=l11985 lab=VSS}
C {bitcell_6t.sym} 5800 14800 0 0 {name=Xr74c29}
N 5760 14840 5740 14840 {}
C {lab_pin.sym} 5740 14840 0 0 {name=l11986 lab=BL29}
N 5760 14800 5740 14800 {}
C {lab_pin.sym} 5740 14800 0 0 {name=l11987 lab=BLB29}
N 5760 14760 5740 14760 {}
C {lab_pin.sym} 5740 14760 0 0 {name=l11988 lab=WL74}
N 5840 14840 5860 14840 {}
C {lab_pin.sym} 5860 14840 0 0 {name=l11989 lab=VDD}
N 5840 14760 5860 14760 {}
C {lab_pin.sym} 5860 14760 0 0 {name=l11990 lab=VSS}
C {bitcell_6t.sym} 6000 14800 0 0 {name=Xr74c30}
N 5960 14840 5940 14840 {}
C {lab_pin.sym} 5940 14840 0 0 {name=l11991 lab=BL30}
N 5960 14800 5940 14800 {}
C {lab_pin.sym} 5940 14800 0 0 {name=l11992 lab=BLB30}
N 5960 14760 5940 14760 {}
C {lab_pin.sym} 5940 14760 0 0 {name=l11993 lab=WL74}
N 6040 14840 6060 14840 {}
C {lab_pin.sym} 6060 14840 0 0 {name=l11994 lab=VDD}
N 6040 14760 6060 14760 {}
C {lab_pin.sym} 6060 14760 0 0 {name=l11995 lab=VSS}
C {bitcell_6t.sym} 6200 14800 0 0 {name=Xr74c31}
N 6160 14840 6140 14840 {}
C {lab_pin.sym} 6140 14840 0 0 {name=l11996 lab=BL31}
N 6160 14800 6140 14800 {}
C {lab_pin.sym} 6140 14800 0 0 {name=l11997 lab=BLB31}
N 6160 14760 6140 14760 {}
C {lab_pin.sym} 6140 14760 0 0 {name=l11998 lab=WL74}
N 6240 14840 6260 14840 {}
C {lab_pin.sym} 6260 14840 0 0 {name=l11999 lab=VDD}
N 6240 14760 6260 14760 {}
C {lab_pin.sym} 6260 14760 0 0 {name=l12000 lab=VSS}
C {bitcell_6t.sym} 0 15000 0 0 {name=Xr75c0}
N -40 15040 -60 15040 {}
C {lab_pin.sym} -60 15040 0 0 {name=l12001 lab=BL0}
N -40 15000 -60 15000 {}
C {lab_pin.sym} -60 15000 0 0 {name=l12002 lab=BLB0}
N -40 14960 -60 14960 {}
C {lab_pin.sym} -60 14960 0 0 {name=l12003 lab=WL75}
N 40 15040 60 15040 {}
C {lab_pin.sym} 60 15040 0 0 {name=l12004 lab=VDD}
N 40 14960 60 14960 {}
C {lab_pin.sym} 60 14960 0 0 {name=l12005 lab=VSS}
C {bitcell_6t.sym} 200 15000 0 0 {name=Xr75c1}
N 160 15040 140 15040 {}
C {lab_pin.sym} 140 15040 0 0 {name=l12006 lab=BL1}
N 160 15000 140 15000 {}
C {lab_pin.sym} 140 15000 0 0 {name=l12007 lab=BLB1}
N 160 14960 140 14960 {}
C {lab_pin.sym} 140 14960 0 0 {name=l12008 lab=WL75}
N 240 15040 260 15040 {}
C {lab_pin.sym} 260 15040 0 0 {name=l12009 lab=VDD}
N 240 14960 260 14960 {}
C {lab_pin.sym} 260 14960 0 0 {name=l12010 lab=VSS}
C {bitcell_6t.sym} 400 15000 0 0 {name=Xr75c2}
N 360 15040 340 15040 {}
C {lab_pin.sym} 340 15040 0 0 {name=l12011 lab=BL2}
N 360 15000 340 15000 {}
C {lab_pin.sym} 340 15000 0 0 {name=l12012 lab=BLB2}
N 360 14960 340 14960 {}
C {lab_pin.sym} 340 14960 0 0 {name=l12013 lab=WL75}
N 440 15040 460 15040 {}
C {lab_pin.sym} 460 15040 0 0 {name=l12014 lab=VDD}
N 440 14960 460 14960 {}
C {lab_pin.sym} 460 14960 0 0 {name=l12015 lab=VSS}
C {bitcell_6t.sym} 600 15000 0 0 {name=Xr75c3}
N 560 15040 540 15040 {}
C {lab_pin.sym} 540 15040 0 0 {name=l12016 lab=BL3}
N 560 15000 540 15000 {}
C {lab_pin.sym} 540 15000 0 0 {name=l12017 lab=BLB3}
N 560 14960 540 14960 {}
C {lab_pin.sym} 540 14960 0 0 {name=l12018 lab=WL75}
N 640 15040 660 15040 {}
C {lab_pin.sym} 660 15040 0 0 {name=l12019 lab=VDD}
N 640 14960 660 14960 {}
C {lab_pin.sym} 660 14960 0 0 {name=l12020 lab=VSS}
C {bitcell_6t.sym} 800 15000 0 0 {name=Xr75c4}
N 760 15040 740 15040 {}
C {lab_pin.sym} 740 15040 0 0 {name=l12021 lab=BL4}
N 760 15000 740 15000 {}
C {lab_pin.sym} 740 15000 0 0 {name=l12022 lab=BLB4}
N 760 14960 740 14960 {}
C {lab_pin.sym} 740 14960 0 0 {name=l12023 lab=WL75}
N 840 15040 860 15040 {}
C {lab_pin.sym} 860 15040 0 0 {name=l12024 lab=VDD}
N 840 14960 860 14960 {}
C {lab_pin.sym} 860 14960 0 0 {name=l12025 lab=VSS}
C {bitcell_6t.sym} 1000 15000 0 0 {name=Xr75c5}
N 960 15040 940 15040 {}
C {lab_pin.sym} 940 15040 0 0 {name=l12026 lab=BL5}
N 960 15000 940 15000 {}
C {lab_pin.sym} 940 15000 0 0 {name=l12027 lab=BLB5}
N 960 14960 940 14960 {}
C {lab_pin.sym} 940 14960 0 0 {name=l12028 lab=WL75}
N 1040 15040 1060 15040 {}
C {lab_pin.sym} 1060 15040 0 0 {name=l12029 lab=VDD}
N 1040 14960 1060 14960 {}
C {lab_pin.sym} 1060 14960 0 0 {name=l12030 lab=VSS}
C {bitcell_6t.sym} 1200 15000 0 0 {name=Xr75c6}
N 1160 15040 1140 15040 {}
C {lab_pin.sym} 1140 15040 0 0 {name=l12031 lab=BL6}
N 1160 15000 1140 15000 {}
C {lab_pin.sym} 1140 15000 0 0 {name=l12032 lab=BLB6}
N 1160 14960 1140 14960 {}
C {lab_pin.sym} 1140 14960 0 0 {name=l12033 lab=WL75}
N 1240 15040 1260 15040 {}
C {lab_pin.sym} 1260 15040 0 0 {name=l12034 lab=VDD}
N 1240 14960 1260 14960 {}
C {lab_pin.sym} 1260 14960 0 0 {name=l12035 lab=VSS}
C {bitcell_6t.sym} 1400 15000 0 0 {name=Xr75c7}
N 1360 15040 1340 15040 {}
C {lab_pin.sym} 1340 15040 0 0 {name=l12036 lab=BL7}
N 1360 15000 1340 15000 {}
C {lab_pin.sym} 1340 15000 0 0 {name=l12037 lab=BLB7}
N 1360 14960 1340 14960 {}
C {lab_pin.sym} 1340 14960 0 0 {name=l12038 lab=WL75}
N 1440 15040 1460 15040 {}
C {lab_pin.sym} 1460 15040 0 0 {name=l12039 lab=VDD}
N 1440 14960 1460 14960 {}
C {lab_pin.sym} 1460 14960 0 0 {name=l12040 lab=VSS}
C {bitcell_6t.sym} 1600 15000 0 0 {name=Xr75c8}
N 1560 15040 1540 15040 {}
C {lab_pin.sym} 1540 15040 0 0 {name=l12041 lab=BL8}
N 1560 15000 1540 15000 {}
C {lab_pin.sym} 1540 15000 0 0 {name=l12042 lab=BLB8}
N 1560 14960 1540 14960 {}
C {lab_pin.sym} 1540 14960 0 0 {name=l12043 lab=WL75}
N 1640 15040 1660 15040 {}
C {lab_pin.sym} 1660 15040 0 0 {name=l12044 lab=VDD}
N 1640 14960 1660 14960 {}
C {lab_pin.sym} 1660 14960 0 0 {name=l12045 lab=VSS}
C {bitcell_6t.sym} 1800 15000 0 0 {name=Xr75c9}
N 1760 15040 1740 15040 {}
C {lab_pin.sym} 1740 15040 0 0 {name=l12046 lab=BL9}
N 1760 15000 1740 15000 {}
C {lab_pin.sym} 1740 15000 0 0 {name=l12047 lab=BLB9}
N 1760 14960 1740 14960 {}
C {lab_pin.sym} 1740 14960 0 0 {name=l12048 lab=WL75}
N 1840 15040 1860 15040 {}
C {lab_pin.sym} 1860 15040 0 0 {name=l12049 lab=VDD}
N 1840 14960 1860 14960 {}
C {lab_pin.sym} 1860 14960 0 0 {name=l12050 lab=VSS}
C {bitcell_6t.sym} 2000 15000 0 0 {name=Xr75c10}
N 1960 15040 1940 15040 {}
C {lab_pin.sym} 1940 15040 0 0 {name=l12051 lab=BL10}
N 1960 15000 1940 15000 {}
C {lab_pin.sym} 1940 15000 0 0 {name=l12052 lab=BLB10}
N 1960 14960 1940 14960 {}
C {lab_pin.sym} 1940 14960 0 0 {name=l12053 lab=WL75}
N 2040 15040 2060 15040 {}
C {lab_pin.sym} 2060 15040 0 0 {name=l12054 lab=VDD}
N 2040 14960 2060 14960 {}
C {lab_pin.sym} 2060 14960 0 0 {name=l12055 lab=VSS}
C {bitcell_6t.sym} 2200 15000 0 0 {name=Xr75c11}
N 2160 15040 2140 15040 {}
C {lab_pin.sym} 2140 15040 0 0 {name=l12056 lab=BL11}
N 2160 15000 2140 15000 {}
C {lab_pin.sym} 2140 15000 0 0 {name=l12057 lab=BLB11}
N 2160 14960 2140 14960 {}
C {lab_pin.sym} 2140 14960 0 0 {name=l12058 lab=WL75}
N 2240 15040 2260 15040 {}
C {lab_pin.sym} 2260 15040 0 0 {name=l12059 lab=VDD}
N 2240 14960 2260 14960 {}
C {lab_pin.sym} 2260 14960 0 0 {name=l12060 lab=VSS}
C {bitcell_6t.sym} 2400 15000 0 0 {name=Xr75c12}
N 2360 15040 2340 15040 {}
C {lab_pin.sym} 2340 15040 0 0 {name=l12061 lab=BL12}
N 2360 15000 2340 15000 {}
C {lab_pin.sym} 2340 15000 0 0 {name=l12062 lab=BLB12}
N 2360 14960 2340 14960 {}
C {lab_pin.sym} 2340 14960 0 0 {name=l12063 lab=WL75}
N 2440 15040 2460 15040 {}
C {lab_pin.sym} 2460 15040 0 0 {name=l12064 lab=VDD}
N 2440 14960 2460 14960 {}
C {lab_pin.sym} 2460 14960 0 0 {name=l12065 lab=VSS}
C {bitcell_6t.sym} 2600 15000 0 0 {name=Xr75c13}
N 2560 15040 2540 15040 {}
C {lab_pin.sym} 2540 15040 0 0 {name=l12066 lab=BL13}
N 2560 15000 2540 15000 {}
C {lab_pin.sym} 2540 15000 0 0 {name=l12067 lab=BLB13}
N 2560 14960 2540 14960 {}
C {lab_pin.sym} 2540 14960 0 0 {name=l12068 lab=WL75}
N 2640 15040 2660 15040 {}
C {lab_pin.sym} 2660 15040 0 0 {name=l12069 lab=VDD}
N 2640 14960 2660 14960 {}
C {lab_pin.sym} 2660 14960 0 0 {name=l12070 lab=VSS}
C {bitcell_6t.sym} 2800 15000 0 0 {name=Xr75c14}
N 2760 15040 2740 15040 {}
C {lab_pin.sym} 2740 15040 0 0 {name=l12071 lab=BL14}
N 2760 15000 2740 15000 {}
C {lab_pin.sym} 2740 15000 0 0 {name=l12072 lab=BLB14}
N 2760 14960 2740 14960 {}
C {lab_pin.sym} 2740 14960 0 0 {name=l12073 lab=WL75}
N 2840 15040 2860 15040 {}
C {lab_pin.sym} 2860 15040 0 0 {name=l12074 lab=VDD}
N 2840 14960 2860 14960 {}
C {lab_pin.sym} 2860 14960 0 0 {name=l12075 lab=VSS}
C {bitcell_6t.sym} 3000 15000 0 0 {name=Xr75c15}
N 2960 15040 2940 15040 {}
C {lab_pin.sym} 2940 15040 0 0 {name=l12076 lab=BL15}
N 2960 15000 2940 15000 {}
C {lab_pin.sym} 2940 15000 0 0 {name=l12077 lab=BLB15}
N 2960 14960 2940 14960 {}
C {lab_pin.sym} 2940 14960 0 0 {name=l12078 lab=WL75}
N 3040 15040 3060 15040 {}
C {lab_pin.sym} 3060 15040 0 0 {name=l12079 lab=VDD}
N 3040 14960 3060 14960 {}
C {lab_pin.sym} 3060 14960 0 0 {name=l12080 lab=VSS}
C {bitcell_6t.sym} 3200 15000 0 0 {name=Xr75c16}
N 3160 15040 3140 15040 {}
C {lab_pin.sym} 3140 15040 0 0 {name=l12081 lab=BL16}
N 3160 15000 3140 15000 {}
C {lab_pin.sym} 3140 15000 0 0 {name=l12082 lab=BLB16}
N 3160 14960 3140 14960 {}
C {lab_pin.sym} 3140 14960 0 0 {name=l12083 lab=WL75}
N 3240 15040 3260 15040 {}
C {lab_pin.sym} 3260 15040 0 0 {name=l12084 lab=VDD}
N 3240 14960 3260 14960 {}
C {lab_pin.sym} 3260 14960 0 0 {name=l12085 lab=VSS}
C {bitcell_6t.sym} 3400 15000 0 0 {name=Xr75c17}
N 3360 15040 3340 15040 {}
C {lab_pin.sym} 3340 15040 0 0 {name=l12086 lab=BL17}
N 3360 15000 3340 15000 {}
C {lab_pin.sym} 3340 15000 0 0 {name=l12087 lab=BLB17}
N 3360 14960 3340 14960 {}
C {lab_pin.sym} 3340 14960 0 0 {name=l12088 lab=WL75}
N 3440 15040 3460 15040 {}
C {lab_pin.sym} 3460 15040 0 0 {name=l12089 lab=VDD}
N 3440 14960 3460 14960 {}
C {lab_pin.sym} 3460 14960 0 0 {name=l12090 lab=VSS}
C {bitcell_6t.sym} 3600 15000 0 0 {name=Xr75c18}
N 3560 15040 3540 15040 {}
C {lab_pin.sym} 3540 15040 0 0 {name=l12091 lab=BL18}
N 3560 15000 3540 15000 {}
C {lab_pin.sym} 3540 15000 0 0 {name=l12092 lab=BLB18}
N 3560 14960 3540 14960 {}
C {lab_pin.sym} 3540 14960 0 0 {name=l12093 lab=WL75}
N 3640 15040 3660 15040 {}
C {lab_pin.sym} 3660 15040 0 0 {name=l12094 lab=VDD}
N 3640 14960 3660 14960 {}
C {lab_pin.sym} 3660 14960 0 0 {name=l12095 lab=VSS}
C {bitcell_6t.sym} 3800 15000 0 0 {name=Xr75c19}
N 3760 15040 3740 15040 {}
C {lab_pin.sym} 3740 15040 0 0 {name=l12096 lab=BL19}
N 3760 15000 3740 15000 {}
C {lab_pin.sym} 3740 15000 0 0 {name=l12097 lab=BLB19}
N 3760 14960 3740 14960 {}
C {lab_pin.sym} 3740 14960 0 0 {name=l12098 lab=WL75}
N 3840 15040 3860 15040 {}
C {lab_pin.sym} 3860 15040 0 0 {name=l12099 lab=VDD}
N 3840 14960 3860 14960 {}
C {lab_pin.sym} 3860 14960 0 0 {name=l12100 lab=VSS}
C {bitcell_6t.sym} 4000 15000 0 0 {name=Xr75c20}
N 3960 15040 3940 15040 {}
C {lab_pin.sym} 3940 15040 0 0 {name=l12101 lab=BL20}
N 3960 15000 3940 15000 {}
C {lab_pin.sym} 3940 15000 0 0 {name=l12102 lab=BLB20}
N 3960 14960 3940 14960 {}
C {lab_pin.sym} 3940 14960 0 0 {name=l12103 lab=WL75}
N 4040 15040 4060 15040 {}
C {lab_pin.sym} 4060 15040 0 0 {name=l12104 lab=VDD}
N 4040 14960 4060 14960 {}
C {lab_pin.sym} 4060 14960 0 0 {name=l12105 lab=VSS}
C {bitcell_6t.sym} 4200 15000 0 0 {name=Xr75c21}
N 4160 15040 4140 15040 {}
C {lab_pin.sym} 4140 15040 0 0 {name=l12106 lab=BL21}
N 4160 15000 4140 15000 {}
C {lab_pin.sym} 4140 15000 0 0 {name=l12107 lab=BLB21}
N 4160 14960 4140 14960 {}
C {lab_pin.sym} 4140 14960 0 0 {name=l12108 lab=WL75}
N 4240 15040 4260 15040 {}
C {lab_pin.sym} 4260 15040 0 0 {name=l12109 lab=VDD}
N 4240 14960 4260 14960 {}
C {lab_pin.sym} 4260 14960 0 0 {name=l12110 lab=VSS}
C {bitcell_6t.sym} 4400 15000 0 0 {name=Xr75c22}
N 4360 15040 4340 15040 {}
C {lab_pin.sym} 4340 15040 0 0 {name=l12111 lab=BL22}
N 4360 15000 4340 15000 {}
C {lab_pin.sym} 4340 15000 0 0 {name=l12112 lab=BLB22}
N 4360 14960 4340 14960 {}
C {lab_pin.sym} 4340 14960 0 0 {name=l12113 lab=WL75}
N 4440 15040 4460 15040 {}
C {lab_pin.sym} 4460 15040 0 0 {name=l12114 lab=VDD}
N 4440 14960 4460 14960 {}
C {lab_pin.sym} 4460 14960 0 0 {name=l12115 lab=VSS}
C {bitcell_6t.sym} 4600 15000 0 0 {name=Xr75c23}
N 4560 15040 4540 15040 {}
C {lab_pin.sym} 4540 15040 0 0 {name=l12116 lab=BL23}
N 4560 15000 4540 15000 {}
C {lab_pin.sym} 4540 15000 0 0 {name=l12117 lab=BLB23}
N 4560 14960 4540 14960 {}
C {lab_pin.sym} 4540 14960 0 0 {name=l12118 lab=WL75}
N 4640 15040 4660 15040 {}
C {lab_pin.sym} 4660 15040 0 0 {name=l12119 lab=VDD}
N 4640 14960 4660 14960 {}
C {lab_pin.sym} 4660 14960 0 0 {name=l12120 lab=VSS}
C {bitcell_6t.sym} 4800 15000 0 0 {name=Xr75c24}
N 4760 15040 4740 15040 {}
C {lab_pin.sym} 4740 15040 0 0 {name=l12121 lab=BL24}
N 4760 15000 4740 15000 {}
C {lab_pin.sym} 4740 15000 0 0 {name=l12122 lab=BLB24}
N 4760 14960 4740 14960 {}
C {lab_pin.sym} 4740 14960 0 0 {name=l12123 lab=WL75}
N 4840 15040 4860 15040 {}
C {lab_pin.sym} 4860 15040 0 0 {name=l12124 lab=VDD}
N 4840 14960 4860 14960 {}
C {lab_pin.sym} 4860 14960 0 0 {name=l12125 lab=VSS}
C {bitcell_6t.sym} 5000 15000 0 0 {name=Xr75c25}
N 4960 15040 4940 15040 {}
C {lab_pin.sym} 4940 15040 0 0 {name=l12126 lab=BL25}
N 4960 15000 4940 15000 {}
C {lab_pin.sym} 4940 15000 0 0 {name=l12127 lab=BLB25}
N 4960 14960 4940 14960 {}
C {lab_pin.sym} 4940 14960 0 0 {name=l12128 lab=WL75}
N 5040 15040 5060 15040 {}
C {lab_pin.sym} 5060 15040 0 0 {name=l12129 lab=VDD}
N 5040 14960 5060 14960 {}
C {lab_pin.sym} 5060 14960 0 0 {name=l12130 lab=VSS}
C {bitcell_6t.sym} 5200 15000 0 0 {name=Xr75c26}
N 5160 15040 5140 15040 {}
C {lab_pin.sym} 5140 15040 0 0 {name=l12131 lab=BL26}
N 5160 15000 5140 15000 {}
C {lab_pin.sym} 5140 15000 0 0 {name=l12132 lab=BLB26}
N 5160 14960 5140 14960 {}
C {lab_pin.sym} 5140 14960 0 0 {name=l12133 lab=WL75}
N 5240 15040 5260 15040 {}
C {lab_pin.sym} 5260 15040 0 0 {name=l12134 lab=VDD}
N 5240 14960 5260 14960 {}
C {lab_pin.sym} 5260 14960 0 0 {name=l12135 lab=VSS}
C {bitcell_6t.sym} 5400 15000 0 0 {name=Xr75c27}
N 5360 15040 5340 15040 {}
C {lab_pin.sym} 5340 15040 0 0 {name=l12136 lab=BL27}
N 5360 15000 5340 15000 {}
C {lab_pin.sym} 5340 15000 0 0 {name=l12137 lab=BLB27}
N 5360 14960 5340 14960 {}
C {lab_pin.sym} 5340 14960 0 0 {name=l12138 lab=WL75}
N 5440 15040 5460 15040 {}
C {lab_pin.sym} 5460 15040 0 0 {name=l12139 lab=VDD}
N 5440 14960 5460 14960 {}
C {lab_pin.sym} 5460 14960 0 0 {name=l12140 lab=VSS}
C {bitcell_6t.sym} 5600 15000 0 0 {name=Xr75c28}
N 5560 15040 5540 15040 {}
C {lab_pin.sym} 5540 15040 0 0 {name=l12141 lab=BL28}
N 5560 15000 5540 15000 {}
C {lab_pin.sym} 5540 15000 0 0 {name=l12142 lab=BLB28}
N 5560 14960 5540 14960 {}
C {lab_pin.sym} 5540 14960 0 0 {name=l12143 lab=WL75}
N 5640 15040 5660 15040 {}
C {lab_pin.sym} 5660 15040 0 0 {name=l12144 lab=VDD}
N 5640 14960 5660 14960 {}
C {lab_pin.sym} 5660 14960 0 0 {name=l12145 lab=VSS}
C {bitcell_6t.sym} 5800 15000 0 0 {name=Xr75c29}
N 5760 15040 5740 15040 {}
C {lab_pin.sym} 5740 15040 0 0 {name=l12146 lab=BL29}
N 5760 15000 5740 15000 {}
C {lab_pin.sym} 5740 15000 0 0 {name=l12147 lab=BLB29}
N 5760 14960 5740 14960 {}
C {lab_pin.sym} 5740 14960 0 0 {name=l12148 lab=WL75}
N 5840 15040 5860 15040 {}
C {lab_pin.sym} 5860 15040 0 0 {name=l12149 lab=VDD}
N 5840 14960 5860 14960 {}
C {lab_pin.sym} 5860 14960 0 0 {name=l12150 lab=VSS}
C {bitcell_6t.sym} 6000 15000 0 0 {name=Xr75c30}
N 5960 15040 5940 15040 {}
C {lab_pin.sym} 5940 15040 0 0 {name=l12151 lab=BL30}
N 5960 15000 5940 15000 {}
C {lab_pin.sym} 5940 15000 0 0 {name=l12152 lab=BLB30}
N 5960 14960 5940 14960 {}
C {lab_pin.sym} 5940 14960 0 0 {name=l12153 lab=WL75}
N 6040 15040 6060 15040 {}
C {lab_pin.sym} 6060 15040 0 0 {name=l12154 lab=VDD}
N 6040 14960 6060 14960 {}
C {lab_pin.sym} 6060 14960 0 0 {name=l12155 lab=VSS}
C {bitcell_6t.sym} 6200 15000 0 0 {name=Xr75c31}
N 6160 15040 6140 15040 {}
C {lab_pin.sym} 6140 15040 0 0 {name=l12156 lab=BL31}
N 6160 15000 6140 15000 {}
C {lab_pin.sym} 6140 15000 0 0 {name=l12157 lab=BLB31}
N 6160 14960 6140 14960 {}
C {lab_pin.sym} 6140 14960 0 0 {name=l12158 lab=WL75}
N 6240 15040 6260 15040 {}
C {lab_pin.sym} 6260 15040 0 0 {name=l12159 lab=VDD}
N 6240 14960 6260 14960 {}
C {lab_pin.sym} 6260 14960 0 0 {name=l12160 lab=VSS}
C {bitcell_6t.sym} 0 15200 0 0 {name=Xr76c0}
N -40 15240 -60 15240 {}
C {lab_pin.sym} -60 15240 0 0 {name=l12161 lab=BL0}
N -40 15200 -60 15200 {}
C {lab_pin.sym} -60 15200 0 0 {name=l12162 lab=BLB0}
N -40 15160 -60 15160 {}
C {lab_pin.sym} -60 15160 0 0 {name=l12163 lab=WL76}
N 40 15240 60 15240 {}
C {lab_pin.sym} 60 15240 0 0 {name=l12164 lab=VDD}
N 40 15160 60 15160 {}
C {lab_pin.sym} 60 15160 0 0 {name=l12165 lab=VSS}
C {bitcell_6t.sym} 200 15200 0 0 {name=Xr76c1}
N 160 15240 140 15240 {}
C {lab_pin.sym} 140 15240 0 0 {name=l12166 lab=BL1}
N 160 15200 140 15200 {}
C {lab_pin.sym} 140 15200 0 0 {name=l12167 lab=BLB1}
N 160 15160 140 15160 {}
C {lab_pin.sym} 140 15160 0 0 {name=l12168 lab=WL76}
N 240 15240 260 15240 {}
C {lab_pin.sym} 260 15240 0 0 {name=l12169 lab=VDD}
N 240 15160 260 15160 {}
C {lab_pin.sym} 260 15160 0 0 {name=l12170 lab=VSS}
C {bitcell_6t.sym} 400 15200 0 0 {name=Xr76c2}
N 360 15240 340 15240 {}
C {lab_pin.sym} 340 15240 0 0 {name=l12171 lab=BL2}
N 360 15200 340 15200 {}
C {lab_pin.sym} 340 15200 0 0 {name=l12172 lab=BLB2}
N 360 15160 340 15160 {}
C {lab_pin.sym} 340 15160 0 0 {name=l12173 lab=WL76}
N 440 15240 460 15240 {}
C {lab_pin.sym} 460 15240 0 0 {name=l12174 lab=VDD}
N 440 15160 460 15160 {}
C {lab_pin.sym} 460 15160 0 0 {name=l12175 lab=VSS}
C {bitcell_6t.sym} 600 15200 0 0 {name=Xr76c3}
N 560 15240 540 15240 {}
C {lab_pin.sym} 540 15240 0 0 {name=l12176 lab=BL3}
N 560 15200 540 15200 {}
C {lab_pin.sym} 540 15200 0 0 {name=l12177 lab=BLB3}
N 560 15160 540 15160 {}
C {lab_pin.sym} 540 15160 0 0 {name=l12178 lab=WL76}
N 640 15240 660 15240 {}
C {lab_pin.sym} 660 15240 0 0 {name=l12179 lab=VDD}
N 640 15160 660 15160 {}
C {lab_pin.sym} 660 15160 0 0 {name=l12180 lab=VSS}
C {bitcell_6t.sym} 800 15200 0 0 {name=Xr76c4}
N 760 15240 740 15240 {}
C {lab_pin.sym} 740 15240 0 0 {name=l12181 lab=BL4}
N 760 15200 740 15200 {}
C {lab_pin.sym} 740 15200 0 0 {name=l12182 lab=BLB4}
N 760 15160 740 15160 {}
C {lab_pin.sym} 740 15160 0 0 {name=l12183 lab=WL76}
N 840 15240 860 15240 {}
C {lab_pin.sym} 860 15240 0 0 {name=l12184 lab=VDD}
N 840 15160 860 15160 {}
C {lab_pin.sym} 860 15160 0 0 {name=l12185 lab=VSS}
C {bitcell_6t.sym} 1000 15200 0 0 {name=Xr76c5}
N 960 15240 940 15240 {}
C {lab_pin.sym} 940 15240 0 0 {name=l12186 lab=BL5}
N 960 15200 940 15200 {}
C {lab_pin.sym} 940 15200 0 0 {name=l12187 lab=BLB5}
N 960 15160 940 15160 {}
C {lab_pin.sym} 940 15160 0 0 {name=l12188 lab=WL76}
N 1040 15240 1060 15240 {}
C {lab_pin.sym} 1060 15240 0 0 {name=l12189 lab=VDD}
N 1040 15160 1060 15160 {}
C {lab_pin.sym} 1060 15160 0 0 {name=l12190 lab=VSS}
C {bitcell_6t.sym} 1200 15200 0 0 {name=Xr76c6}
N 1160 15240 1140 15240 {}
C {lab_pin.sym} 1140 15240 0 0 {name=l12191 lab=BL6}
N 1160 15200 1140 15200 {}
C {lab_pin.sym} 1140 15200 0 0 {name=l12192 lab=BLB6}
N 1160 15160 1140 15160 {}
C {lab_pin.sym} 1140 15160 0 0 {name=l12193 lab=WL76}
N 1240 15240 1260 15240 {}
C {lab_pin.sym} 1260 15240 0 0 {name=l12194 lab=VDD}
N 1240 15160 1260 15160 {}
C {lab_pin.sym} 1260 15160 0 0 {name=l12195 lab=VSS}
C {bitcell_6t.sym} 1400 15200 0 0 {name=Xr76c7}
N 1360 15240 1340 15240 {}
C {lab_pin.sym} 1340 15240 0 0 {name=l12196 lab=BL7}
N 1360 15200 1340 15200 {}
C {lab_pin.sym} 1340 15200 0 0 {name=l12197 lab=BLB7}
N 1360 15160 1340 15160 {}
C {lab_pin.sym} 1340 15160 0 0 {name=l12198 lab=WL76}
N 1440 15240 1460 15240 {}
C {lab_pin.sym} 1460 15240 0 0 {name=l12199 lab=VDD}
N 1440 15160 1460 15160 {}
C {lab_pin.sym} 1460 15160 0 0 {name=l12200 lab=VSS}
C {bitcell_6t.sym} 1600 15200 0 0 {name=Xr76c8}
N 1560 15240 1540 15240 {}
C {lab_pin.sym} 1540 15240 0 0 {name=l12201 lab=BL8}
N 1560 15200 1540 15200 {}
C {lab_pin.sym} 1540 15200 0 0 {name=l12202 lab=BLB8}
N 1560 15160 1540 15160 {}
C {lab_pin.sym} 1540 15160 0 0 {name=l12203 lab=WL76}
N 1640 15240 1660 15240 {}
C {lab_pin.sym} 1660 15240 0 0 {name=l12204 lab=VDD}
N 1640 15160 1660 15160 {}
C {lab_pin.sym} 1660 15160 0 0 {name=l12205 lab=VSS}
C {bitcell_6t.sym} 1800 15200 0 0 {name=Xr76c9}
N 1760 15240 1740 15240 {}
C {lab_pin.sym} 1740 15240 0 0 {name=l12206 lab=BL9}
N 1760 15200 1740 15200 {}
C {lab_pin.sym} 1740 15200 0 0 {name=l12207 lab=BLB9}
N 1760 15160 1740 15160 {}
C {lab_pin.sym} 1740 15160 0 0 {name=l12208 lab=WL76}
N 1840 15240 1860 15240 {}
C {lab_pin.sym} 1860 15240 0 0 {name=l12209 lab=VDD}
N 1840 15160 1860 15160 {}
C {lab_pin.sym} 1860 15160 0 0 {name=l12210 lab=VSS}
C {bitcell_6t.sym} 2000 15200 0 0 {name=Xr76c10}
N 1960 15240 1940 15240 {}
C {lab_pin.sym} 1940 15240 0 0 {name=l12211 lab=BL10}
N 1960 15200 1940 15200 {}
C {lab_pin.sym} 1940 15200 0 0 {name=l12212 lab=BLB10}
N 1960 15160 1940 15160 {}
C {lab_pin.sym} 1940 15160 0 0 {name=l12213 lab=WL76}
N 2040 15240 2060 15240 {}
C {lab_pin.sym} 2060 15240 0 0 {name=l12214 lab=VDD}
N 2040 15160 2060 15160 {}
C {lab_pin.sym} 2060 15160 0 0 {name=l12215 lab=VSS}
C {bitcell_6t.sym} 2200 15200 0 0 {name=Xr76c11}
N 2160 15240 2140 15240 {}
C {lab_pin.sym} 2140 15240 0 0 {name=l12216 lab=BL11}
N 2160 15200 2140 15200 {}
C {lab_pin.sym} 2140 15200 0 0 {name=l12217 lab=BLB11}
N 2160 15160 2140 15160 {}
C {lab_pin.sym} 2140 15160 0 0 {name=l12218 lab=WL76}
N 2240 15240 2260 15240 {}
C {lab_pin.sym} 2260 15240 0 0 {name=l12219 lab=VDD}
N 2240 15160 2260 15160 {}
C {lab_pin.sym} 2260 15160 0 0 {name=l12220 lab=VSS}
C {bitcell_6t.sym} 2400 15200 0 0 {name=Xr76c12}
N 2360 15240 2340 15240 {}
C {lab_pin.sym} 2340 15240 0 0 {name=l12221 lab=BL12}
N 2360 15200 2340 15200 {}
C {lab_pin.sym} 2340 15200 0 0 {name=l12222 lab=BLB12}
N 2360 15160 2340 15160 {}
C {lab_pin.sym} 2340 15160 0 0 {name=l12223 lab=WL76}
N 2440 15240 2460 15240 {}
C {lab_pin.sym} 2460 15240 0 0 {name=l12224 lab=VDD}
N 2440 15160 2460 15160 {}
C {lab_pin.sym} 2460 15160 0 0 {name=l12225 lab=VSS}
C {bitcell_6t.sym} 2600 15200 0 0 {name=Xr76c13}
N 2560 15240 2540 15240 {}
C {lab_pin.sym} 2540 15240 0 0 {name=l12226 lab=BL13}
N 2560 15200 2540 15200 {}
C {lab_pin.sym} 2540 15200 0 0 {name=l12227 lab=BLB13}
N 2560 15160 2540 15160 {}
C {lab_pin.sym} 2540 15160 0 0 {name=l12228 lab=WL76}
N 2640 15240 2660 15240 {}
C {lab_pin.sym} 2660 15240 0 0 {name=l12229 lab=VDD}
N 2640 15160 2660 15160 {}
C {lab_pin.sym} 2660 15160 0 0 {name=l12230 lab=VSS}
C {bitcell_6t.sym} 2800 15200 0 0 {name=Xr76c14}
N 2760 15240 2740 15240 {}
C {lab_pin.sym} 2740 15240 0 0 {name=l12231 lab=BL14}
N 2760 15200 2740 15200 {}
C {lab_pin.sym} 2740 15200 0 0 {name=l12232 lab=BLB14}
N 2760 15160 2740 15160 {}
C {lab_pin.sym} 2740 15160 0 0 {name=l12233 lab=WL76}
N 2840 15240 2860 15240 {}
C {lab_pin.sym} 2860 15240 0 0 {name=l12234 lab=VDD}
N 2840 15160 2860 15160 {}
C {lab_pin.sym} 2860 15160 0 0 {name=l12235 lab=VSS}
C {bitcell_6t.sym} 3000 15200 0 0 {name=Xr76c15}
N 2960 15240 2940 15240 {}
C {lab_pin.sym} 2940 15240 0 0 {name=l12236 lab=BL15}
N 2960 15200 2940 15200 {}
C {lab_pin.sym} 2940 15200 0 0 {name=l12237 lab=BLB15}
N 2960 15160 2940 15160 {}
C {lab_pin.sym} 2940 15160 0 0 {name=l12238 lab=WL76}
N 3040 15240 3060 15240 {}
C {lab_pin.sym} 3060 15240 0 0 {name=l12239 lab=VDD}
N 3040 15160 3060 15160 {}
C {lab_pin.sym} 3060 15160 0 0 {name=l12240 lab=VSS}
C {bitcell_6t.sym} 3200 15200 0 0 {name=Xr76c16}
N 3160 15240 3140 15240 {}
C {lab_pin.sym} 3140 15240 0 0 {name=l12241 lab=BL16}
N 3160 15200 3140 15200 {}
C {lab_pin.sym} 3140 15200 0 0 {name=l12242 lab=BLB16}
N 3160 15160 3140 15160 {}
C {lab_pin.sym} 3140 15160 0 0 {name=l12243 lab=WL76}
N 3240 15240 3260 15240 {}
C {lab_pin.sym} 3260 15240 0 0 {name=l12244 lab=VDD}
N 3240 15160 3260 15160 {}
C {lab_pin.sym} 3260 15160 0 0 {name=l12245 lab=VSS}
C {bitcell_6t.sym} 3400 15200 0 0 {name=Xr76c17}
N 3360 15240 3340 15240 {}
C {lab_pin.sym} 3340 15240 0 0 {name=l12246 lab=BL17}
N 3360 15200 3340 15200 {}
C {lab_pin.sym} 3340 15200 0 0 {name=l12247 lab=BLB17}
N 3360 15160 3340 15160 {}
C {lab_pin.sym} 3340 15160 0 0 {name=l12248 lab=WL76}
N 3440 15240 3460 15240 {}
C {lab_pin.sym} 3460 15240 0 0 {name=l12249 lab=VDD}
N 3440 15160 3460 15160 {}
C {lab_pin.sym} 3460 15160 0 0 {name=l12250 lab=VSS}
C {bitcell_6t.sym} 3600 15200 0 0 {name=Xr76c18}
N 3560 15240 3540 15240 {}
C {lab_pin.sym} 3540 15240 0 0 {name=l12251 lab=BL18}
N 3560 15200 3540 15200 {}
C {lab_pin.sym} 3540 15200 0 0 {name=l12252 lab=BLB18}
N 3560 15160 3540 15160 {}
C {lab_pin.sym} 3540 15160 0 0 {name=l12253 lab=WL76}
N 3640 15240 3660 15240 {}
C {lab_pin.sym} 3660 15240 0 0 {name=l12254 lab=VDD}
N 3640 15160 3660 15160 {}
C {lab_pin.sym} 3660 15160 0 0 {name=l12255 lab=VSS}
C {bitcell_6t.sym} 3800 15200 0 0 {name=Xr76c19}
N 3760 15240 3740 15240 {}
C {lab_pin.sym} 3740 15240 0 0 {name=l12256 lab=BL19}
N 3760 15200 3740 15200 {}
C {lab_pin.sym} 3740 15200 0 0 {name=l12257 lab=BLB19}
N 3760 15160 3740 15160 {}
C {lab_pin.sym} 3740 15160 0 0 {name=l12258 lab=WL76}
N 3840 15240 3860 15240 {}
C {lab_pin.sym} 3860 15240 0 0 {name=l12259 lab=VDD}
N 3840 15160 3860 15160 {}
C {lab_pin.sym} 3860 15160 0 0 {name=l12260 lab=VSS}
C {bitcell_6t.sym} 4000 15200 0 0 {name=Xr76c20}
N 3960 15240 3940 15240 {}
C {lab_pin.sym} 3940 15240 0 0 {name=l12261 lab=BL20}
N 3960 15200 3940 15200 {}
C {lab_pin.sym} 3940 15200 0 0 {name=l12262 lab=BLB20}
N 3960 15160 3940 15160 {}
C {lab_pin.sym} 3940 15160 0 0 {name=l12263 lab=WL76}
N 4040 15240 4060 15240 {}
C {lab_pin.sym} 4060 15240 0 0 {name=l12264 lab=VDD}
N 4040 15160 4060 15160 {}
C {lab_pin.sym} 4060 15160 0 0 {name=l12265 lab=VSS}
C {bitcell_6t.sym} 4200 15200 0 0 {name=Xr76c21}
N 4160 15240 4140 15240 {}
C {lab_pin.sym} 4140 15240 0 0 {name=l12266 lab=BL21}
N 4160 15200 4140 15200 {}
C {lab_pin.sym} 4140 15200 0 0 {name=l12267 lab=BLB21}
N 4160 15160 4140 15160 {}
C {lab_pin.sym} 4140 15160 0 0 {name=l12268 lab=WL76}
N 4240 15240 4260 15240 {}
C {lab_pin.sym} 4260 15240 0 0 {name=l12269 lab=VDD}
N 4240 15160 4260 15160 {}
C {lab_pin.sym} 4260 15160 0 0 {name=l12270 lab=VSS}
C {bitcell_6t.sym} 4400 15200 0 0 {name=Xr76c22}
N 4360 15240 4340 15240 {}
C {lab_pin.sym} 4340 15240 0 0 {name=l12271 lab=BL22}
N 4360 15200 4340 15200 {}
C {lab_pin.sym} 4340 15200 0 0 {name=l12272 lab=BLB22}
N 4360 15160 4340 15160 {}
C {lab_pin.sym} 4340 15160 0 0 {name=l12273 lab=WL76}
N 4440 15240 4460 15240 {}
C {lab_pin.sym} 4460 15240 0 0 {name=l12274 lab=VDD}
N 4440 15160 4460 15160 {}
C {lab_pin.sym} 4460 15160 0 0 {name=l12275 lab=VSS}
C {bitcell_6t.sym} 4600 15200 0 0 {name=Xr76c23}
N 4560 15240 4540 15240 {}
C {lab_pin.sym} 4540 15240 0 0 {name=l12276 lab=BL23}
N 4560 15200 4540 15200 {}
C {lab_pin.sym} 4540 15200 0 0 {name=l12277 lab=BLB23}
N 4560 15160 4540 15160 {}
C {lab_pin.sym} 4540 15160 0 0 {name=l12278 lab=WL76}
N 4640 15240 4660 15240 {}
C {lab_pin.sym} 4660 15240 0 0 {name=l12279 lab=VDD}
N 4640 15160 4660 15160 {}
C {lab_pin.sym} 4660 15160 0 0 {name=l12280 lab=VSS}
C {bitcell_6t.sym} 4800 15200 0 0 {name=Xr76c24}
N 4760 15240 4740 15240 {}
C {lab_pin.sym} 4740 15240 0 0 {name=l12281 lab=BL24}
N 4760 15200 4740 15200 {}
C {lab_pin.sym} 4740 15200 0 0 {name=l12282 lab=BLB24}
N 4760 15160 4740 15160 {}
C {lab_pin.sym} 4740 15160 0 0 {name=l12283 lab=WL76}
N 4840 15240 4860 15240 {}
C {lab_pin.sym} 4860 15240 0 0 {name=l12284 lab=VDD}
N 4840 15160 4860 15160 {}
C {lab_pin.sym} 4860 15160 0 0 {name=l12285 lab=VSS}
C {bitcell_6t.sym} 5000 15200 0 0 {name=Xr76c25}
N 4960 15240 4940 15240 {}
C {lab_pin.sym} 4940 15240 0 0 {name=l12286 lab=BL25}
N 4960 15200 4940 15200 {}
C {lab_pin.sym} 4940 15200 0 0 {name=l12287 lab=BLB25}
N 4960 15160 4940 15160 {}
C {lab_pin.sym} 4940 15160 0 0 {name=l12288 lab=WL76}
N 5040 15240 5060 15240 {}
C {lab_pin.sym} 5060 15240 0 0 {name=l12289 lab=VDD}
N 5040 15160 5060 15160 {}
C {lab_pin.sym} 5060 15160 0 0 {name=l12290 lab=VSS}
C {bitcell_6t.sym} 5200 15200 0 0 {name=Xr76c26}
N 5160 15240 5140 15240 {}
C {lab_pin.sym} 5140 15240 0 0 {name=l12291 lab=BL26}
N 5160 15200 5140 15200 {}
C {lab_pin.sym} 5140 15200 0 0 {name=l12292 lab=BLB26}
N 5160 15160 5140 15160 {}
C {lab_pin.sym} 5140 15160 0 0 {name=l12293 lab=WL76}
N 5240 15240 5260 15240 {}
C {lab_pin.sym} 5260 15240 0 0 {name=l12294 lab=VDD}
N 5240 15160 5260 15160 {}
C {lab_pin.sym} 5260 15160 0 0 {name=l12295 lab=VSS}
C {bitcell_6t.sym} 5400 15200 0 0 {name=Xr76c27}
N 5360 15240 5340 15240 {}
C {lab_pin.sym} 5340 15240 0 0 {name=l12296 lab=BL27}
N 5360 15200 5340 15200 {}
C {lab_pin.sym} 5340 15200 0 0 {name=l12297 lab=BLB27}
N 5360 15160 5340 15160 {}
C {lab_pin.sym} 5340 15160 0 0 {name=l12298 lab=WL76}
N 5440 15240 5460 15240 {}
C {lab_pin.sym} 5460 15240 0 0 {name=l12299 lab=VDD}
N 5440 15160 5460 15160 {}
C {lab_pin.sym} 5460 15160 0 0 {name=l12300 lab=VSS}
C {bitcell_6t.sym} 5600 15200 0 0 {name=Xr76c28}
N 5560 15240 5540 15240 {}
C {lab_pin.sym} 5540 15240 0 0 {name=l12301 lab=BL28}
N 5560 15200 5540 15200 {}
C {lab_pin.sym} 5540 15200 0 0 {name=l12302 lab=BLB28}
N 5560 15160 5540 15160 {}
C {lab_pin.sym} 5540 15160 0 0 {name=l12303 lab=WL76}
N 5640 15240 5660 15240 {}
C {lab_pin.sym} 5660 15240 0 0 {name=l12304 lab=VDD}
N 5640 15160 5660 15160 {}
C {lab_pin.sym} 5660 15160 0 0 {name=l12305 lab=VSS}
C {bitcell_6t.sym} 5800 15200 0 0 {name=Xr76c29}
N 5760 15240 5740 15240 {}
C {lab_pin.sym} 5740 15240 0 0 {name=l12306 lab=BL29}
N 5760 15200 5740 15200 {}
C {lab_pin.sym} 5740 15200 0 0 {name=l12307 lab=BLB29}
N 5760 15160 5740 15160 {}
C {lab_pin.sym} 5740 15160 0 0 {name=l12308 lab=WL76}
N 5840 15240 5860 15240 {}
C {lab_pin.sym} 5860 15240 0 0 {name=l12309 lab=VDD}
N 5840 15160 5860 15160 {}
C {lab_pin.sym} 5860 15160 0 0 {name=l12310 lab=VSS}
C {bitcell_6t.sym} 6000 15200 0 0 {name=Xr76c30}
N 5960 15240 5940 15240 {}
C {lab_pin.sym} 5940 15240 0 0 {name=l12311 lab=BL30}
N 5960 15200 5940 15200 {}
C {lab_pin.sym} 5940 15200 0 0 {name=l12312 lab=BLB30}
N 5960 15160 5940 15160 {}
C {lab_pin.sym} 5940 15160 0 0 {name=l12313 lab=WL76}
N 6040 15240 6060 15240 {}
C {lab_pin.sym} 6060 15240 0 0 {name=l12314 lab=VDD}
N 6040 15160 6060 15160 {}
C {lab_pin.sym} 6060 15160 0 0 {name=l12315 lab=VSS}
C {bitcell_6t.sym} 6200 15200 0 0 {name=Xr76c31}
N 6160 15240 6140 15240 {}
C {lab_pin.sym} 6140 15240 0 0 {name=l12316 lab=BL31}
N 6160 15200 6140 15200 {}
C {lab_pin.sym} 6140 15200 0 0 {name=l12317 lab=BLB31}
N 6160 15160 6140 15160 {}
C {lab_pin.sym} 6140 15160 0 0 {name=l12318 lab=WL76}
N 6240 15240 6260 15240 {}
C {lab_pin.sym} 6260 15240 0 0 {name=l12319 lab=VDD}
N 6240 15160 6260 15160 {}
C {lab_pin.sym} 6260 15160 0 0 {name=l12320 lab=VSS}
C {bitcell_6t.sym} 0 15400 0 0 {name=Xr77c0}
N -40 15440 -60 15440 {}
C {lab_pin.sym} -60 15440 0 0 {name=l12321 lab=BL0}
N -40 15400 -60 15400 {}
C {lab_pin.sym} -60 15400 0 0 {name=l12322 lab=BLB0}
N -40 15360 -60 15360 {}
C {lab_pin.sym} -60 15360 0 0 {name=l12323 lab=WL77}
N 40 15440 60 15440 {}
C {lab_pin.sym} 60 15440 0 0 {name=l12324 lab=VDD}
N 40 15360 60 15360 {}
C {lab_pin.sym} 60 15360 0 0 {name=l12325 lab=VSS}
C {bitcell_6t.sym} 200 15400 0 0 {name=Xr77c1}
N 160 15440 140 15440 {}
C {lab_pin.sym} 140 15440 0 0 {name=l12326 lab=BL1}
N 160 15400 140 15400 {}
C {lab_pin.sym} 140 15400 0 0 {name=l12327 lab=BLB1}
N 160 15360 140 15360 {}
C {lab_pin.sym} 140 15360 0 0 {name=l12328 lab=WL77}
N 240 15440 260 15440 {}
C {lab_pin.sym} 260 15440 0 0 {name=l12329 lab=VDD}
N 240 15360 260 15360 {}
C {lab_pin.sym} 260 15360 0 0 {name=l12330 lab=VSS}
C {bitcell_6t.sym} 400 15400 0 0 {name=Xr77c2}
N 360 15440 340 15440 {}
C {lab_pin.sym} 340 15440 0 0 {name=l12331 lab=BL2}
N 360 15400 340 15400 {}
C {lab_pin.sym} 340 15400 0 0 {name=l12332 lab=BLB2}
N 360 15360 340 15360 {}
C {lab_pin.sym} 340 15360 0 0 {name=l12333 lab=WL77}
N 440 15440 460 15440 {}
C {lab_pin.sym} 460 15440 0 0 {name=l12334 lab=VDD}
N 440 15360 460 15360 {}
C {lab_pin.sym} 460 15360 0 0 {name=l12335 lab=VSS}
C {bitcell_6t.sym} 600 15400 0 0 {name=Xr77c3}
N 560 15440 540 15440 {}
C {lab_pin.sym} 540 15440 0 0 {name=l12336 lab=BL3}
N 560 15400 540 15400 {}
C {lab_pin.sym} 540 15400 0 0 {name=l12337 lab=BLB3}
N 560 15360 540 15360 {}
C {lab_pin.sym} 540 15360 0 0 {name=l12338 lab=WL77}
N 640 15440 660 15440 {}
C {lab_pin.sym} 660 15440 0 0 {name=l12339 lab=VDD}
N 640 15360 660 15360 {}
C {lab_pin.sym} 660 15360 0 0 {name=l12340 lab=VSS}
C {bitcell_6t.sym} 800 15400 0 0 {name=Xr77c4}
N 760 15440 740 15440 {}
C {lab_pin.sym} 740 15440 0 0 {name=l12341 lab=BL4}
N 760 15400 740 15400 {}
C {lab_pin.sym} 740 15400 0 0 {name=l12342 lab=BLB4}
N 760 15360 740 15360 {}
C {lab_pin.sym} 740 15360 0 0 {name=l12343 lab=WL77}
N 840 15440 860 15440 {}
C {lab_pin.sym} 860 15440 0 0 {name=l12344 lab=VDD}
N 840 15360 860 15360 {}
C {lab_pin.sym} 860 15360 0 0 {name=l12345 lab=VSS}
C {bitcell_6t.sym} 1000 15400 0 0 {name=Xr77c5}
N 960 15440 940 15440 {}
C {lab_pin.sym} 940 15440 0 0 {name=l12346 lab=BL5}
N 960 15400 940 15400 {}
C {lab_pin.sym} 940 15400 0 0 {name=l12347 lab=BLB5}
N 960 15360 940 15360 {}
C {lab_pin.sym} 940 15360 0 0 {name=l12348 lab=WL77}
N 1040 15440 1060 15440 {}
C {lab_pin.sym} 1060 15440 0 0 {name=l12349 lab=VDD}
N 1040 15360 1060 15360 {}
C {lab_pin.sym} 1060 15360 0 0 {name=l12350 lab=VSS}
C {bitcell_6t.sym} 1200 15400 0 0 {name=Xr77c6}
N 1160 15440 1140 15440 {}
C {lab_pin.sym} 1140 15440 0 0 {name=l12351 lab=BL6}
N 1160 15400 1140 15400 {}
C {lab_pin.sym} 1140 15400 0 0 {name=l12352 lab=BLB6}
N 1160 15360 1140 15360 {}
C {lab_pin.sym} 1140 15360 0 0 {name=l12353 lab=WL77}
N 1240 15440 1260 15440 {}
C {lab_pin.sym} 1260 15440 0 0 {name=l12354 lab=VDD}
N 1240 15360 1260 15360 {}
C {lab_pin.sym} 1260 15360 0 0 {name=l12355 lab=VSS}
C {bitcell_6t.sym} 1400 15400 0 0 {name=Xr77c7}
N 1360 15440 1340 15440 {}
C {lab_pin.sym} 1340 15440 0 0 {name=l12356 lab=BL7}
N 1360 15400 1340 15400 {}
C {lab_pin.sym} 1340 15400 0 0 {name=l12357 lab=BLB7}
N 1360 15360 1340 15360 {}
C {lab_pin.sym} 1340 15360 0 0 {name=l12358 lab=WL77}
N 1440 15440 1460 15440 {}
C {lab_pin.sym} 1460 15440 0 0 {name=l12359 lab=VDD}
N 1440 15360 1460 15360 {}
C {lab_pin.sym} 1460 15360 0 0 {name=l12360 lab=VSS}
C {bitcell_6t.sym} 1600 15400 0 0 {name=Xr77c8}
N 1560 15440 1540 15440 {}
C {lab_pin.sym} 1540 15440 0 0 {name=l12361 lab=BL8}
N 1560 15400 1540 15400 {}
C {lab_pin.sym} 1540 15400 0 0 {name=l12362 lab=BLB8}
N 1560 15360 1540 15360 {}
C {lab_pin.sym} 1540 15360 0 0 {name=l12363 lab=WL77}
N 1640 15440 1660 15440 {}
C {lab_pin.sym} 1660 15440 0 0 {name=l12364 lab=VDD}
N 1640 15360 1660 15360 {}
C {lab_pin.sym} 1660 15360 0 0 {name=l12365 lab=VSS}
C {bitcell_6t.sym} 1800 15400 0 0 {name=Xr77c9}
N 1760 15440 1740 15440 {}
C {lab_pin.sym} 1740 15440 0 0 {name=l12366 lab=BL9}
N 1760 15400 1740 15400 {}
C {lab_pin.sym} 1740 15400 0 0 {name=l12367 lab=BLB9}
N 1760 15360 1740 15360 {}
C {lab_pin.sym} 1740 15360 0 0 {name=l12368 lab=WL77}
N 1840 15440 1860 15440 {}
C {lab_pin.sym} 1860 15440 0 0 {name=l12369 lab=VDD}
N 1840 15360 1860 15360 {}
C {lab_pin.sym} 1860 15360 0 0 {name=l12370 lab=VSS}
C {bitcell_6t.sym} 2000 15400 0 0 {name=Xr77c10}
N 1960 15440 1940 15440 {}
C {lab_pin.sym} 1940 15440 0 0 {name=l12371 lab=BL10}
N 1960 15400 1940 15400 {}
C {lab_pin.sym} 1940 15400 0 0 {name=l12372 lab=BLB10}
N 1960 15360 1940 15360 {}
C {lab_pin.sym} 1940 15360 0 0 {name=l12373 lab=WL77}
N 2040 15440 2060 15440 {}
C {lab_pin.sym} 2060 15440 0 0 {name=l12374 lab=VDD}
N 2040 15360 2060 15360 {}
C {lab_pin.sym} 2060 15360 0 0 {name=l12375 lab=VSS}
C {bitcell_6t.sym} 2200 15400 0 0 {name=Xr77c11}
N 2160 15440 2140 15440 {}
C {lab_pin.sym} 2140 15440 0 0 {name=l12376 lab=BL11}
N 2160 15400 2140 15400 {}
C {lab_pin.sym} 2140 15400 0 0 {name=l12377 lab=BLB11}
N 2160 15360 2140 15360 {}
C {lab_pin.sym} 2140 15360 0 0 {name=l12378 lab=WL77}
N 2240 15440 2260 15440 {}
C {lab_pin.sym} 2260 15440 0 0 {name=l12379 lab=VDD}
N 2240 15360 2260 15360 {}
C {lab_pin.sym} 2260 15360 0 0 {name=l12380 lab=VSS}
C {bitcell_6t.sym} 2400 15400 0 0 {name=Xr77c12}
N 2360 15440 2340 15440 {}
C {lab_pin.sym} 2340 15440 0 0 {name=l12381 lab=BL12}
N 2360 15400 2340 15400 {}
C {lab_pin.sym} 2340 15400 0 0 {name=l12382 lab=BLB12}
N 2360 15360 2340 15360 {}
C {lab_pin.sym} 2340 15360 0 0 {name=l12383 lab=WL77}
N 2440 15440 2460 15440 {}
C {lab_pin.sym} 2460 15440 0 0 {name=l12384 lab=VDD}
N 2440 15360 2460 15360 {}
C {lab_pin.sym} 2460 15360 0 0 {name=l12385 lab=VSS}
C {bitcell_6t.sym} 2600 15400 0 0 {name=Xr77c13}
N 2560 15440 2540 15440 {}
C {lab_pin.sym} 2540 15440 0 0 {name=l12386 lab=BL13}
N 2560 15400 2540 15400 {}
C {lab_pin.sym} 2540 15400 0 0 {name=l12387 lab=BLB13}
N 2560 15360 2540 15360 {}
C {lab_pin.sym} 2540 15360 0 0 {name=l12388 lab=WL77}
N 2640 15440 2660 15440 {}
C {lab_pin.sym} 2660 15440 0 0 {name=l12389 lab=VDD}
N 2640 15360 2660 15360 {}
C {lab_pin.sym} 2660 15360 0 0 {name=l12390 lab=VSS}
C {bitcell_6t.sym} 2800 15400 0 0 {name=Xr77c14}
N 2760 15440 2740 15440 {}
C {lab_pin.sym} 2740 15440 0 0 {name=l12391 lab=BL14}
N 2760 15400 2740 15400 {}
C {lab_pin.sym} 2740 15400 0 0 {name=l12392 lab=BLB14}
N 2760 15360 2740 15360 {}
C {lab_pin.sym} 2740 15360 0 0 {name=l12393 lab=WL77}
N 2840 15440 2860 15440 {}
C {lab_pin.sym} 2860 15440 0 0 {name=l12394 lab=VDD}
N 2840 15360 2860 15360 {}
C {lab_pin.sym} 2860 15360 0 0 {name=l12395 lab=VSS}
C {bitcell_6t.sym} 3000 15400 0 0 {name=Xr77c15}
N 2960 15440 2940 15440 {}
C {lab_pin.sym} 2940 15440 0 0 {name=l12396 lab=BL15}
N 2960 15400 2940 15400 {}
C {lab_pin.sym} 2940 15400 0 0 {name=l12397 lab=BLB15}
N 2960 15360 2940 15360 {}
C {lab_pin.sym} 2940 15360 0 0 {name=l12398 lab=WL77}
N 3040 15440 3060 15440 {}
C {lab_pin.sym} 3060 15440 0 0 {name=l12399 lab=VDD}
N 3040 15360 3060 15360 {}
C {lab_pin.sym} 3060 15360 0 0 {name=l12400 lab=VSS}
C {bitcell_6t.sym} 3200 15400 0 0 {name=Xr77c16}
N 3160 15440 3140 15440 {}
C {lab_pin.sym} 3140 15440 0 0 {name=l12401 lab=BL16}
N 3160 15400 3140 15400 {}
C {lab_pin.sym} 3140 15400 0 0 {name=l12402 lab=BLB16}
N 3160 15360 3140 15360 {}
C {lab_pin.sym} 3140 15360 0 0 {name=l12403 lab=WL77}
N 3240 15440 3260 15440 {}
C {lab_pin.sym} 3260 15440 0 0 {name=l12404 lab=VDD}
N 3240 15360 3260 15360 {}
C {lab_pin.sym} 3260 15360 0 0 {name=l12405 lab=VSS}
C {bitcell_6t.sym} 3400 15400 0 0 {name=Xr77c17}
N 3360 15440 3340 15440 {}
C {lab_pin.sym} 3340 15440 0 0 {name=l12406 lab=BL17}
N 3360 15400 3340 15400 {}
C {lab_pin.sym} 3340 15400 0 0 {name=l12407 lab=BLB17}
N 3360 15360 3340 15360 {}
C {lab_pin.sym} 3340 15360 0 0 {name=l12408 lab=WL77}
N 3440 15440 3460 15440 {}
C {lab_pin.sym} 3460 15440 0 0 {name=l12409 lab=VDD}
N 3440 15360 3460 15360 {}
C {lab_pin.sym} 3460 15360 0 0 {name=l12410 lab=VSS}
C {bitcell_6t.sym} 3600 15400 0 0 {name=Xr77c18}
N 3560 15440 3540 15440 {}
C {lab_pin.sym} 3540 15440 0 0 {name=l12411 lab=BL18}
N 3560 15400 3540 15400 {}
C {lab_pin.sym} 3540 15400 0 0 {name=l12412 lab=BLB18}
N 3560 15360 3540 15360 {}
C {lab_pin.sym} 3540 15360 0 0 {name=l12413 lab=WL77}
N 3640 15440 3660 15440 {}
C {lab_pin.sym} 3660 15440 0 0 {name=l12414 lab=VDD}
N 3640 15360 3660 15360 {}
C {lab_pin.sym} 3660 15360 0 0 {name=l12415 lab=VSS}
C {bitcell_6t.sym} 3800 15400 0 0 {name=Xr77c19}
N 3760 15440 3740 15440 {}
C {lab_pin.sym} 3740 15440 0 0 {name=l12416 lab=BL19}
N 3760 15400 3740 15400 {}
C {lab_pin.sym} 3740 15400 0 0 {name=l12417 lab=BLB19}
N 3760 15360 3740 15360 {}
C {lab_pin.sym} 3740 15360 0 0 {name=l12418 lab=WL77}
N 3840 15440 3860 15440 {}
C {lab_pin.sym} 3860 15440 0 0 {name=l12419 lab=VDD}
N 3840 15360 3860 15360 {}
C {lab_pin.sym} 3860 15360 0 0 {name=l12420 lab=VSS}
C {bitcell_6t.sym} 4000 15400 0 0 {name=Xr77c20}
N 3960 15440 3940 15440 {}
C {lab_pin.sym} 3940 15440 0 0 {name=l12421 lab=BL20}
N 3960 15400 3940 15400 {}
C {lab_pin.sym} 3940 15400 0 0 {name=l12422 lab=BLB20}
N 3960 15360 3940 15360 {}
C {lab_pin.sym} 3940 15360 0 0 {name=l12423 lab=WL77}
N 4040 15440 4060 15440 {}
C {lab_pin.sym} 4060 15440 0 0 {name=l12424 lab=VDD}
N 4040 15360 4060 15360 {}
C {lab_pin.sym} 4060 15360 0 0 {name=l12425 lab=VSS}
C {bitcell_6t.sym} 4200 15400 0 0 {name=Xr77c21}
N 4160 15440 4140 15440 {}
C {lab_pin.sym} 4140 15440 0 0 {name=l12426 lab=BL21}
N 4160 15400 4140 15400 {}
C {lab_pin.sym} 4140 15400 0 0 {name=l12427 lab=BLB21}
N 4160 15360 4140 15360 {}
C {lab_pin.sym} 4140 15360 0 0 {name=l12428 lab=WL77}
N 4240 15440 4260 15440 {}
C {lab_pin.sym} 4260 15440 0 0 {name=l12429 lab=VDD}
N 4240 15360 4260 15360 {}
C {lab_pin.sym} 4260 15360 0 0 {name=l12430 lab=VSS}
C {bitcell_6t.sym} 4400 15400 0 0 {name=Xr77c22}
N 4360 15440 4340 15440 {}
C {lab_pin.sym} 4340 15440 0 0 {name=l12431 lab=BL22}
N 4360 15400 4340 15400 {}
C {lab_pin.sym} 4340 15400 0 0 {name=l12432 lab=BLB22}
N 4360 15360 4340 15360 {}
C {lab_pin.sym} 4340 15360 0 0 {name=l12433 lab=WL77}
N 4440 15440 4460 15440 {}
C {lab_pin.sym} 4460 15440 0 0 {name=l12434 lab=VDD}
N 4440 15360 4460 15360 {}
C {lab_pin.sym} 4460 15360 0 0 {name=l12435 lab=VSS}
C {bitcell_6t.sym} 4600 15400 0 0 {name=Xr77c23}
N 4560 15440 4540 15440 {}
C {lab_pin.sym} 4540 15440 0 0 {name=l12436 lab=BL23}
N 4560 15400 4540 15400 {}
C {lab_pin.sym} 4540 15400 0 0 {name=l12437 lab=BLB23}
N 4560 15360 4540 15360 {}
C {lab_pin.sym} 4540 15360 0 0 {name=l12438 lab=WL77}
N 4640 15440 4660 15440 {}
C {lab_pin.sym} 4660 15440 0 0 {name=l12439 lab=VDD}
N 4640 15360 4660 15360 {}
C {lab_pin.sym} 4660 15360 0 0 {name=l12440 lab=VSS}
C {bitcell_6t.sym} 4800 15400 0 0 {name=Xr77c24}
N 4760 15440 4740 15440 {}
C {lab_pin.sym} 4740 15440 0 0 {name=l12441 lab=BL24}
N 4760 15400 4740 15400 {}
C {lab_pin.sym} 4740 15400 0 0 {name=l12442 lab=BLB24}
N 4760 15360 4740 15360 {}
C {lab_pin.sym} 4740 15360 0 0 {name=l12443 lab=WL77}
N 4840 15440 4860 15440 {}
C {lab_pin.sym} 4860 15440 0 0 {name=l12444 lab=VDD}
N 4840 15360 4860 15360 {}
C {lab_pin.sym} 4860 15360 0 0 {name=l12445 lab=VSS}
C {bitcell_6t.sym} 5000 15400 0 0 {name=Xr77c25}
N 4960 15440 4940 15440 {}
C {lab_pin.sym} 4940 15440 0 0 {name=l12446 lab=BL25}
N 4960 15400 4940 15400 {}
C {lab_pin.sym} 4940 15400 0 0 {name=l12447 lab=BLB25}
N 4960 15360 4940 15360 {}
C {lab_pin.sym} 4940 15360 0 0 {name=l12448 lab=WL77}
N 5040 15440 5060 15440 {}
C {lab_pin.sym} 5060 15440 0 0 {name=l12449 lab=VDD}
N 5040 15360 5060 15360 {}
C {lab_pin.sym} 5060 15360 0 0 {name=l12450 lab=VSS}
C {bitcell_6t.sym} 5200 15400 0 0 {name=Xr77c26}
N 5160 15440 5140 15440 {}
C {lab_pin.sym} 5140 15440 0 0 {name=l12451 lab=BL26}
N 5160 15400 5140 15400 {}
C {lab_pin.sym} 5140 15400 0 0 {name=l12452 lab=BLB26}
N 5160 15360 5140 15360 {}
C {lab_pin.sym} 5140 15360 0 0 {name=l12453 lab=WL77}
N 5240 15440 5260 15440 {}
C {lab_pin.sym} 5260 15440 0 0 {name=l12454 lab=VDD}
N 5240 15360 5260 15360 {}
C {lab_pin.sym} 5260 15360 0 0 {name=l12455 lab=VSS}
C {bitcell_6t.sym} 5400 15400 0 0 {name=Xr77c27}
N 5360 15440 5340 15440 {}
C {lab_pin.sym} 5340 15440 0 0 {name=l12456 lab=BL27}
N 5360 15400 5340 15400 {}
C {lab_pin.sym} 5340 15400 0 0 {name=l12457 lab=BLB27}
N 5360 15360 5340 15360 {}
C {lab_pin.sym} 5340 15360 0 0 {name=l12458 lab=WL77}
N 5440 15440 5460 15440 {}
C {lab_pin.sym} 5460 15440 0 0 {name=l12459 lab=VDD}
N 5440 15360 5460 15360 {}
C {lab_pin.sym} 5460 15360 0 0 {name=l12460 lab=VSS}
C {bitcell_6t.sym} 5600 15400 0 0 {name=Xr77c28}
N 5560 15440 5540 15440 {}
C {lab_pin.sym} 5540 15440 0 0 {name=l12461 lab=BL28}
N 5560 15400 5540 15400 {}
C {lab_pin.sym} 5540 15400 0 0 {name=l12462 lab=BLB28}
N 5560 15360 5540 15360 {}
C {lab_pin.sym} 5540 15360 0 0 {name=l12463 lab=WL77}
N 5640 15440 5660 15440 {}
C {lab_pin.sym} 5660 15440 0 0 {name=l12464 lab=VDD}
N 5640 15360 5660 15360 {}
C {lab_pin.sym} 5660 15360 0 0 {name=l12465 lab=VSS}
C {bitcell_6t.sym} 5800 15400 0 0 {name=Xr77c29}
N 5760 15440 5740 15440 {}
C {lab_pin.sym} 5740 15440 0 0 {name=l12466 lab=BL29}
N 5760 15400 5740 15400 {}
C {lab_pin.sym} 5740 15400 0 0 {name=l12467 lab=BLB29}
N 5760 15360 5740 15360 {}
C {lab_pin.sym} 5740 15360 0 0 {name=l12468 lab=WL77}
N 5840 15440 5860 15440 {}
C {lab_pin.sym} 5860 15440 0 0 {name=l12469 lab=VDD}
N 5840 15360 5860 15360 {}
C {lab_pin.sym} 5860 15360 0 0 {name=l12470 lab=VSS}
C {bitcell_6t.sym} 6000 15400 0 0 {name=Xr77c30}
N 5960 15440 5940 15440 {}
C {lab_pin.sym} 5940 15440 0 0 {name=l12471 lab=BL30}
N 5960 15400 5940 15400 {}
C {lab_pin.sym} 5940 15400 0 0 {name=l12472 lab=BLB30}
N 5960 15360 5940 15360 {}
C {lab_pin.sym} 5940 15360 0 0 {name=l12473 lab=WL77}
N 6040 15440 6060 15440 {}
C {lab_pin.sym} 6060 15440 0 0 {name=l12474 lab=VDD}
N 6040 15360 6060 15360 {}
C {lab_pin.sym} 6060 15360 0 0 {name=l12475 lab=VSS}
C {bitcell_6t.sym} 6200 15400 0 0 {name=Xr77c31}
N 6160 15440 6140 15440 {}
C {lab_pin.sym} 6140 15440 0 0 {name=l12476 lab=BL31}
N 6160 15400 6140 15400 {}
C {lab_pin.sym} 6140 15400 0 0 {name=l12477 lab=BLB31}
N 6160 15360 6140 15360 {}
C {lab_pin.sym} 6140 15360 0 0 {name=l12478 lab=WL77}
N 6240 15440 6260 15440 {}
C {lab_pin.sym} 6260 15440 0 0 {name=l12479 lab=VDD}
N 6240 15360 6260 15360 {}
C {lab_pin.sym} 6260 15360 0 0 {name=l12480 lab=VSS}
C {bitcell_6t.sym} 0 15600 0 0 {name=Xr78c0}
N -40 15640 -60 15640 {}
C {lab_pin.sym} -60 15640 0 0 {name=l12481 lab=BL0}
N -40 15600 -60 15600 {}
C {lab_pin.sym} -60 15600 0 0 {name=l12482 lab=BLB0}
N -40 15560 -60 15560 {}
C {lab_pin.sym} -60 15560 0 0 {name=l12483 lab=WL78}
N 40 15640 60 15640 {}
C {lab_pin.sym} 60 15640 0 0 {name=l12484 lab=VDD}
N 40 15560 60 15560 {}
C {lab_pin.sym} 60 15560 0 0 {name=l12485 lab=VSS}
C {bitcell_6t.sym} 200 15600 0 0 {name=Xr78c1}
N 160 15640 140 15640 {}
C {lab_pin.sym} 140 15640 0 0 {name=l12486 lab=BL1}
N 160 15600 140 15600 {}
C {lab_pin.sym} 140 15600 0 0 {name=l12487 lab=BLB1}
N 160 15560 140 15560 {}
C {lab_pin.sym} 140 15560 0 0 {name=l12488 lab=WL78}
N 240 15640 260 15640 {}
C {lab_pin.sym} 260 15640 0 0 {name=l12489 lab=VDD}
N 240 15560 260 15560 {}
C {lab_pin.sym} 260 15560 0 0 {name=l12490 lab=VSS}
C {bitcell_6t.sym} 400 15600 0 0 {name=Xr78c2}
N 360 15640 340 15640 {}
C {lab_pin.sym} 340 15640 0 0 {name=l12491 lab=BL2}
N 360 15600 340 15600 {}
C {lab_pin.sym} 340 15600 0 0 {name=l12492 lab=BLB2}
N 360 15560 340 15560 {}
C {lab_pin.sym} 340 15560 0 0 {name=l12493 lab=WL78}
N 440 15640 460 15640 {}
C {lab_pin.sym} 460 15640 0 0 {name=l12494 lab=VDD}
N 440 15560 460 15560 {}
C {lab_pin.sym} 460 15560 0 0 {name=l12495 lab=VSS}
C {bitcell_6t.sym} 600 15600 0 0 {name=Xr78c3}
N 560 15640 540 15640 {}
C {lab_pin.sym} 540 15640 0 0 {name=l12496 lab=BL3}
N 560 15600 540 15600 {}
C {lab_pin.sym} 540 15600 0 0 {name=l12497 lab=BLB3}
N 560 15560 540 15560 {}
C {lab_pin.sym} 540 15560 0 0 {name=l12498 lab=WL78}
N 640 15640 660 15640 {}
C {lab_pin.sym} 660 15640 0 0 {name=l12499 lab=VDD}
N 640 15560 660 15560 {}
C {lab_pin.sym} 660 15560 0 0 {name=l12500 lab=VSS}
C {bitcell_6t.sym} 800 15600 0 0 {name=Xr78c4}
N 760 15640 740 15640 {}
C {lab_pin.sym} 740 15640 0 0 {name=l12501 lab=BL4}
N 760 15600 740 15600 {}
C {lab_pin.sym} 740 15600 0 0 {name=l12502 lab=BLB4}
N 760 15560 740 15560 {}
C {lab_pin.sym} 740 15560 0 0 {name=l12503 lab=WL78}
N 840 15640 860 15640 {}
C {lab_pin.sym} 860 15640 0 0 {name=l12504 lab=VDD}
N 840 15560 860 15560 {}
C {lab_pin.sym} 860 15560 0 0 {name=l12505 lab=VSS}
C {bitcell_6t.sym} 1000 15600 0 0 {name=Xr78c5}
N 960 15640 940 15640 {}
C {lab_pin.sym} 940 15640 0 0 {name=l12506 lab=BL5}
N 960 15600 940 15600 {}
C {lab_pin.sym} 940 15600 0 0 {name=l12507 lab=BLB5}
N 960 15560 940 15560 {}
C {lab_pin.sym} 940 15560 0 0 {name=l12508 lab=WL78}
N 1040 15640 1060 15640 {}
C {lab_pin.sym} 1060 15640 0 0 {name=l12509 lab=VDD}
N 1040 15560 1060 15560 {}
C {lab_pin.sym} 1060 15560 0 0 {name=l12510 lab=VSS}
C {bitcell_6t.sym} 1200 15600 0 0 {name=Xr78c6}
N 1160 15640 1140 15640 {}
C {lab_pin.sym} 1140 15640 0 0 {name=l12511 lab=BL6}
N 1160 15600 1140 15600 {}
C {lab_pin.sym} 1140 15600 0 0 {name=l12512 lab=BLB6}
N 1160 15560 1140 15560 {}
C {lab_pin.sym} 1140 15560 0 0 {name=l12513 lab=WL78}
N 1240 15640 1260 15640 {}
C {lab_pin.sym} 1260 15640 0 0 {name=l12514 lab=VDD}
N 1240 15560 1260 15560 {}
C {lab_pin.sym} 1260 15560 0 0 {name=l12515 lab=VSS}
C {bitcell_6t.sym} 1400 15600 0 0 {name=Xr78c7}
N 1360 15640 1340 15640 {}
C {lab_pin.sym} 1340 15640 0 0 {name=l12516 lab=BL7}
N 1360 15600 1340 15600 {}
C {lab_pin.sym} 1340 15600 0 0 {name=l12517 lab=BLB7}
N 1360 15560 1340 15560 {}
C {lab_pin.sym} 1340 15560 0 0 {name=l12518 lab=WL78}
N 1440 15640 1460 15640 {}
C {lab_pin.sym} 1460 15640 0 0 {name=l12519 lab=VDD}
N 1440 15560 1460 15560 {}
C {lab_pin.sym} 1460 15560 0 0 {name=l12520 lab=VSS}
C {bitcell_6t.sym} 1600 15600 0 0 {name=Xr78c8}
N 1560 15640 1540 15640 {}
C {lab_pin.sym} 1540 15640 0 0 {name=l12521 lab=BL8}
N 1560 15600 1540 15600 {}
C {lab_pin.sym} 1540 15600 0 0 {name=l12522 lab=BLB8}
N 1560 15560 1540 15560 {}
C {lab_pin.sym} 1540 15560 0 0 {name=l12523 lab=WL78}
N 1640 15640 1660 15640 {}
C {lab_pin.sym} 1660 15640 0 0 {name=l12524 lab=VDD}
N 1640 15560 1660 15560 {}
C {lab_pin.sym} 1660 15560 0 0 {name=l12525 lab=VSS}
C {bitcell_6t.sym} 1800 15600 0 0 {name=Xr78c9}
N 1760 15640 1740 15640 {}
C {lab_pin.sym} 1740 15640 0 0 {name=l12526 lab=BL9}
N 1760 15600 1740 15600 {}
C {lab_pin.sym} 1740 15600 0 0 {name=l12527 lab=BLB9}
N 1760 15560 1740 15560 {}
C {lab_pin.sym} 1740 15560 0 0 {name=l12528 lab=WL78}
N 1840 15640 1860 15640 {}
C {lab_pin.sym} 1860 15640 0 0 {name=l12529 lab=VDD}
N 1840 15560 1860 15560 {}
C {lab_pin.sym} 1860 15560 0 0 {name=l12530 lab=VSS}
C {bitcell_6t.sym} 2000 15600 0 0 {name=Xr78c10}
N 1960 15640 1940 15640 {}
C {lab_pin.sym} 1940 15640 0 0 {name=l12531 lab=BL10}
N 1960 15600 1940 15600 {}
C {lab_pin.sym} 1940 15600 0 0 {name=l12532 lab=BLB10}
N 1960 15560 1940 15560 {}
C {lab_pin.sym} 1940 15560 0 0 {name=l12533 lab=WL78}
N 2040 15640 2060 15640 {}
C {lab_pin.sym} 2060 15640 0 0 {name=l12534 lab=VDD}
N 2040 15560 2060 15560 {}
C {lab_pin.sym} 2060 15560 0 0 {name=l12535 lab=VSS}
C {bitcell_6t.sym} 2200 15600 0 0 {name=Xr78c11}
N 2160 15640 2140 15640 {}
C {lab_pin.sym} 2140 15640 0 0 {name=l12536 lab=BL11}
N 2160 15600 2140 15600 {}
C {lab_pin.sym} 2140 15600 0 0 {name=l12537 lab=BLB11}
N 2160 15560 2140 15560 {}
C {lab_pin.sym} 2140 15560 0 0 {name=l12538 lab=WL78}
N 2240 15640 2260 15640 {}
C {lab_pin.sym} 2260 15640 0 0 {name=l12539 lab=VDD}
N 2240 15560 2260 15560 {}
C {lab_pin.sym} 2260 15560 0 0 {name=l12540 lab=VSS}
C {bitcell_6t.sym} 2400 15600 0 0 {name=Xr78c12}
N 2360 15640 2340 15640 {}
C {lab_pin.sym} 2340 15640 0 0 {name=l12541 lab=BL12}
N 2360 15600 2340 15600 {}
C {lab_pin.sym} 2340 15600 0 0 {name=l12542 lab=BLB12}
N 2360 15560 2340 15560 {}
C {lab_pin.sym} 2340 15560 0 0 {name=l12543 lab=WL78}
N 2440 15640 2460 15640 {}
C {lab_pin.sym} 2460 15640 0 0 {name=l12544 lab=VDD}
N 2440 15560 2460 15560 {}
C {lab_pin.sym} 2460 15560 0 0 {name=l12545 lab=VSS}
C {bitcell_6t.sym} 2600 15600 0 0 {name=Xr78c13}
N 2560 15640 2540 15640 {}
C {lab_pin.sym} 2540 15640 0 0 {name=l12546 lab=BL13}
N 2560 15600 2540 15600 {}
C {lab_pin.sym} 2540 15600 0 0 {name=l12547 lab=BLB13}
N 2560 15560 2540 15560 {}
C {lab_pin.sym} 2540 15560 0 0 {name=l12548 lab=WL78}
N 2640 15640 2660 15640 {}
C {lab_pin.sym} 2660 15640 0 0 {name=l12549 lab=VDD}
N 2640 15560 2660 15560 {}
C {lab_pin.sym} 2660 15560 0 0 {name=l12550 lab=VSS}
C {bitcell_6t.sym} 2800 15600 0 0 {name=Xr78c14}
N 2760 15640 2740 15640 {}
C {lab_pin.sym} 2740 15640 0 0 {name=l12551 lab=BL14}
N 2760 15600 2740 15600 {}
C {lab_pin.sym} 2740 15600 0 0 {name=l12552 lab=BLB14}
N 2760 15560 2740 15560 {}
C {lab_pin.sym} 2740 15560 0 0 {name=l12553 lab=WL78}
N 2840 15640 2860 15640 {}
C {lab_pin.sym} 2860 15640 0 0 {name=l12554 lab=VDD}
N 2840 15560 2860 15560 {}
C {lab_pin.sym} 2860 15560 0 0 {name=l12555 lab=VSS}
C {bitcell_6t.sym} 3000 15600 0 0 {name=Xr78c15}
N 2960 15640 2940 15640 {}
C {lab_pin.sym} 2940 15640 0 0 {name=l12556 lab=BL15}
N 2960 15600 2940 15600 {}
C {lab_pin.sym} 2940 15600 0 0 {name=l12557 lab=BLB15}
N 2960 15560 2940 15560 {}
C {lab_pin.sym} 2940 15560 0 0 {name=l12558 lab=WL78}
N 3040 15640 3060 15640 {}
C {lab_pin.sym} 3060 15640 0 0 {name=l12559 lab=VDD}
N 3040 15560 3060 15560 {}
C {lab_pin.sym} 3060 15560 0 0 {name=l12560 lab=VSS}
C {bitcell_6t.sym} 3200 15600 0 0 {name=Xr78c16}
N 3160 15640 3140 15640 {}
C {lab_pin.sym} 3140 15640 0 0 {name=l12561 lab=BL16}
N 3160 15600 3140 15600 {}
C {lab_pin.sym} 3140 15600 0 0 {name=l12562 lab=BLB16}
N 3160 15560 3140 15560 {}
C {lab_pin.sym} 3140 15560 0 0 {name=l12563 lab=WL78}
N 3240 15640 3260 15640 {}
C {lab_pin.sym} 3260 15640 0 0 {name=l12564 lab=VDD}
N 3240 15560 3260 15560 {}
C {lab_pin.sym} 3260 15560 0 0 {name=l12565 lab=VSS}
C {bitcell_6t.sym} 3400 15600 0 0 {name=Xr78c17}
N 3360 15640 3340 15640 {}
C {lab_pin.sym} 3340 15640 0 0 {name=l12566 lab=BL17}
N 3360 15600 3340 15600 {}
C {lab_pin.sym} 3340 15600 0 0 {name=l12567 lab=BLB17}
N 3360 15560 3340 15560 {}
C {lab_pin.sym} 3340 15560 0 0 {name=l12568 lab=WL78}
N 3440 15640 3460 15640 {}
C {lab_pin.sym} 3460 15640 0 0 {name=l12569 lab=VDD}
N 3440 15560 3460 15560 {}
C {lab_pin.sym} 3460 15560 0 0 {name=l12570 lab=VSS}
C {bitcell_6t.sym} 3600 15600 0 0 {name=Xr78c18}
N 3560 15640 3540 15640 {}
C {lab_pin.sym} 3540 15640 0 0 {name=l12571 lab=BL18}
N 3560 15600 3540 15600 {}
C {lab_pin.sym} 3540 15600 0 0 {name=l12572 lab=BLB18}
N 3560 15560 3540 15560 {}
C {lab_pin.sym} 3540 15560 0 0 {name=l12573 lab=WL78}
N 3640 15640 3660 15640 {}
C {lab_pin.sym} 3660 15640 0 0 {name=l12574 lab=VDD}
N 3640 15560 3660 15560 {}
C {lab_pin.sym} 3660 15560 0 0 {name=l12575 lab=VSS}
C {bitcell_6t.sym} 3800 15600 0 0 {name=Xr78c19}
N 3760 15640 3740 15640 {}
C {lab_pin.sym} 3740 15640 0 0 {name=l12576 lab=BL19}
N 3760 15600 3740 15600 {}
C {lab_pin.sym} 3740 15600 0 0 {name=l12577 lab=BLB19}
N 3760 15560 3740 15560 {}
C {lab_pin.sym} 3740 15560 0 0 {name=l12578 lab=WL78}
N 3840 15640 3860 15640 {}
C {lab_pin.sym} 3860 15640 0 0 {name=l12579 lab=VDD}
N 3840 15560 3860 15560 {}
C {lab_pin.sym} 3860 15560 0 0 {name=l12580 lab=VSS}
C {bitcell_6t.sym} 4000 15600 0 0 {name=Xr78c20}
N 3960 15640 3940 15640 {}
C {lab_pin.sym} 3940 15640 0 0 {name=l12581 lab=BL20}
N 3960 15600 3940 15600 {}
C {lab_pin.sym} 3940 15600 0 0 {name=l12582 lab=BLB20}
N 3960 15560 3940 15560 {}
C {lab_pin.sym} 3940 15560 0 0 {name=l12583 lab=WL78}
N 4040 15640 4060 15640 {}
C {lab_pin.sym} 4060 15640 0 0 {name=l12584 lab=VDD}
N 4040 15560 4060 15560 {}
C {lab_pin.sym} 4060 15560 0 0 {name=l12585 lab=VSS}
C {bitcell_6t.sym} 4200 15600 0 0 {name=Xr78c21}
N 4160 15640 4140 15640 {}
C {lab_pin.sym} 4140 15640 0 0 {name=l12586 lab=BL21}
N 4160 15600 4140 15600 {}
C {lab_pin.sym} 4140 15600 0 0 {name=l12587 lab=BLB21}
N 4160 15560 4140 15560 {}
C {lab_pin.sym} 4140 15560 0 0 {name=l12588 lab=WL78}
N 4240 15640 4260 15640 {}
C {lab_pin.sym} 4260 15640 0 0 {name=l12589 lab=VDD}
N 4240 15560 4260 15560 {}
C {lab_pin.sym} 4260 15560 0 0 {name=l12590 lab=VSS}
C {bitcell_6t.sym} 4400 15600 0 0 {name=Xr78c22}
N 4360 15640 4340 15640 {}
C {lab_pin.sym} 4340 15640 0 0 {name=l12591 lab=BL22}
N 4360 15600 4340 15600 {}
C {lab_pin.sym} 4340 15600 0 0 {name=l12592 lab=BLB22}
N 4360 15560 4340 15560 {}
C {lab_pin.sym} 4340 15560 0 0 {name=l12593 lab=WL78}
N 4440 15640 4460 15640 {}
C {lab_pin.sym} 4460 15640 0 0 {name=l12594 lab=VDD}
N 4440 15560 4460 15560 {}
C {lab_pin.sym} 4460 15560 0 0 {name=l12595 lab=VSS}
C {bitcell_6t.sym} 4600 15600 0 0 {name=Xr78c23}
N 4560 15640 4540 15640 {}
C {lab_pin.sym} 4540 15640 0 0 {name=l12596 lab=BL23}
N 4560 15600 4540 15600 {}
C {lab_pin.sym} 4540 15600 0 0 {name=l12597 lab=BLB23}
N 4560 15560 4540 15560 {}
C {lab_pin.sym} 4540 15560 0 0 {name=l12598 lab=WL78}
N 4640 15640 4660 15640 {}
C {lab_pin.sym} 4660 15640 0 0 {name=l12599 lab=VDD}
N 4640 15560 4660 15560 {}
C {lab_pin.sym} 4660 15560 0 0 {name=l12600 lab=VSS}
C {bitcell_6t.sym} 4800 15600 0 0 {name=Xr78c24}
N 4760 15640 4740 15640 {}
C {lab_pin.sym} 4740 15640 0 0 {name=l12601 lab=BL24}
N 4760 15600 4740 15600 {}
C {lab_pin.sym} 4740 15600 0 0 {name=l12602 lab=BLB24}
N 4760 15560 4740 15560 {}
C {lab_pin.sym} 4740 15560 0 0 {name=l12603 lab=WL78}
N 4840 15640 4860 15640 {}
C {lab_pin.sym} 4860 15640 0 0 {name=l12604 lab=VDD}
N 4840 15560 4860 15560 {}
C {lab_pin.sym} 4860 15560 0 0 {name=l12605 lab=VSS}
C {bitcell_6t.sym} 5000 15600 0 0 {name=Xr78c25}
N 4960 15640 4940 15640 {}
C {lab_pin.sym} 4940 15640 0 0 {name=l12606 lab=BL25}
N 4960 15600 4940 15600 {}
C {lab_pin.sym} 4940 15600 0 0 {name=l12607 lab=BLB25}
N 4960 15560 4940 15560 {}
C {lab_pin.sym} 4940 15560 0 0 {name=l12608 lab=WL78}
N 5040 15640 5060 15640 {}
C {lab_pin.sym} 5060 15640 0 0 {name=l12609 lab=VDD}
N 5040 15560 5060 15560 {}
C {lab_pin.sym} 5060 15560 0 0 {name=l12610 lab=VSS}
C {bitcell_6t.sym} 5200 15600 0 0 {name=Xr78c26}
N 5160 15640 5140 15640 {}
C {lab_pin.sym} 5140 15640 0 0 {name=l12611 lab=BL26}
N 5160 15600 5140 15600 {}
C {lab_pin.sym} 5140 15600 0 0 {name=l12612 lab=BLB26}
N 5160 15560 5140 15560 {}
C {lab_pin.sym} 5140 15560 0 0 {name=l12613 lab=WL78}
N 5240 15640 5260 15640 {}
C {lab_pin.sym} 5260 15640 0 0 {name=l12614 lab=VDD}
N 5240 15560 5260 15560 {}
C {lab_pin.sym} 5260 15560 0 0 {name=l12615 lab=VSS}
C {bitcell_6t.sym} 5400 15600 0 0 {name=Xr78c27}
N 5360 15640 5340 15640 {}
C {lab_pin.sym} 5340 15640 0 0 {name=l12616 lab=BL27}
N 5360 15600 5340 15600 {}
C {lab_pin.sym} 5340 15600 0 0 {name=l12617 lab=BLB27}
N 5360 15560 5340 15560 {}
C {lab_pin.sym} 5340 15560 0 0 {name=l12618 lab=WL78}
N 5440 15640 5460 15640 {}
C {lab_pin.sym} 5460 15640 0 0 {name=l12619 lab=VDD}
N 5440 15560 5460 15560 {}
C {lab_pin.sym} 5460 15560 0 0 {name=l12620 lab=VSS}
C {bitcell_6t.sym} 5600 15600 0 0 {name=Xr78c28}
N 5560 15640 5540 15640 {}
C {lab_pin.sym} 5540 15640 0 0 {name=l12621 lab=BL28}
N 5560 15600 5540 15600 {}
C {lab_pin.sym} 5540 15600 0 0 {name=l12622 lab=BLB28}
N 5560 15560 5540 15560 {}
C {lab_pin.sym} 5540 15560 0 0 {name=l12623 lab=WL78}
N 5640 15640 5660 15640 {}
C {lab_pin.sym} 5660 15640 0 0 {name=l12624 lab=VDD}
N 5640 15560 5660 15560 {}
C {lab_pin.sym} 5660 15560 0 0 {name=l12625 lab=VSS}
C {bitcell_6t.sym} 5800 15600 0 0 {name=Xr78c29}
N 5760 15640 5740 15640 {}
C {lab_pin.sym} 5740 15640 0 0 {name=l12626 lab=BL29}
N 5760 15600 5740 15600 {}
C {lab_pin.sym} 5740 15600 0 0 {name=l12627 lab=BLB29}
N 5760 15560 5740 15560 {}
C {lab_pin.sym} 5740 15560 0 0 {name=l12628 lab=WL78}
N 5840 15640 5860 15640 {}
C {lab_pin.sym} 5860 15640 0 0 {name=l12629 lab=VDD}
N 5840 15560 5860 15560 {}
C {lab_pin.sym} 5860 15560 0 0 {name=l12630 lab=VSS}
C {bitcell_6t.sym} 6000 15600 0 0 {name=Xr78c30}
N 5960 15640 5940 15640 {}
C {lab_pin.sym} 5940 15640 0 0 {name=l12631 lab=BL30}
N 5960 15600 5940 15600 {}
C {lab_pin.sym} 5940 15600 0 0 {name=l12632 lab=BLB30}
N 5960 15560 5940 15560 {}
C {lab_pin.sym} 5940 15560 0 0 {name=l12633 lab=WL78}
N 6040 15640 6060 15640 {}
C {lab_pin.sym} 6060 15640 0 0 {name=l12634 lab=VDD}
N 6040 15560 6060 15560 {}
C {lab_pin.sym} 6060 15560 0 0 {name=l12635 lab=VSS}
C {bitcell_6t.sym} 6200 15600 0 0 {name=Xr78c31}
N 6160 15640 6140 15640 {}
C {lab_pin.sym} 6140 15640 0 0 {name=l12636 lab=BL31}
N 6160 15600 6140 15600 {}
C {lab_pin.sym} 6140 15600 0 0 {name=l12637 lab=BLB31}
N 6160 15560 6140 15560 {}
C {lab_pin.sym} 6140 15560 0 0 {name=l12638 lab=WL78}
N 6240 15640 6260 15640 {}
C {lab_pin.sym} 6260 15640 0 0 {name=l12639 lab=VDD}
N 6240 15560 6260 15560 {}
C {lab_pin.sym} 6260 15560 0 0 {name=l12640 lab=VSS}
C {bitcell_6t.sym} 0 15800 0 0 {name=Xr79c0}
N -40 15840 -60 15840 {}
C {lab_pin.sym} -60 15840 0 0 {name=l12641 lab=BL0}
N -40 15800 -60 15800 {}
C {lab_pin.sym} -60 15800 0 0 {name=l12642 lab=BLB0}
N -40 15760 -60 15760 {}
C {lab_pin.sym} -60 15760 0 0 {name=l12643 lab=WL79}
N 40 15840 60 15840 {}
C {lab_pin.sym} 60 15840 0 0 {name=l12644 lab=VDD}
N 40 15760 60 15760 {}
C {lab_pin.sym} 60 15760 0 0 {name=l12645 lab=VSS}
C {bitcell_6t.sym} 200 15800 0 0 {name=Xr79c1}
N 160 15840 140 15840 {}
C {lab_pin.sym} 140 15840 0 0 {name=l12646 lab=BL1}
N 160 15800 140 15800 {}
C {lab_pin.sym} 140 15800 0 0 {name=l12647 lab=BLB1}
N 160 15760 140 15760 {}
C {lab_pin.sym} 140 15760 0 0 {name=l12648 lab=WL79}
N 240 15840 260 15840 {}
C {lab_pin.sym} 260 15840 0 0 {name=l12649 lab=VDD}
N 240 15760 260 15760 {}
C {lab_pin.sym} 260 15760 0 0 {name=l12650 lab=VSS}
C {bitcell_6t.sym} 400 15800 0 0 {name=Xr79c2}
N 360 15840 340 15840 {}
C {lab_pin.sym} 340 15840 0 0 {name=l12651 lab=BL2}
N 360 15800 340 15800 {}
C {lab_pin.sym} 340 15800 0 0 {name=l12652 lab=BLB2}
N 360 15760 340 15760 {}
C {lab_pin.sym} 340 15760 0 0 {name=l12653 lab=WL79}
N 440 15840 460 15840 {}
C {lab_pin.sym} 460 15840 0 0 {name=l12654 lab=VDD}
N 440 15760 460 15760 {}
C {lab_pin.sym} 460 15760 0 0 {name=l12655 lab=VSS}
C {bitcell_6t.sym} 600 15800 0 0 {name=Xr79c3}
N 560 15840 540 15840 {}
C {lab_pin.sym} 540 15840 0 0 {name=l12656 lab=BL3}
N 560 15800 540 15800 {}
C {lab_pin.sym} 540 15800 0 0 {name=l12657 lab=BLB3}
N 560 15760 540 15760 {}
C {lab_pin.sym} 540 15760 0 0 {name=l12658 lab=WL79}
N 640 15840 660 15840 {}
C {lab_pin.sym} 660 15840 0 0 {name=l12659 lab=VDD}
N 640 15760 660 15760 {}
C {lab_pin.sym} 660 15760 0 0 {name=l12660 lab=VSS}
C {bitcell_6t.sym} 800 15800 0 0 {name=Xr79c4}
N 760 15840 740 15840 {}
C {lab_pin.sym} 740 15840 0 0 {name=l12661 lab=BL4}
N 760 15800 740 15800 {}
C {lab_pin.sym} 740 15800 0 0 {name=l12662 lab=BLB4}
N 760 15760 740 15760 {}
C {lab_pin.sym} 740 15760 0 0 {name=l12663 lab=WL79}
N 840 15840 860 15840 {}
C {lab_pin.sym} 860 15840 0 0 {name=l12664 lab=VDD}
N 840 15760 860 15760 {}
C {lab_pin.sym} 860 15760 0 0 {name=l12665 lab=VSS}
C {bitcell_6t.sym} 1000 15800 0 0 {name=Xr79c5}
N 960 15840 940 15840 {}
C {lab_pin.sym} 940 15840 0 0 {name=l12666 lab=BL5}
N 960 15800 940 15800 {}
C {lab_pin.sym} 940 15800 0 0 {name=l12667 lab=BLB5}
N 960 15760 940 15760 {}
C {lab_pin.sym} 940 15760 0 0 {name=l12668 lab=WL79}
N 1040 15840 1060 15840 {}
C {lab_pin.sym} 1060 15840 0 0 {name=l12669 lab=VDD}
N 1040 15760 1060 15760 {}
C {lab_pin.sym} 1060 15760 0 0 {name=l12670 lab=VSS}
C {bitcell_6t.sym} 1200 15800 0 0 {name=Xr79c6}
N 1160 15840 1140 15840 {}
C {lab_pin.sym} 1140 15840 0 0 {name=l12671 lab=BL6}
N 1160 15800 1140 15800 {}
C {lab_pin.sym} 1140 15800 0 0 {name=l12672 lab=BLB6}
N 1160 15760 1140 15760 {}
C {lab_pin.sym} 1140 15760 0 0 {name=l12673 lab=WL79}
N 1240 15840 1260 15840 {}
C {lab_pin.sym} 1260 15840 0 0 {name=l12674 lab=VDD}
N 1240 15760 1260 15760 {}
C {lab_pin.sym} 1260 15760 0 0 {name=l12675 lab=VSS}
C {bitcell_6t.sym} 1400 15800 0 0 {name=Xr79c7}
N 1360 15840 1340 15840 {}
C {lab_pin.sym} 1340 15840 0 0 {name=l12676 lab=BL7}
N 1360 15800 1340 15800 {}
C {lab_pin.sym} 1340 15800 0 0 {name=l12677 lab=BLB7}
N 1360 15760 1340 15760 {}
C {lab_pin.sym} 1340 15760 0 0 {name=l12678 lab=WL79}
N 1440 15840 1460 15840 {}
C {lab_pin.sym} 1460 15840 0 0 {name=l12679 lab=VDD}
N 1440 15760 1460 15760 {}
C {lab_pin.sym} 1460 15760 0 0 {name=l12680 lab=VSS}
C {bitcell_6t.sym} 1600 15800 0 0 {name=Xr79c8}
N 1560 15840 1540 15840 {}
C {lab_pin.sym} 1540 15840 0 0 {name=l12681 lab=BL8}
N 1560 15800 1540 15800 {}
C {lab_pin.sym} 1540 15800 0 0 {name=l12682 lab=BLB8}
N 1560 15760 1540 15760 {}
C {lab_pin.sym} 1540 15760 0 0 {name=l12683 lab=WL79}
N 1640 15840 1660 15840 {}
C {lab_pin.sym} 1660 15840 0 0 {name=l12684 lab=VDD}
N 1640 15760 1660 15760 {}
C {lab_pin.sym} 1660 15760 0 0 {name=l12685 lab=VSS}
C {bitcell_6t.sym} 1800 15800 0 0 {name=Xr79c9}
N 1760 15840 1740 15840 {}
C {lab_pin.sym} 1740 15840 0 0 {name=l12686 lab=BL9}
N 1760 15800 1740 15800 {}
C {lab_pin.sym} 1740 15800 0 0 {name=l12687 lab=BLB9}
N 1760 15760 1740 15760 {}
C {lab_pin.sym} 1740 15760 0 0 {name=l12688 lab=WL79}
N 1840 15840 1860 15840 {}
C {lab_pin.sym} 1860 15840 0 0 {name=l12689 lab=VDD}
N 1840 15760 1860 15760 {}
C {lab_pin.sym} 1860 15760 0 0 {name=l12690 lab=VSS}
C {bitcell_6t.sym} 2000 15800 0 0 {name=Xr79c10}
N 1960 15840 1940 15840 {}
C {lab_pin.sym} 1940 15840 0 0 {name=l12691 lab=BL10}
N 1960 15800 1940 15800 {}
C {lab_pin.sym} 1940 15800 0 0 {name=l12692 lab=BLB10}
N 1960 15760 1940 15760 {}
C {lab_pin.sym} 1940 15760 0 0 {name=l12693 lab=WL79}
N 2040 15840 2060 15840 {}
C {lab_pin.sym} 2060 15840 0 0 {name=l12694 lab=VDD}
N 2040 15760 2060 15760 {}
C {lab_pin.sym} 2060 15760 0 0 {name=l12695 lab=VSS}
C {bitcell_6t.sym} 2200 15800 0 0 {name=Xr79c11}
N 2160 15840 2140 15840 {}
C {lab_pin.sym} 2140 15840 0 0 {name=l12696 lab=BL11}
N 2160 15800 2140 15800 {}
C {lab_pin.sym} 2140 15800 0 0 {name=l12697 lab=BLB11}
N 2160 15760 2140 15760 {}
C {lab_pin.sym} 2140 15760 0 0 {name=l12698 lab=WL79}
N 2240 15840 2260 15840 {}
C {lab_pin.sym} 2260 15840 0 0 {name=l12699 lab=VDD}
N 2240 15760 2260 15760 {}
C {lab_pin.sym} 2260 15760 0 0 {name=l12700 lab=VSS}
C {bitcell_6t.sym} 2400 15800 0 0 {name=Xr79c12}
N 2360 15840 2340 15840 {}
C {lab_pin.sym} 2340 15840 0 0 {name=l12701 lab=BL12}
N 2360 15800 2340 15800 {}
C {lab_pin.sym} 2340 15800 0 0 {name=l12702 lab=BLB12}
N 2360 15760 2340 15760 {}
C {lab_pin.sym} 2340 15760 0 0 {name=l12703 lab=WL79}
N 2440 15840 2460 15840 {}
C {lab_pin.sym} 2460 15840 0 0 {name=l12704 lab=VDD}
N 2440 15760 2460 15760 {}
C {lab_pin.sym} 2460 15760 0 0 {name=l12705 lab=VSS}
C {bitcell_6t.sym} 2600 15800 0 0 {name=Xr79c13}
N 2560 15840 2540 15840 {}
C {lab_pin.sym} 2540 15840 0 0 {name=l12706 lab=BL13}
N 2560 15800 2540 15800 {}
C {lab_pin.sym} 2540 15800 0 0 {name=l12707 lab=BLB13}
N 2560 15760 2540 15760 {}
C {lab_pin.sym} 2540 15760 0 0 {name=l12708 lab=WL79}
N 2640 15840 2660 15840 {}
C {lab_pin.sym} 2660 15840 0 0 {name=l12709 lab=VDD}
N 2640 15760 2660 15760 {}
C {lab_pin.sym} 2660 15760 0 0 {name=l12710 lab=VSS}
C {bitcell_6t.sym} 2800 15800 0 0 {name=Xr79c14}
N 2760 15840 2740 15840 {}
C {lab_pin.sym} 2740 15840 0 0 {name=l12711 lab=BL14}
N 2760 15800 2740 15800 {}
C {lab_pin.sym} 2740 15800 0 0 {name=l12712 lab=BLB14}
N 2760 15760 2740 15760 {}
C {lab_pin.sym} 2740 15760 0 0 {name=l12713 lab=WL79}
N 2840 15840 2860 15840 {}
C {lab_pin.sym} 2860 15840 0 0 {name=l12714 lab=VDD}
N 2840 15760 2860 15760 {}
C {lab_pin.sym} 2860 15760 0 0 {name=l12715 lab=VSS}
C {bitcell_6t.sym} 3000 15800 0 0 {name=Xr79c15}
N 2960 15840 2940 15840 {}
C {lab_pin.sym} 2940 15840 0 0 {name=l12716 lab=BL15}
N 2960 15800 2940 15800 {}
C {lab_pin.sym} 2940 15800 0 0 {name=l12717 lab=BLB15}
N 2960 15760 2940 15760 {}
C {lab_pin.sym} 2940 15760 0 0 {name=l12718 lab=WL79}
N 3040 15840 3060 15840 {}
C {lab_pin.sym} 3060 15840 0 0 {name=l12719 lab=VDD}
N 3040 15760 3060 15760 {}
C {lab_pin.sym} 3060 15760 0 0 {name=l12720 lab=VSS}
C {bitcell_6t.sym} 3200 15800 0 0 {name=Xr79c16}
N 3160 15840 3140 15840 {}
C {lab_pin.sym} 3140 15840 0 0 {name=l12721 lab=BL16}
N 3160 15800 3140 15800 {}
C {lab_pin.sym} 3140 15800 0 0 {name=l12722 lab=BLB16}
N 3160 15760 3140 15760 {}
C {lab_pin.sym} 3140 15760 0 0 {name=l12723 lab=WL79}
N 3240 15840 3260 15840 {}
C {lab_pin.sym} 3260 15840 0 0 {name=l12724 lab=VDD}
N 3240 15760 3260 15760 {}
C {lab_pin.sym} 3260 15760 0 0 {name=l12725 lab=VSS}
C {bitcell_6t.sym} 3400 15800 0 0 {name=Xr79c17}
N 3360 15840 3340 15840 {}
C {lab_pin.sym} 3340 15840 0 0 {name=l12726 lab=BL17}
N 3360 15800 3340 15800 {}
C {lab_pin.sym} 3340 15800 0 0 {name=l12727 lab=BLB17}
N 3360 15760 3340 15760 {}
C {lab_pin.sym} 3340 15760 0 0 {name=l12728 lab=WL79}
N 3440 15840 3460 15840 {}
C {lab_pin.sym} 3460 15840 0 0 {name=l12729 lab=VDD}
N 3440 15760 3460 15760 {}
C {lab_pin.sym} 3460 15760 0 0 {name=l12730 lab=VSS}
C {bitcell_6t.sym} 3600 15800 0 0 {name=Xr79c18}
N 3560 15840 3540 15840 {}
C {lab_pin.sym} 3540 15840 0 0 {name=l12731 lab=BL18}
N 3560 15800 3540 15800 {}
C {lab_pin.sym} 3540 15800 0 0 {name=l12732 lab=BLB18}
N 3560 15760 3540 15760 {}
C {lab_pin.sym} 3540 15760 0 0 {name=l12733 lab=WL79}
N 3640 15840 3660 15840 {}
C {lab_pin.sym} 3660 15840 0 0 {name=l12734 lab=VDD}
N 3640 15760 3660 15760 {}
C {lab_pin.sym} 3660 15760 0 0 {name=l12735 lab=VSS}
C {bitcell_6t.sym} 3800 15800 0 0 {name=Xr79c19}
N 3760 15840 3740 15840 {}
C {lab_pin.sym} 3740 15840 0 0 {name=l12736 lab=BL19}
N 3760 15800 3740 15800 {}
C {lab_pin.sym} 3740 15800 0 0 {name=l12737 lab=BLB19}
N 3760 15760 3740 15760 {}
C {lab_pin.sym} 3740 15760 0 0 {name=l12738 lab=WL79}
N 3840 15840 3860 15840 {}
C {lab_pin.sym} 3860 15840 0 0 {name=l12739 lab=VDD}
N 3840 15760 3860 15760 {}
C {lab_pin.sym} 3860 15760 0 0 {name=l12740 lab=VSS}
C {bitcell_6t.sym} 4000 15800 0 0 {name=Xr79c20}
N 3960 15840 3940 15840 {}
C {lab_pin.sym} 3940 15840 0 0 {name=l12741 lab=BL20}
N 3960 15800 3940 15800 {}
C {lab_pin.sym} 3940 15800 0 0 {name=l12742 lab=BLB20}
N 3960 15760 3940 15760 {}
C {lab_pin.sym} 3940 15760 0 0 {name=l12743 lab=WL79}
N 4040 15840 4060 15840 {}
C {lab_pin.sym} 4060 15840 0 0 {name=l12744 lab=VDD}
N 4040 15760 4060 15760 {}
C {lab_pin.sym} 4060 15760 0 0 {name=l12745 lab=VSS}
C {bitcell_6t.sym} 4200 15800 0 0 {name=Xr79c21}
N 4160 15840 4140 15840 {}
C {lab_pin.sym} 4140 15840 0 0 {name=l12746 lab=BL21}
N 4160 15800 4140 15800 {}
C {lab_pin.sym} 4140 15800 0 0 {name=l12747 lab=BLB21}
N 4160 15760 4140 15760 {}
C {lab_pin.sym} 4140 15760 0 0 {name=l12748 lab=WL79}
N 4240 15840 4260 15840 {}
C {lab_pin.sym} 4260 15840 0 0 {name=l12749 lab=VDD}
N 4240 15760 4260 15760 {}
C {lab_pin.sym} 4260 15760 0 0 {name=l12750 lab=VSS}
C {bitcell_6t.sym} 4400 15800 0 0 {name=Xr79c22}
N 4360 15840 4340 15840 {}
C {lab_pin.sym} 4340 15840 0 0 {name=l12751 lab=BL22}
N 4360 15800 4340 15800 {}
C {lab_pin.sym} 4340 15800 0 0 {name=l12752 lab=BLB22}
N 4360 15760 4340 15760 {}
C {lab_pin.sym} 4340 15760 0 0 {name=l12753 lab=WL79}
N 4440 15840 4460 15840 {}
C {lab_pin.sym} 4460 15840 0 0 {name=l12754 lab=VDD}
N 4440 15760 4460 15760 {}
C {lab_pin.sym} 4460 15760 0 0 {name=l12755 lab=VSS}
C {bitcell_6t.sym} 4600 15800 0 0 {name=Xr79c23}
N 4560 15840 4540 15840 {}
C {lab_pin.sym} 4540 15840 0 0 {name=l12756 lab=BL23}
N 4560 15800 4540 15800 {}
C {lab_pin.sym} 4540 15800 0 0 {name=l12757 lab=BLB23}
N 4560 15760 4540 15760 {}
C {lab_pin.sym} 4540 15760 0 0 {name=l12758 lab=WL79}
N 4640 15840 4660 15840 {}
C {lab_pin.sym} 4660 15840 0 0 {name=l12759 lab=VDD}
N 4640 15760 4660 15760 {}
C {lab_pin.sym} 4660 15760 0 0 {name=l12760 lab=VSS}
C {bitcell_6t.sym} 4800 15800 0 0 {name=Xr79c24}
N 4760 15840 4740 15840 {}
C {lab_pin.sym} 4740 15840 0 0 {name=l12761 lab=BL24}
N 4760 15800 4740 15800 {}
C {lab_pin.sym} 4740 15800 0 0 {name=l12762 lab=BLB24}
N 4760 15760 4740 15760 {}
C {lab_pin.sym} 4740 15760 0 0 {name=l12763 lab=WL79}
N 4840 15840 4860 15840 {}
C {lab_pin.sym} 4860 15840 0 0 {name=l12764 lab=VDD}
N 4840 15760 4860 15760 {}
C {lab_pin.sym} 4860 15760 0 0 {name=l12765 lab=VSS}
C {bitcell_6t.sym} 5000 15800 0 0 {name=Xr79c25}
N 4960 15840 4940 15840 {}
C {lab_pin.sym} 4940 15840 0 0 {name=l12766 lab=BL25}
N 4960 15800 4940 15800 {}
C {lab_pin.sym} 4940 15800 0 0 {name=l12767 lab=BLB25}
N 4960 15760 4940 15760 {}
C {lab_pin.sym} 4940 15760 0 0 {name=l12768 lab=WL79}
N 5040 15840 5060 15840 {}
C {lab_pin.sym} 5060 15840 0 0 {name=l12769 lab=VDD}
N 5040 15760 5060 15760 {}
C {lab_pin.sym} 5060 15760 0 0 {name=l12770 lab=VSS}
C {bitcell_6t.sym} 5200 15800 0 0 {name=Xr79c26}
N 5160 15840 5140 15840 {}
C {lab_pin.sym} 5140 15840 0 0 {name=l12771 lab=BL26}
N 5160 15800 5140 15800 {}
C {lab_pin.sym} 5140 15800 0 0 {name=l12772 lab=BLB26}
N 5160 15760 5140 15760 {}
C {lab_pin.sym} 5140 15760 0 0 {name=l12773 lab=WL79}
N 5240 15840 5260 15840 {}
C {lab_pin.sym} 5260 15840 0 0 {name=l12774 lab=VDD}
N 5240 15760 5260 15760 {}
C {lab_pin.sym} 5260 15760 0 0 {name=l12775 lab=VSS}
C {bitcell_6t.sym} 5400 15800 0 0 {name=Xr79c27}
N 5360 15840 5340 15840 {}
C {lab_pin.sym} 5340 15840 0 0 {name=l12776 lab=BL27}
N 5360 15800 5340 15800 {}
C {lab_pin.sym} 5340 15800 0 0 {name=l12777 lab=BLB27}
N 5360 15760 5340 15760 {}
C {lab_pin.sym} 5340 15760 0 0 {name=l12778 lab=WL79}
N 5440 15840 5460 15840 {}
C {lab_pin.sym} 5460 15840 0 0 {name=l12779 lab=VDD}
N 5440 15760 5460 15760 {}
C {lab_pin.sym} 5460 15760 0 0 {name=l12780 lab=VSS}
C {bitcell_6t.sym} 5600 15800 0 0 {name=Xr79c28}
N 5560 15840 5540 15840 {}
C {lab_pin.sym} 5540 15840 0 0 {name=l12781 lab=BL28}
N 5560 15800 5540 15800 {}
C {lab_pin.sym} 5540 15800 0 0 {name=l12782 lab=BLB28}
N 5560 15760 5540 15760 {}
C {lab_pin.sym} 5540 15760 0 0 {name=l12783 lab=WL79}
N 5640 15840 5660 15840 {}
C {lab_pin.sym} 5660 15840 0 0 {name=l12784 lab=VDD}
N 5640 15760 5660 15760 {}
C {lab_pin.sym} 5660 15760 0 0 {name=l12785 lab=VSS}
C {bitcell_6t.sym} 5800 15800 0 0 {name=Xr79c29}
N 5760 15840 5740 15840 {}
C {lab_pin.sym} 5740 15840 0 0 {name=l12786 lab=BL29}
N 5760 15800 5740 15800 {}
C {lab_pin.sym} 5740 15800 0 0 {name=l12787 lab=BLB29}
N 5760 15760 5740 15760 {}
C {lab_pin.sym} 5740 15760 0 0 {name=l12788 lab=WL79}
N 5840 15840 5860 15840 {}
C {lab_pin.sym} 5860 15840 0 0 {name=l12789 lab=VDD}
N 5840 15760 5860 15760 {}
C {lab_pin.sym} 5860 15760 0 0 {name=l12790 lab=VSS}
C {bitcell_6t.sym} 6000 15800 0 0 {name=Xr79c30}
N 5960 15840 5940 15840 {}
C {lab_pin.sym} 5940 15840 0 0 {name=l12791 lab=BL30}
N 5960 15800 5940 15800 {}
C {lab_pin.sym} 5940 15800 0 0 {name=l12792 lab=BLB30}
N 5960 15760 5940 15760 {}
C {lab_pin.sym} 5940 15760 0 0 {name=l12793 lab=WL79}
N 6040 15840 6060 15840 {}
C {lab_pin.sym} 6060 15840 0 0 {name=l12794 lab=VDD}
N 6040 15760 6060 15760 {}
C {lab_pin.sym} 6060 15760 0 0 {name=l12795 lab=VSS}
C {bitcell_6t.sym} 6200 15800 0 0 {name=Xr79c31}
N 6160 15840 6140 15840 {}
C {lab_pin.sym} 6140 15840 0 0 {name=l12796 lab=BL31}
N 6160 15800 6140 15800 {}
C {lab_pin.sym} 6140 15800 0 0 {name=l12797 lab=BLB31}
N 6160 15760 6140 15760 {}
C {lab_pin.sym} 6140 15760 0 0 {name=l12798 lab=WL79}
N 6240 15840 6260 15840 {}
C {lab_pin.sym} 6260 15840 0 0 {name=l12799 lab=VDD}
N 6240 15760 6260 15760 {}
C {lab_pin.sym} 6260 15760 0 0 {name=l12800 lab=VSS}
C {bitcell_6t.sym} 0 16000 0 0 {name=Xr80c0}
N -40 16040 -60 16040 {}
C {lab_pin.sym} -60 16040 0 0 {name=l12801 lab=BL0}
N -40 16000 -60 16000 {}
C {lab_pin.sym} -60 16000 0 0 {name=l12802 lab=BLB0}
N -40 15960 -60 15960 {}
C {lab_pin.sym} -60 15960 0 0 {name=l12803 lab=WL80}
N 40 16040 60 16040 {}
C {lab_pin.sym} 60 16040 0 0 {name=l12804 lab=VDD}
N 40 15960 60 15960 {}
C {lab_pin.sym} 60 15960 0 0 {name=l12805 lab=VSS}
C {bitcell_6t.sym} 200 16000 0 0 {name=Xr80c1}
N 160 16040 140 16040 {}
C {lab_pin.sym} 140 16040 0 0 {name=l12806 lab=BL1}
N 160 16000 140 16000 {}
C {lab_pin.sym} 140 16000 0 0 {name=l12807 lab=BLB1}
N 160 15960 140 15960 {}
C {lab_pin.sym} 140 15960 0 0 {name=l12808 lab=WL80}
N 240 16040 260 16040 {}
C {lab_pin.sym} 260 16040 0 0 {name=l12809 lab=VDD}
N 240 15960 260 15960 {}
C {lab_pin.sym} 260 15960 0 0 {name=l12810 lab=VSS}
C {bitcell_6t.sym} 400 16000 0 0 {name=Xr80c2}
N 360 16040 340 16040 {}
C {lab_pin.sym} 340 16040 0 0 {name=l12811 lab=BL2}
N 360 16000 340 16000 {}
C {lab_pin.sym} 340 16000 0 0 {name=l12812 lab=BLB2}
N 360 15960 340 15960 {}
C {lab_pin.sym} 340 15960 0 0 {name=l12813 lab=WL80}
N 440 16040 460 16040 {}
C {lab_pin.sym} 460 16040 0 0 {name=l12814 lab=VDD}
N 440 15960 460 15960 {}
C {lab_pin.sym} 460 15960 0 0 {name=l12815 lab=VSS}
C {bitcell_6t.sym} 600 16000 0 0 {name=Xr80c3}
N 560 16040 540 16040 {}
C {lab_pin.sym} 540 16040 0 0 {name=l12816 lab=BL3}
N 560 16000 540 16000 {}
C {lab_pin.sym} 540 16000 0 0 {name=l12817 lab=BLB3}
N 560 15960 540 15960 {}
C {lab_pin.sym} 540 15960 0 0 {name=l12818 lab=WL80}
N 640 16040 660 16040 {}
C {lab_pin.sym} 660 16040 0 0 {name=l12819 lab=VDD}
N 640 15960 660 15960 {}
C {lab_pin.sym} 660 15960 0 0 {name=l12820 lab=VSS}
C {bitcell_6t.sym} 800 16000 0 0 {name=Xr80c4}
N 760 16040 740 16040 {}
C {lab_pin.sym} 740 16040 0 0 {name=l12821 lab=BL4}
N 760 16000 740 16000 {}
C {lab_pin.sym} 740 16000 0 0 {name=l12822 lab=BLB4}
N 760 15960 740 15960 {}
C {lab_pin.sym} 740 15960 0 0 {name=l12823 lab=WL80}
N 840 16040 860 16040 {}
C {lab_pin.sym} 860 16040 0 0 {name=l12824 lab=VDD}
N 840 15960 860 15960 {}
C {lab_pin.sym} 860 15960 0 0 {name=l12825 lab=VSS}
C {bitcell_6t.sym} 1000 16000 0 0 {name=Xr80c5}
N 960 16040 940 16040 {}
C {lab_pin.sym} 940 16040 0 0 {name=l12826 lab=BL5}
N 960 16000 940 16000 {}
C {lab_pin.sym} 940 16000 0 0 {name=l12827 lab=BLB5}
N 960 15960 940 15960 {}
C {lab_pin.sym} 940 15960 0 0 {name=l12828 lab=WL80}
N 1040 16040 1060 16040 {}
C {lab_pin.sym} 1060 16040 0 0 {name=l12829 lab=VDD}
N 1040 15960 1060 15960 {}
C {lab_pin.sym} 1060 15960 0 0 {name=l12830 lab=VSS}
C {bitcell_6t.sym} 1200 16000 0 0 {name=Xr80c6}
N 1160 16040 1140 16040 {}
C {lab_pin.sym} 1140 16040 0 0 {name=l12831 lab=BL6}
N 1160 16000 1140 16000 {}
C {lab_pin.sym} 1140 16000 0 0 {name=l12832 lab=BLB6}
N 1160 15960 1140 15960 {}
C {lab_pin.sym} 1140 15960 0 0 {name=l12833 lab=WL80}
N 1240 16040 1260 16040 {}
C {lab_pin.sym} 1260 16040 0 0 {name=l12834 lab=VDD}
N 1240 15960 1260 15960 {}
C {lab_pin.sym} 1260 15960 0 0 {name=l12835 lab=VSS}
C {bitcell_6t.sym} 1400 16000 0 0 {name=Xr80c7}
N 1360 16040 1340 16040 {}
C {lab_pin.sym} 1340 16040 0 0 {name=l12836 lab=BL7}
N 1360 16000 1340 16000 {}
C {lab_pin.sym} 1340 16000 0 0 {name=l12837 lab=BLB7}
N 1360 15960 1340 15960 {}
C {lab_pin.sym} 1340 15960 0 0 {name=l12838 lab=WL80}
N 1440 16040 1460 16040 {}
C {lab_pin.sym} 1460 16040 0 0 {name=l12839 lab=VDD}
N 1440 15960 1460 15960 {}
C {lab_pin.sym} 1460 15960 0 0 {name=l12840 lab=VSS}
C {bitcell_6t.sym} 1600 16000 0 0 {name=Xr80c8}
N 1560 16040 1540 16040 {}
C {lab_pin.sym} 1540 16040 0 0 {name=l12841 lab=BL8}
N 1560 16000 1540 16000 {}
C {lab_pin.sym} 1540 16000 0 0 {name=l12842 lab=BLB8}
N 1560 15960 1540 15960 {}
C {lab_pin.sym} 1540 15960 0 0 {name=l12843 lab=WL80}
N 1640 16040 1660 16040 {}
C {lab_pin.sym} 1660 16040 0 0 {name=l12844 lab=VDD}
N 1640 15960 1660 15960 {}
C {lab_pin.sym} 1660 15960 0 0 {name=l12845 lab=VSS}
C {bitcell_6t.sym} 1800 16000 0 0 {name=Xr80c9}
N 1760 16040 1740 16040 {}
C {lab_pin.sym} 1740 16040 0 0 {name=l12846 lab=BL9}
N 1760 16000 1740 16000 {}
C {lab_pin.sym} 1740 16000 0 0 {name=l12847 lab=BLB9}
N 1760 15960 1740 15960 {}
C {lab_pin.sym} 1740 15960 0 0 {name=l12848 lab=WL80}
N 1840 16040 1860 16040 {}
C {lab_pin.sym} 1860 16040 0 0 {name=l12849 lab=VDD}
N 1840 15960 1860 15960 {}
C {lab_pin.sym} 1860 15960 0 0 {name=l12850 lab=VSS}
C {bitcell_6t.sym} 2000 16000 0 0 {name=Xr80c10}
N 1960 16040 1940 16040 {}
C {lab_pin.sym} 1940 16040 0 0 {name=l12851 lab=BL10}
N 1960 16000 1940 16000 {}
C {lab_pin.sym} 1940 16000 0 0 {name=l12852 lab=BLB10}
N 1960 15960 1940 15960 {}
C {lab_pin.sym} 1940 15960 0 0 {name=l12853 lab=WL80}
N 2040 16040 2060 16040 {}
C {lab_pin.sym} 2060 16040 0 0 {name=l12854 lab=VDD}
N 2040 15960 2060 15960 {}
C {lab_pin.sym} 2060 15960 0 0 {name=l12855 lab=VSS}
C {bitcell_6t.sym} 2200 16000 0 0 {name=Xr80c11}
N 2160 16040 2140 16040 {}
C {lab_pin.sym} 2140 16040 0 0 {name=l12856 lab=BL11}
N 2160 16000 2140 16000 {}
C {lab_pin.sym} 2140 16000 0 0 {name=l12857 lab=BLB11}
N 2160 15960 2140 15960 {}
C {lab_pin.sym} 2140 15960 0 0 {name=l12858 lab=WL80}
N 2240 16040 2260 16040 {}
C {lab_pin.sym} 2260 16040 0 0 {name=l12859 lab=VDD}
N 2240 15960 2260 15960 {}
C {lab_pin.sym} 2260 15960 0 0 {name=l12860 lab=VSS}
C {bitcell_6t.sym} 2400 16000 0 0 {name=Xr80c12}
N 2360 16040 2340 16040 {}
C {lab_pin.sym} 2340 16040 0 0 {name=l12861 lab=BL12}
N 2360 16000 2340 16000 {}
C {lab_pin.sym} 2340 16000 0 0 {name=l12862 lab=BLB12}
N 2360 15960 2340 15960 {}
C {lab_pin.sym} 2340 15960 0 0 {name=l12863 lab=WL80}
N 2440 16040 2460 16040 {}
C {lab_pin.sym} 2460 16040 0 0 {name=l12864 lab=VDD}
N 2440 15960 2460 15960 {}
C {lab_pin.sym} 2460 15960 0 0 {name=l12865 lab=VSS}
C {bitcell_6t.sym} 2600 16000 0 0 {name=Xr80c13}
N 2560 16040 2540 16040 {}
C {lab_pin.sym} 2540 16040 0 0 {name=l12866 lab=BL13}
N 2560 16000 2540 16000 {}
C {lab_pin.sym} 2540 16000 0 0 {name=l12867 lab=BLB13}
N 2560 15960 2540 15960 {}
C {lab_pin.sym} 2540 15960 0 0 {name=l12868 lab=WL80}
N 2640 16040 2660 16040 {}
C {lab_pin.sym} 2660 16040 0 0 {name=l12869 lab=VDD}
N 2640 15960 2660 15960 {}
C {lab_pin.sym} 2660 15960 0 0 {name=l12870 lab=VSS}
C {bitcell_6t.sym} 2800 16000 0 0 {name=Xr80c14}
N 2760 16040 2740 16040 {}
C {lab_pin.sym} 2740 16040 0 0 {name=l12871 lab=BL14}
N 2760 16000 2740 16000 {}
C {lab_pin.sym} 2740 16000 0 0 {name=l12872 lab=BLB14}
N 2760 15960 2740 15960 {}
C {lab_pin.sym} 2740 15960 0 0 {name=l12873 lab=WL80}
N 2840 16040 2860 16040 {}
C {lab_pin.sym} 2860 16040 0 0 {name=l12874 lab=VDD}
N 2840 15960 2860 15960 {}
C {lab_pin.sym} 2860 15960 0 0 {name=l12875 lab=VSS}
C {bitcell_6t.sym} 3000 16000 0 0 {name=Xr80c15}
N 2960 16040 2940 16040 {}
C {lab_pin.sym} 2940 16040 0 0 {name=l12876 lab=BL15}
N 2960 16000 2940 16000 {}
C {lab_pin.sym} 2940 16000 0 0 {name=l12877 lab=BLB15}
N 2960 15960 2940 15960 {}
C {lab_pin.sym} 2940 15960 0 0 {name=l12878 lab=WL80}
N 3040 16040 3060 16040 {}
C {lab_pin.sym} 3060 16040 0 0 {name=l12879 lab=VDD}
N 3040 15960 3060 15960 {}
C {lab_pin.sym} 3060 15960 0 0 {name=l12880 lab=VSS}
C {bitcell_6t.sym} 3200 16000 0 0 {name=Xr80c16}
N 3160 16040 3140 16040 {}
C {lab_pin.sym} 3140 16040 0 0 {name=l12881 lab=BL16}
N 3160 16000 3140 16000 {}
C {lab_pin.sym} 3140 16000 0 0 {name=l12882 lab=BLB16}
N 3160 15960 3140 15960 {}
C {lab_pin.sym} 3140 15960 0 0 {name=l12883 lab=WL80}
N 3240 16040 3260 16040 {}
C {lab_pin.sym} 3260 16040 0 0 {name=l12884 lab=VDD}
N 3240 15960 3260 15960 {}
C {lab_pin.sym} 3260 15960 0 0 {name=l12885 lab=VSS}
C {bitcell_6t.sym} 3400 16000 0 0 {name=Xr80c17}
N 3360 16040 3340 16040 {}
C {lab_pin.sym} 3340 16040 0 0 {name=l12886 lab=BL17}
N 3360 16000 3340 16000 {}
C {lab_pin.sym} 3340 16000 0 0 {name=l12887 lab=BLB17}
N 3360 15960 3340 15960 {}
C {lab_pin.sym} 3340 15960 0 0 {name=l12888 lab=WL80}
N 3440 16040 3460 16040 {}
C {lab_pin.sym} 3460 16040 0 0 {name=l12889 lab=VDD}
N 3440 15960 3460 15960 {}
C {lab_pin.sym} 3460 15960 0 0 {name=l12890 lab=VSS}
C {bitcell_6t.sym} 3600 16000 0 0 {name=Xr80c18}
N 3560 16040 3540 16040 {}
C {lab_pin.sym} 3540 16040 0 0 {name=l12891 lab=BL18}
N 3560 16000 3540 16000 {}
C {lab_pin.sym} 3540 16000 0 0 {name=l12892 lab=BLB18}
N 3560 15960 3540 15960 {}
C {lab_pin.sym} 3540 15960 0 0 {name=l12893 lab=WL80}
N 3640 16040 3660 16040 {}
C {lab_pin.sym} 3660 16040 0 0 {name=l12894 lab=VDD}
N 3640 15960 3660 15960 {}
C {lab_pin.sym} 3660 15960 0 0 {name=l12895 lab=VSS}
C {bitcell_6t.sym} 3800 16000 0 0 {name=Xr80c19}
N 3760 16040 3740 16040 {}
C {lab_pin.sym} 3740 16040 0 0 {name=l12896 lab=BL19}
N 3760 16000 3740 16000 {}
C {lab_pin.sym} 3740 16000 0 0 {name=l12897 lab=BLB19}
N 3760 15960 3740 15960 {}
C {lab_pin.sym} 3740 15960 0 0 {name=l12898 lab=WL80}
N 3840 16040 3860 16040 {}
C {lab_pin.sym} 3860 16040 0 0 {name=l12899 lab=VDD}
N 3840 15960 3860 15960 {}
C {lab_pin.sym} 3860 15960 0 0 {name=l12900 lab=VSS}
C {bitcell_6t.sym} 4000 16000 0 0 {name=Xr80c20}
N 3960 16040 3940 16040 {}
C {lab_pin.sym} 3940 16040 0 0 {name=l12901 lab=BL20}
N 3960 16000 3940 16000 {}
C {lab_pin.sym} 3940 16000 0 0 {name=l12902 lab=BLB20}
N 3960 15960 3940 15960 {}
C {lab_pin.sym} 3940 15960 0 0 {name=l12903 lab=WL80}
N 4040 16040 4060 16040 {}
C {lab_pin.sym} 4060 16040 0 0 {name=l12904 lab=VDD}
N 4040 15960 4060 15960 {}
C {lab_pin.sym} 4060 15960 0 0 {name=l12905 lab=VSS}
C {bitcell_6t.sym} 4200 16000 0 0 {name=Xr80c21}
N 4160 16040 4140 16040 {}
C {lab_pin.sym} 4140 16040 0 0 {name=l12906 lab=BL21}
N 4160 16000 4140 16000 {}
C {lab_pin.sym} 4140 16000 0 0 {name=l12907 lab=BLB21}
N 4160 15960 4140 15960 {}
C {lab_pin.sym} 4140 15960 0 0 {name=l12908 lab=WL80}
N 4240 16040 4260 16040 {}
C {lab_pin.sym} 4260 16040 0 0 {name=l12909 lab=VDD}
N 4240 15960 4260 15960 {}
C {lab_pin.sym} 4260 15960 0 0 {name=l12910 lab=VSS}
C {bitcell_6t.sym} 4400 16000 0 0 {name=Xr80c22}
N 4360 16040 4340 16040 {}
C {lab_pin.sym} 4340 16040 0 0 {name=l12911 lab=BL22}
N 4360 16000 4340 16000 {}
C {lab_pin.sym} 4340 16000 0 0 {name=l12912 lab=BLB22}
N 4360 15960 4340 15960 {}
C {lab_pin.sym} 4340 15960 0 0 {name=l12913 lab=WL80}
N 4440 16040 4460 16040 {}
C {lab_pin.sym} 4460 16040 0 0 {name=l12914 lab=VDD}
N 4440 15960 4460 15960 {}
C {lab_pin.sym} 4460 15960 0 0 {name=l12915 lab=VSS}
C {bitcell_6t.sym} 4600 16000 0 0 {name=Xr80c23}
N 4560 16040 4540 16040 {}
C {lab_pin.sym} 4540 16040 0 0 {name=l12916 lab=BL23}
N 4560 16000 4540 16000 {}
C {lab_pin.sym} 4540 16000 0 0 {name=l12917 lab=BLB23}
N 4560 15960 4540 15960 {}
C {lab_pin.sym} 4540 15960 0 0 {name=l12918 lab=WL80}
N 4640 16040 4660 16040 {}
C {lab_pin.sym} 4660 16040 0 0 {name=l12919 lab=VDD}
N 4640 15960 4660 15960 {}
C {lab_pin.sym} 4660 15960 0 0 {name=l12920 lab=VSS}
C {bitcell_6t.sym} 4800 16000 0 0 {name=Xr80c24}
N 4760 16040 4740 16040 {}
C {lab_pin.sym} 4740 16040 0 0 {name=l12921 lab=BL24}
N 4760 16000 4740 16000 {}
C {lab_pin.sym} 4740 16000 0 0 {name=l12922 lab=BLB24}
N 4760 15960 4740 15960 {}
C {lab_pin.sym} 4740 15960 0 0 {name=l12923 lab=WL80}
N 4840 16040 4860 16040 {}
C {lab_pin.sym} 4860 16040 0 0 {name=l12924 lab=VDD}
N 4840 15960 4860 15960 {}
C {lab_pin.sym} 4860 15960 0 0 {name=l12925 lab=VSS}
C {bitcell_6t.sym} 5000 16000 0 0 {name=Xr80c25}
N 4960 16040 4940 16040 {}
C {lab_pin.sym} 4940 16040 0 0 {name=l12926 lab=BL25}
N 4960 16000 4940 16000 {}
C {lab_pin.sym} 4940 16000 0 0 {name=l12927 lab=BLB25}
N 4960 15960 4940 15960 {}
C {lab_pin.sym} 4940 15960 0 0 {name=l12928 lab=WL80}
N 5040 16040 5060 16040 {}
C {lab_pin.sym} 5060 16040 0 0 {name=l12929 lab=VDD}
N 5040 15960 5060 15960 {}
C {lab_pin.sym} 5060 15960 0 0 {name=l12930 lab=VSS}
C {bitcell_6t.sym} 5200 16000 0 0 {name=Xr80c26}
N 5160 16040 5140 16040 {}
C {lab_pin.sym} 5140 16040 0 0 {name=l12931 lab=BL26}
N 5160 16000 5140 16000 {}
C {lab_pin.sym} 5140 16000 0 0 {name=l12932 lab=BLB26}
N 5160 15960 5140 15960 {}
C {lab_pin.sym} 5140 15960 0 0 {name=l12933 lab=WL80}
N 5240 16040 5260 16040 {}
C {lab_pin.sym} 5260 16040 0 0 {name=l12934 lab=VDD}
N 5240 15960 5260 15960 {}
C {lab_pin.sym} 5260 15960 0 0 {name=l12935 lab=VSS}
C {bitcell_6t.sym} 5400 16000 0 0 {name=Xr80c27}
N 5360 16040 5340 16040 {}
C {lab_pin.sym} 5340 16040 0 0 {name=l12936 lab=BL27}
N 5360 16000 5340 16000 {}
C {lab_pin.sym} 5340 16000 0 0 {name=l12937 lab=BLB27}
N 5360 15960 5340 15960 {}
C {lab_pin.sym} 5340 15960 0 0 {name=l12938 lab=WL80}
N 5440 16040 5460 16040 {}
C {lab_pin.sym} 5460 16040 0 0 {name=l12939 lab=VDD}
N 5440 15960 5460 15960 {}
C {lab_pin.sym} 5460 15960 0 0 {name=l12940 lab=VSS}
C {bitcell_6t.sym} 5600 16000 0 0 {name=Xr80c28}
N 5560 16040 5540 16040 {}
C {lab_pin.sym} 5540 16040 0 0 {name=l12941 lab=BL28}
N 5560 16000 5540 16000 {}
C {lab_pin.sym} 5540 16000 0 0 {name=l12942 lab=BLB28}
N 5560 15960 5540 15960 {}
C {lab_pin.sym} 5540 15960 0 0 {name=l12943 lab=WL80}
N 5640 16040 5660 16040 {}
C {lab_pin.sym} 5660 16040 0 0 {name=l12944 lab=VDD}
N 5640 15960 5660 15960 {}
C {lab_pin.sym} 5660 15960 0 0 {name=l12945 lab=VSS}
C {bitcell_6t.sym} 5800 16000 0 0 {name=Xr80c29}
N 5760 16040 5740 16040 {}
C {lab_pin.sym} 5740 16040 0 0 {name=l12946 lab=BL29}
N 5760 16000 5740 16000 {}
C {lab_pin.sym} 5740 16000 0 0 {name=l12947 lab=BLB29}
N 5760 15960 5740 15960 {}
C {lab_pin.sym} 5740 15960 0 0 {name=l12948 lab=WL80}
N 5840 16040 5860 16040 {}
C {lab_pin.sym} 5860 16040 0 0 {name=l12949 lab=VDD}
N 5840 15960 5860 15960 {}
C {lab_pin.sym} 5860 15960 0 0 {name=l12950 lab=VSS}
C {bitcell_6t.sym} 6000 16000 0 0 {name=Xr80c30}
N 5960 16040 5940 16040 {}
C {lab_pin.sym} 5940 16040 0 0 {name=l12951 lab=BL30}
N 5960 16000 5940 16000 {}
C {lab_pin.sym} 5940 16000 0 0 {name=l12952 lab=BLB30}
N 5960 15960 5940 15960 {}
C {lab_pin.sym} 5940 15960 0 0 {name=l12953 lab=WL80}
N 6040 16040 6060 16040 {}
C {lab_pin.sym} 6060 16040 0 0 {name=l12954 lab=VDD}
N 6040 15960 6060 15960 {}
C {lab_pin.sym} 6060 15960 0 0 {name=l12955 lab=VSS}
C {bitcell_6t.sym} 6200 16000 0 0 {name=Xr80c31}
N 6160 16040 6140 16040 {}
C {lab_pin.sym} 6140 16040 0 0 {name=l12956 lab=BL31}
N 6160 16000 6140 16000 {}
C {lab_pin.sym} 6140 16000 0 0 {name=l12957 lab=BLB31}
N 6160 15960 6140 15960 {}
C {lab_pin.sym} 6140 15960 0 0 {name=l12958 lab=WL80}
N 6240 16040 6260 16040 {}
C {lab_pin.sym} 6260 16040 0 0 {name=l12959 lab=VDD}
N 6240 15960 6260 15960 {}
C {lab_pin.sym} 6260 15960 0 0 {name=l12960 lab=VSS}
C {bitcell_6t.sym} 0 16200 0 0 {name=Xr81c0}
N -40 16240 -60 16240 {}
C {lab_pin.sym} -60 16240 0 0 {name=l12961 lab=BL0}
N -40 16200 -60 16200 {}
C {lab_pin.sym} -60 16200 0 0 {name=l12962 lab=BLB0}
N -40 16160 -60 16160 {}
C {lab_pin.sym} -60 16160 0 0 {name=l12963 lab=WL81}
N 40 16240 60 16240 {}
C {lab_pin.sym} 60 16240 0 0 {name=l12964 lab=VDD}
N 40 16160 60 16160 {}
C {lab_pin.sym} 60 16160 0 0 {name=l12965 lab=VSS}
C {bitcell_6t.sym} 200 16200 0 0 {name=Xr81c1}
N 160 16240 140 16240 {}
C {lab_pin.sym} 140 16240 0 0 {name=l12966 lab=BL1}
N 160 16200 140 16200 {}
C {lab_pin.sym} 140 16200 0 0 {name=l12967 lab=BLB1}
N 160 16160 140 16160 {}
C {lab_pin.sym} 140 16160 0 0 {name=l12968 lab=WL81}
N 240 16240 260 16240 {}
C {lab_pin.sym} 260 16240 0 0 {name=l12969 lab=VDD}
N 240 16160 260 16160 {}
C {lab_pin.sym} 260 16160 0 0 {name=l12970 lab=VSS}
C {bitcell_6t.sym} 400 16200 0 0 {name=Xr81c2}
N 360 16240 340 16240 {}
C {lab_pin.sym} 340 16240 0 0 {name=l12971 lab=BL2}
N 360 16200 340 16200 {}
C {lab_pin.sym} 340 16200 0 0 {name=l12972 lab=BLB2}
N 360 16160 340 16160 {}
C {lab_pin.sym} 340 16160 0 0 {name=l12973 lab=WL81}
N 440 16240 460 16240 {}
C {lab_pin.sym} 460 16240 0 0 {name=l12974 lab=VDD}
N 440 16160 460 16160 {}
C {lab_pin.sym} 460 16160 0 0 {name=l12975 lab=VSS}
C {bitcell_6t.sym} 600 16200 0 0 {name=Xr81c3}
N 560 16240 540 16240 {}
C {lab_pin.sym} 540 16240 0 0 {name=l12976 lab=BL3}
N 560 16200 540 16200 {}
C {lab_pin.sym} 540 16200 0 0 {name=l12977 lab=BLB3}
N 560 16160 540 16160 {}
C {lab_pin.sym} 540 16160 0 0 {name=l12978 lab=WL81}
N 640 16240 660 16240 {}
C {lab_pin.sym} 660 16240 0 0 {name=l12979 lab=VDD}
N 640 16160 660 16160 {}
C {lab_pin.sym} 660 16160 0 0 {name=l12980 lab=VSS}
C {bitcell_6t.sym} 800 16200 0 0 {name=Xr81c4}
N 760 16240 740 16240 {}
C {lab_pin.sym} 740 16240 0 0 {name=l12981 lab=BL4}
N 760 16200 740 16200 {}
C {lab_pin.sym} 740 16200 0 0 {name=l12982 lab=BLB4}
N 760 16160 740 16160 {}
C {lab_pin.sym} 740 16160 0 0 {name=l12983 lab=WL81}
N 840 16240 860 16240 {}
C {lab_pin.sym} 860 16240 0 0 {name=l12984 lab=VDD}
N 840 16160 860 16160 {}
C {lab_pin.sym} 860 16160 0 0 {name=l12985 lab=VSS}
C {bitcell_6t.sym} 1000 16200 0 0 {name=Xr81c5}
N 960 16240 940 16240 {}
C {lab_pin.sym} 940 16240 0 0 {name=l12986 lab=BL5}
N 960 16200 940 16200 {}
C {lab_pin.sym} 940 16200 0 0 {name=l12987 lab=BLB5}
N 960 16160 940 16160 {}
C {lab_pin.sym} 940 16160 0 0 {name=l12988 lab=WL81}
N 1040 16240 1060 16240 {}
C {lab_pin.sym} 1060 16240 0 0 {name=l12989 lab=VDD}
N 1040 16160 1060 16160 {}
C {lab_pin.sym} 1060 16160 0 0 {name=l12990 lab=VSS}
C {bitcell_6t.sym} 1200 16200 0 0 {name=Xr81c6}
N 1160 16240 1140 16240 {}
C {lab_pin.sym} 1140 16240 0 0 {name=l12991 lab=BL6}
N 1160 16200 1140 16200 {}
C {lab_pin.sym} 1140 16200 0 0 {name=l12992 lab=BLB6}
N 1160 16160 1140 16160 {}
C {lab_pin.sym} 1140 16160 0 0 {name=l12993 lab=WL81}
N 1240 16240 1260 16240 {}
C {lab_pin.sym} 1260 16240 0 0 {name=l12994 lab=VDD}
N 1240 16160 1260 16160 {}
C {lab_pin.sym} 1260 16160 0 0 {name=l12995 lab=VSS}
C {bitcell_6t.sym} 1400 16200 0 0 {name=Xr81c7}
N 1360 16240 1340 16240 {}
C {lab_pin.sym} 1340 16240 0 0 {name=l12996 lab=BL7}
N 1360 16200 1340 16200 {}
C {lab_pin.sym} 1340 16200 0 0 {name=l12997 lab=BLB7}
N 1360 16160 1340 16160 {}
C {lab_pin.sym} 1340 16160 0 0 {name=l12998 lab=WL81}
N 1440 16240 1460 16240 {}
C {lab_pin.sym} 1460 16240 0 0 {name=l12999 lab=VDD}
N 1440 16160 1460 16160 {}
C {lab_pin.sym} 1460 16160 0 0 {name=l13000 lab=VSS}
C {bitcell_6t.sym} 1600 16200 0 0 {name=Xr81c8}
N 1560 16240 1540 16240 {}
C {lab_pin.sym} 1540 16240 0 0 {name=l13001 lab=BL8}
N 1560 16200 1540 16200 {}
C {lab_pin.sym} 1540 16200 0 0 {name=l13002 lab=BLB8}
N 1560 16160 1540 16160 {}
C {lab_pin.sym} 1540 16160 0 0 {name=l13003 lab=WL81}
N 1640 16240 1660 16240 {}
C {lab_pin.sym} 1660 16240 0 0 {name=l13004 lab=VDD}
N 1640 16160 1660 16160 {}
C {lab_pin.sym} 1660 16160 0 0 {name=l13005 lab=VSS}
C {bitcell_6t.sym} 1800 16200 0 0 {name=Xr81c9}
N 1760 16240 1740 16240 {}
C {lab_pin.sym} 1740 16240 0 0 {name=l13006 lab=BL9}
N 1760 16200 1740 16200 {}
C {lab_pin.sym} 1740 16200 0 0 {name=l13007 lab=BLB9}
N 1760 16160 1740 16160 {}
C {lab_pin.sym} 1740 16160 0 0 {name=l13008 lab=WL81}
N 1840 16240 1860 16240 {}
C {lab_pin.sym} 1860 16240 0 0 {name=l13009 lab=VDD}
N 1840 16160 1860 16160 {}
C {lab_pin.sym} 1860 16160 0 0 {name=l13010 lab=VSS}
C {bitcell_6t.sym} 2000 16200 0 0 {name=Xr81c10}
N 1960 16240 1940 16240 {}
C {lab_pin.sym} 1940 16240 0 0 {name=l13011 lab=BL10}
N 1960 16200 1940 16200 {}
C {lab_pin.sym} 1940 16200 0 0 {name=l13012 lab=BLB10}
N 1960 16160 1940 16160 {}
C {lab_pin.sym} 1940 16160 0 0 {name=l13013 lab=WL81}
N 2040 16240 2060 16240 {}
C {lab_pin.sym} 2060 16240 0 0 {name=l13014 lab=VDD}
N 2040 16160 2060 16160 {}
C {lab_pin.sym} 2060 16160 0 0 {name=l13015 lab=VSS}
C {bitcell_6t.sym} 2200 16200 0 0 {name=Xr81c11}
N 2160 16240 2140 16240 {}
C {lab_pin.sym} 2140 16240 0 0 {name=l13016 lab=BL11}
N 2160 16200 2140 16200 {}
C {lab_pin.sym} 2140 16200 0 0 {name=l13017 lab=BLB11}
N 2160 16160 2140 16160 {}
C {lab_pin.sym} 2140 16160 0 0 {name=l13018 lab=WL81}
N 2240 16240 2260 16240 {}
C {lab_pin.sym} 2260 16240 0 0 {name=l13019 lab=VDD}
N 2240 16160 2260 16160 {}
C {lab_pin.sym} 2260 16160 0 0 {name=l13020 lab=VSS}
C {bitcell_6t.sym} 2400 16200 0 0 {name=Xr81c12}
N 2360 16240 2340 16240 {}
C {lab_pin.sym} 2340 16240 0 0 {name=l13021 lab=BL12}
N 2360 16200 2340 16200 {}
C {lab_pin.sym} 2340 16200 0 0 {name=l13022 lab=BLB12}
N 2360 16160 2340 16160 {}
C {lab_pin.sym} 2340 16160 0 0 {name=l13023 lab=WL81}
N 2440 16240 2460 16240 {}
C {lab_pin.sym} 2460 16240 0 0 {name=l13024 lab=VDD}
N 2440 16160 2460 16160 {}
C {lab_pin.sym} 2460 16160 0 0 {name=l13025 lab=VSS}
C {bitcell_6t.sym} 2600 16200 0 0 {name=Xr81c13}
N 2560 16240 2540 16240 {}
C {lab_pin.sym} 2540 16240 0 0 {name=l13026 lab=BL13}
N 2560 16200 2540 16200 {}
C {lab_pin.sym} 2540 16200 0 0 {name=l13027 lab=BLB13}
N 2560 16160 2540 16160 {}
C {lab_pin.sym} 2540 16160 0 0 {name=l13028 lab=WL81}
N 2640 16240 2660 16240 {}
C {lab_pin.sym} 2660 16240 0 0 {name=l13029 lab=VDD}
N 2640 16160 2660 16160 {}
C {lab_pin.sym} 2660 16160 0 0 {name=l13030 lab=VSS}
C {bitcell_6t.sym} 2800 16200 0 0 {name=Xr81c14}
N 2760 16240 2740 16240 {}
C {lab_pin.sym} 2740 16240 0 0 {name=l13031 lab=BL14}
N 2760 16200 2740 16200 {}
C {lab_pin.sym} 2740 16200 0 0 {name=l13032 lab=BLB14}
N 2760 16160 2740 16160 {}
C {lab_pin.sym} 2740 16160 0 0 {name=l13033 lab=WL81}
N 2840 16240 2860 16240 {}
C {lab_pin.sym} 2860 16240 0 0 {name=l13034 lab=VDD}
N 2840 16160 2860 16160 {}
C {lab_pin.sym} 2860 16160 0 0 {name=l13035 lab=VSS}
C {bitcell_6t.sym} 3000 16200 0 0 {name=Xr81c15}
N 2960 16240 2940 16240 {}
C {lab_pin.sym} 2940 16240 0 0 {name=l13036 lab=BL15}
N 2960 16200 2940 16200 {}
C {lab_pin.sym} 2940 16200 0 0 {name=l13037 lab=BLB15}
N 2960 16160 2940 16160 {}
C {lab_pin.sym} 2940 16160 0 0 {name=l13038 lab=WL81}
N 3040 16240 3060 16240 {}
C {lab_pin.sym} 3060 16240 0 0 {name=l13039 lab=VDD}
N 3040 16160 3060 16160 {}
C {lab_pin.sym} 3060 16160 0 0 {name=l13040 lab=VSS}
C {bitcell_6t.sym} 3200 16200 0 0 {name=Xr81c16}
N 3160 16240 3140 16240 {}
C {lab_pin.sym} 3140 16240 0 0 {name=l13041 lab=BL16}
N 3160 16200 3140 16200 {}
C {lab_pin.sym} 3140 16200 0 0 {name=l13042 lab=BLB16}
N 3160 16160 3140 16160 {}
C {lab_pin.sym} 3140 16160 0 0 {name=l13043 lab=WL81}
N 3240 16240 3260 16240 {}
C {lab_pin.sym} 3260 16240 0 0 {name=l13044 lab=VDD}
N 3240 16160 3260 16160 {}
C {lab_pin.sym} 3260 16160 0 0 {name=l13045 lab=VSS}
C {bitcell_6t.sym} 3400 16200 0 0 {name=Xr81c17}
N 3360 16240 3340 16240 {}
C {lab_pin.sym} 3340 16240 0 0 {name=l13046 lab=BL17}
N 3360 16200 3340 16200 {}
C {lab_pin.sym} 3340 16200 0 0 {name=l13047 lab=BLB17}
N 3360 16160 3340 16160 {}
C {lab_pin.sym} 3340 16160 0 0 {name=l13048 lab=WL81}
N 3440 16240 3460 16240 {}
C {lab_pin.sym} 3460 16240 0 0 {name=l13049 lab=VDD}
N 3440 16160 3460 16160 {}
C {lab_pin.sym} 3460 16160 0 0 {name=l13050 lab=VSS}
C {bitcell_6t.sym} 3600 16200 0 0 {name=Xr81c18}
N 3560 16240 3540 16240 {}
C {lab_pin.sym} 3540 16240 0 0 {name=l13051 lab=BL18}
N 3560 16200 3540 16200 {}
C {lab_pin.sym} 3540 16200 0 0 {name=l13052 lab=BLB18}
N 3560 16160 3540 16160 {}
C {lab_pin.sym} 3540 16160 0 0 {name=l13053 lab=WL81}
N 3640 16240 3660 16240 {}
C {lab_pin.sym} 3660 16240 0 0 {name=l13054 lab=VDD}
N 3640 16160 3660 16160 {}
C {lab_pin.sym} 3660 16160 0 0 {name=l13055 lab=VSS}
C {bitcell_6t.sym} 3800 16200 0 0 {name=Xr81c19}
N 3760 16240 3740 16240 {}
C {lab_pin.sym} 3740 16240 0 0 {name=l13056 lab=BL19}
N 3760 16200 3740 16200 {}
C {lab_pin.sym} 3740 16200 0 0 {name=l13057 lab=BLB19}
N 3760 16160 3740 16160 {}
C {lab_pin.sym} 3740 16160 0 0 {name=l13058 lab=WL81}
N 3840 16240 3860 16240 {}
C {lab_pin.sym} 3860 16240 0 0 {name=l13059 lab=VDD}
N 3840 16160 3860 16160 {}
C {lab_pin.sym} 3860 16160 0 0 {name=l13060 lab=VSS}
C {bitcell_6t.sym} 4000 16200 0 0 {name=Xr81c20}
N 3960 16240 3940 16240 {}
C {lab_pin.sym} 3940 16240 0 0 {name=l13061 lab=BL20}
N 3960 16200 3940 16200 {}
C {lab_pin.sym} 3940 16200 0 0 {name=l13062 lab=BLB20}
N 3960 16160 3940 16160 {}
C {lab_pin.sym} 3940 16160 0 0 {name=l13063 lab=WL81}
N 4040 16240 4060 16240 {}
C {lab_pin.sym} 4060 16240 0 0 {name=l13064 lab=VDD}
N 4040 16160 4060 16160 {}
C {lab_pin.sym} 4060 16160 0 0 {name=l13065 lab=VSS}
C {bitcell_6t.sym} 4200 16200 0 0 {name=Xr81c21}
N 4160 16240 4140 16240 {}
C {lab_pin.sym} 4140 16240 0 0 {name=l13066 lab=BL21}
N 4160 16200 4140 16200 {}
C {lab_pin.sym} 4140 16200 0 0 {name=l13067 lab=BLB21}
N 4160 16160 4140 16160 {}
C {lab_pin.sym} 4140 16160 0 0 {name=l13068 lab=WL81}
N 4240 16240 4260 16240 {}
C {lab_pin.sym} 4260 16240 0 0 {name=l13069 lab=VDD}
N 4240 16160 4260 16160 {}
C {lab_pin.sym} 4260 16160 0 0 {name=l13070 lab=VSS}
C {bitcell_6t.sym} 4400 16200 0 0 {name=Xr81c22}
N 4360 16240 4340 16240 {}
C {lab_pin.sym} 4340 16240 0 0 {name=l13071 lab=BL22}
N 4360 16200 4340 16200 {}
C {lab_pin.sym} 4340 16200 0 0 {name=l13072 lab=BLB22}
N 4360 16160 4340 16160 {}
C {lab_pin.sym} 4340 16160 0 0 {name=l13073 lab=WL81}
N 4440 16240 4460 16240 {}
C {lab_pin.sym} 4460 16240 0 0 {name=l13074 lab=VDD}
N 4440 16160 4460 16160 {}
C {lab_pin.sym} 4460 16160 0 0 {name=l13075 lab=VSS}
C {bitcell_6t.sym} 4600 16200 0 0 {name=Xr81c23}
N 4560 16240 4540 16240 {}
C {lab_pin.sym} 4540 16240 0 0 {name=l13076 lab=BL23}
N 4560 16200 4540 16200 {}
C {lab_pin.sym} 4540 16200 0 0 {name=l13077 lab=BLB23}
N 4560 16160 4540 16160 {}
C {lab_pin.sym} 4540 16160 0 0 {name=l13078 lab=WL81}
N 4640 16240 4660 16240 {}
C {lab_pin.sym} 4660 16240 0 0 {name=l13079 lab=VDD}
N 4640 16160 4660 16160 {}
C {lab_pin.sym} 4660 16160 0 0 {name=l13080 lab=VSS}
C {bitcell_6t.sym} 4800 16200 0 0 {name=Xr81c24}
N 4760 16240 4740 16240 {}
C {lab_pin.sym} 4740 16240 0 0 {name=l13081 lab=BL24}
N 4760 16200 4740 16200 {}
C {lab_pin.sym} 4740 16200 0 0 {name=l13082 lab=BLB24}
N 4760 16160 4740 16160 {}
C {lab_pin.sym} 4740 16160 0 0 {name=l13083 lab=WL81}
N 4840 16240 4860 16240 {}
C {lab_pin.sym} 4860 16240 0 0 {name=l13084 lab=VDD}
N 4840 16160 4860 16160 {}
C {lab_pin.sym} 4860 16160 0 0 {name=l13085 lab=VSS}
C {bitcell_6t.sym} 5000 16200 0 0 {name=Xr81c25}
N 4960 16240 4940 16240 {}
C {lab_pin.sym} 4940 16240 0 0 {name=l13086 lab=BL25}
N 4960 16200 4940 16200 {}
C {lab_pin.sym} 4940 16200 0 0 {name=l13087 lab=BLB25}
N 4960 16160 4940 16160 {}
C {lab_pin.sym} 4940 16160 0 0 {name=l13088 lab=WL81}
N 5040 16240 5060 16240 {}
C {lab_pin.sym} 5060 16240 0 0 {name=l13089 lab=VDD}
N 5040 16160 5060 16160 {}
C {lab_pin.sym} 5060 16160 0 0 {name=l13090 lab=VSS}
C {bitcell_6t.sym} 5200 16200 0 0 {name=Xr81c26}
N 5160 16240 5140 16240 {}
C {lab_pin.sym} 5140 16240 0 0 {name=l13091 lab=BL26}
N 5160 16200 5140 16200 {}
C {lab_pin.sym} 5140 16200 0 0 {name=l13092 lab=BLB26}
N 5160 16160 5140 16160 {}
C {lab_pin.sym} 5140 16160 0 0 {name=l13093 lab=WL81}
N 5240 16240 5260 16240 {}
C {lab_pin.sym} 5260 16240 0 0 {name=l13094 lab=VDD}
N 5240 16160 5260 16160 {}
C {lab_pin.sym} 5260 16160 0 0 {name=l13095 lab=VSS}
C {bitcell_6t.sym} 5400 16200 0 0 {name=Xr81c27}
N 5360 16240 5340 16240 {}
C {lab_pin.sym} 5340 16240 0 0 {name=l13096 lab=BL27}
N 5360 16200 5340 16200 {}
C {lab_pin.sym} 5340 16200 0 0 {name=l13097 lab=BLB27}
N 5360 16160 5340 16160 {}
C {lab_pin.sym} 5340 16160 0 0 {name=l13098 lab=WL81}
N 5440 16240 5460 16240 {}
C {lab_pin.sym} 5460 16240 0 0 {name=l13099 lab=VDD}
N 5440 16160 5460 16160 {}
C {lab_pin.sym} 5460 16160 0 0 {name=l13100 lab=VSS}
C {bitcell_6t.sym} 5600 16200 0 0 {name=Xr81c28}
N 5560 16240 5540 16240 {}
C {lab_pin.sym} 5540 16240 0 0 {name=l13101 lab=BL28}
N 5560 16200 5540 16200 {}
C {lab_pin.sym} 5540 16200 0 0 {name=l13102 lab=BLB28}
N 5560 16160 5540 16160 {}
C {lab_pin.sym} 5540 16160 0 0 {name=l13103 lab=WL81}
N 5640 16240 5660 16240 {}
C {lab_pin.sym} 5660 16240 0 0 {name=l13104 lab=VDD}
N 5640 16160 5660 16160 {}
C {lab_pin.sym} 5660 16160 0 0 {name=l13105 lab=VSS}
C {bitcell_6t.sym} 5800 16200 0 0 {name=Xr81c29}
N 5760 16240 5740 16240 {}
C {lab_pin.sym} 5740 16240 0 0 {name=l13106 lab=BL29}
N 5760 16200 5740 16200 {}
C {lab_pin.sym} 5740 16200 0 0 {name=l13107 lab=BLB29}
N 5760 16160 5740 16160 {}
C {lab_pin.sym} 5740 16160 0 0 {name=l13108 lab=WL81}
N 5840 16240 5860 16240 {}
C {lab_pin.sym} 5860 16240 0 0 {name=l13109 lab=VDD}
N 5840 16160 5860 16160 {}
C {lab_pin.sym} 5860 16160 0 0 {name=l13110 lab=VSS}
C {bitcell_6t.sym} 6000 16200 0 0 {name=Xr81c30}
N 5960 16240 5940 16240 {}
C {lab_pin.sym} 5940 16240 0 0 {name=l13111 lab=BL30}
N 5960 16200 5940 16200 {}
C {lab_pin.sym} 5940 16200 0 0 {name=l13112 lab=BLB30}
N 5960 16160 5940 16160 {}
C {lab_pin.sym} 5940 16160 0 0 {name=l13113 lab=WL81}
N 6040 16240 6060 16240 {}
C {lab_pin.sym} 6060 16240 0 0 {name=l13114 lab=VDD}
N 6040 16160 6060 16160 {}
C {lab_pin.sym} 6060 16160 0 0 {name=l13115 lab=VSS}
C {bitcell_6t.sym} 6200 16200 0 0 {name=Xr81c31}
N 6160 16240 6140 16240 {}
C {lab_pin.sym} 6140 16240 0 0 {name=l13116 lab=BL31}
N 6160 16200 6140 16200 {}
C {lab_pin.sym} 6140 16200 0 0 {name=l13117 lab=BLB31}
N 6160 16160 6140 16160 {}
C {lab_pin.sym} 6140 16160 0 0 {name=l13118 lab=WL81}
N 6240 16240 6260 16240 {}
C {lab_pin.sym} 6260 16240 0 0 {name=l13119 lab=VDD}
N 6240 16160 6260 16160 {}
C {lab_pin.sym} 6260 16160 0 0 {name=l13120 lab=VSS}
C {bitcell_6t.sym} 0 16400 0 0 {name=Xr82c0}
N -40 16440 -60 16440 {}
C {lab_pin.sym} -60 16440 0 0 {name=l13121 lab=BL0}
N -40 16400 -60 16400 {}
C {lab_pin.sym} -60 16400 0 0 {name=l13122 lab=BLB0}
N -40 16360 -60 16360 {}
C {lab_pin.sym} -60 16360 0 0 {name=l13123 lab=WL82}
N 40 16440 60 16440 {}
C {lab_pin.sym} 60 16440 0 0 {name=l13124 lab=VDD}
N 40 16360 60 16360 {}
C {lab_pin.sym} 60 16360 0 0 {name=l13125 lab=VSS}
C {bitcell_6t.sym} 200 16400 0 0 {name=Xr82c1}
N 160 16440 140 16440 {}
C {lab_pin.sym} 140 16440 0 0 {name=l13126 lab=BL1}
N 160 16400 140 16400 {}
C {lab_pin.sym} 140 16400 0 0 {name=l13127 lab=BLB1}
N 160 16360 140 16360 {}
C {lab_pin.sym} 140 16360 0 0 {name=l13128 lab=WL82}
N 240 16440 260 16440 {}
C {lab_pin.sym} 260 16440 0 0 {name=l13129 lab=VDD}
N 240 16360 260 16360 {}
C {lab_pin.sym} 260 16360 0 0 {name=l13130 lab=VSS}
C {bitcell_6t.sym} 400 16400 0 0 {name=Xr82c2}
N 360 16440 340 16440 {}
C {lab_pin.sym} 340 16440 0 0 {name=l13131 lab=BL2}
N 360 16400 340 16400 {}
C {lab_pin.sym} 340 16400 0 0 {name=l13132 lab=BLB2}
N 360 16360 340 16360 {}
C {lab_pin.sym} 340 16360 0 0 {name=l13133 lab=WL82}
N 440 16440 460 16440 {}
C {lab_pin.sym} 460 16440 0 0 {name=l13134 lab=VDD}
N 440 16360 460 16360 {}
C {lab_pin.sym} 460 16360 0 0 {name=l13135 lab=VSS}
C {bitcell_6t.sym} 600 16400 0 0 {name=Xr82c3}
N 560 16440 540 16440 {}
C {lab_pin.sym} 540 16440 0 0 {name=l13136 lab=BL3}
N 560 16400 540 16400 {}
C {lab_pin.sym} 540 16400 0 0 {name=l13137 lab=BLB3}
N 560 16360 540 16360 {}
C {lab_pin.sym} 540 16360 0 0 {name=l13138 lab=WL82}
N 640 16440 660 16440 {}
C {lab_pin.sym} 660 16440 0 0 {name=l13139 lab=VDD}
N 640 16360 660 16360 {}
C {lab_pin.sym} 660 16360 0 0 {name=l13140 lab=VSS}
C {bitcell_6t.sym} 800 16400 0 0 {name=Xr82c4}
N 760 16440 740 16440 {}
C {lab_pin.sym} 740 16440 0 0 {name=l13141 lab=BL4}
N 760 16400 740 16400 {}
C {lab_pin.sym} 740 16400 0 0 {name=l13142 lab=BLB4}
N 760 16360 740 16360 {}
C {lab_pin.sym} 740 16360 0 0 {name=l13143 lab=WL82}
N 840 16440 860 16440 {}
C {lab_pin.sym} 860 16440 0 0 {name=l13144 lab=VDD}
N 840 16360 860 16360 {}
C {lab_pin.sym} 860 16360 0 0 {name=l13145 lab=VSS}
C {bitcell_6t.sym} 1000 16400 0 0 {name=Xr82c5}
N 960 16440 940 16440 {}
C {lab_pin.sym} 940 16440 0 0 {name=l13146 lab=BL5}
N 960 16400 940 16400 {}
C {lab_pin.sym} 940 16400 0 0 {name=l13147 lab=BLB5}
N 960 16360 940 16360 {}
C {lab_pin.sym} 940 16360 0 0 {name=l13148 lab=WL82}
N 1040 16440 1060 16440 {}
C {lab_pin.sym} 1060 16440 0 0 {name=l13149 lab=VDD}
N 1040 16360 1060 16360 {}
C {lab_pin.sym} 1060 16360 0 0 {name=l13150 lab=VSS}
C {bitcell_6t.sym} 1200 16400 0 0 {name=Xr82c6}
N 1160 16440 1140 16440 {}
C {lab_pin.sym} 1140 16440 0 0 {name=l13151 lab=BL6}
N 1160 16400 1140 16400 {}
C {lab_pin.sym} 1140 16400 0 0 {name=l13152 lab=BLB6}
N 1160 16360 1140 16360 {}
C {lab_pin.sym} 1140 16360 0 0 {name=l13153 lab=WL82}
N 1240 16440 1260 16440 {}
C {lab_pin.sym} 1260 16440 0 0 {name=l13154 lab=VDD}
N 1240 16360 1260 16360 {}
C {lab_pin.sym} 1260 16360 0 0 {name=l13155 lab=VSS}
C {bitcell_6t.sym} 1400 16400 0 0 {name=Xr82c7}
N 1360 16440 1340 16440 {}
C {lab_pin.sym} 1340 16440 0 0 {name=l13156 lab=BL7}
N 1360 16400 1340 16400 {}
C {lab_pin.sym} 1340 16400 0 0 {name=l13157 lab=BLB7}
N 1360 16360 1340 16360 {}
C {lab_pin.sym} 1340 16360 0 0 {name=l13158 lab=WL82}
N 1440 16440 1460 16440 {}
C {lab_pin.sym} 1460 16440 0 0 {name=l13159 lab=VDD}
N 1440 16360 1460 16360 {}
C {lab_pin.sym} 1460 16360 0 0 {name=l13160 lab=VSS}
C {bitcell_6t.sym} 1600 16400 0 0 {name=Xr82c8}
N 1560 16440 1540 16440 {}
C {lab_pin.sym} 1540 16440 0 0 {name=l13161 lab=BL8}
N 1560 16400 1540 16400 {}
C {lab_pin.sym} 1540 16400 0 0 {name=l13162 lab=BLB8}
N 1560 16360 1540 16360 {}
C {lab_pin.sym} 1540 16360 0 0 {name=l13163 lab=WL82}
N 1640 16440 1660 16440 {}
C {lab_pin.sym} 1660 16440 0 0 {name=l13164 lab=VDD}
N 1640 16360 1660 16360 {}
C {lab_pin.sym} 1660 16360 0 0 {name=l13165 lab=VSS}
C {bitcell_6t.sym} 1800 16400 0 0 {name=Xr82c9}
N 1760 16440 1740 16440 {}
C {lab_pin.sym} 1740 16440 0 0 {name=l13166 lab=BL9}
N 1760 16400 1740 16400 {}
C {lab_pin.sym} 1740 16400 0 0 {name=l13167 lab=BLB9}
N 1760 16360 1740 16360 {}
C {lab_pin.sym} 1740 16360 0 0 {name=l13168 lab=WL82}
N 1840 16440 1860 16440 {}
C {lab_pin.sym} 1860 16440 0 0 {name=l13169 lab=VDD}
N 1840 16360 1860 16360 {}
C {lab_pin.sym} 1860 16360 0 0 {name=l13170 lab=VSS}
C {bitcell_6t.sym} 2000 16400 0 0 {name=Xr82c10}
N 1960 16440 1940 16440 {}
C {lab_pin.sym} 1940 16440 0 0 {name=l13171 lab=BL10}
N 1960 16400 1940 16400 {}
C {lab_pin.sym} 1940 16400 0 0 {name=l13172 lab=BLB10}
N 1960 16360 1940 16360 {}
C {lab_pin.sym} 1940 16360 0 0 {name=l13173 lab=WL82}
N 2040 16440 2060 16440 {}
C {lab_pin.sym} 2060 16440 0 0 {name=l13174 lab=VDD}
N 2040 16360 2060 16360 {}
C {lab_pin.sym} 2060 16360 0 0 {name=l13175 lab=VSS}
C {bitcell_6t.sym} 2200 16400 0 0 {name=Xr82c11}
N 2160 16440 2140 16440 {}
C {lab_pin.sym} 2140 16440 0 0 {name=l13176 lab=BL11}
N 2160 16400 2140 16400 {}
C {lab_pin.sym} 2140 16400 0 0 {name=l13177 lab=BLB11}
N 2160 16360 2140 16360 {}
C {lab_pin.sym} 2140 16360 0 0 {name=l13178 lab=WL82}
N 2240 16440 2260 16440 {}
C {lab_pin.sym} 2260 16440 0 0 {name=l13179 lab=VDD}
N 2240 16360 2260 16360 {}
C {lab_pin.sym} 2260 16360 0 0 {name=l13180 lab=VSS}
C {bitcell_6t.sym} 2400 16400 0 0 {name=Xr82c12}
N 2360 16440 2340 16440 {}
C {lab_pin.sym} 2340 16440 0 0 {name=l13181 lab=BL12}
N 2360 16400 2340 16400 {}
C {lab_pin.sym} 2340 16400 0 0 {name=l13182 lab=BLB12}
N 2360 16360 2340 16360 {}
C {lab_pin.sym} 2340 16360 0 0 {name=l13183 lab=WL82}
N 2440 16440 2460 16440 {}
C {lab_pin.sym} 2460 16440 0 0 {name=l13184 lab=VDD}
N 2440 16360 2460 16360 {}
C {lab_pin.sym} 2460 16360 0 0 {name=l13185 lab=VSS}
C {bitcell_6t.sym} 2600 16400 0 0 {name=Xr82c13}
N 2560 16440 2540 16440 {}
C {lab_pin.sym} 2540 16440 0 0 {name=l13186 lab=BL13}
N 2560 16400 2540 16400 {}
C {lab_pin.sym} 2540 16400 0 0 {name=l13187 lab=BLB13}
N 2560 16360 2540 16360 {}
C {lab_pin.sym} 2540 16360 0 0 {name=l13188 lab=WL82}
N 2640 16440 2660 16440 {}
C {lab_pin.sym} 2660 16440 0 0 {name=l13189 lab=VDD}
N 2640 16360 2660 16360 {}
C {lab_pin.sym} 2660 16360 0 0 {name=l13190 lab=VSS}
C {bitcell_6t.sym} 2800 16400 0 0 {name=Xr82c14}
N 2760 16440 2740 16440 {}
C {lab_pin.sym} 2740 16440 0 0 {name=l13191 lab=BL14}
N 2760 16400 2740 16400 {}
C {lab_pin.sym} 2740 16400 0 0 {name=l13192 lab=BLB14}
N 2760 16360 2740 16360 {}
C {lab_pin.sym} 2740 16360 0 0 {name=l13193 lab=WL82}
N 2840 16440 2860 16440 {}
C {lab_pin.sym} 2860 16440 0 0 {name=l13194 lab=VDD}
N 2840 16360 2860 16360 {}
C {lab_pin.sym} 2860 16360 0 0 {name=l13195 lab=VSS}
C {bitcell_6t.sym} 3000 16400 0 0 {name=Xr82c15}
N 2960 16440 2940 16440 {}
C {lab_pin.sym} 2940 16440 0 0 {name=l13196 lab=BL15}
N 2960 16400 2940 16400 {}
C {lab_pin.sym} 2940 16400 0 0 {name=l13197 lab=BLB15}
N 2960 16360 2940 16360 {}
C {lab_pin.sym} 2940 16360 0 0 {name=l13198 lab=WL82}
N 3040 16440 3060 16440 {}
C {lab_pin.sym} 3060 16440 0 0 {name=l13199 lab=VDD}
N 3040 16360 3060 16360 {}
C {lab_pin.sym} 3060 16360 0 0 {name=l13200 lab=VSS}
C {bitcell_6t.sym} 3200 16400 0 0 {name=Xr82c16}
N 3160 16440 3140 16440 {}
C {lab_pin.sym} 3140 16440 0 0 {name=l13201 lab=BL16}
N 3160 16400 3140 16400 {}
C {lab_pin.sym} 3140 16400 0 0 {name=l13202 lab=BLB16}
N 3160 16360 3140 16360 {}
C {lab_pin.sym} 3140 16360 0 0 {name=l13203 lab=WL82}
N 3240 16440 3260 16440 {}
C {lab_pin.sym} 3260 16440 0 0 {name=l13204 lab=VDD}
N 3240 16360 3260 16360 {}
C {lab_pin.sym} 3260 16360 0 0 {name=l13205 lab=VSS}
C {bitcell_6t.sym} 3400 16400 0 0 {name=Xr82c17}
N 3360 16440 3340 16440 {}
C {lab_pin.sym} 3340 16440 0 0 {name=l13206 lab=BL17}
N 3360 16400 3340 16400 {}
C {lab_pin.sym} 3340 16400 0 0 {name=l13207 lab=BLB17}
N 3360 16360 3340 16360 {}
C {lab_pin.sym} 3340 16360 0 0 {name=l13208 lab=WL82}
N 3440 16440 3460 16440 {}
C {lab_pin.sym} 3460 16440 0 0 {name=l13209 lab=VDD}
N 3440 16360 3460 16360 {}
C {lab_pin.sym} 3460 16360 0 0 {name=l13210 lab=VSS}
C {bitcell_6t.sym} 3600 16400 0 0 {name=Xr82c18}
N 3560 16440 3540 16440 {}
C {lab_pin.sym} 3540 16440 0 0 {name=l13211 lab=BL18}
N 3560 16400 3540 16400 {}
C {lab_pin.sym} 3540 16400 0 0 {name=l13212 lab=BLB18}
N 3560 16360 3540 16360 {}
C {lab_pin.sym} 3540 16360 0 0 {name=l13213 lab=WL82}
N 3640 16440 3660 16440 {}
C {lab_pin.sym} 3660 16440 0 0 {name=l13214 lab=VDD}
N 3640 16360 3660 16360 {}
C {lab_pin.sym} 3660 16360 0 0 {name=l13215 lab=VSS}
C {bitcell_6t.sym} 3800 16400 0 0 {name=Xr82c19}
N 3760 16440 3740 16440 {}
C {lab_pin.sym} 3740 16440 0 0 {name=l13216 lab=BL19}
N 3760 16400 3740 16400 {}
C {lab_pin.sym} 3740 16400 0 0 {name=l13217 lab=BLB19}
N 3760 16360 3740 16360 {}
C {lab_pin.sym} 3740 16360 0 0 {name=l13218 lab=WL82}
N 3840 16440 3860 16440 {}
C {lab_pin.sym} 3860 16440 0 0 {name=l13219 lab=VDD}
N 3840 16360 3860 16360 {}
C {lab_pin.sym} 3860 16360 0 0 {name=l13220 lab=VSS}
C {bitcell_6t.sym} 4000 16400 0 0 {name=Xr82c20}
N 3960 16440 3940 16440 {}
C {lab_pin.sym} 3940 16440 0 0 {name=l13221 lab=BL20}
N 3960 16400 3940 16400 {}
C {lab_pin.sym} 3940 16400 0 0 {name=l13222 lab=BLB20}
N 3960 16360 3940 16360 {}
C {lab_pin.sym} 3940 16360 0 0 {name=l13223 lab=WL82}
N 4040 16440 4060 16440 {}
C {lab_pin.sym} 4060 16440 0 0 {name=l13224 lab=VDD}
N 4040 16360 4060 16360 {}
C {lab_pin.sym} 4060 16360 0 0 {name=l13225 lab=VSS}
C {bitcell_6t.sym} 4200 16400 0 0 {name=Xr82c21}
N 4160 16440 4140 16440 {}
C {lab_pin.sym} 4140 16440 0 0 {name=l13226 lab=BL21}
N 4160 16400 4140 16400 {}
C {lab_pin.sym} 4140 16400 0 0 {name=l13227 lab=BLB21}
N 4160 16360 4140 16360 {}
C {lab_pin.sym} 4140 16360 0 0 {name=l13228 lab=WL82}
N 4240 16440 4260 16440 {}
C {lab_pin.sym} 4260 16440 0 0 {name=l13229 lab=VDD}
N 4240 16360 4260 16360 {}
C {lab_pin.sym} 4260 16360 0 0 {name=l13230 lab=VSS}
C {bitcell_6t.sym} 4400 16400 0 0 {name=Xr82c22}
N 4360 16440 4340 16440 {}
C {lab_pin.sym} 4340 16440 0 0 {name=l13231 lab=BL22}
N 4360 16400 4340 16400 {}
C {lab_pin.sym} 4340 16400 0 0 {name=l13232 lab=BLB22}
N 4360 16360 4340 16360 {}
C {lab_pin.sym} 4340 16360 0 0 {name=l13233 lab=WL82}
N 4440 16440 4460 16440 {}
C {lab_pin.sym} 4460 16440 0 0 {name=l13234 lab=VDD}
N 4440 16360 4460 16360 {}
C {lab_pin.sym} 4460 16360 0 0 {name=l13235 lab=VSS}
C {bitcell_6t.sym} 4600 16400 0 0 {name=Xr82c23}
N 4560 16440 4540 16440 {}
C {lab_pin.sym} 4540 16440 0 0 {name=l13236 lab=BL23}
N 4560 16400 4540 16400 {}
C {lab_pin.sym} 4540 16400 0 0 {name=l13237 lab=BLB23}
N 4560 16360 4540 16360 {}
C {lab_pin.sym} 4540 16360 0 0 {name=l13238 lab=WL82}
N 4640 16440 4660 16440 {}
C {lab_pin.sym} 4660 16440 0 0 {name=l13239 lab=VDD}
N 4640 16360 4660 16360 {}
C {lab_pin.sym} 4660 16360 0 0 {name=l13240 lab=VSS}
C {bitcell_6t.sym} 4800 16400 0 0 {name=Xr82c24}
N 4760 16440 4740 16440 {}
C {lab_pin.sym} 4740 16440 0 0 {name=l13241 lab=BL24}
N 4760 16400 4740 16400 {}
C {lab_pin.sym} 4740 16400 0 0 {name=l13242 lab=BLB24}
N 4760 16360 4740 16360 {}
C {lab_pin.sym} 4740 16360 0 0 {name=l13243 lab=WL82}
N 4840 16440 4860 16440 {}
C {lab_pin.sym} 4860 16440 0 0 {name=l13244 lab=VDD}
N 4840 16360 4860 16360 {}
C {lab_pin.sym} 4860 16360 0 0 {name=l13245 lab=VSS}
C {bitcell_6t.sym} 5000 16400 0 0 {name=Xr82c25}
N 4960 16440 4940 16440 {}
C {lab_pin.sym} 4940 16440 0 0 {name=l13246 lab=BL25}
N 4960 16400 4940 16400 {}
C {lab_pin.sym} 4940 16400 0 0 {name=l13247 lab=BLB25}
N 4960 16360 4940 16360 {}
C {lab_pin.sym} 4940 16360 0 0 {name=l13248 lab=WL82}
N 5040 16440 5060 16440 {}
C {lab_pin.sym} 5060 16440 0 0 {name=l13249 lab=VDD}
N 5040 16360 5060 16360 {}
C {lab_pin.sym} 5060 16360 0 0 {name=l13250 lab=VSS}
C {bitcell_6t.sym} 5200 16400 0 0 {name=Xr82c26}
N 5160 16440 5140 16440 {}
C {lab_pin.sym} 5140 16440 0 0 {name=l13251 lab=BL26}
N 5160 16400 5140 16400 {}
C {lab_pin.sym} 5140 16400 0 0 {name=l13252 lab=BLB26}
N 5160 16360 5140 16360 {}
C {lab_pin.sym} 5140 16360 0 0 {name=l13253 lab=WL82}
N 5240 16440 5260 16440 {}
C {lab_pin.sym} 5260 16440 0 0 {name=l13254 lab=VDD}
N 5240 16360 5260 16360 {}
C {lab_pin.sym} 5260 16360 0 0 {name=l13255 lab=VSS}
C {bitcell_6t.sym} 5400 16400 0 0 {name=Xr82c27}
N 5360 16440 5340 16440 {}
C {lab_pin.sym} 5340 16440 0 0 {name=l13256 lab=BL27}
N 5360 16400 5340 16400 {}
C {lab_pin.sym} 5340 16400 0 0 {name=l13257 lab=BLB27}
N 5360 16360 5340 16360 {}
C {lab_pin.sym} 5340 16360 0 0 {name=l13258 lab=WL82}
N 5440 16440 5460 16440 {}
C {lab_pin.sym} 5460 16440 0 0 {name=l13259 lab=VDD}
N 5440 16360 5460 16360 {}
C {lab_pin.sym} 5460 16360 0 0 {name=l13260 lab=VSS}
C {bitcell_6t.sym} 5600 16400 0 0 {name=Xr82c28}
N 5560 16440 5540 16440 {}
C {lab_pin.sym} 5540 16440 0 0 {name=l13261 lab=BL28}
N 5560 16400 5540 16400 {}
C {lab_pin.sym} 5540 16400 0 0 {name=l13262 lab=BLB28}
N 5560 16360 5540 16360 {}
C {lab_pin.sym} 5540 16360 0 0 {name=l13263 lab=WL82}
N 5640 16440 5660 16440 {}
C {lab_pin.sym} 5660 16440 0 0 {name=l13264 lab=VDD}
N 5640 16360 5660 16360 {}
C {lab_pin.sym} 5660 16360 0 0 {name=l13265 lab=VSS}
C {bitcell_6t.sym} 5800 16400 0 0 {name=Xr82c29}
N 5760 16440 5740 16440 {}
C {lab_pin.sym} 5740 16440 0 0 {name=l13266 lab=BL29}
N 5760 16400 5740 16400 {}
C {lab_pin.sym} 5740 16400 0 0 {name=l13267 lab=BLB29}
N 5760 16360 5740 16360 {}
C {lab_pin.sym} 5740 16360 0 0 {name=l13268 lab=WL82}
N 5840 16440 5860 16440 {}
C {lab_pin.sym} 5860 16440 0 0 {name=l13269 lab=VDD}
N 5840 16360 5860 16360 {}
C {lab_pin.sym} 5860 16360 0 0 {name=l13270 lab=VSS}
C {bitcell_6t.sym} 6000 16400 0 0 {name=Xr82c30}
N 5960 16440 5940 16440 {}
C {lab_pin.sym} 5940 16440 0 0 {name=l13271 lab=BL30}
N 5960 16400 5940 16400 {}
C {lab_pin.sym} 5940 16400 0 0 {name=l13272 lab=BLB30}
N 5960 16360 5940 16360 {}
C {lab_pin.sym} 5940 16360 0 0 {name=l13273 lab=WL82}
N 6040 16440 6060 16440 {}
C {lab_pin.sym} 6060 16440 0 0 {name=l13274 lab=VDD}
N 6040 16360 6060 16360 {}
C {lab_pin.sym} 6060 16360 0 0 {name=l13275 lab=VSS}
C {bitcell_6t.sym} 6200 16400 0 0 {name=Xr82c31}
N 6160 16440 6140 16440 {}
C {lab_pin.sym} 6140 16440 0 0 {name=l13276 lab=BL31}
N 6160 16400 6140 16400 {}
C {lab_pin.sym} 6140 16400 0 0 {name=l13277 lab=BLB31}
N 6160 16360 6140 16360 {}
C {lab_pin.sym} 6140 16360 0 0 {name=l13278 lab=WL82}
N 6240 16440 6260 16440 {}
C {lab_pin.sym} 6260 16440 0 0 {name=l13279 lab=VDD}
N 6240 16360 6260 16360 {}
C {lab_pin.sym} 6260 16360 0 0 {name=l13280 lab=VSS}
C {bitcell_6t.sym} 0 16600 0 0 {name=Xr83c0}
N -40 16640 -60 16640 {}
C {lab_pin.sym} -60 16640 0 0 {name=l13281 lab=BL0}
N -40 16600 -60 16600 {}
C {lab_pin.sym} -60 16600 0 0 {name=l13282 lab=BLB0}
N -40 16560 -60 16560 {}
C {lab_pin.sym} -60 16560 0 0 {name=l13283 lab=WL83}
N 40 16640 60 16640 {}
C {lab_pin.sym} 60 16640 0 0 {name=l13284 lab=VDD}
N 40 16560 60 16560 {}
C {lab_pin.sym} 60 16560 0 0 {name=l13285 lab=VSS}
C {bitcell_6t.sym} 200 16600 0 0 {name=Xr83c1}
N 160 16640 140 16640 {}
C {lab_pin.sym} 140 16640 0 0 {name=l13286 lab=BL1}
N 160 16600 140 16600 {}
C {lab_pin.sym} 140 16600 0 0 {name=l13287 lab=BLB1}
N 160 16560 140 16560 {}
C {lab_pin.sym} 140 16560 0 0 {name=l13288 lab=WL83}
N 240 16640 260 16640 {}
C {lab_pin.sym} 260 16640 0 0 {name=l13289 lab=VDD}
N 240 16560 260 16560 {}
C {lab_pin.sym} 260 16560 0 0 {name=l13290 lab=VSS}
C {bitcell_6t.sym} 400 16600 0 0 {name=Xr83c2}
N 360 16640 340 16640 {}
C {lab_pin.sym} 340 16640 0 0 {name=l13291 lab=BL2}
N 360 16600 340 16600 {}
C {lab_pin.sym} 340 16600 0 0 {name=l13292 lab=BLB2}
N 360 16560 340 16560 {}
C {lab_pin.sym} 340 16560 0 0 {name=l13293 lab=WL83}
N 440 16640 460 16640 {}
C {lab_pin.sym} 460 16640 0 0 {name=l13294 lab=VDD}
N 440 16560 460 16560 {}
C {lab_pin.sym} 460 16560 0 0 {name=l13295 lab=VSS}
C {bitcell_6t.sym} 600 16600 0 0 {name=Xr83c3}
N 560 16640 540 16640 {}
C {lab_pin.sym} 540 16640 0 0 {name=l13296 lab=BL3}
N 560 16600 540 16600 {}
C {lab_pin.sym} 540 16600 0 0 {name=l13297 lab=BLB3}
N 560 16560 540 16560 {}
C {lab_pin.sym} 540 16560 0 0 {name=l13298 lab=WL83}
N 640 16640 660 16640 {}
C {lab_pin.sym} 660 16640 0 0 {name=l13299 lab=VDD}
N 640 16560 660 16560 {}
C {lab_pin.sym} 660 16560 0 0 {name=l13300 lab=VSS}
C {bitcell_6t.sym} 800 16600 0 0 {name=Xr83c4}
N 760 16640 740 16640 {}
C {lab_pin.sym} 740 16640 0 0 {name=l13301 lab=BL4}
N 760 16600 740 16600 {}
C {lab_pin.sym} 740 16600 0 0 {name=l13302 lab=BLB4}
N 760 16560 740 16560 {}
C {lab_pin.sym} 740 16560 0 0 {name=l13303 lab=WL83}
N 840 16640 860 16640 {}
C {lab_pin.sym} 860 16640 0 0 {name=l13304 lab=VDD}
N 840 16560 860 16560 {}
C {lab_pin.sym} 860 16560 0 0 {name=l13305 lab=VSS}
C {bitcell_6t.sym} 1000 16600 0 0 {name=Xr83c5}
N 960 16640 940 16640 {}
C {lab_pin.sym} 940 16640 0 0 {name=l13306 lab=BL5}
N 960 16600 940 16600 {}
C {lab_pin.sym} 940 16600 0 0 {name=l13307 lab=BLB5}
N 960 16560 940 16560 {}
C {lab_pin.sym} 940 16560 0 0 {name=l13308 lab=WL83}
N 1040 16640 1060 16640 {}
C {lab_pin.sym} 1060 16640 0 0 {name=l13309 lab=VDD}
N 1040 16560 1060 16560 {}
C {lab_pin.sym} 1060 16560 0 0 {name=l13310 lab=VSS}
C {bitcell_6t.sym} 1200 16600 0 0 {name=Xr83c6}
N 1160 16640 1140 16640 {}
C {lab_pin.sym} 1140 16640 0 0 {name=l13311 lab=BL6}
N 1160 16600 1140 16600 {}
C {lab_pin.sym} 1140 16600 0 0 {name=l13312 lab=BLB6}
N 1160 16560 1140 16560 {}
C {lab_pin.sym} 1140 16560 0 0 {name=l13313 lab=WL83}
N 1240 16640 1260 16640 {}
C {lab_pin.sym} 1260 16640 0 0 {name=l13314 lab=VDD}
N 1240 16560 1260 16560 {}
C {lab_pin.sym} 1260 16560 0 0 {name=l13315 lab=VSS}
C {bitcell_6t.sym} 1400 16600 0 0 {name=Xr83c7}
N 1360 16640 1340 16640 {}
C {lab_pin.sym} 1340 16640 0 0 {name=l13316 lab=BL7}
N 1360 16600 1340 16600 {}
C {lab_pin.sym} 1340 16600 0 0 {name=l13317 lab=BLB7}
N 1360 16560 1340 16560 {}
C {lab_pin.sym} 1340 16560 0 0 {name=l13318 lab=WL83}
N 1440 16640 1460 16640 {}
C {lab_pin.sym} 1460 16640 0 0 {name=l13319 lab=VDD}
N 1440 16560 1460 16560 {}
C {lab_pin.sym} 1460 16560 0 0 {name=l13320 lab=VSS}
C {bitcell_6t.sym} 1600 16600 0 0 {name=Xr83c8}
N 1560 16640 1540 16640 {}
C {lab_pin.sym} 1540 16640 0 0 {name=l13321 lab=BL8}
N 1560 16600 1540 16600 {}
C {lab_pin.sym} 1540 16600 0 0 {name=l13322 lab=BLB8}
N 1560 16560 1540 16560 {}
C {lab_pin.sym} 1540 16560 0 0 {name=l13323 lab=WL83}
N 1640 16640 1660 16640 {}
C {lab_pin.sym} 1660 16640 0 0 {name=l13324 lab=VDD}
N 1640 16560 1660 16560 {}
C {lab_pin.sym} 1660 16560 0 0 {name=l13325 lab=VSS}
C {bitcell_6t.sym} 1800 16600 0 0 {name=Xr83c9}
N 1760 16640 1740 16640 {}
C {lab_pin.sym} 1740 16640 0 0 {name=l13326 lab=BL9}
N 1760 16600 1740 16600 {}
C {lab_pin.sym} 1740 16600 0 0 {name=l13327 lab=BLB9}
N 1760 16560 1740 16560 {}
C {lab_pin.sym} 1740 16560 0 0 {name=l13328 lab=WL83}
N 1840 16640 1860 16640 {}
C {lab_pin.sym} 1860 16640 0 0 {name=l13329 lab=VDD}
N 1840 16560 1860 16560 {}
C {lab_pin.sym} 1860 16560 0 0 {name=l13330 lab=VSS}
C {bitcell_6t.sym} 2000 16600 0 0 {name=Xr83c10}
N 1960 16640 1940 16640 {}
C {lab_pin.sym} 1940 16640 0 0 {name=l13331 lab=BL10}
N 1960 16600 1940 16600 {}
C {lab_pin.sym} 1940 16600 0 0 {name=l13332 lab=BLB10}
N 1960 16560 1940 16560 {}
C {lab_pin.sym} 1940 16560 0 0 {name=l13333 lab=WL83}
N 2040 16640 2060 16640 {}
C {lab_pin.sym} 2060 16640 0 0 {name=l13334 lab=VDD}
N 2040 16560 2060 16560 {}
C {lab_pin.sym} 2060 16560 0 0 {name=l13335 lab=VSS}
C {bitcell_6t.sym} 2200 16600 0 0 {name=Xr83c11}
N 2160 16640 2140 16640 {}
C {lab_pin.sym} 2140 16640 0 0 {name=l13336 lab=BL11}
N 2160 16600 2140 16600 {}
C {lab_pin.sym} 2140 16600 0 0 {name=l13337 lab=BLB11}
N 2160 16560 2140 16560 {}
C {lab_pin.sym} 2140 16560 0 0 {name=l13338 lab=WL83}
N 2240 16640 2260 16640 {}
C {lab_pin.sym} 2260 16640 0 0 {name=l13339 lab=VDD}
N 2240 16560 2260 16560 {}
C {lab_pin.sym} 2260 16560 0 0 {name=l13340 lab=VSS}
C {bitcell_6t.sym} 2400 16600 0 0 {name=Xr83c12}
N 2360 16640 2340 16640 {}
C {lab_pin.sym} 2340 16640 0 0 {name=l13341 lab=BL12}
N 2360 16600 2340 16600 {}
C {lab_pin.sym} 2340 16600 0 0 {name=l13342 lab=BLB12}
N 2360 16560 2340 16560 {}
C {lab_pin.sym} 2340 16560 0 0 {name=l13343 lab=WL83}
N 2440 16640 2460 16640 {}
C {lab_pin.sym} 2460 16640 0 0 {name=l13344 lab=VDD}
N 2440 16560 2460 16560 {}
C {lab_pin.sym} 2460 16560 0 0 {name=l13345 lab=VSS}
C {bitcell_6t.sym} 2600 16600 0 0 {name=Xr83c13}
N 2560 16640 2540 16640 {}
C {lab_pin.sym} 2540 16640 0 0 {name=l13346 lab=BL13}
N 2560 16600 2540 16600 {}
C {lab_pin.sym} 2540 16600 0 0 {name=l13347 lab=BLB13}
N 2560 16560 2540 16560 {}
C {lab_pin.sym} 2540 16560 0 0 {name=l13348 lab=WL83}
N 2640 16640 2660 16640 {}
C {lab_pin.sym} 2660 16640 0 0 {name=l13349 lab=VDD}
N 2640 16560 2660 16560 {}
C {lab_pin.sym} 2660 16560 0 0 {name=l13350 lab=VSS}
C {bitcell_6t.sym} 2800 16600 0 0 {name=Xr83c14}
N 2760 16640 2740 16640 {}
C {lab_pin.sym} 2740 16640 0 0 {name=l13351 lab=BL14}
N 2760 16600 2740 16600 {}
C {lab_pin.sym} 2740 16600 0 0 {name=l13352 lab=BLB14}
N 2760 16560 2740 16560 {}
C {lab_pin.sym} 2740 16560 0 0 {name=l13353 lab=WL83}
N 2840 16640 2860 16640 {}
C {lab_pin.sym} 2860 16640 0 0 {name=l13354 lab=VDD}
N 2840 16560 2860 16560 {}
C {lab_pin.sym} 2860 16560 0 0 {name=l13355 lab=VSS}
C {bitcell_6t.sym} 3000 16600 0 0 {name=Xr83c15}
N 2960 16640 2940 16640 {}
C {lab_pin.sym} 2940 16640 0 0 {name=l13356 lab=BL15}
N 2960 16600 2940 16600 {}
C {lab_pin.sym} 2940 16600 0 0 {name=l13357 lab=BLB15}
N 2960 16560 2940 16560 {}
C {lab_pin.sym} 2940 16560 0 0 {name=l13358 lab=WL83}
N 3040 16640 3060 16640 {}
C {lab_pin.sym} 3060 16640 0 0 {name=l13359 lab=VDD}
N 3040 16560 3060 16560 {}
C {lab_pin.sym} 3060 16560 0 0 {name=l13360 lab=VSS}
C {bitcell_6t.sym} 3200 16600 0 0 {name=Xr83c16}
N 3160 16640 3140 16640 {}
C {lab_pin.sym} 3140 16640 0 0 {name=l13361 lab=BL16}
N 3160 16600 3140 16600 {}
C {lab_pin.sym} 3140 16600 0 0 {name=l13362 lab=BLB16}
N 3160 16560 3140 16560 {}
C {lab_pin.sym} 3140 16560 0 0 {name=l13363 lab=WL83}
N 3240 16640 3260 16640 {}
C {lab_pin.sym} 3260 16640 0 0 {name=l13364 lab=VDD}
N 3240 16560 3260 16560 {}
C {lab_pin.sym} 3260 16560 0 0 {name=l13365 lab=VSS}
C {bitcell_6t.sym} 3400 16600 0 0 {name=Xr83c17}
N 3360 16640 3340 16640 {}
C {lab_pin.sym} 3340 16640 0 0 {name=l13366 lab=BL17}
N 3360 16600 3340 16600 {}
C {lab_pin.sym} 3340 16600 0 0 {name=l13367 lab=BLB17}
N 3360 16560 3340 16560 {}
C {lab_pin.sym} 3340 16560 0 0 {name=l13368 lab=WL83}
N 3440 16640 3460 16640 {}
C {lab_pin.sym} 3460 16640 0 0 {name=l13369 lab=VDD}
N 3440 16560 3460 16560 {}
C {lab_pin.sym} 3460 16560 0 0 {name=l13370 lab=VSS}
C {bitcell_6t.sym} 3600 16600 0 0 {name=Xr83c18}
N 3560 16640 3540 16640 {}
C {lab_pin.sym} 3540 16640 0 0 {name=l13371 lab=BL18}
N 3560 16600 3540 16600 {}
C {lab_pin.sym} 3540 16600 0 0 {name=l13372 lab=BLB18}
N 3560 16560 3540 16560 {}
C {lab_pin.sym} 3540 16560 0 0 {name=l13373 lab=WL83}
N 3640 16640 3660 16640 {}
C {lab_pin.sym} 3660 16640 0 0 {name=l13374 lab=VDD}
N 3640 16560 3660 16560 {}
C {lab_pin.sym} 3660 16560 0 0 {name=l13375 lab=VSS}
C {bitcell_6t.sym} 3800 16600 0 0 {name=Xr83c19}
N 3760 16640 3740 16640 {}
C {lab_pin.sym} 3740 16640 0 0 {name=l13376 lab=BL19}
N 3760 16600 3740 16600 {}
C {lab_pin.sym} 3740 16600 0 0 {name=l13377 lab=BLB19}
N 3760 16560 3740 16560 {}
C {lab_pin.sym} 3740 16560 0 0 {name=l13378 lab=WL83}
N 3840 16640 3860 16640 {}
C {lab_pin.sym} 3860 16640 0 0 {name=l13379 lab=VDD}
N 3840 16560 3860 16560 {}
C {lab_pin.sym} 3860 16560 0 0 {name=l13380 lab=VSS}
C {bitcell_6t.sym} 4000 16600 0 0 {name=Xr83c20}
N 3960 16640 3940 16640 {}
C {lab_pin.sym} 3940 16640 0 0 {name=l13381 lab=BL20}
N 3960 16600 3940 16600 {}
C {lab_pin.sym} 3940 16600 0 0 {name=l13382 lab=BLB20}
N 3960 16560 3940 16560 {}
C {lab_pin.sym} 3940 16560 0 0 {name=l13383 lab=WL83}
N 4040 16640 4060 16640 {}
C {lab_pin.sym} 4060 16640 0 0 {name=l13384 lab=VDD}
N 4040 16560 4060 16560 {}
C {lab_pin.sym} 4060 16560 0 0 {name=l13385 lab=VSS}
C {bitcell_6t.sym} 4200 16600 0 0 {name=Xr83c21}
N 4160 16640 4140 16640 {}
C {lab_pin.sym} 4140 16640 0 0 {name=l13386 lab=BL21}
N 4160 16600 4140 16600 {}
C {lab_pin.sym} 4140 16600 0 0 {name=l13387 lab=BLB21}
N 4160 16560 4140 16560 {}
C {lab_pin.sym} 4140 16560 0 0 {name=l13388 lab=WL83}
N 4240 16640 4260 16640 {}
C {lab_pin.sym} 4260 16640 0 0 {name=l13389 lab=VDD}
N 4240 16560 4260 16560 {}
C {lab_pin.sym} 4260 16560 0 0 {name=l13390 lab=VSS}
C {bitcell_6t.sym} 4400 16600 0 0 {name=Xr83c22}
N 4360 16640 4340 16640 {}
C {lab_pin.sym} 4340 16640 0 0 {name=l13391 lab=BL22}
N 4360 16600 4340 16600 {}
C {lab_pin.sym} 4340 16600 0 0 {name=l13392 lab=BLB22}
N 4360 16560 4340 16560 {}
C {lab_pin.sym} 4340 16560 0 0 {name=l13393 lab=WL83}
N 4440 16640 4460 16640 {}
C {lab_pin.sym} 4460 16640 0 0 {name=l13394 lab=VDD}
N 4440 16560 4460 16560 {}
C {lab_pin.sym} 4460 16560 0 0 {name=l13395 lab=VSS}
C {bitcell_6t.sym} 4600 16600 0 0 {name=Xr83c23}
N 4560 16640 4540 16640 {}
C {lab_pin.sym} 4540 16640 0 0 {name=l13396 lab=BL23}
N 4560 16600 4540 16600 {}
C {lab_pin.sym} 4540 16600 0 0 {name=l13397 lab=BLB23}
N 4560 16560 4540 16560 {}
C {lab_pin.sym} 4540 16560 0 0 {name=l13398 lab=WL83}
N 4640 16640 4660 16640 {}
C {lab_pin.sym} 4660 16640 0 0 {name=l13399 lab=VDD}
N 4640 16560 4660 16560 {}
C {lab_pin.sym} 4660 16560 0 0 {name=l13400 lab=VSS}
C {bitcell_6t.sym} 4800 16600 0 0 {name=Xr83c24}
N 4760 16640 4740 16640 {}
C {lab_pin.sym} 4740 16640 0 0 {name=l13401 lab=BL24}
N 4760 16600 4740 16600 {}
C {lab_pin.sym} 4740 16600 0 0 {name=l13402 lab=BLB24}
N 4760 16560 4740 16560 {}
C {lab_pin.sym} 4740 16560 0 0 {name=l13403 lab=WL83}
N 4840 16640 4860 16640 {}
C {lab_pin.sym} 4860 16640 0 0 {name=l13404 lab=VDD}
N 4840 16560 4860 16560 {}
C {lab_pin.sym} 4860 16560 0 0 {name=l13405 lab=VSS}
C {bitcell_6t.sym} 5000 16600 0 0 {name=Xr83c25}
N 4960 16640 4940 16640 {}
C {lab_pin.sym} 4940 16640 0 0 {name=l13406 lab=BL25}
N 4960 16600 4940 16600 {}
C {lab_pin.sym} 4940 16600 0 0 {name=l13407 lab=BLB25}
N 4960 16560 4940 16560 {}
C {lab_pin.sym} 4940 16560 0 0 {name=l13408 lab=WL83}
N 5040 16640 5060 16640 {}
C {lab_pin.sym} 5060 16640 0 0 {name=l13409 lab=VDD}
N 5040 16560 5060 16560 {}
C {lab_pin.sym} 5060 16560 0 0 {name=l13410 lab=VSS}
C {bitcell_6t.sym} 5200 16600 0 0 {name=Xr83c26}
N 5160 16640 5140 16640 {}
C {lab_pin.sym} 5140 16640 0 0 {name=l13411 lab=BL26}
N 5160 16600 5140 16600 {}
C {lab_pin.sym} 5140 16600 0 0 {name=l13412 lab=BLB26}
N 5160 16560 5140 16560 {}
C {lab_pin.sym} 5140 16560 0 0 {name=l13413 lab=WL83}
N 5240 16640 5260 16640 {}
C {lab_pin.sym} 5260 16640 0 0 {name=l13414 lab=VDD}
N 5240 16560 5260 16560 {}
C {lab_pin.sym} 5260 16560 0 0 {name=l13415 lab=VSS}
C {bitcell_6t.sym} 5400 16600 0 0 {name=Xr83c27}
N 5360 16640 5340 16640 {}
C {lab_pin.sym} 5340 16640 0 0 {name=l13416 lab=BL27}
N 5360 16600 5340 16600 {}
C {lab_pin.sym} 5340 16600 0 0 {name=l13417 lab=BLB27}
N 5360 16560 5340 16560 {}
C {lab_pin.sym} 5340 16560 0 0 {name=l13418 lab=WL83}
N 5440 16640 5460 16640 {}
C {lab_pin.sym} 5460 16640 0 0 {name=l13419 lab=VDD}
N 5440 16560 5460 16560 {}
C {lab_pin.sym} 5460 16560 0 0 {name=l13420 lab=VSS}
C {bitcell_6t.sym} 5600 16600 0 0 {name=Xr83c28}
N 5560 16640 5540 16640 {}
C {lab_pin.sym} 5540 16640 0 0 {name=l13421 lab=BL28}
N 5560 16600 5540 16600 {}
C {lab_pin.sym} 5540 16600 0 0 {name=l13422 lab=BLB28}
N 5560 16560 5540 16560 {}
C {lab_pin.sym} 5540 16560 0 0 {name=l13423 lab=WL83}
N 5640 16640 5660 16640 {}
C {lab_pin.sym} 5660 16640 0 0 {name=l13424 lab=VDD}
N 5640 16560 5660 16560 {}
C {lab_pin.sym} 5660 16560 0 0 {name=l13425 lab=VSS}
C {bitcell_6t.sym} 5800 16600 0 0 {name=Xr83c29}
N 5760 16640 5740 16640 {}
C {lab_pin.sym} 5740 16640 0 0 {name=l13426 lab=BL29}
N 5760 16600 5740 16600 {}
C {lab_pin.sym} 5740 16600 0 0 {name=l13427 lab=BLB29}
N 5760 16560 5740 16560 {}
C {lab_pin.sym} 5740 16560 0 0 {name=l13428 lab=WL83}
N 5840 16640 5860 16640 {}
C {lab_pin.sym} 5860 16640 0 0 {name=l13429 lab=VDD}
N 5840 16560 5860 16560 {}
C {lab_pin.sym} 5860 16560 0 0 {name=l13430 lab=VSS}
C {bitcell_6t.sym} 6000 16600 0 0 {name=Xr83c30}
N 5960 16640 5940 16640 {}
C {lab_pin.sym} 5940 16640 0 0 {name=l13431 lab=BL30}
N 5960 16600 5940 16600 {}
C {lab_pin.sym} 5940 16600 0 0 {name=l13432 lab=BLB30}
N 5960 16560 5940 16560 {}
C {lab_pin.sym} 5940 16560 0 0 {name=l13433 lab=WL83}
N 6040 16640 6060 16640 {}
C {lab_pin.sym} 6060 16640 0 0 {name=l13434 lab=VDD}
N 6040 16560 6060 16560 {}
C {lab_pin.sym} 6060 16560 0 0 {name=l13435 lab=VSS}
C {bitcell_6t.sym} 6200 16600 0 0 {name=Xr83c31}
N 6160 16640 6140 16640 {}
C {lab_pin.sym} 6140 16640 0 0 {name=l13436 lab=BL31}
N 6160 16600 6140 16600 {}
C {lab_pin.sym} 6140 16600 0 0 {name=l13437 lab=BLB31}
N 6160 16560 6140 16560 {}
C {lab_pin.sym} 6140 16560 0 0 {name=l13438 lab=WL83}
N 6240 16640 6260 16640 {}
C {lab_pin.sym} 6260 16640 0 0 {name=l13439 lab=VDD}
N 6240 16560 6260 16560 {}
C {lab_pin.sym} 6260 16560 0 0 {name=l13440 lab=VSS}
C {bitcell_6t.sym} 0 16800 0 0 {name=Xr84c0}
N -40 16840 -60 16840 {}
C {lab_pin.sym} -60 16840 0 0 {name=l13441 lab=BL0}
N -40 16800 -60 16800 {}
C {lab_pin.sym} -60 16800 0 0 {name=l13442 lab=BLB0}
N -40 16760 -60 16760 {}
C {lab_pin.sym} -60 16760 0 0 {name=l13443 lab=WL84}
N 40 16840 60 16840 {}
C {lab_pin.sym} 60 16840 0 0 {name=l13444 lab=VDD}
N 40 16760 60 16760 {}
C {lab_pin.sym} 60 16760 0 0 {name=l13445 lab=VSS}
C {bitcell_6t.sym} 200 16800 0 0 {name=Xr84c1}
N 160 16840 140 16840 {}
C {lab_pin.sym} 140 16840 0 0 {name=l13446 lab=BL1}
N 160 16800 140 16800 {}
C {lab_pin.sym} 140 16800 0 0 {name=l13447 lab=BLB1}
N 160 16760 140 16760 {}
C {lab_pin.sym} 140 16760 0 0 {name=l13448 lab=WL84}
N 240 16840 260 16840 {}
C {lab_pin.sym} 260 16840 0 0 {name=l13449 lab=VDD}
N 240 16760 260 16760 {}
C {lab_pin.sym} 260 16760 0 0 {name=l13450 lab=VSS}
C {bitcell_6t.sym} 400 16800 0 0 {name=Xr84c2}
N 360 16840 340 16840 {}
C {lab_pin.sym} 340 16840 0 0 {name=l13451 lab=BL2}
N 360 16800 340 16800 {}
C {lab_pin.sym} 340 16800 0 0 {name=l13452 lab=BLB2}
N 360 16760 340 16760 {}
C {lab_pin.sym} 340 16760 0 0 {name=l13453 lab=WL84}
N 440 16840 460 16840 {}
C {lab_pin.sym} 460 16840 0 0 {name=l13454 lab=VDD}
N 440 16760 460 16760 {}
C {lab_pin.sym} 460 16760 0 0 {name=l13455 lab=VSS}
C {bitcell_6t.sym} 600 16800 0 0 {name=Xr84c3}
N 560 16840 540 16840 {}
C {lab_pin.sym} 540 16840 0 0 {name=l13456 lab=BL3}
N 560 16800 540 16800 {}
C {lab_pin.sym} 540 16800 0 0 {name=l13457 lab=BLB3}
N 560 16760 540 16760 {}
C {lab_pin.sym} 540 16760 0 0 {name=l13458 lab=WL84}
N 640 16840 660 16840 {}
C {lab_pin.sym} 660 16840 0 0 {name=l13459 lab=VDD}
N 640 16760 660 16760 {}
C {lab_pin.sym} 660 16760 0 0 {name=l13460 lab=VSS}
C {bitcell_6t.sym} 800 16800 0 0 {name=Xr84c4}
N 760 16840 740 16840 {}
C {lab_pin.sym} 740 16840 0 0 {name=l13461 lab=BL4}
N 760 16800 740 16800 {}
C {lab_pin.sym} 740 16800 0 0 {name=l13462 lab=BLB4}
N 760 16760 740 16760 {}
C {lab_pin.sym} 740 16760 0 0 {name=l13463 lab=WL84}
N 840 16840 860 16840 {}
C {lab_pin.sym} 860 16840 0 0 {name=l13464 lab=VDD}
N 840 16760 860 16760 {}
C {lab_pin.sym} 860 16760 0 0 {name=l13465 lab=VSS}
C {bitcell_6t.sym} 1000 16800 0 0 {name=Xr84c5}
N 960 16840 940 16840 {}
C {lab_pin.sym} 940 16840 0 0 {name=l13466 lab=BL5}
N 960 16800 940 16800 {}
C {lab_pin.sym} 940 16800 0 0 {name=l13467 lab=BLB5}
N 960 16760 940 16760 {}
C {lab_pin.sym} 940 16760 0 0 {name=l13468 lab=WL84}
N 1040 16840 1060 16840 {}
C {lab_pin.sym} 1060 16840 0 0 {name=l13469 lab=VDD}
N 1040 16760 1060 16760 {}
C {lab_pin.sym} 1060 16760 0 0 {name=l13470 lab=VSS}
C {bitcell_6t.sym} 1200 16800 0 0 {name=Xr84c6}
N 1160 16840 1140 16840 {}
C {lab_pin.sym} 1140 16840 0 0 {name=l13471 lab=BL6}
N 1160 16800 1140 16800 {}
C {lab_pin.sym} 1140 16800 0 0 {name=l13472 lab=BLB6}
N 1160 16760 1140 16760 {}
C {lab_pin.sym} 1140 16760 0 0 {name=l13473 lab=WL84}
N 1240 16840 1260 16840 {}
C {lab_pin.sym} 1260 16840 0 0 {name=l13474 lab=VDD}
N 1240 16760 1260 16760 {}
C {lab_pin.sym} 1260 16760 0 0 {name=l13475 lab=VSS}
C {bitcell_6t.sym} 1400 16800 0 0 {name=Xr84c7}
N 1360 16840 1340 16840 {}
C {lab_pin.sym} 1340 16840 0 0 {name=l13476 lab=BL7}
N 1360 16800 1340 16800 {}
C {lab_pin.sym} 1340 16800 0 0 {name=l13477 lab=BLB7}
N 1360 16760 1340 16760 {}
C {lab_pin.sym} 1340 16760 0 0 {name=l13478 lab=WL84}
N 1440 16840 1460 16840 {}
C {lab_pin.sym} 1460 16840 0 0 {name=l13479 lab=VDD}
N 1440 16760 1460 16760 {}
C {lab_pin.sym} 1460 16760 0 0 {name=l13480 lab=VSS}
C {bitcell_6t.sym} 1600 16800 0 0 {name=Xr84c8}
N 1560 16840 1540 16840 {}
C {lab_pin.sym} 1540 16840 0 0 {name=l13481 lab=BL8}
N 1560 16800 1540 16800 {}
C {lab_pin.sym} 1540 16800 0 0 {name=l13482 lab=BLB8}
N 1560 16760 1540 16760 {}
C {lab_pin.sym} 1540 16760 0 0 {name=l13483 lab=WL84}
N 1640 16840 1660 16840 {}
C {lab_pin.sym} 1660 16840 0 0 {name=l13484 lab=VDD}
N 1640 16760 1660 16760 {}
C {lab_pin.sym} 1660 16760 0 0 {name=l13485 lab=VSS}
C {bitcell_6t.sym} 1800 16800 0 0 {name=Xr84c9}
N 1760 16840 1740 16840 {}
C {lab_pin.sym} 1740 16840 0 0 {name=l13486 lab=BL9}
N 1760 16800 1740 16800 {}
C {lab_pin.sym} 1740 16800 0 0 {name=l13487 lab=BLB9}
N 1760 16760 1740 16760 {}
C {lab_pin.sym} 1740 16760 0 0 {name=l13488 lab=WL84}
N 1840 16840 1860 16840 {}
C {lab_pin.sym} 1860 16840 0 0 {name=l13489 lab=VDD}
N 1840 16760 1860 16760 {}
C {lab_pin.sym} 1860 16760 0 0 {name=l13490 lab=VSS}
C {bitcell_6t.sym} 2000 16800 0 0 {name=Xr84c10}
N 1960 16840 1940 16840 {}
C {lab_pin.sym} 1940 16840 0 0 {name=l13491 lab=BL10}
N 1960 16800 1940 16800 {}
C {lab_pin.sym} 1940 16800 0 0 {name=l13492 lab=BLB10}
N 1960 16760 1940 16760 {}
C {lab_pin.sym} 1940 16760 0 0 {name=l13493 lab=WL84}
N 2040 16840 2060 16840 {}
C {lab_pin.sym} 2060 16840 0 0 {name=l13494 lab=VDD}
N 2040 16760 2060 16760 {}
C {lab_pin.sym} 2060 16760 0 0 {name=l13495 lab=VSS}
C {bitcell_6t.sym} 2200 16800 0 0 {name=Xr84c11}
N 2160 16840 2140 16840 {}
C {lab_pin.sym} 2140 16840 0 0 {name=l13496 lab=BL11}
N 2160 16800 2140 16800 {}
C {lab_pin.sym} 2140 16800 0 0 {name=l13497 lab=BLB11}
N 2160 16760 2140 16760 {}
C {lab_pin.sym} 2140 16760 0 0 {name=l13498 lab=WL84}
N 2240 16840 2260 16840 {}
C {lab_pin.sym} 2260 16840 0 0 {name=l13499 lab=VDD}
N 2240 16760 2260 16760 {}
C {lab_pin.sym} 2260 16760 0 0 {name=l13500 lab=VSS}
C {bitcell_6t.sym} 2400 16800 0 0 {name=Xr84c12}
N 2360 16840 2340 16840 {}
C {lab_pin.sym} 2340 16840 0 0 {name=l13501 lab=BL12}
N 2360 16800 2340 16800 {}
C {lab_pin.sym} 2340 16800 0 0 {name=l13502 lab=BLB12}
N 2360 16760 2340 16760 {}
C {lab_pin.sym} 2340 16760 0 0 {name=l13503 lab=WL84}
N 2440 16840 2460 16840 {}
C {lab_pin.sym} 2460 16840 0 0 {name=l13504 lab=VDD}
N 2440 16760 2460 16760 {}
C {lab_pin.sym} 2460 16760 0 0 {name=l13505 lab=VSS}
C {bitcell_6t.sym} 2600 16800 0 0 {name=Xr84c13}
N 2560 16840 2540 16840 {}
C {lab_pin.sym} 2540 16840 0 0 {name=l13506 lab=BL13}
N 2560 16800 2540 16800 {}
C {lab_pin.sym} 2540 16800 0 0 {name=l13507 lab=BLB13}
N 2560 16760 2540 16760 {}
C {lab_pin.sym} 2540 16760 0 0 {name=l13508 lab=WL84}
N 2640 16840 2660 16840 {}
C {lab_pin.sym} 2660 16840 0 0 {name=l13509 lab=VDD}
N 2640 16760 2660 16760 {}
C {lab_pin.sym} 2660 16760 0 0 {name=l13510 lab=VSS}
C {bitcell_6t.sym} 2800 16800 0 0 {name=Xr84c14}
N 2760 16840 2740 16840 {}
C {lab_pin.sym} 2740 16840 0 0 {name=l13511 lab=BL14}
N 2760 16800 2740 16800 {}
C {lab_pin.sym} 2740 16800 0 0 {name=l13512 lab=BLB14}
N 2760 16760 2740 16760 {}
C {lab_pin.sym} 2740 16760 0 0 {name=l13513 lab=WL84}
N 2840 16840 2860 16840 {}
C {lab_pin.sym} 2860 16840 0 0 {name=l13514 lab=VDD}
N 2840 16760 2860 16760 {}
C {lab_pin.sym} 2860 16760 0 0 {name=l13515 lab=VSS}
C {bitcell_6t.sym} 3000 16800 0 0 {name=Xr84c15}
N 2960 16840 2940 16840 {}
C {lab_pin.sym} 2940 16840 0 0 {name=l13516 lab=BL15}
N 2960 16800 2940 16800 {}
C {lab_pin.sym} 2940 16800 0 0 {name=l13517 lab=BLB15}
N 2960 16760 2940 16760 {}
C {lab_pin.sym} 2940 16760 0 0 {name=l13518 lab=WL84}
N 3040 16840 3060 16840 {}
C {lab_pin.sym} 3060 16840 0 0 {name=l13519 lab=VDD}
N 3040 16760 3060 16760 {}
C {lab_pin.sym} 3060 16760 0 0 {name=l13520 lab=VSS}
C {bitcell_6t.sym} 3200 16800 0 0 {name=Xr84c16}
N 3160 16840 3140 16840 {}
C {lab_pin.sym} 3140 16840 0 0 {name=l13521 lab=BL16}
N 3160 16800 3140 16800 {}
C {lab_pin.sym} 3140 16800 0 0 {name=l13522 lab=BLB16}
N 3160 16760 3140 16760 {}
C {lab_pin.sym} 3140 16760 0 0 {name=l13523 lab=WL84}
N 3240 16840 3260 16840 {}
C {lab_pin.sym} 3260 16840 0 0 {name=l13524 lab=VDD}
N 3240 16760 3260 16760 {}
C {lab_pin.sym} 3260 16760 0 0 {name=l13525 lab=VSS}
C {bitcell_6t.sym} 3400 16800 0 0 {name=Xr84c17}
N 3360 16840 3340 16840 {}
C {lab_pin.sym} 3340 16840 0 0 {name=l13526 lab=BL17}
N 3360 16800 3340 16800 {}
C {lab_pin.sym} 3340 16800 0 0 {name=l13527 lab=BLB17}
N 3360 16760 3340 16760 {}
C {lab_pin.sym} 3340 16760 0 0 {name=l13528 lab=WL84}
N 3440 16840 3460 16840 {}
C {lab_pin.sym} 3460 16840 0 0 {name=l13529 lab=VDD}
N 3440 16760 3460 16760 {}
C {lab_pin.sym} 3460 16760 0 0 {name=l13530 lab=VSS}
C {bitcell_6t.sym} 3600 16800 0 0 {name=Xr84c18}
N 3560 16840 3540 16840 {}
C {lab_pin.sym} 3540 16840 0 0 {name=l13531 lab=BL18}
N 3560 16800 3540 16800 {}
C {lab_pin.sym} 3540 16800 0 0 {name=l13532 lab=BLB18}
N 3560 16760 3540 16760 {}
C {lab_pin.sym} 3540 16760 0 0 {name=l13533 lab=WL84}
N 3640 16840 3660 16840 {}
C {lab_pin.sym} 3660 16840 0 0 {name=l13534 lab=VDD}
N 3640 16760 3660 16760 {}
C {lab_pin.sym} 3660 16760 0 0 {name=l13535 lab=VSS}
C {bitcell_6t.sym} 3800 16800 0 0 {name=Xr84c19}
N 3760 16840 3740 16840 {}
C {lab_pin.sym} 3740 16840 0 0 {name=l13536 lab=BL19}
N 3760 16800 3740 16800 {}
C {lab_pin.sym} 3740 16800 0 0 {name=l13537 lab=BLB19}
N 3760 16760 3740 16760 {}
C {lab_pin.sym} 3740 16760 0 0 {name=l13538 lab=WL84}
N 3840 16840 3860 16840 {}
C {lab_pin.sym} 3860 16840 0 0 {name=l13539 lab=VDD}
N 3840 16760 3860 16760 {}
C {lab_pin.sym} 3860 16760 0 0 {name=l13540 lab=VSS}
C {bitcell_6t.sym} 4000 16800 0 0 {name=Xr84c20}
N 3960 16840 3940 16840 {}
C {lab_pin.sym} 3940 16840 0 0 {name=l13541 lab=BL20}
N 3960 16800 3940 16800 {}
C {lab_pin.sym} 3940 16800 0 0 {name=l13542 lab=BLB20}
N 3960 16760 3940 16760 {}
C {lab_pin.sym} 3940 16760 0 0 {name=l13543 lab=WL84}
N 4040 16840 4060 16840 {}
C {lab_pin.sym} 4060 16840 0 0 {name=l13544 lab=VDD}
N 4040 16760 4060 16760 {}
C {lab_pin.sym} 4060 16760 0 0 {name=l13545 lab=VSS}
C {bitcell_6t.sym} 4200 16800 0 0 {name=Xr84c21}
N 4160 16840 4140 16840 {}
C {lab_pin.sym} 4140 16840 0 0 {name=l13546 lab=BL21}
N 4160 16800 4140 16800 {}
C {lab_pin.sym} 4140 16800 0 0 {name=l13547 lab=BLB21}
N 4160 16760 4140 16760 {}
C {lab_pin.sym} 4140 16760 0 0 {name=l13548 lab=WL84}
N 4240 16840 4260 16840 {}
C {lab_pin.sym} 4260 16840 0 0 {name=l13549 lab=VDD}
N 4240 16760 4260 16760 {}
C {lab_pin.sym} 4260 16760 0 0 {name=l13550 lab=VSS}
C {bitcell_6t.sym} 4400 16800 0 0 {name=Xr84c22}
N 4360 16840 4340 16840 {}
C {lab_pin.sym} 4340 16840 0 0 {name=l13551 lab=BL22}
N 4360 16800 4340 16800 {}
C {lab_pin.sym} 4340 16800 0 0 {name=l13552 lab=BLB22}
N 4360 16760 4340 16760 {}
C {lab_pin.sym} 4340 16760 0 0 {name=l13553 lab=WL84}
N 4440 16840 4460 16840 {}
C {lab_pin.sym} 4460 16840 0 0 {name=l13554 lab=VDD}
N 4440 16760 4460 16760 {}
C {lab_pin.sym} 4460 16760 0 0 {name=l13555 lab=VSS}
C {bitcell_6t.sym} 4600 16800 0 0 {name=Xr84c23}
N 4560 16840 4540 16840 {}
C {lab_pin.sym} 4540 16840 0 0 {name=l13556 lab=BL23}
N 4560 16800 4540 16800 {}
C {lab_pin.sym} 4540 16800 0 0 {name=l13557 lab=BLB23}
N 4560 16760 4540 16760 {}
C {lab_pin.sym} 4540 16760 0 0 {name=l13558 lab=WL84}
N 4640 16840 4660 16840 {}
C {lab_pin.sym} 4660 16840 0 0 {name=l13559 lab=VDD}
N 4640 16760 4660 16760 {}
C {lab_pin.sym} 4660 16760 0 0 {name=l13560 lab=VSS}
C {bitcell_6t.sym} 4800 16800 0 0 {name=Xr84c24}
N 4760 16840 4740 16840 {}
C {lab_pin.sym} 4740 16840 0 0 {name=l13561 lab=BL24}
N 4760 16800 4740 16800 {}
C {lab_pin.sym} 4740 16800 0 0 {name=l13562 lab=BLB24}
N 4760 16760 4740 16760 {}
C {lab_pin.sym} 4740 16760 0 0 {name=l13563 lab=WL84}
N 4840 16840 4860 16840 {}
C {lab_pin.sym} 4860 16840 0 0 {name=l13564 lab=VDD}
N 4840 16760 4860 16760 {}
C {lab_pin.sym} 4860 16760 0 0 {name=l13565 lab=VSS}
C {bitcell_6t.sym} 5000 16800 0 0 {name=Xr84c25}
N 4960 16840 4940 16840 {}
C {lab_pin.sym} 4940 16840 0 0 {name=l13566 lab=BL25}
N 4960 16800 4940 16800 {}
C {lab_pin.sym} 4940 16800 0 0 {name=l13567 lab=BLB25}
N 4960 16760 4940 16760 {}
C {lab_pin.sym} 4940 16760 0 0 {name=l13568 lab=WL84}
N 5040 16840 5060 16840 {}
C {lab_pin.sym} 5060 16840 0 0 {name=l13569 lab=VDD}
N 5040 16760 5060 16760 {}
C {lab_pin.sym} 5060 16760 0 0 {name=l13570 lab=VSS}
C {bitcell_6t.sym} 5200 16800 0 0 {name=Xr84c26}
N 5160 16840 5140 16840 {}
C {lab_pin.sym} 5140 16840 0 0 {name=l13571 lab=BL26}
N 5160 16800 5140 16800 {}
C {lab_pin.sym} 5140 16800 0 0 {name=l13572 lab=BLB26}
N 5160 16760 5140 16760 {}
C {lab_pin.sym} 5140 16760 0 0 {name=l13573 lab=WL84}
N 5240 16840 5260 16840 {}
C {lab_pin.sym} 5260 16840 0 0 {name=l13574 lab=VDD}
N 5240 16760 5260 16760 {}
C {lab_pin.sym} 5260 16760 0 0 {name=l13575 lab=VSS}
C {bitcell_6t.sym} 5400 16800 0 0 {name=Xr84c27}
N 5360 16840 5340 16840 {}
C {lab_pin.sym} 5340 16840 0 0 {name=l13576 lab=BL27}
N 5360 16800 5340 16800 {}
C {lab_pin.sym} 5340 16800 0 0 {name=l13577 lab=BLB27}
N 5360 16760 5340 16760 {}
C {lab_pin.sym} 5340 16760 0 0 {name=l13578 lab=WL84}
N 5440 16840 5460 16840 {}
C {lab_pin.sym} 5460 16840 0 0 {name=l13579 lab=VDD}
N 5440 16760 5460 16760 {}
C {lab_pin.sym} 5460 16760 0 0 {name=l13580 lab=VSS}
C {bitcell_6t.sym} 5600 16800 0 0 {name=Xr84c28}
N 5560 16840 5540 16840 {}
C {lab_pin.sym} 5540 16840 0 0 {name=l13581 lab=BL28}
N 5560 16800 5540 16800 {}
C {lab_pin.sym} 5540 16800 0 0 {name=l13582 lab=BLB28}
N 5560 16760 5540 16760 {}
C {lab_pin.sym} 5540 16760 0 0 {name=l13583 lab=WL84}
N 5640 16840 5660 16840 {}
C {lab_pin.sym} 5660 16840 0 0 {name=l13584 lab=VDD}
N 5640 16760 5660 16760 {}
C {lab_pin.sym} 5660 16760 0 0 {name=l13585 lab=VSS}
C {bitcell_6t.sym} 5800 16800 0 0 {name=Xr84c29}
N 5760 16840 5740 16840 {}
C {lab_pin.sym} 5740 16840 0 0 {name=l13586 lab=BL29}
N 5760 16800 5740 16800 {}
C {lab_pin.sym} 5740 16800 0 0 {name=l13587 lab=BLB29}
N 5760 16760 5740 16760 {}
C {lab_pin.sym} 5740 16760 0 0 {name=l13588 lab=WL84}
N 5840 16840 5860 16840 {}
C {lab_pin.sym} 5860 16840 0 0 {name=l13589 lab=VDD}
N 5840 16760 5860 16760 {}
C {lab_pin.sym} 5860 16760 0 0 {name=l13590 lab=VSS}
C {bitcell_6t.sym} 6000 16800 0 0 {name=Xr84c30}
N 5960 16840 5940 16840 {}
C {lab_pin.sym} 5940 16840 0 0 {name=l13591 lab=BL30}
N 5960 16800 5940 16800 {}
C {lab_pin.sym} 5940 16800 0 0 {name=l13592 lab=BLB30}
N 5960 16760 5940 16760 {}
C {lab_pin.sym} 5940 16760 0 0 {name=l13593 lab=WL84}
N 6040 16840 6060 16840 {}
C {lab_pin.sym} 6060 16840 0 0 {name=l13594 lab=VDD}
N 6040 16760 6060 16760 {}
C {lab_pin.sym} 6060 16760 0 0 {name=l13595 lab=VSS}
C {bitcell_6t.sym} 6200 16800 0 0 {name=Xr84c31}
N 6160 16840 6140 16840 {}
C {lab_pin.sym} 6140 16840 0 0 {name=l13596 lab=BL31}
N 6160 16800 6140 16800 {}
C {lab_pin.sym} 6140 16800 0 0 {name=l13597 lab=BLB31}
N 6160 16760 6140 16760 {}
C {lab_pin.sym} 6140 16760 0 0 {name=l13598 lab=WL84}
N 6240 16840 6260 16840 {}
C {lab_pin.sym} 6260 16840 0 0 {name=l13599 lab=VDD}
N 6240 16760 6260 16760 {}
C {lab_pin.sym} 6260 16760 0 0 {name=l13600 lab=VSS}
C {bitcell_6t.sym} 0 17000 0 0 {name=Xr85c0}
N -40 17040 -60 17040 {}
C {lab_pin.sym} -60 17040 0 0 {name=l13601 lab=BL0}
N -40 17000 -60 17000 {}
C {lab_pin.sym} -60 17000 0 0 {name=l13602 lab=BLB0}
N -40 16960 -60 16960 {}
C {lab_pin.sym} -60 16960 0 0 {name=l13603 lab=WL85}
N 40 17040 60 17040 {}
C {lab_pin.sym} 60 17040 0 0 {name=l13604 lab=VDD}
N 40 16960 60 16960 {}
C {lab_pin.sym} 60 16960 0 0 {name=l13605 lab=VSS}
C {bitcell_6t.sym} 200 17000 0 0 {name=Xr85c1}
N 160 17040 140 17040 {}
C {lab_pin.sym} 140 17040 0 0 {name=l13606 lab=BL1}
N 160 17000 140 17000 {}
C {lab_pin.sym} 140 17000 0 0 {name=l13607 lab=BLB1}
N 160 16960 140 16960 {}
C {lab_pin.sym} 140 16960 0 0 {name=l13608 lab=WL85}
N 240 17040 260 17040 {}
C {lab_pin.sym} 260 17040 0 0 {name=l13609 lab=VDD}
N 240 16960 260 16960 {}
C {lab_pin.sym} 260 16960 0 0 {name=l13610 lab=VSS}
C {bitcell_6t.sym} 400 17000 0 0 {name=Xr85c2}
N 360 17040 340 17040 {}
C {lab_pin.sym} 340 17040 0 0 {name=l13611 lab=BL2}
N 360 17000 340 17000 {}
C {lab_pin.sym} 340 17000 0 0 {name=l13612 lab=BLB2}
N 360 16960 340 16960 {}
C {lab_pin.sym} 340 16960 0 0 {name=l13613 lab=WL85}
N 440 17040 460 17040 {}
C {lab_pin.sym} 460 17040 0 0 {name=l13614 lab=VDD}
N 440 16960 460 16960 {}
C {lab_pin.sym} 460 16960 0 0 {name=l13615 lab=VSS}
C {bitcell_6t.sym} 600 17000 0 0 {name=Xr85c3}
N 560 17040 540 17040 {}
C {lab_pin.sym} 540 17040 0 0 {name=l13616 lab=BL3}
N 560 17000 540 17000 {}
C {lab_pin.sym} 540 17000 0 0 {name=l13617 lab=BLB3}
N 560 16960 540 16960 {}
C {lab_pin.sym} 540 16960 0 0 {name=l13618 lab=WL85}
N 640 17040 660 17040 {}
C {lab_pin.sym} 660 17040 0 0 {name=l13619 lab=VDD}
N 640 16960 660 16960 {}
C {lab_pin.sym} 660 16960 0 0 {name=l13620 lab=VSS}
C {bitcell_6t.sym} 800 17000 0 0 {name=Xr85c4}
N 760 17040 740 17040 {}
C {lab_pin.sym} 740 17040 0 0 {name=l13621 lab=BL4}
N 760 17000 740 17000 {}
C {lab_pin.sym} 740 17000 0 0 {name=l13622 lab=BLB4}
N 760 16960 740 16960 {}
C {lab_pin.sym} 740 16960 0 0 {name=l13623 lab=WL85}
N 840 17040 860 17040 {}
C {lab_pin.sym} 860 17040 0 0 {name=l13624 lab=VDD}
N 840 16960 860 16960 {}
C {lab_pin.sym} 860 16960 0 0 {name=l13625 lab=VSS}
C {bitcell_6t.sym} 1000 17000 0 0 {name=Xr85c5}
N 960 17040 940 17040 {}
C {lab_pin.sym} 940 17040 0 0 {name=l13626 lab=BL5}
N 960 17000 940 17000 {}
C {lab_pin.sym} 940 17000 0 0 {name=l13627 lab=BLB5}
N 960 16960 940 16960 {}
C {lab_pin.sym} 940 16960 0 0 {name=l13628 lab=WL85}
N 1040 17040 1060 17040 {}
C {lab_pin.sym} 1060 17040 0 0 {name=l13629 lab=VDD}
N 1040 16960 1060 16960 {}
C {lab_pin.sym} 1060 16960 0 0 {name=l13630 lab=VSS}
C {bitcell_6t.sym} 1200 17000 0 0 {name=Xr85c6}
N 1160 17040 1140 17040 {}
C {lab_pin.sym} 1140 17040 0 0 {name=l13631 lab=BL6}
N 1160 17000 1140 17000 {}
C {lab_pin.sym} 1140 17000 0 0 {name=l13632 lab=BLB6}
N 1160 16960 1140 16960 {}
C {lab_pin.sym} 1140 16960 0 0 {name=l13633 lab=WL85}
N 1240 17040 1260 17040 {}
C {lab_pin.sym} 1260 17040 0 0 {name=l13634 lab=VDD}
N 1240 16960 1260 16960 {}
C {lab_pin.sym} 1260 16960 0 0 {name=l13635 lab=VSS}
C {bitcell_6t.sym} 1400 17000 0 0 {name=Xr85c7}
N 1360 17040 1340 17040 {}
C {lab_pin.sym} 1340 17040 0 0 {name=l13636 lab=BL7}
N 1360 17000 1340 17000 {}
C {lab_pin.sym} 1340 17000 0 0 {name=l13637 lab=BLB7}
N 1360 16960 1340 16960 {}
C {lab_pin.sym} 1340 16960 0 0 {name=l13638 lab=WL85}
N 1440 17040 1460 17040 {}
C {lab_pin.sym} 1460 17040 0 0 {name=l13639 lab=VDD}
N 1440 16960 1460 16960 {}
C {lab_pin.sym} 1460 16960 0 0 {name=l13640 lab=VSS}
C {bitcell_6t.sym} 1600 17000 0 0 {name=Xr85c8}
N 1560 17040 1540 17040 {}
C {lab_pin.sym} 1540 17040 0 0 {name=l13641 lab=BL8}
N 1560 17000 1540 17000 {}
C {lab_pin.sym} 1540 17000 0 0 {name=l13642 lab=BLB8}
N 1560 16960 1540 16960 {}
C {lab_pin.sym} 1540 16960 0 0 {name=l13643 lab=WL85}
N 1640 17040 1660 17040 {}
C {lab_pin.sym} 1660 17040 0 0 {name=l13644 lab=VDD}
N 1640 16960 1660 16960 {}
C {lab_pin.sym} 1660 16960 0 0 {name=l13645 lab=VSS}
C {bitcell_6t.sym} 1800 17000 0 0 {name=Xr85c9}
N 1760 17040 1740 17040 {}
C {lab_pin.sym} 1740 17040 0 0 {name=l13646 lab=BL9}
N 1760 17000 1740 17000 {}
C {lab_pin.sym} 1740 17000 0 0 {name=l13647 lab=BLB9}
N 1760 16960 1740 16960 {}
C {lab_pin.sym} 1740 16960 0 0 {name=l13648 lab=WL85}
N 1840 17040 1860 17040 {}
C {lab_pin.sym} 1860 17040 0 0 {name=l13649 lab=VDD}
N 1840 16960 1860 16960 {}
C {lab_pin.sym} 1860 16960 0 0 {name=l13650 lab=VSS}
C {bitcell_6t.sym} 2000 17000 0 0 {name=Xr85c10}
N 1960 17040 1940 17040 {}
C {lab_pin.sym} 1940 17040 0 0 {name=l13651 lab=BL10}
N 1960 17000 1940 17000 {}
C {lab_pin.sym} 1940 17000 0 0 {name=l13652 lab=BLB10}
N 1960 16960 1940 16960 {}
C {lab_pin.sym} 1940 16960 0 0 {name=l13653 lab=WL85}
N 2040 17040 2060 17040 {}
C {lab_pin.sym} 2060 17040 0 0 {name=l13654 lab=VDD}
N 2040 16960 2060 16960 {}
C {lab_pin.sym} 2060 16960 0 0 {name=l13655 lab=VSS}
C {bitcell_6t.sym} 2200 17000 0 0 {name=Xr85c11}
N 2160 17040 2140 17040 {}
C {lab_pin.sym} 2140 17040 0 0 {name=l13656 lab=BL11}
N 2160 17000 2140 17000 {}
C {lab_pin.sym} 2140 17000 0 0 {name=l13657 lab=BLB11}
N 2160 16960 2140 16960 {}
C {lab_pin.sym} 2140 16960 0 0 {name=l13658 lab=WL85}
N 2240 17040 2260 17040 {}
C {lab_pin.sym} 2260 17040 0 0 {name=l13659 lab=VDD}
N 2240 16960 2260 16960 {}
C {lab_pin.sym} 2260 16960 0 0 {name=l13660 lab=VSS}
C {bitcell_6t.sym} 2400 17000 0 0 {name=Xr85c12}
N 2360 17040 2340 17040 {}
C {lab_pin.sym} 2340 17040 0 0 {name=l13661 lab=BL12}
N 2360 17000 2340 17000 {}
C {lab_pin.sym} 2340 17000 0 0 {name=l13662 lab=BLB12}
N 2360 16960 2340 16960 {}
C {lab_pin.sym} 2340 16960 0 0 {name=l13663 lab=WL85}
N 2440 17040 2460 17040 {}
C {lab_pin.sym} 2460 17040 0 0 {name=l13664 lab=VDD}
N 2440 16960 2460 16960 {}
C {lab_pin.sym} 2460 16960 0 0 {name=l13665 lab=VSS}
C {bitcell_6t.sym} 2600 17000 0 0 {name=Xr85c13}
N 2560 17040 2540 17040 {}
C {lab_pin.sym} 2540 17040 0 0 {name=l13666 lab=BL13}
N 2560 17000 2540 17000 {}
C {lab_pin.sym} 2540 17000 0 0 {name=l13667 lab=BLB13}
N 2560 16960 2540 16960 {}
C {lab_pin.sym} 2540 16960 0 0 {name=l13668 lab=WL85}
N 2640 17040 2660 17040 {}
C {lab_pin.sym} 2660 17040 0 0 {name=l13669 lab=VDD}
N 2640 16960 2660 16960 {}
C {lab_pin.sym} 2660 16960 0 0 {name=l13670 lab=VSS}
C {bitcell_6t.sym} 2800 17000 0 0 {name=Xr85c14}
N 2760 17040 2740 17040 {}
C {lab_pin.sym} 2740 17040 0 0 {name=l13671 lab=BL14}
N 2760 17000 2740 17000 {}
C {lab_pin.sym} 2740 17000 0 0 {name=l13672 lab=BLB14}
N 2760 16960 2740 16960 {}
C {lab_pin.sym} 2740 16960 0 0 {name=l13673 lab=WL85}
N 2840 17040 2860 17040 {}
C {lab_pin.sym} 2860 17040 0 0 {name=l13674 lab=VDD}
N 2840 16960 2860 16960 {}
C {lab_pin.sym} 2860 16960 0 0 {name=l13675 lab=VSS}
C {bitcell_6t.sym} 3000 17000 0 0 {name=Xr85c15}
N 2960 17040 2940 17040 {}
C {lab_pin.sym} 2940 17040 0 0 {name=l13676 lab=BL15}
N 2960 17000 2940 17000 {}
C {lab_pin.sym} 2940 17000 0 0 {name=l13677 lab=BLB15}
N 2960 16960 2940 16960 {}
C {lab_pin.sym} 2940 16960 0 0 {name=l13678 lab=WL85}
N 3040 17040 3060 17040 {}
C {lab_pin.sym} 3060 17040 0 0 {name=l13679 lab=VDD}
N 3040 16960 3060 16960 {}
C {lab_pin.sym} 3060 16960 0 0 {name=l13680 lab=VSS}
C {bitcell_6t.sym} 3200 17000 0 0 {name=Xr85c16}
N 3160 17040 3140 17040 {}
C {lab_pin.sym} 3140 17040 0 0 {name=l13681 lab=BL16}
N 3160 17000 3140 17000 {}
C {lab_pin.sym} 3140 17000 0 0 {name=l13682 lab=BLB16}
N 3160 16960 3140 16960 {}
C {lab_pin.sym} 3140 16960 0 0 {name=l13683 lab=WL85}
N 3240 17040 3260 17040 {}
C {lab_pin.sym} 3260 17040 0 0 {name=l13684 lab=VDD}
N 3240 16960 3260 16960 {}
C {lab_pin.sym} 3260 16960 0 0 {name=l13685 lab=VSS}
C {bitcell_6t.sym} 3400 17000 0 0 {name=Xr85c17}
N 3360 17040 3340 17040 {}
C {lab_pin.sym} 3340 17040 0 0 {name=l13686 lab=BL17}
N 3360 17000 3340 17000 {}
C {lab_pin.sym} 3340 17000 0 0 {name=l13687 lab=BLB17}
N 3360 16960 3340 16960 {}
C {lab_pin.sym} 3340 16960 0 0 {name=l13688 lab=WL85}
N 3440 17040 3460 17040 {}
C {lab_pin.sym} 3460 17040 0 0 {name=l13689 lab=VDD}
N 3440 16960 3460 16960 {}
C {lab_pin.sym} 3460 16960 0 0 {name=l13690 lab=VSS}
C {bitcell_6t.sym} 3600 17000 0 0 {name=Xr85c18}
N 3560 17040 3540 17040 {}
C {lab_pin.sym} 3540 17040 0 0 {name=l13691 lab=BL18}
N 3560 17000 3540 17000 {}
C {lab_pin.sym} 3540 17000 0 0 {name=l13692 lab=BLB18}
N 3560 16960 3540 16960 {}
C {lab_pin.sym} 3540 16960 0 0 {name=l13693 lab=WL85}
N 3640 17040 3660 17040 {}
C {lab_pin.sym} 3660 17040 0 0 {name=l13694 lab=VDD}
N 3640 16960 3660 16960 {}
C {lab_pin.sym} 3660 16960 0 0 {name=l13695 lab=VSS}
C {bitcell_6t.sym} 3800 17000 0 0 {name=Xr85c19}
N 3760 17040 3740 17040 {}
C {lab_pin.sym} 3740 17040 0 0 {name=l13696 lab=BL19}
N 3760 17000 3740 17000 {}
C {lab_pin.sym} 3740 17000 0 0 {name=l13697 lab=BLB19}
N 3760 16960 3740 16960 {}
C {lab_pin.sym} 3740 16960 0 0 {name=l13698 lab=WL85}
N 3840 17040 3860 17040 {}
C {lab_pin.sym} 3860 17040 0 0 {name=l13699 lab=VDD}
N 3840 16960 3860 16960 {}
C {lab_pin.sym} 3860 16960 0 0 {name=l13700 lab=VSS}
C {bitcell_6t.sym} 4000 17000 0 0 {name=Xr85c20}
N 3960 17040 3940 17040 {}
C {lab_pin.sym} 3940 17040 0 0 {name=l13701 lab=BL20}
N 3960 17000 3940 17000 {}
C {lab_pin.sym} 3940 17000 0 0 {name=l13702 lab=BLB20}
N 3960 16960 3940 16960 {}
C {lab_pin.sym} 3940 16960 0 0 {name=l13703 lab=WL85}
N 4040 17040 4060 17040 {}
C {lab_pin.sym} 4060 17040 0 0 {name=l13704 lab=VDD}
N 4040 16960 4060 16960 {}
C {lab_pin.sym} 4060 16960 0 0 {name=l13705 lab=VSS}
C {bitcell_6t.sym} 4200 17000 0 0 {name=Xr85c21}
N 4160 17040 4140 17040 {}
C {lab_pin.sym} 4140 17040 0 0 {name=l13706 lab=BL21}
N 4160 17000 4140 17000 {}
C {lab_pin.sym} 4140 17000 0 0 {name=l13707 lab=BLB21}
N 4160 16960 4140 16960 {}
C {lab_pin.sym} 4140 16960 0 0 {name=l13708 lab=WL85}
N 4240 17040 4260 17040 {}
C {lab_pin.sym} 4260 17040 0 0 {name=l13709 lab=VDD}
N 4240 16960 4260 16960 {}
C {lab_pin.sym} 4260 16960 0 0 {name=l13710 lab=VSS}
C {bitcell_6t.sym} 4400 17000 0 0 {name=Xr85c22}
N 4360 17040 4340 17040 {}
C {lab_pin.sym} 4340 17040 0 0 {name=l13711 lab=BL22}
N 4360 17000 4340 17000 {}
C {lab_pin.sym} 4340 17000 0 0 {name=l13712 lab=BLB22}
N 4360 16960 4340 16960 {}
C {lab_pin.sym} 4340 16960 0 0 {name=l13713 lab=WL85}
N 4440 17040 4460 17040 {}
C {lab_pin.sym} 4460 17040 0 0 {name=l13714 lab=VDD}
N 4440 16960 4460 16960 {}
C {lab_pin.sym} 4460 16960 0 0 {name=l13715 lab=VSS}
C {bitcell_6t.sym} 4600 17000 0 0 {name=Xr85c23}
N 4560 17040 4540 17040 {}
C {lab_pin.sym} 4540 17040 0 0 {name=l13716 lab=BL23}
N 4560 17000 4540 17000 {}
C {lab_pin.sym} 4540 17000 0 0 {name=l13717 lab=BLB23}
N 4560 16960 4540 16960 {}
C {lab_pin.sym} 4540 16960 0 0 {name=l13718 lab=WL85}
N 4640 17040 4660 17040 {}
C {lab_pin.sym} 4660 17040 0 0 {name=l13719 lab=VDD}
N 4640 16960 4660 16960 {}
C {lab_pin.sym} 4660 16960 0 0 {name=l13720 lab=VSS}
C {bitcell_6t.sym} 4800 17000 0 0 {name=Xr85c24}
N 4760 17040 4740 17040 {}
C {lab_pin.sym} 4740 17040 0 0 {name=l13721 lab=BL24}
N 4760 17000 4740 17000 {}
C {lab_pin.sym} 4740 17000 0 0 {name=l13722 lab=BLB24}
N 4760 16960 4740 16960 {}
C {lab_pin.sym} 4740 16960 0 0 {name=l13723 lab=WL85}
N 4840 17040 4860 17040 {}
C {lab_pin.sym} 4860 17040 0 0 {name=l13724 lab=VDD}
N 4840 16960 4860 16960 {}
C {lab_pin.sym} 4860 16960 0 0 {name=l13725 lab=VSS}
C {bitcell_6t.sym} 5000 17000 0 0 {name=Xr85c25}
N 4960 17040 4940 17040 {}
C {lab_pin.sym} 4940 17040 0 0 {name=l13726 lab=BL25}
N 4960 17000 4940 17000 {}
C {lab_pin.sym} 4940 17000 0 0 {name=l13727 lab=BLB25}
N 4960 16960 4940 16960 {}
C {lab_pin.sym} 4940 16960 0 0 {name=l13728 lab=WL85}
N 5040 17040 5060 17040 {}
C {lab_pin.sym} 5060 17040 0 0 {name=l13729 lab=VDD}
N 5040 16960 5060 16960 {}
C {lab_pin.sym} 5060 16960 0 0 {name=l13730 lab=VSS}
C {bitcell_6t.sym} 5200 17000 0 0 {name=Xr85c26}
N 5160 17040 5140 17040 {}
C {lab_pin.sym} 5140 17040 0 0 {name=l13731 lab=BL26}
N 5160 17000 5140 17000 {}
C {lab_pin.sym} 5140 17000 0 0 {name=l13732 lab=BLB26}
N 5160 16960 5140 16960 {}
C {lab_pin.sym} 5140 16960 0 0 {name=l13733 lab=WL85}
N 5240 17040 5260 17040 {}
C {lab_pin.sym} 5260 17040 0 0 {name=l13734 lab=VDD}
N 5240 16960 5260 16960 {}
C {lab_pin.sym} 5260 16960 0 0 {name=l13735 lab=VSS}
C {bitcell_6t.sym} 5400 17000 0 0 {name=Xr85c27}
N 5360 17040 5340 17040 {}
C {lab_pin.sym} 5340 17040 0 0 {name=l13736 lab=BL27}
N 5360 17000 5340 17000 {}
C {lab_pin.sym} 5340 17000 0 0 {name=l13737 lab=BLB27}
N 5360 16960 5340 16960 {}
C {lab_pin.sym} 5340 16960 0 0 {name=l13738 lab=WL85}
N 5440 17040 5460 17040 {}
C {lab_pin.sym} 5460 17040 0 0 {name=l13739 lab=VDD}
N 5440 16960 5460 16960 {}
C {lab_pin.sym} 5460 16960 0 0 {name=l13740 lab=VSS}
C {bitcell_6t.sym} 5600 17000 0 0 {name=Xr85c28}
N 5560 17040 5540 17040 {}
C {lab_pin.sym} 5540 17040 0 0 {name=l13741 lab=BL28}
N 5560 17000 5540 17000 {}
C {lab_pin.sym} 5540 17000 0 0 {name=l13742 lab=BLB28}
N 5560 16960 5540 16960 {}
C {lab_pin.sym} 5540 16960 0 0 {name=l13743 lab=WL85}
N 5640 17040 5660 17040 {}
C {lab_pin.sym} 5660 17040 0 0 {name=l13744 lab=VDD}
N 5640 16960 5660 16960 {}
C {lab_pin.sym} 5660 16960 0 0 {name=l13745 lab=VSS}
C {bitcell_6t.sym} 5800 17000 0 0 {name=Xr85c29}
N 5760 17040 5740 17040 {}
C {lab_pin.sym} 5740 17040 0 0 {name=l13746 lab=BL29}
N 5760 17000 5740 17000 {}
C {lab_pin.sym} 5740 17000 0 0 {name=l13747 lab=BLB29}
N 5760 16960 5740 16960 {}
C {lab_pin.sym} 5740 16960 0 0 {name=l13748 lab=WL85}
N 5840 17040 5860 17040 {}
C {lab_pin.sym} 5860 17040 0 0 {name=l13749 lab=VDD}
N 5840 16960 5860 16960 {}
C {lab_pin.sym} 5860 16960 0 0 {name=l13750 lab=VSS}
C {bitcell_6t.sym} 6000 17000 0 0 {name=Xr85c30}
N 5960 17040 5940 17040 {}
C {lab_pin.sym} 5940 17040 0 0 {name=l13751 lab=BL30}
N 5960 17000 5940 17000 {}
C {lab_pin.sym} 5940 17000 0 0 {name=l13752 lab=BLB30}
N 5960 16960 5940 16960 {}
C {lab_pin.sym} 5940 16960 0 0 {name=l13753 lab=WL85}
N 6040 17040 6060 17040 {}
C {lab_pin.sym} 6060 17040 0 0 {name=l13754 lab=VDD}
N 6040 16960 6060 16960 {}
C {lab_pin.sym} 6060 16960 0 0 {name=l13755 lab=VSS}
C {bitcell_6t.sym} 6200 17000 0 0 {name=Xr85c31}
N 6160 17040 6140 17040 {}
C {lab_pin.sym} 6140 17040 0 0 {name=l13756 lab=BL31}
N 6160 17000 6140 17000 {}
C {lab_pin.sym} 6140 17000 0 0 {name=l13757 lab=BLB31}
N 6160 16960 6140 16960 {}
C {lab_pin.sym} 6140 16960 0 0 {name=l13758 lab=WL85}
N 6240 17040 6260 17040 {}
C {lab_pin.sym} 6260 17040 0 0 {name=l13759 lab=VDD}
N 6240 16960 6260 16960 {}
C {lab_pin.sym} 6260 16960 0 0 {name=l13760 lab=VSS}
C {bitcell_6t.sym} 0 17200 0 0 {name=Xr86c0}
N -40 17240 -60 17240 {}
C {lab_pin.sym} -60 17240 0 0 {name=l13761 lab=BL0}
N -40 17200 -60 17200 {}
C {lab_pin.sym} -60 17200 0 0 {name=l13762 lab=BLB0}
N -40 17160 -60 17160 {}
C {lab_pin.sym} -60 17160 0 0 {name=l13763 lab=WL86}
N 40 17240 60 17240 {}
C {lab_pin.sym} 60 17240 0 0 {name=l13764 lab=VDD}
N 40 17160 60 17160 {}
C {lab_pin.sym} 60 17160 0 0 {name=l13765 lab=VSS}
C {bitcell_6t.sym} 200 17200 0 0 {name=Xr86c1}
N 160 17240 140 17240 {}
C {lab_pin.sym} 140 17240 0 0 {name=l13766 lab=BL1}
N 160 17200 140 17200 {}
C {lab_pin.sym} 140 17200 0 0 {name=l13767 lab=BLB1}
N 160 17160 140 17160 {}
C {lab_pin.sym} 140 17160 0 0 {name=l13768 lab=WL86}
N 240 17240 260 17240 {}
C {lab_pin.sym} 260 17240 0 0 {name=l13769 lab=VDD}
N 240 17160 260 17160 {}
C {lab_pin.sym} 260 17160 0 0 {name=l13770 lab=VSS}
C {bitcell_6t.sym} 400 17200 0 0 {name=Xr86c2}
N 360 17240 340 17240 {}
C {lab_pin.sym} 340 17240 0 0 {name=l13771 lab=BL2}
N 360 17200 340 17200 {}
C {lab_pin.sym} 340 17200 0 0 {name=l13772 lab=BLB2}
N 360 17160 340 17160 {}
C {lab_pin.sym} 340 17160 0 0 {name=l13773 lab=WL86}
N 440 17240 460 17240 {}
C {lab_pin.sym} 460 17240 0 0 {name=l13774 lab=VDD}
N 440 17160 460 17160 {}
C {lab_pin.sym} 460 17160 0 0 {name=l13775 lab=VSS}
C {bitcell_6t.sym} 600 17200 0 0 {name=Xr86c3}
N 560 17240 540 17240 {}
C {lab_pin.sym} 540 17240 0 0 {name=l13776 lab=BL3}
N 560 17200 540 17200 {}
C {lab_pin.sym} 540 17200 0 0 {name=l13777 lab=BLB3}
N 560 17160 540 17160 {}
C {lab_pin.sym} 540 17160 0 0 {name=l13778 lab=WL86}
N 640 17240 660 17240 {}
C {lab_pin.sym} 660 17240 0 0 {name=l13779 lab=VDD}
N 640 17160 660 17160 {}
C {lab_pin.sym} 660 17160 0 0 {name=l13780 lab=VSS}
C {bitcell_6t.sym} 800 17200 0 0 {name=Xr86c4}
N 760 17240 740 17240 {}
C {lab_pin.sym} 740 17240 0 0 {name=l13781 lab=BL4}
N 760 17200 740 17200 {}
C {lab_pin.sym} 740 17200 0 0 {name=l13782 lab=BLB4}
N 760 17160 740 17160 {}
C {lab_pin.sym} 740 17160 0 0 {name=l13783 lab=WL86}
N 840 17240 860 17240 {}
C {lab_pin.sym} 860 17240 0 0 {name=l13784 lab=VDD}
N 840 17160 860 17160 {}
C {lab_pin.sym} 860 17160 0 0 {name=l13785 lab=VSS}
C {bitcell_6t.sym} 1000 17200 0 0 {name=Xr86c5}
N 960 17240 940 17240 {}
C {lab_pin.sym} 940 17240 0 0 {name=l13786 lab=BL5}
N 960 17200 940 17200 {}
C {lab_pin.sym} 940 17200 0 0 {name=l13787 lab=BLB5}
N 960 17160 940 17160 {}
C {lab_pin.sym} 940 17160 0 0 {name=l13788 lab=WL86}
N 1040 17240 1060 17240 {}
C {lab_pin.sym} 1060 17240 0 0 {name=l13789 lab=VDD}
N 1040 17160 1060 17160 {}
C {lab_pin.sym} 1060 17160 0 0 {name=l13790 lab=VSS}
C {bitcell_6t.sym} 1200 17200 0 0 {name=Xr86c6}
N 1160 17240 1140 17240 {}
C {lab_pin.sym} 1140 17240 0 0 {name=l13791 lab=BL6}
N 1160 17200 1140 17200 {}
C {lab_pin.sym} 1140 17200 0 0 {name=l13792 lab=BLB6}
N 1160 17160 1140 17160 {}
C {lab_pin.sym} 1140 17160 0 0 {name=l13793 lab=WL86}
N 1240 17240 1260 17240 {}
C {lab_pin.sym} 1260 17240 0 0 {name=l13794 lab=VDD}
N 1240 17160 1260 17160 {}
C {lab_pin.sym} 1260 17160 0 0 {name=l13795 lab=VSS}
C {bitcell_6t.sym} 1400 17200 0 0 {name=Xr86c7}
N 1360 17240 1340 17240 {}
C {lab_pin.sym} 1340 17240 0 0 {name=l13796 lab=BL7}
N 1360 17200 1340 17200 {}
C {lab_pin.sym} 1340 17200 0 0 {name=l13797 lab=BLB7}
N 1360 17160 1340 17160 {}
C {lab_pin.sym} 1340 17160 0 0 {name=l13798 lab=WL86}
N 1440 17240 1460 17240 {}
C {lab_pin.sym} 1460 17240 0 0 {name=l13799 lab=VDD}
N 1440 17160 1460 17160 {}
