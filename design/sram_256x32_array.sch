C {lab_pin.sym} 2860 5840 0 0 {name=l4714 lab=VDD}
N 2840 5760 2860 5760 {}
C {lab_pin.sym} 2860 5760 0 0 {name=l4715 lab=VSS}
C {bitcell_6t.sym} 3000 5800 0 0 {name=Xr29c15}
N 2960 5840 2940 5840 {}
C {lab_pin.sym} 2940 5840 0 0 {name=l4716 lab=BL15}
N 2960 5800 2940 5800 {}
C {lab_pin.sym} 2940 5800 0 0 {name=l4717 lab=BLB15}
N 2960 5760 2940 5760 {}
C {lab_pin.sym} 2940 5760 0 0 {name=l4718 lab=WL29}
N 3040 5840 3060 5840 {}
C {lab_pin.sym} 3060 5840 0 0 {name=l4719 lab=VDD}
N 3040 5760 3060 5760 {}
C {lab_pin.sym} 3060 5760 0 0 {name=l4720 lab=VSS}
C {bitcell_6t.sym} 3200 5800 0 0 {name=Xr29c16}
N 3160 5840 3140 5840 {}
C {lab_pin.sym} 3140 5840 0 0 {name=l4721 lab=BL16}
N 3160 5800 3140 5800 {}
C {lab_pin.sym} 3140 5800 0 0 {name=l4722 lab=BLB16}
N 3160 5760 3140 5760 {}
C {lab_pin.sym} 3140 5760 0 0 {name=l4723 lab=WL29}
N 3240 5840 3260 5840 {}
C {lab_pin.sym} 3260 5840 0 0 {name=l4724 lab=VDD}
N 3240 5760 3260 5760 {}
C {lab_pin.sym} 3260 5760 0 0 {name=l4725 lab=VSS}
C {bitcell_6t.sym} 3400 5800 0 0 {name=Xr29c17}
N 3360 5840 3340 5840 {}
C {lab_pin.sym} 3340 5840 0 0 {name=l4726 lab=BL17}
N 3360 5800 3340 5800 {}
C {lab_pin.sym} 3340 5800 0 0 {name=l4727 lab=BLB17}
N 3360 5760 3340 5760 {}
C {lab_pin.sym} 3340 5760 0 0 {name=l4728 lab=WL29}
N 3440 5840 3460 5840 {}
C {lab_pin.sym} 3460 5840 0 0 {name=l4729 lab=VDD}
N 3440 5760 3460 5760 {}
C {lab_pin.sym} 3460 5760 0 0 {name=l4730 lab=VSS}
C {bitcell_6t.sym} 3600 5800 0 0 {name=Xr29c18}
N 3560 5840 3540 5840 {}
C {lab_pin.sym} 3540 5840 0 0 {name=l4731 lab=BL18}
N 3560 5800 3540 5800 {}
C {lab_pin.sym} 3540 5800 0 0 {name=l4732 lab=BLB18}
N 3560 5760 3540 5760 {}
C {lab_pin.sym} 3540 5760 0 0 {name=l4733 lab=WL29}
N 3640 5840 3660 5840 {}
C {lab_pin.sym} 3660 5840 0 0 {name=l4734 lab=VDD}
N 3640 5760 3660 5760 {}
C {lab_pin.sym} 3660 5760 0 0 {name=l4735 lab=VSS}
C {bitcell_6t.sym} 3800 5800 0 0 {name=Xr29c19}
N 3760 5840 3740 5840 {}
C {lab_pin.sym} 3740 5840 0 0 {name=l4736 lab=BL19}
N 3760 5800 3740 5800 {}
C {lab_pin.sym} 3740 5800 0 0 {name=l4737 lab=BLB19}
N 3760 5760 3740 5760 {}
C {lab_pin.sym} 3740 5760 0 0 {name=l4738 lab=WL29}
N 3840 5840 3860 5840 {}
C {lab_pin.sym} 3860 5840 0 0 {name=l4739 lab=VDD}
N 3840 5760 3860 5760 {}
C {lab_pin.sym} 3860 5760 0 0 {name=l4740 lab=VSS}
C {bitcell_6t.sym} 4000 5800 0 0 {name=Xr29c20}
N 3960 5840 3940 5840 {}
C {lab_pin.sym} 3940 5840 0 0 {name=l4741 lab=BL20}
N 3960 5800 3940 5800 {}
C {lab_pin.sym} 3940 5800 0 0 {name=l4742 lab=BLB20}
N 3960 5760 3940 5760 {}
C {lab_pin.sym} 3940 5760 0 0 {name=l4743 lab=WL29}
N 4040 5840 4060 5840 {}
C {lab_pin.sym} 4060 5840 0 0 {name=l4744 lab=VDD}
N 4040 5760 4060 5760 {}
C {lab_pin.sym} 4060 5760 0 0 {name=l4745 lab=VSS}
C {bitcell_6t.sym} 4200 5800 0 0 {name=Xr29c21}
N 4160 5840 4140 5840 {}
C {lab_pin.sym} 4140 5840 0 0 {name=l4746 lab=BL21}
N 4160 5800 4140 5800 {}
C {lab_pin.sym} 4140 5800 0 0 {name=l4747 lab=BLB21}
N 4160 5760 4140 5760 {}
C {lab_pin.sym} 4140 5760 0 0 {name=l4748 lab=WL29}
N 4240 5840 4260 5840 {}
C {lab_pin.sym} 4260 5840 0 0 {name=l4749 lab=VDD}
N 4240 5760 4260 5760 {}
C {lab_pin.sym} 4260 5760 0 0 {name=l4750 lab=VSS}
C {bitcell_6t.sym} 4400 5800 0 0 {name=Xr29c22}
N 4360 5840 4340 5840 {}
C {lab_pin.sym} 4340 5840 0 0 {name=l4751 lab=BL22}
N 4360 5800 4340 5800 {}
C {lab_pin.sym} 4340 5800 0 0 {name=l4752 lab=BLB22}
N 4360 5760 4340 5760 {}
C {lab_pin.sym} 4340 5760 0 0 {name=l4753 lab=WL29}
N 4440 5840 4460 5840 {}
C {lab_pin.sym} 4460 5840 0 0 {name=l4754 lab=VDD}
N 4440 5760 4460 5760 {}
C {lab_pin.sym} 4460 5760 0 0 {name=l4755 lab=VSS}
C {bitcell_6t.sym} 4600 5800 0 0 {name=Xr29c23}
N 4560 5840 4540 5840 {}
C {lab_pin.sym} 4540 5840 0 0 {name=l4756 lab=BL23}
N 4560 5800 4540 5800 {}
C {lab_pin.sym} 4540 5800 0 0 {name=l4757 lab=BLB23}
N 4560 5760 4540 5760 {}
C {lab_pin.sym} 4540 5760 0 0 {name=l4758 lab=WL29}
N 4640 5840 4660 5840 {}
C {lab_pin.sym} 4660 5840 0 0 {name=l4759 lab=VDD}
N 4640 5760 4660 5760 {}
C {lab_pin.sym} 4660 5760 0 0 {name=l4760 lab=VSS}
C {bitcell_6t.sym} 4800 5800 0 0 {name=Xr29c24}
N 4760 5840 4740 5840 {}
C {lab_pin.sym} 4740 5840 0 0 {name=l4761 lab=BL24}
N 4760 5800 4740 5800 {}
C {lab_pin.sym} 4740 5800 0 0 {name=l4762 lab=BLB24}
N 4760 5760 4740 5760 {}
C {lab_pin.sym} 4740 5760 0 0 {name=l4763 lab=WL29}
N 4840 5840 4860 5840 {}
C {lab_pin.sym} 4860 5840 0 0 {name=l4764 lab=VDD}
N 4840 5760 4860 5760 {}
C {lab_pin.sym} 4860 5760 0 0 {name=l4765 lab=VSS}
C {bitcell_6t.sym} 5000 5800 0 0 {name=Xr29c25}
N 4960 5840 4940 5840 {}
C {lab_pin.sym} 4940 5840 0 0 {name=l4766 lab=BL25}
N 4960 5800 4940 5800 {}
C {lab_pin.sym} 4940 5800 0 0 {name=l4767 lab=BLB25}
N 4960 5760 4940 5760 {}
C {lab_pin.sym} 4940 5760 0 0 {name=l4768 lab=WL29}
N 5040 5840 5060 5840 {}
C {lab_pin.sym} 5060 5840 0 0 {name=l4769 lab=VDD}
N 5040 5760 5060 5760 {}
C {lab_pin.sym} 5060 5760 0 0 {name=l4770 lab=VSS}
C {bitcell_6t.sym} 5200 5800 0 0 {name=Xr29c26}
N 5160 5840 5140 5840 {}
C {lab_pin.sym} 5140 5840 0 0 {name=l4771 lab=BL26}
N 5160 5800 5140 5800 {}
C {lab_pin.sym} 5140 5800 0 0 {name=l4772 lab=BLB26}
N 5160 5760 5140 5760 {}
C {lab_pin.sym} 5140 5760 0 0 {name=l4773 lab=WL29}
N 5240 5840 5260 5840 {}
C {lab_pin.sym} 5260 5840 0 0 {name=l4774 lab=VDD}
N 5240 5760 5260 5760 {}
C {lab_pin.sym} 5260 5760 0 0 {name=l4775 lab=VSS}
C {bitcell_6t.sym} 5400 5800 0 0 {name=Xr29c27}
N 5360 5840 5340 5840 {}
C {lab_pin.sym} 5340 5840 0 0 {name=l4776 lab=BL27}
N 5360 5800 5340 5800 {}
C {lab_pin.sym} 5340 5800 0 0 {name=l4777 lab=BLB27}
N 5360 5760 5340 5760 {}
C {lab_pin.sym} 5340 5760 0 0 {name=l4778 lab=WL29}
N 5440 5840 5460 5840 {}
C {lab_pin.sym} 5460 5840 0 0 {name=l4779 lab=VDD}
N 5440 5760 5460 5760 {}
C {lab_pin.sym} 5460 5760 0 0 {name=l4780 lab=VSS}
C {bitcell_6t.sym} 5600 5800 0 0 {name=Xr29c28}
N 5560 5840 5540 5840 {}
C {lab_pin.sym} 5540 5840 0 0 {name=l4781 lab=BL28}
N 5560 5800 5540 5800 {}
C {lab_pin.sym} 5540 5800 0 0 {name=l4782 lab=BLB28}
N 5560 5760 5540 5760 {}
C {lab_pin.sym} 5540 5760 0 0 {name=l4783 lab=WL29}
N 5640 5840 5660 5840 {}
C {lab_pin.sym} 5660 5840 0 0 {name=l4784 lab=VDD}
N 5640 5760 5660 5760 {}
C {lab_pin.sym} 5660 5760 0 0 {name=l4785 lab=VSS}
C {bitcell_6t.sym} 5800 5800 0 0 {name=Xr29c29}
N 5760 5840 5740 5840 {}
C {lab_pin.sym} 5740 5840 0 0 {name=l4786 lab=BL29}
N 5760 5800 5740 5800 {}
C {lab_pin.sym} 5740 5800 0 0 {name=l4787 lab=BLB29}
N 5760 5760 5740 5760 {}
C {lab_pin.sym} 5740 5760 0 0 {name=l4788 lab=WL29}
N 5840 5840 5860 5840 {}
C {lab_pin.sym} 5860 5840 0 0 {name=l4789 lab=VDD}
N 5840 5760 5860 5760 {}
C {lab_pin.sym} 5860 5760 0 0 {name=l4790 lab=VSS}
C {bitcell_6t.sym} 6000 5800 0 0 {name=Xr29c30}
N 5960 5840 5940 5840 {}
C {lab_pin.sym} 5940 5840 0 0 {name=l4791 lab=BL30}
N 5960 5800 5940 5800 {}
C {lab_pin.sym} 5940 5800 0 0 {name=l4792 lab=BLB30}
N 5960 5760 5940 5760 {}
C {lab_pin.sym} 5940 5760 0 0 {name=l4793 lab=WL29}
N 6040 5840 6060 5840 {}
C {lab_pin.sym} 6060 5840 0 0 {name=l4794 lab=VDD}
N 6040 5760 6060 5760 {}
C {lab_pin.sym} 6060 5760 0 0 {name=l4795 lab=VSS}
C {bitcell_6t.sym} 6200 5800 0 0 {name=Xr29c31}
N 6160 5840 6140 5840 {}
C {lab_pin.sym} 6140 5840 0 0 {name=l4796 lab=BL31}
N 6160 5800 6140 5800 {}
C {lab_pin.sym} 6140 5800 0 0 {name=l4797 lab=BLB31}
N 6160 5760 6140 5760 {}
C {lab_pin.sym} 6140 5760 0 0 {name=l4798 lab=WL29}
N 6240 5840 6260 5840 {}
C {lab_pin.sym} 6260 5840 0 0 {name=l4799 lab=VDD}
N 6240 5760 6260 5760 {}
C {lab_pin.sym} 6260 5760 0 0 {name=l4800 lab=VSS}
C {bitcell_6t.sym} 0 6000 0 0 {name=Xr30c0}
N -40 6040 -60 6040 {}
C {lab_pin.sym} -60 6040 0 0 {name=l4801 lab=BL0}
N -40 6000 -60 6000 {}
C {lab_pin.sym} -60 6000 0 0 {name=l4802 lab=BLB0}
N -40 5960 -60 5960 {}
C {lab_pin.sym} -60 5960 0 0 {name=l4803 lab=WL30}
N 40 6040 60 6040 {}
C {lab_pin.sym} 60 6040 0 0 {name=l4804 lab=VDD}
N 40 5960 60 5960 {}
C {lab_pin.sym} 60 5960 0 0 {name=l4805 lab=VSS}
C {bitcell_6t.sym} 200 6000 0 0 {name=Xr30c1}
N 160 6040 140 6040 {}
C {lab_pin.sym} 140 6040 0 0 {name=l4806 lab=BL1}
N 160 6000 140 6000 {}
C {lab_pin.sym} 140 6000 0 0 {name=l4807 lab=BLB1}
N 160 5960 140 5960 {}
C {lab_pin.sym} 140 5960 0 0 {name=l4808 lab=WL30}
N 240 6040 260 6040 {}
C {lab_pin.sym} 260 6040 0 0 {name=l4809 lab=VDD}
N 240 5960 260 5960 {}
C {lab_pin.sym} 260 5960 0 0 {name=l4810 lab=VSS}
C {bitcell_6t.sym} 400 6000 0 0 {name=Xr30c2}
N 360 6040 340 6040 {}
C {lab_pin.sym} 340 6040 0 0 {name=l4811 lab=BL2}
N 360 6000 340 6000 {}
C {lab_pin.sym} 340 6000 0 0 {name=l4812 lab=BLB2}
N 360 5960 340 5960 {}
C {lab_pin.sym} 340 5960 0 0 {name=l4813 lab=WL30}
N 440 6040 460 6040 {}
C {lab_pin.sym} 460 6040 0 0 {name=l4814 lab=VDD}
N 440 5960 460 5960 {}
C {lab_pin.sym} 460 5960 0 0 {name=l4815 lab=VSS}
C {bitcell_6t.sym} 600 6000 0 0 {name=Xr30c3}
N 560 6040 540 6040 {}
C {lab_pin.sym} 540 6040 0 0 {name=l4816 lab=BL3}
N 560 6000 540 6000 {}
C {lab_pin.sym} 540 6000 0 0 {name=l4817 lab=BLB3}
N 560 5960 540 5960 {}
C {lab_pin.sym} 540 5960 0 0 {name=l4818 lab=WL30}
N 640 6040 660 6040 {}
C {lab_pin.sym} 660 6040 0 0 {name=l4819 lab=VDD}
N 640 5960 660 5960 {}
C {lab_pin.sym} 660 5960 0 0 {name=l4820 lab=VSS}
C {bitcell_6t.sym} 800 6000 0 0 {name=Xr30c4}
N 760 6040 740 6040 {}
C {lab_pin.sym} 740 6040 0 0 {name=l4821 lab=BL4}
N 760 6000 740 6000 {}
C {lab_pin.sym} 740 6000 0 0 {name=l4822 lab=BLB4}
N 760 5960 740 5960 {}
C {lab_pin.sym} 740 5960 0 0 {name=l4823 lab=WL30}
N 840 6040 860 6040 {}
C {lab_pin.sym} 860 6040 0 0 {name=l4824 lab=VDD}
N 840 5960 860 5960 {}
C {lab_pin.sym} 860 5960 0 0 {name=l4825 lab=VSS}
C {bitcell_6t.sym} 1000 6000 0 0 {name=Xr30c5}
N 960 6040 940 6040 {}
C {lab_pin.sym} 940 6040 0 0 {name=l4826 lab=BL5}
N 960 6000 940 6000 {}
C {lab_pin.sym} 940 6000 0 0 {name=l4827 lab=BLB5}
N 960 5960 940 5960 {}
C {lab_pin.sym} 940 5960 0 0 {name=l4828 lab=WL30}
N 1040 6040 1060 6040 {}
C {lab_pin.sym} 1060 6040 0 0 {name=l4829 lab=VDD}
N 1040 5960 1060 5960 {}
C {lab_pin.sym} 1060 5960 0 0 {name=l4830 lab=VSS}
C {bitcell_6t.sym} 1200 6000 0 0 {name=Xr30c6}
N 1160 6040 1140 6040 {}
C {lab_pin.sym} 1140 6040 0 0 {name=l4831 lab=BL6}
N 1160 6000 1140 6000 {}
C {lab_pin.sym} 1140 6000 0 0 {name=l4832 lab=BLB6}
N 1160 5960 1140 5960 {}
C {lab_pin.sym} 1140 5960 0 0 {name=l4833 lab=WL30}
N 1240 6040 1260 6040 {}
C {lab_pin.sym} 1260 6040 0 0 {name=l4834 lab=VDD}
N 1240 5960 1260 5960 {}
C {lab_pin.sym} 1260 5960 0 0 {name=l4835 lab=VSS}
C {bitcell_6t.sym} 1400 6000 0 0 {name=Xr30c7}
N 1360 6040 1340 6040 {}
C {lab_pin.sym} 1340 6040 0 0 {name=l4836 lab=BL7}
N 1360 6000 1340 6000 {}
C {lab_pin.sym} 1340 6000 0 0 {name=l4837 lab=BLB7}
N 1360 5960 1340 5960 {}
C {lab_pin.sym} 1340 5960 0 0 {name=l4838 lab=WL30}
N 1440 6040 1460 6040 {}
C {lab_pin.sym} 1460 6040 0 0 {name=l4839 lab=VDD}
N 1440 5960 1460 5960 {}
C {lab_pin.sym} 1460 5960 0 0 {name=l4840 lab=VSS}
C {bitcell_6t.sym} 1600 6000 0 0 {name=Xr30c8}
N 1560 6040 1540 6040 {}
C {lab_pin.sym} 1540 6040 0 0 {name=l4841 lab=BL8}
N 1560 6000 1540 6000 {}
C {lab_pin.sym} 1540 6000 0 0 {name=l4842 lab=BLB8}
N 1560 5960 1540 5960 {}
C {lab_pin.sym} 1540 5960 0 0 {name=l4843 lab=WL30}
N 1640 6040 1660 6040 {}
C {lab_pin.sym} 1660 6040 0 0 {name=l4844 lab=VDD}
N 1640 5960 1660 5960 {}
C {lab_pin.sym} 1660 5960 0 0 {name=l4845 lab=VSS}
C {bitcell_6t.sym} 1800 6000 0 0 {name=Xr30c9}
N 1760 6040 1740 6040 {}
C {lab_pin.sym} 1740 6040 0 0 {name=l4846 lab=BL9}
N 1760 6000 1740 6000 {}
C {lab_pin.sym} 1740 6000 0 0 {name=l4847 lab=BLB9}
N 1760 5960 1740 5960 {}
C {lab_pin.sym} 1740 5960 0 0 {name=l4848 lab=WL30}
N 1840 6040 1860 6040 {}
C {lab_pin.sym} 1860 6040 0 0 {name=l4849 lab=VDD}
N 1840 5960 1860 5960 {}
C {lab_pin.sym} 1860 5960 0 0 {name=l4850 lab=VSS}
C {bitcell_6t.sym} 2000 6000 0 0 {name=Xr30c10}
N 1960 6040 1940 6040 {}
C {lab_pin.sym} 1940 6040 0 0 {name=l4851 lab=BL10}
N 1960 6000 1940 6000 {}
C {lab_pin.sym} 1940 6000 0 0 {name=l4852 lab=BLB10}
N 1960 5960 1940 5960 {}
C {lab_pin.sym} 1940 5960 0 0 {name=l4853 lab=WL30}
N 2040 6040 2060 6040 {}
C {lab_pin.sym} 2060 6040 0 0 {name=l4854 lab=VDD}
N 2040 5960 2060 5960 {}
C {lab_pin.sym} 2060 5960 0 0 {name=l4855 lab=VSS}
C {bitcell_6t.sym} 2200 6000 0 0 {name=Xr30c11}
N 2160 6040 2140 6040 {}
C {lab_pin.sym} 2140 6040 0 0 {name=l4856 lab=BL11}
N 2160 6000 2140 6000 {}
C {lab_pin.sym} 2140 6000 0 0 {name=l4857 lab=BLB11}
N 2160 5960 2140 5960 {}
C {lab_pin.sym} 2140 5960 0 0 {name=l4858 lab=WL30}
N 2240 6040 2260 6040 {}
C {lab_pin.sym} 2260 6040 0 0 {name=l4859 lab=VDD}
N 2240 5960 2260 5960 {}
C {lab_pin.sym} 2260 5960 0 0 {name=l4860 lab=VSS}
C {bitcell_6t.sym} 2400 6000 0 0 {name=Xr30c12}
N 2360 6040 2340 6040 {}
C {lab_pin.sym} 2340 6040 0 0 {name=l4861 lab=BL12}
N 2360 6000 2340 6000 {}
C {lab_pin.sym} 2340 6000 0 0 {name=l4862 lab=BLB12}
N 2360 5960 2340 5960 {}
C {lab_pin.sym} 2340 5960 0 0 {name=l4863 lab=WL30}
N 2440 6040 2460 6040 {}
C {lab_pin.sym} 2460 6040 0 0 {name=l4864 lab=VDD}
N 2440 5960 2460 5960 {}
C {lab_pin.sym} 2460 5960 0 0 {name=l4865 lab=VSS}
C {bitcell_6t.sym} 2600 6000 0 0 {name=Xr30c13}
N 2560 6040 2540 6040 {}
C {lab_pin.sym} 2540 6040 0 0 {name=l4866 lab=BL13}
N 2560 6000 2540 6000 {}
C {lab_pin.sym} 2540 6000 0 0 {name=l4867 lab=BLB13}
N 2560 5960 2540 5960 {}
C {lab_pin.sym} 2540 5960 0 0 {name=l4868 lab=WL30}
N 2640 6040 2660 6040 {}
C {lab_pin.sym} 2660 6040 0 0 {name=l4869 lab=VDD}
N 2640 5960 2660 5960 {}
C {lab_pin.sym} 2660 5960 0 0 {name=l4870 lab=VSS}
C {bitcell_6t.sym} 2800 6000 0 0 {name=Xr30c14}
N 2760 6040 2740 6040 {}
C {lab_pin.sym} 2740 6040 0 0 {name=l4871 lab=BL14}
N 2760 6000 2740 6000 {}
C {lab_pin.sym} 2740 6000 0 0 {name=l4872 lab=BLB14}
N 2760 5960 2740 5960 {}
C {lab_pin.sym} 2740 5960 0 0 {name=l4873 lab=WL30}
N 2840 6040 2860 6040 {}
C {lab_pin.sym} 2860 6040 0 0 {name=l4874 lab=VDD}
N 2840 5960 2860 5960 {}
C {lab_pin.sym} 2860 5960 0 0 {name=l4875 lab=VSS}
C {bitcell_6t.sym} 3000 6000 0 0 {name=Xr30c15}
N 2960 6040 2940 6040 {}
C {lab_pin.sym} 2940 6040 0 0 {name=l4876 lab=BL15}
N 2960 6000 2940 6000 {}
C {lab_pin.sym} 2940 6000 0 0 {name=l4877 lab=BLB15}
N 2960 5960 2940 5960 {}
C {lab_pin.sym} 2940 5960 0 0 {name=l4878 lab=WL30}
N 3040 6040 3060 6040 {}
C {lab_pin.sym} 3060 6040 0 0 {name=l4879 lab=VDD}
N 3040 5960 3060 5960 {}
C {lab_pin.sym} 3060 5960 0 0 {name=l4880 lab=VSS}
C {bitcell_6t.sym} 3200 6000 0 0 {name=Xr30c16}
N 3160 6040 3140 6040 {}
C {lab_pin.sym} 3140 6040 0 0 {name=l4881 lab=BL16}
N 3160 6000 3140 6000 {}
C {lab_pin.sym} 3140 6000 0 0 {name=l4882 lab=BLB16}
N 3160 5960 3140 5960 {}
C {lab_pin.sym} 3140 5960 0 0 {name=l4883 lab=WL30}
N 3240 6040 3260 6040 {}
C {lab_pin.sym} 3260 6040 0 0 {name=l4884 lab=VDD}
N 3240 5960 3260 5960 {}
C {lab_pin.sym} 3260 5960 0 0 {name=l4885 lab=VSS}
C {bitcell_6t.sym} 3400 6000 0 0 {name=Xr30c17}
N 3360 6040 3340 6040 {}
C {lab_pin.sym} 3340 6040 0 0 {name=l4886 lab=BL17}
N 3360 6000 3340 6000 {}
C {lab_pin.sym} 3340 6000 0 0 {name=l4887 lab=BLB17}
N 3360 5960 3340 5960 {}
C {lab_pin.sym} 3340 5960 0 0 {name=l4888 lab=WL30}
N 3440 6040 3460 6040 {}
C {lab_pin.sym} 3460 6040 0 0 {name=l4889 lab=VDD}
N 3440 5960 3460 5960 {}
C {lab_pin.sym} 3460 5960 0 0 {name=l4890 lab=VSS}
C {bitcell_6t.sym} 3600 6000 0 0 {name=Xr30c18}
N 3560 6040 3540 6040 {}
C {lab_pin.sym} 3540 6040 0 0 {name=l4891 lab=BL18}
N 3560 6000 3540 6000 {}
C {lab_pin.sym} 3540 6000 0 0 {name=l4892 lab=BLB18}
N 3560 5960 3540 5960 {}
C {lab_pin.sym} 3540 5960 0 0 {name=l4893 lab=WL30}
N 3640 6040 3660 6040 {}
C {lab_pin.sym} 3660 6040 0 0 {name=l4894 lab=VDD}
N 3640 5960 3660 5960 {}
C {lab_pin.sym} 3660 5960 0 0 {name=l4895 lab=VSS}
C {bitcell_6t.sym} 3800 6000 0 0 {name=Xr30c19}
N 3760 6040 3740 6040 {}
C {lab_pin.sym} 3740 6040 0 0 {name=l4896 lab=BL19}
N 3760 6000 3740 6000 {}
C {lab_pin.sym} 3740 6000 0 0 {name=l4897 lab=BLB19}
N 3760 5960 3740 5960 {}
C {lab_pin.sym} 3740 5960 0 0 {name=l4898 lab=WL30}
N 3840 6040 3860 6040 {}
C {lab_pin.sym} 3860 6040 0 0 {name=l4899 lab=VDD}
N 3840 5960 3860 5960 {}
C {lab_pin.sym} 3860 5960 0 0 {name=l4900 lab=VSS}
C {bitcell_6t.sym} 4000 6000 0 0 {name=Xr30c20}
N 3960 6040 3940 6040 {}
C {lab_pin.sym} 3940 6040 0 0 {name=l4901 lab=BL20}
N 3960 6000 3940 6000 {}
C {lab_pin.sym} 3940 6000 0 0 {name=l4902 lab=BLB20}
N 3960 5960 3940 5960 {}
C {lab_pin.sym} 3940 5960 0 0 {name=l4903 lab=WL30}
N 4040 6040 4060 6040 {}
C {lab_pin.sym} 4060 6040 0 0 {name=l4904 lab=VDD}
N 4040 5960 4060 5960 {}
C {lab_pin.sym} 4060 5960 0 0 {name=l4905 lab=VSS}
C {bitcell_6t.sym} 4200 6000 0 0 {name=Xr30c21}
N 4160 6040 4140 6040 {}
C {lab_pin.sym} 4140 6040 0 0 {name=l4906 lab=BL21}
N 4160 6000 4140 6000 {}
C {lab_pin.sym} 4140 6000 0 0 {name=l4907 lab=BLB21}
N 4160 5960 4140 5960 {}
C {lab_pin.sym} 4140 5960 0 0 {name=l4908 lab=WL30}
N 4240 6040 4260 6040 {}
C {lab_pin.sym} 4260 6040 0 0 {name=l4909 lab=VDD}
N 4240 5960 4260 5960 {}
C {lab_pin.sym} 4260 5960 0 0 {name=l4910 lab=VSS}
C {bitcell_6t.sym} 4400 6000 0 0 {name=Xr30c22}
N 4360 6040 4340 6040 {}
C {lab_pin.sym} 4340 6040 0 0 {name=l4911 lab=BL22}
N 4360 6000 4340 6000 {}
C {lab_pin.sym} 4340 6000 0 0 {name=l4912 lab=BLB22}
N 4360 5960 4340 5960 {}
C {lab_pin.sym} 4340 5960 0 0 {name=l4913 lab=WL30}
N 4440 6040 4460 6040 {}
C {lab_pin.sym} 4460 6040 0 0 {name=l4914 lab=VDD}
N 4440 5960 4460 5960 {}
C {lab_pin.sym} 4460 5960 0 0 {name=l4915 lab=VSS}
C {bitcell_6t.sym} 4600 6000 0 0 {name=Xr30c23}
N 4560 6040 4540 6040 {}
C {lab_pin.sym} 4540 6040 0 0 {name=l4916 lab=BL23}
N 4560 6000 4540 6000 {}
C {lab_pin.sym} 4540 6000 0 0 {name=l4917 lab=BLB23}
N 4560 5960 4540 5960 {}
C {lab_pin.sym} 4540 5960 0 0 {name=l4918 lab=WL30}
N 4640 6040 4660 6040 {}
C {lab_pin.sym} 4660 6040 0 0 {name=l4919 lab=VDD}
N 4640 5960 4660 5960 {}
C {lab_pin.sym} 4660 5960 0 0 {name=l4920 lab=VSS}
C {bitcell_6t.sym} 4800 6000 0 0 {name=Xr30c24}
N 4760 6040 4740 6040 {}
C {lab_pin.sym} 4740 6040 0 0 {name=l4921 lab=BL24}
N 4760 6000 4740 6000 {}
C {lab_pin.sym} 4740 6000 0 0 {name=l4922 lab=BLB24}
N 4760 5960 4740 5960 {}
C {lab_pin.sym} 4740 5960 0 0 {name=l4923 lab=WL30}
N 4840 6040 4860 6040 {}
C {lab_pin.sym} 4860 6040 0 0 {name=l4924 lab=VDD}
N 4840 5960 4860 5960 {}
C {lab_pin.sym} 4860 5960 0 0 {name=l4925 lab=VSS}
C {bitcell_6t.sym} 5000 6000 0 0 {name=Xr30c25}
N 4960 6040 4940 6040 {}
C {lab_pin.sym} 4940 6040 0 0 {name=l4926 lab=BL25}
N 4960 6000 4940 6000 {}
C {lab_pin.sym} 4940 6000 0 0 {name=l4927 lab=BLB25}
N 4960 5960 4940 5960 {}
C {lab_pin.sym} 4940 5960 0 0 {name=l4928 lab=WL30}
N 5040 6040 5060 6040 {}
C {lab_pin.sym} 5060 6040 0 0 {name=l4929 lab=VDD}
N 5040 5960 5060 5960 {}
C {lab_pin.sym} 5060 5960 0 0 {name=l4930 lab=VSS}
C {bitcell_6t.sym} 5200 6000 0 0 {name=Xr30c26}
N 5160 6040 5140 6040 {}
C {lab_pin.sym} 5140 6040 0 0 {name=l4931 lab=BL26}
N 5160 6000 5140 6000 {}
C {lab_pin.sym} 5140 6000 0 0 {name=l4932 lab=BLB26}
N 5160 5960 5140 5960 {}
C {lab_pin.sym} 5140 5960 0 0 {name=l4933 lab=WL30}
N 5240 6040 5260 6040 {}
C {lab_pin.sym} 5260 6040 0 0 {name=l4934 lab=VDD}
N 5240 5960 5260 5960 {}
C {lab_pin.sym} 5260 5960 0 0 {name=l4935 lab=VSS}
C {bitcell_6t.sym} 5400 6000 0 0 {name=Xr30c27}
N 5360 6040 5340 6040 {}
C {lab_pin.sym} 5340 6040 0 0 {name=l4936 lab=BL27}
N 5360 6000 5340 6000 {}
C {lab_pin.sym} 5340 6000 0 0 {name=l4937 lab=BLB27}
N 5360 5960 5340 5960 {}
C {lab_pin.sym} 5340 5960 0 0 {name=l4938 lab=WL30}
N 5440 6040 5460 6040 {}
C {lab_pin.sym} 5460 6040 0 0 {name=l4939 lab=VDD}
N 5440 5960 5460 5960 {}
C {lab_pin.sym} 5460 5960 0 0 {name=l4940 lab=VSS}
C {bitcell_6t.sym} 5600 6000 0 0 {name=Xr30c28}
N 5560 6040 5540 6040 {}
C {lab_pin.sym} 5540 6040 0 0 {name=l4941 lab=BL28}
N 5560 6000 5540 6000 {}
C {lab_pin.sym} 5540 6000 0 0 {name=l4942 lab=BLB28}
N 5560 5960 5540 5960 {}
C {lab_pin.sym} 5540 5960 0 0 {name=l4943 lab=WL30}
N 5640 6040 5660 6040 {}
C {lab_pin.sym} 5660 6040 0 0 {name=l4944 lab=VDD}
N 5640 5960 5660 5960 {}
C {lab_pin.sym} 5660 5960 0 0 {name=l4945 lab=VSS}
C {bitcell_6t.sym} 5800 6000 0 0 {name=Xr30c29}
N 5760 6040 5740 6040 {}
C {lab_pin.sym} 5740 6040 0 0 {name=l4946 lab=BL29}
N 5760 6000 5740 6000 {}
C {lab_pin.sym} 5740 6000 0 0 {name=l4947 lab=BLB29}
N 5760 5960 5740 5960 {}
C {lab_pin.sym} 5740 5960 0 0 {name=l4948 lab=WL30}
N 5840 6040 5860 6040 {}
C {lab_pin.sym} 5860 6040 0 0 {name=l4949 lab=VDD}
N 5840 5960 5860 5960 {}
C {lab_pin.sym} 5860 5960 0 0 {name=l4950 lab=VSS}
C {bitcell_6t.sym} 6000 6000 0 0 {name=Xr30c30}
N 5960 6040 5940 6040 {}
C {lab_pin.sym} 5940 6040 0 0 {name=l4951 lab=BL30}
N 5960 6000 5940 6000 {}
C {lab_pin.sym} 5940 6000 0 0 {name=l4952 lab=BLB30}
N 5960 5960 5940 5960 {}
C {lab_pin.sym} 5940 5960 0 0 {name=l4953 lab=WL30}
N 6040 6040 6060 6040 {}
C {lab_pin.sym} 6060 6040 0 0 {name=l4954 lab=VDD}
N 6040 5960 6060 5960 {}
C {lab_pin.sym} 6060 5960 0 0 {name=l4955 lab=VSS}
C {bitcell_6t.sym} 6200 6000 0 0 {name=Xr30c31}
N 6160 6040 6140 6040 {}
C {lab_pin.sym} 6140 6040 0 0 {name=l4956 lab=BL31}
N 6160 6000 6140 6000 {}
C {lab_pin.sym} 6140 6000 0 0 {name=l4957 lab=BLB31}
N 6160 5960 6140 5960 {}
C {lab_pin.sym} 6140 5960 0 0 {name=l4958 lab=WL30}
N 6240 6040 6260 6040 {}
C {lab_pin.sym} 6260 6040 0 0 {name=l4959 lab=VDD}
N 6240 5960 6260 5960 {}
C {lab_pin.sym} 6260 5960 0 0 {name=l4960 lab=VSS}
C {bitcell_6t.sym} 0 6200 0 0 {name=Xr31c0}
N -40 6240 -60 6240 {}
C {lab_pin.sym} -60 6240 0 0 {name=l4961 lab=BL0}
N -40 6200 -60 6200 {}
C {lab_pin.sym} -60 6200 0 0 {name=l4962 lab=BLB0}
N -40 6160 -60 6160 {}
C {lab_pin.sym} -60 6160 0 0 {name=l4963 lab=WL31}
N 40 6240 60 6240 {}
C {lab_pin.sym} 60 6240 0 0 {name=l4964 lab=VDD}
N 40 6160 60 6160 {}
C {lab_pin.sym} 60 6160 0 0 {name=l4965 lab=VSS}
C {bitcell_6t.sym} 200 6200 0 0 {name=Xr31c1}
N 160 6240 140 6240 {}
C {lab_pin.sym} 140 6240 0 0 {name=l4966 lab=BL1}
N 160 6200 140 6200 {}
C {lab_pin.sym} 140 6200 0 0 {name=l4967 lab=BLB1}
N 160 6160 140 6160 {}
C {lab_pin.sym} 140 6160 0 0 {name=l4968 lab=WL31}
N 240 6240 260 6240 {}
C {lab_pin.sym} 260 6240 0 0 {name=l4969 lab=VDD}
N 240 6160 260 6160 {}
C {lab_pin.sym} 260 6160 0 0 {name=l4970 lab=VSS}
C {bitcell_6t.sym} 400 6200 0 0 {name=Xr31c2}
N 360 6240 340 6240 {}
C {lab_pin.sym} 340 6240 0 0 {name=l4971 lab=BL2}
N 360 6200 340 6200 {}
C {lab_pin.sym} 340 6200 0 0 {name=l4972 lab=BLB2}
N 360 6160 340 6160 {}
C {lab_pin.sym} 340 6160 0 0 {name=l4973 lab=WL31}
N 440 6240 460 6240 {}
C {lab_pin.sym} 460 6240 0 0 {name=l4974 lab=VDD}
N 440 6160 460 6160 {}
C {lab_pin.sym} 460 6160 0 0 {name=l4975 lab=VSS}
C {bitcell_6t.sym} 600 6200 0 0 {name=Xr31c3}
N 560 6240 540 6240 {}
C {lab_pin.sym} 540 6240 0 0 {name=l4976 lab=BL3}
N 560 6200 540 6200 {}
C {lab_pin.sym} 540 6200 0 0 {name=l4977 lab=BLB3}
N 560 6160 540 6160 {}
C {lab_pin.sym} 540 6160 0 0 {name=l4978 lab=WL31}
N 640 6240 660 6240 {}
C {lab_pin.sym} 660 6240 0 0 {name=l4979 lab=VDD}
N 640 6160 660 6160 {}
C {lab_pin.sym} 660 6160 0 0 {name=l4980 lab=VSS}
C {bitcell_6t.sym} 800 6200 0 0 {name=Xr31c4}
N 760 6240 740 6240 {}
C {lab_pin.sym} 740 6240 0 0 {name=l4981 lab=BL4}
N 760 6200 740 6200 {}
C {lab_pin.sym} 740 6200 0 0 {name=l4982 lab=BLB4}
N 760 6160 740 6160 {}
C {lab_pin.sym} 740 6160 0 0 {name=l4983 lab=WL31}
N 840 6240 860 6240 {}
C {lab_pin.sym} 860 6240 0 0 {name=l4984 lab=VDD}
N 840 6160 860 6160 {}
C {lab_pin.sym} 860 6160 0 0 {name=l4985 lab=VSS}
C {bitcell_6t.sym} 1000 6200 0 0 {name=Xr31c5}
N 960 6240 940 6240 {}
C {lab_pin.sym} 940 6240 0 0 {name=l4986 lab=BL5}
N 960 6200 940 6200 {}
C {lab_pin.sym} 940 6200 0 0 {name=l4987 lab=BLB5}
N 960 6160 940 6160 {}
C {lab_pin.sym} 940 6160 0 0 {name=l4988 lab=WL31}
N 1040 6240 1060 6240 {}
C {lab_pin.sym} 1060 6240 0 0 {name=l4989 lab=VDD}
N 1040 6160 1060 6160 {}
C {lab_pin.sym} 1060 6160 0 0 {name=l4990 lab=VSS}
C {bitcell_6t.sym} 1200 6200 0 0 {name=Xr31c6}
N 1160 6240 1140 6240 {}
C {lab_pin.sym} 1140 6240 0 0 {name=l4991 lab=BL6}
N 1160 6200 1140 6200 {}
C {lab_pin.sym} 1140 6200 0 0 {name=l4992 lab=BLB6}
N 1160 6160 1140 6160 {}
C {lab_pin.sym} 1140 6160 0 0 {name=l4993 lab=WL31}
N 1240 6240 1260 6240 {}
C {lab_pin.sym} 1260 6240 0 0 {name=l4994 lab=VDD}
N 1240 6160 1260 6160 {}
C {lab_pin.sym} 1260 6160 0 0 {name=l4995 lab=VSS}
C {bitcell_6t.sym} 1400 6200 0 0 {name=Xr31c7}
N 1360 6240 1340 6240 {}
C {lab_pin.sym} 1340 6240 0 0 {name=l4996 lab=BL7}
N 1360 6200 1340 6200 {}
C {lab_pin.sym} 1340 6200 0 0 {name=l4997 lab=BLB7}
N 1360 6160 1340 6160 {}
C {lab_pin.sym} 1340 6160 0 0 {name=l4998 lab=WL31}
N 1440 6240 1460 6240 {}
C {lab_pin.sym} 1460 6240 0 0 {name=l4999 lab=VDD}
N 1440 6160 1460 6160 {}
C {lab_pin.sym} 1460 6160 0 0 {name=l5000 lab=VSS}
C {bitcell_6t.sym} 1600 6200 0 0 {name=Xr31c8}
N 1560 6240 1540 6240 {}
C {lab_pin.sym} 1540 6240 0 0 {name=l5001 lab=BL8}
N 1560 6200 1540 6200 {}
C {lab_pin.sym} 1540 6200 0 0 {name=l5002 lab=BLB8}
N 1560 6160 1540 6160 {}
C {lab_pin.sym} 1540 6160 0 0 {name=l5003 lab=WL31}
N 1640 6240 1660 6240 {}
C {lab_pin.sym} 1660 6240 0 0 {name=l5004 lab=VDD}
N 1640 6160 1660 6160 {}
C {lab_pin.sym} 1660 6160 0 0 {name=l5005 lab=VSS}
C {bitcell_6t.sym} 1800 6200 0 0 {name=Xr31c9}
N 1760 6240 1740 6240 {}
C {lab_pin.sym} 1740 6240 0 0 {name=l5006 lab=BL9}
N 1760 6200 1740 6200 {}
C {lab_pin.sym} 1740 6200 0 0 {name=l5007 lab=BLB9}
N 1760 6160 1740 6160 {}
C {lab_pin.sym} 1740 6160 0 0 {name=l5008 lab=WL31}
N 1840 6240 1860 6240 {}
C {lab_pin.sym} 1860 6240 0 0 {name=l5009 lab=VDD}
N 1840 6160 1860 6160 {}
C {lab_pin.sym} 1860 6160 0 0 {name=l5010 lab=VSS}
C {bitcell_6t.sym} 2000 6200 0 0 {name=Xr31c10}
N 1960 6240 1940 6240 {}
C {lab_pin.sym} 1940 6240 0 0 {name=l5011 lab=BL10}
N 1960 6200 1940 6200 {}
C {lab_pin.sym} 1940 6200 0 0 {name=l5012 lab=BLB10}
N 1960 6160 1940 6160 {}
C {lab_pin.sym} 1940 6160 0 0 {name=l5013 lab=WL31}
N 2040 6240 2060 6240 {}
C {lab_pin.sym} 2060 6240 0 0 {name=l5014 lab=VDD}
N 2040 6160 2060 6160 {}
C {lab_pin.sym} 2060 6160 0 0 {name=l5015 lab=VSS}
C {bitcell_6t.sym} 2200 6200 0 0 {name=Xr31c11}
N 2160 6240 2140 6240 {}
C {lab_pin.sym} 2140 6240 0 0 {name=l5016 lab=BL11}
N 2160 6200 2140 6200 {}
C {lab_pin.sym} 2140 6200 0 0 {name=l5017 lab=BLB11}
N 2160 6160 2140 6160 {}
C {lab_pin.sym} 2140 6160 0 0 {name=l5018 lab=WL31}
N 2240 6240 2260 6240 {}
C {lab_pin.sym} 2260 6240 0 0 {name=l5019 lab=VDD}
N 2240 6160 2260 6160 {}
C {lab_pin.sym} 2260 6160 0 0 {name=l5020 lab=VSS}
C {bitcell_6t.sym} 2400 6200 0 0 {name=Xr31c12}
N 2360 6240 2340 6240 {}
C {lab_pin.sym} 2340 6240 0 0 {name=l5021 lab=BL12}
N 2360 6200 2340 6200 {}
C {lab_pin.sym} 2340 6200 0 0 {name=l5022 lab=BLB12}
N 2360 6160 2340 6160 {}
C {lab_pin.sym} 2340 6160 0 0 {name=l5023 lab=WL31}
N 2440 6240 2460 6240 {}
C {lab_pin.sym} 2460 6240 0 0 {name=l5024 lab=VDD}
N 2440 6160 2460 6160 {}
C {lab_pin.sym} 2460 6160 0 0 {name=l5025 lab=VSS}
C {bitcell_6t.sym} 2600 6200 0 0 {name=Xr31c13}
N 2560 6240 2540 6240 {}
C {lab_pin.sym} 2540 6240 0 0 {name=l5026 lab=BL13}
N 2560 6200 2540 6200 {}
C {lab_pin.sym} 2540 6200 0 0 {name=l5027 lab=BLB13}
N 2560 6160 2540 6160 {}
C {lab_pin.sym} 2540 6160 0 0 {name=l5028 lab=WL31}
N 2640 6240 2660 6240 {}
C {lab_pin.sym} 2660 6240 0 0 {name=l5029 lab=VDD}
N 2640 6160 2660 6160 {}
C {lab_pin.sym} 2660 6160 0 0 {name=l5030 lab=VSS}
C {bitcell_6t.sym} 2800 6200 0 0 {name=Xr31c14}
N 2760 6240 2740 6240 {}
C {lab_pin.sym} 2740 6240 0 0 {name=l5031 lab=BL14}
N 2760 6200 2740 6200 {}
C {lab_pin.sym} 2740 6200 0 0 {name=l5032 lab=BLB14}
N 2760 6160 2740 6160 {}
C {lab_pin.sym} 2740 6160 0 0 {name=l5033 lab=WL31}
N 2840 6240 2860 6240 {}
C {lab_pin.sym} 2860 6240 0 0 {name=l5034 lab=VDD}
N 2840 6160 2860 6160 {}
C {lab_pin.sym} 2860 6160 0 0 {name=l5035 lab=VSS}
C {bitcell_6t.sym} 3000 6200 0 0 {name=Xr31c15}
N 2960 6240 2940 6240 {}
C {lab_pin.sym} 2940 6240 0 0 {name=l5036 lab=BL15}
N 2960 6200 2940 6200 {}
C {lab_pin.sym} 2940 6200 0 0 {name=l5037 lab=BLB15}
N 2960 6160 2940 6160 {}
C {lab_pin.sym} 2940 6160 0 0 {name=l5038 lab=WL31}
N 3040 6240 3060 6240 {}
C {lab_pin.sym} 3060 6240 0 0 {name=l5039 lab=VDD}
N 3040 6160 3060 6160 {}
C {lab_pin.sym} 3060 6160 0 0 {name=l5040 lab=VSS}
C {bitcell_6t.sym} 3200 6200 0 0 {name=Xr31c16}
N 3160 6240 3140 6240 {}
C {lab_pin.sym} 3140 6240 0 0 {name=l5041 lab=BL16}
N 3160 6200 3140 6200 {}
C {lab_pin.sym} 3140 6200 0 0 {name=l5042 lab=BLB16}
N 3160 6160 3140 6160 {}
C {lab_pin.sym} 3140 6160 0 0 {name=l5043 lab=WL31}
N 3240 6240 3260 6240 {}
C {lab_pin.sym} 3260 6240 0 0 {name=l5044 lab=VDD}
N 3240 6160 3260 6160 {}
C {lab_pin.sym} 3260 6160 0 0 {name=l5045 lab=VSS}
C {bitcell_6t.sym} 3400 6200 0 0 {name=Xr31c17}
N 3360 6240 3340 6240 {}
C {lab_pin.sym} 3340 6240 0 0 {name=l5046 lab=BL17}
N 3360 6200 3340 6200 {}
C {lab_pin.sym} 3340 6200 0 0 {name=l5047 lab=BLB17}
N 3360 6160 3340 6160 {}
C {lab_pin.sym} 3340 6160 0 0 {name=l5048 lab=WL31}
N 3440 6240 3460 6240 {}
C {lab_pin.sym} 3460 6240 0 0 {name=l5049 lab=VDD}
N 3440 6160 3460 6160 {}
C {lab_pin.sym} 3460 6160 0 0 {name=l5050 lab=VSS}
C {bitcell_6t.sym} 3600 6200 0 0 {name=Xr31c18}
N 3560 6240 3540 6240 {}
C {lab_pin.sym} 3540 6240 0 0 {name=l5051 lab=BL18}
N 3560 6200 3540 6200 {}
C {lab_pin.sym} 3540 6200 0 0 {name=l5052 lab=BLB18}
N 3560 6160 3540 6160 {}
C {lab_pin.sym} 3540 6160 0 0 {name=l5053 lab=WL31}
N 3640 6240 3660 6240 {}
C {lab_pin.sym} 3660 6240 0 0 {name=l5054 lab=VDD}
N 3640 6160 3660 6160 {}
C {lab_pin.sym} 3660 6160 0 0 {name=l5055 lab=VSS}
C {bitcell_6t.sym} 3800 6200 0 0 {name=Xr31c19}
N 3760 6240 3740 6240 {}
C {lab_pin.sym} 3740 6240 0 0 {name=l5056 lab=BL19}
N 3760 6200 3740 6200 {}
C {lab_pin.sym} 3740 6200 0 0 {name=l5057 lab=BLB19}
N 3760 6160 3740 6160 {}
C {lab_pin.sym} 3740 6160 0 0 {name=l5058 lab=WL31}
N 3840 6240 3860 6240 {}
C {lab_pin.sym} 3860 6240 0 0 {name=l5059 lab=VDD}
N 3840 6160 3860 6160 {}
C {lab_pin.sym} 3860 6160 0 0 {name=l5060 lab=VSS}
C {bitcell_6t.sym} 4000 6200 0 0 {name=Xr31c20}
N 3960 6240 3940 6240 {}
C {lab_pin.sym} 3940 6240 0 0 {name=l5061 lab=BL20}
N 3960 6200 3940 6200 {}
C {lab_pin.sym} 3940 6200 0 0 {name=l5062 lab=BLB20}
N 3960 6160 3940 6160 {}
C {lab_pin.sym} 3940 6160 0 0 {name=l5063 lab=WL31}
N 4040 6240 4060 6240 {}
C {lab_pin.sym} 4060 6240 0 0 {name=l5064 lab=VDD}
N 4040 6160 4060 6160 {}
C {lab_pin.sym} 4060 6160 0 0 {name=l5065 lab=VSS}
C {bitcell_6t.sym} 4200 6200 0 0 {name=Xr31c21}
N 4160 6240 4140 6240 {}
C {lab_pin.sym} 4140 6240 0 0 {name=l5066 lab=BL21}
N 4160 6200 4140 6200 {}
C {lab_pin.sym} 4140 6200 0 0 {name=l5067 lab=BLB21}
N 4160 6160 4140 6160 {}
C {lab_pin.sym} 4140 6160 0 0 {name=l5068 lab=WL31}
N 4240 6240 4260 6240 {}
C {lab_pin.sym} 4260 6240 0 0 {name=l5069 lab=VDD}
N 4240 6160 4260 6160 {}
C {lab_pin.sym} 4260 6160 0 0 {name=l5070 lab=VSS}
C {bitcell_6t.sym} 4400 6200 0 0 {name=Xr31c22}
N 4360 6240 4340 6240 {}
C {lab_pin.sym} 4340 6240 0 0 {name=l5071 lab=BL22}
N 4360 6200 4340 6200 {}
C {lab_pin.sym} 4340 6200 0 0 {name=l5072 lab=BLB22}
N 4360 6160 4340 6160 {}
C {lab_pin.sym} 4340 6160 0 0 {name=l5073 lab=WL31}
N 4440 6240 4460 6240 {}
C {lab_pin.sym} 4460 6240 0 0 {name=l5074 lab=VDD}
N 4440 6160 4460 6160 {}
C {lab_pin.sym} 4460 6160 0 0 {name=l5075 lab=VSS}
C {bitcell_6t.sym} 4600 6200 0 0 {name=Xr31c23}
N 4560 6240 4540 6240 {}
C {lab_pin.sym} 4540 6240 0 0 {name=l5076 lab=BL23}
N 4560 6200 4540 6200 {}
C {lab_pin.sym} 4540 6200 0 0 {name=l5077 lab=BLB23}
N 4560 6160 4540 6160 {}
C {lab_pin.sym} 4540 6160 0 0 {name=l5078 lab=WL31}
N 4640 6240 4660 6240 {}
C {lab_pin.sym} 4660 6240 0 0 {name=l5079 lab=VDD}
N 4640 6160 4660 6160 {}
C {lab_pin.sym} 4660 6160 0 0 {name=l5080 lab=VSS}
C {bitcell_6t.sym} 4800 6200 0 0 {name=Xr31c24}
N 4760 6240 4740 6240 {}
C {lab_pin.sym} 4740 6240 0 0 {name=l5081 lab=BL24}
N 4760 6200 4740 6200 {}
C {lab_pin.sym} 4740 6200 0 0 {name=l5082 lab=BLB24}
N 4760 6160 4740 6160 {}
C {lab_pin.sym} 4740 6160 0 0 {name=l5083 lab=WL31}
N 4840 6240 4860 6240 {}
C {lab_pin.sym} 4860 6240 0 0 {name=l5084 lab=VDD}
N 4840 6160 4860 6160 {}
C {lab_pin.sym} 4860 6160 0 0 {name=l5085 lab=VSS}
C {bitcell_6t.sym} 5000 6200 0 0 {name=Xr31c25}
N 4960 6240 4940 6240 {}
C {lab_pin.sym} 4940 6240 0 0 {name=l5086 lab=BL25}
N 4960 6200 4940 6200 {}
C {lab_pin.sym} 4940 6200 0 0 {name=l5087 lab=BLB25}
N 4960 6160 4940 6160 {}
C {lab_pin.sym} 4940 6160 0 0 {name=l5088 lab=WL31}
N 5040 6240 5060 6240 {}
C {lab_pin.sym} 5060 6240 0 0 {name=l5089 lab=VDD}
N 5040 6160 5060 6160 {}
C {lab_pin.sym} 5060 6160 0 0 {name=l5090 lab=VSS}
C {bitcell_6t.sym} 5200 6200 0 0 {name=Xr31c26}
N 5160 6240 5140 6240 {}
C {lab_pin.sym} 5140 6240 0 0 {name=l5091 lab=BL26}
N 5160 6200 5140 6200 {}
C {lab_pin.sym} 5140 6200 0 0 {name=l5092 lab=BLB26}
N 5160 6160 5140 6160 {}
C {lab_pin.sym} 5140 6160 0 0 {name=l5093 lab=WL31}
N 5240 6240 5260 6240 {}
C {lab_pin.sym} 5260 6240 0 0 {name=l5094 lab=VDD}
N 5240 6160 5260 6160 {}
C {lab_pin.sym} 5260 6160 0 0 {name=l5095 lab=VSS}
C {bitcell_6t.sym} 5400 6200 0 0 {name=Xr31c27}
N 5360 6240 5340 6240 {}
C {lab_pin.sym} 5340 6240 0 0 {name=l5096 lab=BL27}
N 5360 6200 5340 6200 {}
C {lab_pin.sym} 5340 6200 0 0 {name=l5097 lab=BLB27}
N 5360 6160 5340 6160 {}
C {lab_pin.sym} 5340 6160 0 0 {name=l5098 lab=WL31}
N 5440 6240 5460 6240 {}
C {lab_pin.sym} 5460 6240 0 0 {name=l5099 lab=VDD}
N 5440 6160 5460 6160 {}
C {lab_pin.sym} 5460 6160 0 0 {name=l5100 lab=VSS}
C {bitcell_6t.sym} 5600 6200 0 0 {name=Xr31c28}
N 5560 6240 5540 6240 {}
C {lab_pin.sym} 5540 6240 0 0 {name=l5101 lab=BL28}
N 5560 6200 5540 6200 {}
C {lab_pin.sym} 5540 6200 0 0 {name=l5102 lab=BLB28}
N 5560 6160 5540 6160 {}
C {lab_pin.sym} 5540 6160 0 0 {name=l5103 lab=WL31}
N 5640 6240 5660 6240 {}
C {lab_pin.sym} 5660 6240 0 0 {name=l5104 lab=VDD}
N 5640 6160 5660 6160 {}
C {lab_pin.sym} 5660 6160 0 0 {name=l5105 lab=VSS}
C {bitcell_6t.sym} 5800 6200 0 0 {name=Xr31c29}
N 5760 6240 5740 6240 {}
C {lab_pin.sym} 5740 6240 0 0 {name=l5106 lab=BL29}
N 5760 6200 5740 6200 {}
C {lab_pin.sym} 5740 6200 0 0 {name=l5107 lab=BLB29}
N 5760 6160 5740 6160 {}
C {lab_pin.sym} 5740 6160 0 0 {name=l5108 lab=WL31}
N 5840 6240 5860 6240 {}
C {lab_pin.sym} 5860 6240 0 0 {name=l5109 lab=VDD}
N 5840 6160 5860 6160 {}
C {lab_pin.sym} 5860 6160 0 0 {name=l5110 lab=VSS}
C {bitcell_6t.sym} 6000 6200 0 0 {name=Xr31c30}
N 5960 6240 5940 6240 {}
C {lab_pin.sym} 5940 6240 0 0 {name=l5111 lab=BL30}
N 5960 6200 5940 6200 {}
C {lab_pin.sym} 5940 6200 0 0 {name=l5112 lab=BLB30}
N 5960 6160 5940 6160 {}
C {lab_pin.sym} 5940 6160 0 0 {name=l5113 lab=WL31}
N 6040 6240 6060 6240 {}
C {lab_pin.sym} 6060 6240 0 0 {name=l5114 lab=VDD}
N 6040 6160 6060 6160 {}
C {lab_pin.sym} 6060 6160 0 0 {name=l5115 lab=VSS}
C {bitcell_6t.sym} 6200 6200 0 0 {name=Xr31c31}
N 6160 6240 6140 6240 {}
C {lab_pin.sym} 6140 6240 0 0 {name=l5116 lab=BL31}
N 6160 6200 6140 6200 {}
C {lab_pin.sym} 6140 6200 0 0 {name=l5117 lab=BLB31}
N 6160 6160 6140 6160 {}
C {lab_pin.sym} 6140 6160 0 0 {name=l5118 lab=WL31}
N 6240 6240 6260 6240 {}
C {lab_pin.sym} 6260 6240 0 0 {name=l5119 lab=VDD}
N 6240 6160 6260 6160 {}
C {lab_pin.sym} 6260 6160 0 0 {name=l5120 lab=VSS}
C {bitcell_6t.sym} 0 6400 0 0 {name=Xr32c0}
N -40 6440 -60 6440 {}
C {lab_pin.sym} -60 6440 0 0 {name=l5121 lab=BL0}
N -40 6400 -60 6400 {}
C {lab_pin.sym} -60 6400 0 0 {name=l5122 lab=BLB0}
N -40 6360 -60 6360 {}
C {lab_pin.sym} -60 6360 0 0 {name=l5123 lab=WL32}
N 40 6440 60 6440 {}
C {lab_pin.sym} 60 6440 0 0 {name=l5124 lab=VDD}
N 40 6360 60 6360 {}
C {lab_pin.sym} 60 6360 0 0 {name=l5125 lab=VSS}
C {bitcell_6t.sym} 200 6400 0 0 {name=Xr32c1}
N 160 6440 140 6440 {}
C {lab_pin.sym} 140 6440 0 0 {name=l5126 lab=BL1}
N 160 6400 140 6400 {}
C {lab_pin.sym} 140 6400 0 0 {name=l5127 lab=BLB1}
N 160 6360 140 6360 {}
C {lab_pin.sym} 140 6360 0 0 {name=l5128 lab=WL32}
N 240 6440 260 6440 {}
C {lab_pin.sym} 260 6440 0 0 {name=l5129 lab=VDD}
N 240 6360 260 6360 {}
C {lab_pin.sym} 260 6360 0 0 {name=l5130 lab=VSS}
C {bitcell_6t.sym} 400 6400 0 0 {name=Xr32c2}
N 360 6440 340 6440 {}
C {lab_pin.sym} 340 6440 0 0 {name=l5131 lab=BL2}
N 360 6400 340 6400 {}
C {lab_pin.sym} 340 6400 0 0 {name=l5132 lab=BLB2}
N 360 6360 340 6360 {}
C {lab_pin.sym} 340 6360 0 0 {name=l5133 lab=WL32}
N 440 6440 460 6440 {}
C {lab_pin.sym} 460 6440 0 0 {name=l5134 lab=VDD}
N 440 6360 460 6360 {}
C {lab_pin.sym} 460 6360 0 0 {name=l5135 lab=VSS}
C {bitcell_6t.sym} 600 6400 0 0 {name=Xr32c3}
N 560 6440 540 6440 {}
C {lab_pin.sym} 540 6440 0 0 {name=l5136 lab=BL3}
N 560 6400 540 6400 {}
C {lab_pin.sym} 540 6400 0 0 {name=l5137 lab=BLB3}
N 560 6360 540 6360 {}
C {lab_pin.sym} 540 6360 0 0 {name=l5138 lab=WL32}
N 640 6440 660 6440 {}
C {lab_pin.sym} 660 6440 0 0 {name=l5139 lab=VDD}
N 640 6360 660 6360 {}
C {lab_pin.sym} 660 6360 0 0 {name=l5140 lab=VSS}
C {bitcell_6t.sym} 800 6400 0 0 {name=Xr32c4}
N 760 6440 740 6440 {}
C {lab_pin.sym} 740 6440 0 0 {name=l5141 lab=BL4}
N 760 6400 740 6400 {}
C {lab_pin.sym} 740 6400 0 0 {name=l5142 lab=BLB4}
N 760 6360 740 6360 {}
C {lab_pin.sym} 740 6360 0 0 {name=l5143 lab=WL32}
N 840 6440 860 6440 {}
C {lab_pin.sym} 860 6440 0 0 {name=l5144 lab=VDD}
N 840 6360 860 6360 {}
C {lab_pin.sym} 860 6360 0 0 {name=l5145 lab=VSS}
C {bitcell_6t.sym} 1000 6400 0 0 {name=Xr32c5}
N 960 6440 940 6440 {}
C {lab_pin.sym} 940 6440 0 0 {name=l5146 lab=BL5}
N 960 6400 940 6400 {}
C {lab_pin.sym} 940 6400 0 0 {name=l5147 lab=BLB5}
N 960 6360 940 6360 {}
C {lab_pin.sym} 940 6360 0 0 {name=l5148 lab=WL32}
N 1040 6440 1060 6440 {}
C {lab_pin.sym} 1060 6440 0 0 {name=l5149 lab=VDD}
N 1040 6360 1060 6360 {}
C {lab_pin.sym} 1060 6360 0 0 {name=l5150 lab=VSS}
C {bitcell_6t.sym} 1200 6400 0 0 {name=Xr32c6}
N 1160 6440 1140 6440 {}
C {lab_pin.sym} 1140 6440 0 0 {name=l5151 lab=BL6}
N 1160 6400 1140 6400 {}
C {lab_pin.sym} 1140 6400 0 0 {name=l5152 lab=BLB6}
N 1160 6360 1140 6360 {}
C {lab_pin.sym} 1140 6360 0 0 {name=l5153 lab=WL32}
N 1240 6440 1260 6440 {}
C {lab_pin.sym} 1260 6440 0 0 {name=l5154 lab=VDD}
N 1240 6360 1260 6360 {}
C {lab_pin.sym} 1260 6360 0 0 {name=l5155 lab=VSS}
C {bitcell_6t.sym} 1400 6400 0 0 {name=Xr32c7}
N 1360 6440 1340 6440 {}
C {lab_pin.sym} 1340 6440 0 0 {name=l5156 lab=BL7}
N 1360 6400 1340 6400 {}
C {lab_pin.sym} 1340 6400 0 0 {name=l5157 lab=BLB7}
N 1360 6360 1340 6360 {}
C {lab_pin.sym} 1340 6360 0 0 {name=l5158 lab=WL32}
N 1440 6440 1460 6440 {}
C {lab_pin.sym} 1460 6440 0 0 {name=l5159 lab=VDD}
N 1440 6360 1460 6360 {}
C {lab_pin.sym} 1460 6360 0 0 {name=l5160 lab=VSS}
C {bitcell_6t.sym} 1600 6400 0 0 {name=Xr32c8}
N 1560 6440 1540 6440 {}
C {lab_pin.sym} 1540 6440 0 0 {name=l5161 lab=BL8}
N 1560 6400 1540 6400 {}
C {lab_pin.sym} 1540 6400 0 0 {name=l5162 lab=BLB8}
N 1560 6360 1540 6360 {}
C {lab_pin.sym} 1540 6360 0 0 {name=l5163 lab=WL32}
N 1640 6440 1660 6440 {}
C {lab_pin.sym} 1660 6440 0 0 {name=l5164 lab=VDD}
N 1640 6360 1660 6360 {}
C {lab_pin.sym} 1660 6360 0 0 {name=l5165 lab=VSS}
C {bitcell_6t.sym} 1800 6400 0 0 {name=Xr32c9}
N 1760 6440 1740 6440 {}
C {lab_pin.sym} 1740 6440 0 0 {name=l5166 lab=BL9}
N 1760 6400 1740 6400 {}
C {lab_pin.sym} 1740 6400 0 0 {name=l5167 lab=BLB9}
N 1760 6360 1740 6360 {}
C {lab_pin.sym} 1740 6360 0 0 {name=l5168 lab=WL32}
N 1840 6440 1860 6440 {}
C {lab_pin.sym} 1860 6440 0 0 {name=l5169 lab=VDD}
N 1840 6360 1860 6360 {}
C {lab_pin.sym} 1860 6360 0 0 {name=l5170 lab=VSS}
C {bitcell_6t.sym} 2000 6400 0 0 {name=Xr32c10}
N 1960 6440 1940 6440 {}
C {lab_pin.sym} 1940 6440 0 0 {name=l5171 lab=BL10}
N 1960 6400 1940 6400 {}
C {lab_pin.sym} 1940 6400 0 0 {name=l5172 lab=BLB10}
N 1960 6360 1940 6360 {}
C {lab_pin.sym} 1940 6360 0 0 {name=l5173 lab=WL32}
N 2040 6440 2060 6440 {}
C {lab_pin.sym} 2060 6440 0 0 {name=l5174 lab=VDD}
N 2040 6360 2060 6360 {}
C {lab_pin.sym} 2060 6360 0 0 {name=l5175 lab=VSS}
C {bitcell_6t.sym} 2200 6400 0 0 {name=Xr32c11}
N 2160 6440 2140 6440 {}
C {lab_pin.sym} 2140 6440 0 0 {name=l5176 lab=BL11}
N 2160 6400 2140 6400 {}
C {lab_pin.sym} 2140 6400 0 0 {name=l5177 lab=BLB11}
N 2160 6360 2140 6360 {}
C {lab_pin.sym} 2140 6360 0 0 {name=l5178 lab=WL32}
N 2240 6440 2260 6440 {}
C {lab_pin.sym} 2260 6440 0 0 {name=l5179 lab=VDD}
N 2240 6360 2260 6360 {}
C {lab_pin.sym} 2260 6360 0 0 {name=l5180 lab=VSS}
C {bitcell_6t.sym} 2400 6400 0 0 {name=Xr32c12}
N 2360 6440 2340 6440 {}
C {lab_pin.sym} 2340 6440 0 0 {name=l5181 lab=BL12}
N 2360 6400 2340 6400 {}
C {lab_pin.sym} 2340 6400 0 0 {name=l5182 lab=BLB12}
N 2360 6360 2340 6360 {}
C {lab_pin.sym} 2340 6360 0 0 {name=l5183 lab=WL32}
N 2440 6440 2460 6440 {}
C {lab_pin.sym} 2460 6440 0 0 {name=l5184 lab=VDD}
N 2440 6360 2460 6360 {}
C {lab_pin.sym} 2460 6360 0 0 {name=l5185 lab=VSS}
C {bitcell_6t.sym} 2600 6400 0 0 {name=Xr32c13}
N 2560 6440 2540 6440 {}
C {lab_pin.sym} 2540 6440 0 0 {name=l5186 lab=BL13}
N 2560 6400 2540 6400 {}
C {lab_pin.sym} 2540 6400 0 0 {name=l5187 lab=BLB13}
N 2560 6360 2540 6360 {}
C {lab_pin.sym} 2540 6360 0 0 {name=l5188 lab=WL32}
N 2640 6440 2660 6440 {}
C {lab_pin.sym} 2660 6440 0 0 {name=l5189 lab=VDD}
N 2640 6360 2660 6360 {}
C {lab_pin.sym} 2660 6360 0 0 {name=l5190 lab=VSS}
C {bitcell_6t.sym} 2800 6400 0 0 {name=Xr32c14}
N 2760 6440 2740 6440 {}
C {lab_pin.sym} 2740 6440 0 0 {name=l5191 lab=BL14}
N 2760 6400 2740 6400 {}
C {lab_pin.sym} 2740 6400 0 0 {name=l5192 lab=BLB14}
N 2760 6360 2740 6360 {}
C {lab_pin.sym} 2740 6360 0 0 {name=l5193 lab=WL32}
N 2840 6440 2860 6440 {}
C {lab_pin.sym} 2860 6440 0 0 {name=l5194 lab=VDD}
N 2840 6360 2860 6360 {}
C {lab_pin.sym} 2860 6360 0 0 {name=l5195 lab=VSS}
C {bitcell_6t.sym} 3000 6400 0 0 {name=Xr32c15}
N 2960 6440 2940 6440 {}
C {lab_pin.sym} 2940 6440 0 0 {name=l5196 lab=BL15}
N 2960 6400 2940 6400 {}
C {lab_pin.sym} 2940 6400 0 0 {name=l5197 lab=BLB15}
N 2960 6360 2940 6360 {}
C {lab_pin.sym} 2940 6360 0 0 {name=l5198 lab=WL32}
N 3040 6440 3060 6440 {}
C {lab_pin.sym} 3060 6440 0 0 {name=l5199 lab=VDD}
N 3040 6360 3060 6360 {}
C {lab_pin.sym} 3060 6360 0 0 {name=l5200 lab=VSS}
C {bitcell_6t.sym} 3200 6400 0 0 {name=Xr32c16}
N 3160 6440 3140 6440 {}
C {lab_pin.sym} 3140 6440 0 0 {name=l5201 lab=BL16}
N 3160 6400 3140 6400 {}
C {lab_pin.sym} 3140 6400 0 0 {name=l5202 lab=BLB16}
N 3160 6360 3140 6360 {}
C {lab_pin.sym} 3140 6360 0 0 {name=l5203 lab=WL32}
N 3240 6440 3260 6440 {}
C {lab_pin.sym} 3260 6440 0 0 {name=l5204 lab=VDD}
N 3240 6360 3260 6360 {}
C {lab_pin.sym} 3260 6360 0 0 {name=l5205 lab=VSS}
C {bitcell_6t.sym} 3400 6400 0 0 {name=Xr32c17}
N 3360 6440 3340 6440 {}
C {lab_pin.sym} 3340 6440 0 0 {name=l5206 lab=BL17}
N 3360 6400 3340 6400 {}
C {lab_pin.sym} 3340 6400 0 0 {name=l5207 lab=BLB17}
N 3360 6360 3340 6360 {}
C {lab_pin.sym} 3340 6360 0 0 {name=l5208 lab=WL32}
N 3440 6440 3460 6440 {}
C {lab_pin.sym} 3460 6440 0 0 {name=l5209 lab=VDD}
N 3440 6360 3460 6360 {}
C {lab_pin.sym} 3460 6360 0 0 {name=l5210 lab=VSS}
C {bitcell_6t.sym} 3600 6400 0 0 {name=Xr32c18}
N 3560 6440 3540 6440 {}
C {lab_pin.sym} 3540 6440 0 0 {name=l5211 lab=BL18}
N 3560 6400 3540 6400 {}
C {lab_pin.sym} 3540 6400 0 0 {name=l5212 lab=BLB18}
N 3560 6360 3540 6360 {}
C {lab_pin.sym} 3540 6360 0 0 {name=l5213 lab=WL32}
N 3640 6440 3660 6440 {}
C {lab_pin.sym} 3660 6440 0 0 {name=l5214 lab=VDD}
N 3640 6360 3660 6360 {}
C {lab_pin.sym} 3660 6360 0 0 {name=l5215 lab=VSS}
C {bitcell_6t.sym} 3800 6400 0 0 {name=Xr32c19}
N 3760 6440 3740 6440 {}
C {lab_pin.sym} 3740 6440 0 0 {name=l5216 lab=BL19}
N 3760 6400 3740 6400 {}
C {lab_pin.sym} 3740 6400 0 0 {name=l5217 lab=BLB19}
N 3760 6360 3740 6360 {}
C {lab_pin.sym} 3740 6360 0 0 {name=l5218 lab=WL32}
N 3840 6440 3860 6440 {}
C {lab_pin.sym} 3860 6440 0 0 {name=l5219 lab=VDD}
N 3840 6360 3860 6360 {}
C {lab_pin.sym} 3860 6360 0 0 {name=l5220 lab=VSS}
C {bitcell_6t.sym} 4000 6400 0 0 {name=Xr32c20}
N 3960 6440 3940 6440 {}
C {lab_pin.sym} 3940 6440 0 0 {name=l5221 lab=BL20}
N 3960 6400 3940 6400 {}
C {lab_pin.sym} 3940 6400 0 0 {name=l5222 lab=BLB20}
N 3960 6360 3940 6360 {}
C {lab_pin.sym} 3940 6360 0 0 {name=l5223 lab=WL32}
N 4040 6440 4060 6440 {}
C {lab_pin.sym} 4060 6440 0 0 {name=l5224 lab=VDD}
N 4040 6360 4060 6360 {}
C {lab_pin.sym} 4060 6360 0 0 {name=l5225 lab=VSS}
C {bitcell_6t.sym} 4200 6400 0 0 {name=Xr32c21}
N 4160 6440 4140 6440 {}
C {lab_pin.sym} 4140 6440 0 0 {name=l5226 lab=BL21}
N 4160 6400 4140 6400 {}
C {lab_pin.sym} 4140 6400 0 0 {name=l5227 lab=BLB21}
N 4160 6360 4140 6360 {}
C {lab_pin.sym} 4140 6360 0 0 {name=l5228 lab=WL32}
N 4240 6440 4260 6440 {}
C {lab_pin.sym} 4260 6440 0 0 {name=l5229 lab=VDD}
N 4240 6360 4260 6360 {}
C {lab_pin.sym} 4260 6360 0 0 {name=l5230 lab=VSS}
C {bitcell_6t.sym} 4400 6400 0 0 {name=Xr32c22}
N 4360 6440 4340 6440 {}
C {lab_pin.sym} 4340 6440 0 0 {name=l5231 lab=BL22}
N 4360 6400 4340 6400 {}
C {lab_pin.sym} 4340 6400 0 0 {name=l5232 lab=BLB22}
N 4360 6360 4340 6360 {}
C {lab_pin.sym} 4340 6360 0 0 {name=l5233 lab=WL32}
N 4440 6440 4460 6440 {}
C {lab_pin.sym} 4460 6440 0 0 {name=l5234 lab=VDD}
N 4440 6360 4460 6360 {}
C {lab_pin.sym} 4460 6360 0 0 {name=l5235 lab=VSS}
C {bitcell_6t.sym} 4600 6400 0 0 {name=Xr32c23}
N 4560 6440 4540 6440 {}
C {lab_pin.sym} 4540 6440 0 0 {name=l5236 lab=BL23}
N 4560 6400 4540 6400 {}
C {lab_pin.sym} 4540 6400 0 0 {name=l5237 lab=BLB23}
N 4560 6360 4540 6360 {}
C {lab_pin.sym} 4540 6360 0 0 {name=l5238 lab=WL32}
N 4640 6440 4660 6440 {}
C {lab_pin.sym} 4660 6440 0 0 {name=l5239 lab=VDD}
N 4640 6360 4660 6360 {}
C {lab_pin.sym} 4660 6360 0 0 {name=l5240 lab=VSS}
C {bitcell_6t.sym} 4800 6400 0 0 {name=Xr32c24}
N 4760 6440 4740 6440 {}
C {lab_pin.sym} 4740 6440 0 0 {name=l5241 lab=BL24}
N 4760 6400 4740 6400 {}
C {lab_pin.sym} 4740 6400 0 0 {name=l5242 lab=BLB24}
N 4760 6360 4740 6360 {}
C {lab_pin.sym} 4740 6360 0 0 {name=l5243 lab=WL32}
N 4840 6440 4860 6440 {}
C {lab_pin.sym} 4860 6440 0 0 {name=l5244 lab=VDD}
N 4840 6360 4860 6360 {}
C {lab_pin.sym} 4860 6360 0 0 {name=l5245 lab=VSS}
C {bitcell_6t.sym} 5000 6400 0 0 {name=Xr32c25}
N 4960 6440 4940 6440 {}
C {lab_pin.sym} 4940 6440 0 0 {name=l5246 lab=BL25}
N 4960 6400 4940 6400 {}
C {lab_pin.sym} 4940 6400 0 0 {name=l5247 lab=BLB25}
N 4960 6360 4940 6360 {}
C {lab_pin.sym} 4940 6360 0 0 {name=l5248 lab=WL32}
N 5040 6440 5060 6440 {}
C {lab_pin.sym} 5060 6440 0 0 {name=l5249 lab=VDD}
N 5040 6360 5060 6360 {}
C {lab_pin.sym} 5060 6360 0 0 {name=l5250 lab=VSS}
C {bitcell_6t.sym} 5200 6400 0 0 {name=Xr32c26}
N 5160 6440 5140 6440 {}
C {lab_pin.sym} 5140 6440 0 0 {name=l5251 lab=BL26}
N 5160 6400 5140 6400 {}
C {lab_pin.sym} 5140 6400 0 0 {name=l5252 lab=BLB26}
N 5160 6360 5140 6360 {}
C {lab_pin.sym} 5140 6360 0 0 {name=l5253 lab=WL32}
N 5240 6440 5260 6440 {}
C {lab_pin.sym} 5260 6440 0 0 {name=l5254 lab=VDD}
N 5240 6360 5260 6360 {}
C {lab_pin.sym} 5260 6360 0 0 {name=l5255 lab=VSS}
C {bitcell_6t.sym} 5400 6400 0 0 {name=Xr32c27}
N 5360 6440 5340 6440 {}
C {lab_pin.sym} 5340 6440 0 0 {name=l5256 lab=BL27}
N 5360 6400 5340 6400 {}
C {lab_pin.sym} 5340 6400 0 0 {name=l5257 lab=BLB27}
N 5360 6360 5340 6360 {}
C {lab_pin.sym} 5340 6360 0 0 {name=l5258 lab=WL32}
N 5440 6440 5460 6440 {}
C {lab_pin.sym} 5460 6440 0 0 {name=l5259 lab=VDD}
N 5440 6360 5460 6360 {}
C {lab_pin.sym} 5460 6360 0 0 {name=l5260 lab=VSS}
C {bitcell_6t.sym} 5600 6400 0 0 {name=Xr32c28}
N 5560 6440 5540 6440 {}
C {lab_pin.sym} 5540 6440 0 0 {name=l5261 lab=BL28}
N 5560 6400 5540 6400 {}
C {lab_pin.sym} 5540 6400 0 0 {name=l5262 lab=BLB28}
N 5560 6360 5540 6360 {}
C {lab_pin.sym} 5540 6360 0 0 {name=l5263 lab=WL32}
N 5640 6440 5660 6440 {}
C {lab_pin.sym} 5660 6440 0 0 {name=l5264 lab=VDD}
N 5640 6360 5660 6360 {}
C {lab_pin.sym} 5660 6360 0 0 {name=l5265 lab=VSS}
C {bitcell_6t.sym} 5800 6400 0 0 {name=Xr32c29}
N 5760 6440 5740 6440 {}
C {lab_pin.sym} 5740 6440 0 0 {name=l5266 lab=BL29}
N 5760 6400 5740 6400 {}
C {lab_pin.sym} 5740 6400 0 0 {name=l5267 lab=BLB29}
N 5760 6360 5740 6360 {}
C {lab_pin.sym} 5740 6360 0 0 {name=l5268 lab=WL32}
N 5840 6440 5860 6440 {}
C {lab_pin.sym} 5860 6440 0 0 {name=l5269 lab=VDD}
N 5840 6360 5860 6360 {}
C {lab_pin.sym} 5860 6360 0 0 {name=l5270 lab=VSS}
C {bitcell_6t.sym} 6000 6400 0 0 {name=Xr32c30}
N 5960 6440 5940 6440 {}
C {lab_pin.sym} 5940 6440 0 0 {name=l5271 lab=BL30}
N 5960 6400 5940 6400 {}
C {lab_pin.sym} 5940 6400 0 0 {name=l5272 lab=BLB30}
N 5960 6360 5940 6360 {}
C {lab_pin.sym} 5940 6360 0 0 {name=l5273 lab=WL32}
N 6040 6440 6060 6440 {}
C {lab_pin.sym} 6060 6440 0 0 {name=l5274 lab=VDD}
N 6040 6360 6060 6360 {}
C {lab_pin.sym} 6060 6360 0 0 {name=l5275 lab=VSS}
C {bitcell_6t.sym} 6200 6400 0 0 {name=Xr32c31}
N 6160 6440 6140 6440 {}
C {lab_pin.sym} 6140 6440 0 0 {name=l5276 lab=BL31}
N 6160 6400 6140 6400 {}
C {lab_pin.sym} 6140 6400 0 0 {name=l5277 lab=BLB31}
N 6160 6360 6140 6360 {}
C {lab_pin.sym} 6140 6360 0 0 {name=l5278 lab=WL32}
N 6240 6440 6260 6440 {}
C {lab_pin.sym} 6260 6440 0 0 {name=l5279 lab=VDD}
N 6240 6360 6260 6360 {}
C {lab_pin.sym} 6260 6360 0 0 {name=l5280 lab=VSS}
C {bitcell_6t.sym} 0 6600 0 0 {name=Xr33c0}
N -40 6640 -60 6640 {}
C {lab_pin.sym} -60 6640 0 0 {name=l5281 lab=BL0}
N -40 6600 -60 6600 {}
C {lab_pin.sym} -60 6600 0 0 {name=l5282 lab=BLB0}
N -40 6560 -60 6560 {}
C {lab_pin.sym} -60 6560 0 0 {name=l5283 lab=WL33}
N 40 6640 60 6640 {}
C {lab_pin.sym} 60 6640 0 0 {name=l5284 lab=VDD}
N 40 6560 60 6560 {}
C {lab_pin.sym} 60 6560 0 0 {name=l5285 lab=VSS}
C {bitcell_6t.sym} 200 6600 0 0 {name=Xr33c1}
N 160 6640 140 6640 {}
C {lab_pin.sym} 140 6640 0 0 {name=l5286 lab=BL1}
N 160 6600 140 6600 {}
C {lab_pin.sym} 140 6600 0 0 {name=l5287 lab=BLB1}
N 160 6560 140 6560 {}
C {lab_pin.sym} 140 6560 0 0 {name=l5288 lab=WL33}
N 240 6640 260 6640 {}
C {lab_pin.sym} 260 6640 0 0 {name=l5289 lab=VDD}
N 240 6560 260 6560 {}
C {lab_pin.sym} 260 6560 0 0 {name=l5290 lab=VSS}
C {bitcell_6t.sym} 400 6600 0 0 {name=Xr33c2}
N 360 6640 340 6640 {}
C {lab_pin.sym} 340 6640 0 0 {name=l5291 lab=BL2}
N 360 6600 340 6600 {}
C {lab_pin.sym} 340 6600 0 0 {name=l5292 lab=BLB2}
N 360 6560 340 6560 {}
C {lab_pin.sym} 340 6560 0 0 {name=l5293 lab=WL33}
N 440 6640 460 6640 {}
C {lab_pin.sym} 460 6640 0 0 {name=l5294 lab=VDD}
N 440 6560 460 6560 {}
C {lab_pin.sym} 460 6560 0 0 {name=l5295 lab=VSS}
C {bitcell_6t.sym} 600 6600 0 0 {name=Xr33c3}
N 560 6640 540 6640 {}
C {lab_pin.sym} 540 6640 0 0 {name=l5296 lab=BL3}
N 560 6600 540 6600 {}
C {lab_pin.sym} 540 6600 0 0 {name=l5297 lab=BLB3}
N 560 6560 540 6560 {}
C {lab_pin.sym} 540 6560 0 0 {name=l5298 lab=WL33}
N 640 6640 660 6640 {}
C {lab_pin.sym} 660 6640 0 0 {name=l5299 lab=VDD}
N 640 6560 660 6560 {}
C {lab_pin.sym} 660 6560 0 0 {name=l5300 lab=VSS}
C {bitcell_6t.sym} 800 6600 0 0 {name=Xr33c4}
N 760 6640 740 6640 {}
C {lab_pin.sym} 740 6640 0 0 {name=l5301 lab=BL4}
N 760 6600 740 6600 {}
C {lab_pin.sym} 740 6600 0 0 {name=l5302 lab=BLB4}
N 760 6560 740 6560 {}
C {lab_pin.sym} 740 6560 0 0 {name=l5303 lab=WL33}
N 840 6640 860 6640 {}
C {lab_pin.sym} 860 6640 0 0 {name=l5304 lab=VDD}
N 840 6560 860 6560 {}
C {lab_pin.sym} 860 6560 0 0 {name=l5305 lab=VSS}
C {bitcell_6t.sym} 1000 6600 0 0 {name=Xr33c5}
N 960 6640 940 6640 {}
C {lab_pin.sym} 940 6640 0 0 {name=l5306 lab=BL5}
N 960 6600 940 6600 {}
C {lab_pin.sym} 940 6600 0 0 {name=l5307 lab=BLB5}
N 960 6560 940 6560 {}
C {lab_pin.sym} 940 6560 0 0 {name=l5308 lab=WL33}
N 1040 6640 1060 6640 {}
C {lab_pin.sym} 1060 6640 0 0 {name=l5309 lab=VDD}
N 1040 6560 1060 6560 {}
C {lab_pin.sym} 1060 6560 0 0 {name=l5310 lab=VSS}
C {bitcell_6t.sym} 1200 6600 0 0 {name=Xr33c6}
N 1160 6640 1140 6640 {}
C {lab_pin.sym} 1140 6640 0 0 {name=l5311 lab=BL6}
N 1160 6600 1140 6600 {}
C {lab_pin.sym} 1140 6600 0 0 {name=l5312 lab=BLB6}
N 1160 6560 1140 6560 {}
C {lab_pin.sym} 1140 6560 0 0 {name=l5313 lab=WL33}
N 1240 6640 1260 6640 {}
C {lab_pin.sym} 1260 6640 0 0 {name=l5314 lab=VDD}
N 1240 6560 1260 6560 {}
C {lab_pin.sym} 1260 6560 0 0 {name=l5315 lab=VSS}
C {bitcell_6t.sym} 1400 6600 0 0 {name=Xr33c7}
N 1360 6640 1340 6640 {}
C {lab_pin.sym} 1340 6640 0 0 {name=l5316 lab=BL7}
N 1360 6600 1340 6600 {}
C {lab_pin.sym} 1340 6600 0 0 {name=l5317 lab=BLB7}
N 1360 6560 1340 6560 {}
C {lab_pin.sym} 1340 6560 0 0 {name=l5318 lab=WL33}
N 1440 6640 1460 6640 {}
C {lab_pin.sym} 1460 6640 0 0 {name=l5319 lab=VDD}
N 1440 6560 1460 6560 {}
C {lab_pin.sym} 1460 6560 0 0 {name=l5320 lab=VSS}
C {bitcell_6t.sym} 1600 6600 0 0 {name=Xr33c8}
N 1560 6640 1540 6640 {}
C {lab_pin.sym} 1540 6640 0 0 {name=l5321 lab=BL8}
N 1560 6600 1540 6600 {}
C {lab_pin.sym} 1540 6600 0 0 {name=l5322 lab=BLB8}
N 1560 6560 1540 6560 {}
C {lab_pin.sym} 1540 6560 0 0 {name=l5323 lab=WL33}
N 1640 6640 1660 6640 {}
C {lab_pin.sym} 1660 6640 0 0 {name=l5324 lab=VDD}
N 1640 6560 1660 6560 {}
C {lab_pin.sym} 1660 6560 0 0 {name=l5325 lab=VSS}
C {bitcell_6t.sym} 1800 6600 0 0 {name=Xr33c9}
N 1760 6640 1740 6640 {}
C {lab_pin.sym} 1740 6640 0 0 {name=l5326 lab=BL9}
N 1760 6600 1740 6600 {}
C {lab_pin.sym} 1740 6600 0 0 {name=l5327 lab=BLB9}
N 1760 6560 1740 6560 {}
C {lab_pin.sym} 1740 6560 0 0 {name=l5328 lab=WL33}
N 1840 6640 1860 6640 {}
C {lab_pin.sym} 1860 6640 0 0 {name=l5329 lab=VDD}
N 1840 6560 1860 6560 {}
C {lab_pin.sym} 1860 6560 0 0 {name=l5330 lab=VSS}
C {bitcell_6t.sym} 2000 6600 0 0 {name=Xr33c10}
N 1960 6640 1940 6640 {}
C {lab_pin.sym} 1940 6640 0 0 {name=l5331 lab=BL10}
N 1960 6600 1940 6600 {}
C {lab_pin.sym} 1940 6600 0 0 {name=l5332 lab=BLB10}
N 1960 6560 1940 6560 {}
C {lab_pin.sym} 1940 6560 0 0 {name=l5333 lab=WL33}
N 2040 6640 2060 6640 {}
C {lab_pin.sym} 2060 6640 0 0 {name=l5334 lab=VDD}
N 2040 6560 2060 6560 {}
C {lab_pin.sym} 2060 6560 0 0 {name=l5335 lab=VSS}
C {bitcell_6t.sym} 2200 6600 0 0 {name=Xr33c11}
N 2160 6640 2140 6640 {}
C {lab_pin.sym} 2140 6640 0 0 {name=l5336 lab=BL11}
N 2160 6600 2140 6600 {}
C {lab_pin.sym} 2140 6600 0 0 {name=l5337 lab=BLB11}
N 2160 6560 2140 6560 {}
C {lab_pin.sym} 2140 6560 0 0 {name=l5338 lab=WL33}
N 2240 6640 2260 6640 {}
C {lab_pin.sym} 2260 6640 0 0 {name=l5339 lab=VDD}
N 2240 6560 2260 6560 {}
C {lab_pin.sym} 2260 6560 0 0 {name=l5340 lab=VSS}
C {bitcell_6t.sym} 2400 6600 0 0 {name=Xr33c12}
N 2360 6640 2340 6640 {}
C {lab_pin.sym} 2340 6640 0 0 {name=l5341 lab=BL12}
N 2360 6600 2340 6600 {}
C {lab_pin.sym} 2340 6600 0 0 {name=l5342 lab=BLB12}
N 2360 6560 2340 6560 {}
C {lab_pin.sym} 2340 6560 0 0 {name=l5343 lab=WL33}
N 2440 6640 2460 6640 {}
C {lab_pin.sym} 2460 6640 0 0 {name=l5344 lab=VDD}
N 2440 6560 2460 6560 {}
C {lab_pin.sym} 2460 6560 0 0 {name=l5345 lab=VSS}
C {bitcell_6t.sym} 2600 6600 0 0 {name=Xr33c13}
N 2560 6640 2540 6640 {}
C {lab_pin.sym} 2540 6640 0 0 {name=l5346 lab=BL13}
N 2560 6600 2540 6600 {}
C {lab_pin.sym} 2540 6600 0 0 {name=l5347 lab=BLB13}
N 2560 6560 2540 6560 {}
C {lab_pin.sym} 2540 6560 0 0 {name=l5348 lab=WL33}
N 2640 6640 2660 6640 {}
C {lab_pin.sym} 2660 6640 0 0 {name=l5349 lab=VDD}
N 2640 6560 2660 6560 {}
C {lab_pin.sym} 2660 6560 0 0 {name=l5350 lab=VSS}
C {bitcell_6t.sym} 2800 6600 0 0 {name=Xr33c14}
N 2760 6640 2740 6640 {}
C {lab_pin.sym} 2740 6640 0 0 {name=l5351 lab=BL14}
N 2760 6600 2740 6600 {}
C {lab_pin.sym} 2740 6600 0 0 {name=l5352 lab=BLB14}
N 2760 6560 2740 6560 {}
C {lab_pin.sym} 2740 6560 0 0 {name=l5353 lab=WL33}
N 2840 6640 2860 6640 {}
C {lab_pin.sym} 2860 6640 0 0 {name=l5354 lab=VDD}
N 2840 6560 2860 6560 {}
C {lab_pin.sym} 2860 6560 0 0 {name=l5355 lab=VSS}
C {bitcell_6t.sym} 3000 6600 0 0 {name=Xr33c15}
N 2960 6640 2940 6640 {}
C {lab_pin.sym} 2940 6640 0 0 {name=l5356 lab=BL15}
N 2960 6600 2940 6600 {}
C {lab_pin.sym} 2940 6600 0 0 {name=l5357 lab=BLB15}
N 2960 6560 2940 6560 {}
C {lab_pin.sym} 2940 6560 0 0 {name=l5358 lab=WL33}
N 3040 6640 3060 6640 {}
C {lab_pin.sym} 3060 6640 0 0 {name=l5359 lab=VDD}
N 3040 6560 3060 6560 {}
C {lab_pin.sym} 3060 6560 0 0 {name=l5360 lab=VSS}
C {bitcell_6t.sym} 3200 6600 0 0 {name=Xr33c16}
N 3160 6640 3140 6640 {}
C {lab_pin.sym} 3140 6640 0 0 {name=l5361 lab=BL16}
N 3160 6600 3140 6600 {}
C {lab_pin.sym} 3140 6600 0 0 {name=l5362 lab=BLB16}
N 3160 6560 3140 6560 {}
C {lab_pin.sym} 3140 6560 0 0 {name=l5363 lab=WL33}
N 3240 6640 3260 6640 {}
C {lab_pin.sym} 3260 6640 0 0 {name=l5364 lab=VDD}
N 3240 6560 3260 6560 {}
C {lab_pin.sym} 3260 6560 0 0 {name=l5365 lab=VSS}
C {bitcell_6t.sym} 3400 6600 0 0 {name=Xr33c17}
N 3360 6640 3340 6640 {}
C {lab_pin.sym} 3340 6640 0 0 {name=l5366 lab=BL17}
N 3360 6600 3340 6600 {}
C {lab_pin.sym} 3340 6600 0 0 {name=l5367 lab=BLB17}
N 3360 6560 3340 6560 {}
C {lab_pin.sym} 3340 6560 0 0 {name=l5368 lab=WL33}
N 3440 6640 3460 6640 {}
C {lab_pin.sym} 3460 6640 0 0 {name=l5369 lab=VDD}
N 3440 6560 3460 6560 {}
C {lab_pin.sym} 3460 6560 0 0 {name=l5370 lab=VSS}
C {bitcell_6t.sym} 3600 6600 0 0 {name=Xr33c18}
N 3560 6640 3540 6640 {}
C {lab_pin.sym} 3540 6640 0 0 {name=l5371 lab=BL18}
N 3560 6600 3540 6600 {}
C {lab_pin.sym} 3540 6600 0 0 {name=l5372 lab=BLB18}
N 3560 6560 3540 6560 {}
C {lab_pin.sym} 3540 6560 0 0 {name=l5373 lab=WL33}
N 3640 6640 3660 6640 {}
C {lab_pin.sym} 3660 6640 0 0 {name=l5374 lab=VDD}
N 3640 6560 3660 6560 {}
C {lab_pin.sym} 3660 6560 0 0 {name=l5375 lab=VSS}
C {bitcell_6t.sym} 3800 6600 0 0 {name=Xr33c19}
N 3760 6640 3740 6640 {}
C {lab_pin.sym} 3740 6640 0 0 {name=l5376 lab=BL19}
N 3760 6600 3740 6600 {}
C {lab_pin.sym} 3740 6600 0 0 {name=l5377 lab=BLB19}
N 3760 6560 3740 6560 {}
C {lab_pin.sym} 3740 6560 0 0 {name=l5378 lab=WL33}
N 3840 6640 3860 6640 {}
C {lab_pin.sym} 3860 6640 0 0 {name=l5379 lab=VDD}
N 3840 6560 3860 6560 {}
C {lab_pin.sym} 3860 6560 0 0 {name=l5380 lab=VSS}
C {bitcell_6t.sym} 4000 6600 0 0 {name=Xr33c20}
N 3960 6640 3940 6640 {}
C {lab_pin.sym} 3940 6640 0 0 {name=l5381 lab=BL20}
N 3960 6600 3940 6600 {}
C {lab_pin.sym} 3940 6600 0 0 {name=l5382 lab=BLB20}
N 3960 6560 3940 6560 {}
C {lab_pin.sym} 3940 6560 0 0 {name=l5383 lab=WL33}
N 4040 6640 4060 6640 {}
C {lab_pin.sym} 4060 6640 0 0 {name=l5384 lab=VDD}
N 4040 6560 4060 6560 {}
C {lab_pin.sym} 4060 6560 0 0 {name=l5385 lab=VSS}
C {bitcell_6t.sym} 4200 6600 0 0 {name=Xr33c21}
N 4160 6640 4140 6640 {}
C {lab_pin.sym} 4140 6640 0 0 {name=l5386 lab=BL21}
N 4160 6600 4140 6600 {}
C {lab_pin.sym} 4140 6600 0 0 {name=l5387 lab=BLB21}
N 4160 6560 4140 6560 {}
C {lab_pin.sym} 4140 6560 0 0 {name=l5388 lab=WL33}
N 4240 6640 4260 6640 {}
C {lab_pin.sym} 4260 6640 0 0 {name=l5389 lab=VDD}
N 4240 6560 4260 6560 {}
C {lab_pin.sym} 4260 6560 0 0 {name=l5390 lab=VSS}
C {bitcell_6t.sym} 4400 6600 0 0 {name=Xr33c22}
N 4360 6640 4340 6640 {}
C {lab_pin.sym} 4340 6640 0 0 {name=l5391 lab=BL22}
N 4360 6600 4340 6600 {}
C {lab_pin.sym} 4340 6600 0 0 {name=l5392 lab=BLB22}
N 4360 6560 4340 6560 {}
C {lab_pin.sym} 4340 6560 0 0 {name=l5393 lab=WL33}
N 4440 6640 4460 6640 {}
C {lab_pin.sym} 4460 6640 0 0 {name=l5394 lab=VDD}
N 4440 6560 4460 6560 {}
C {lab_pin.sym} 4460 6560 0 0 {name=l5395 lab=VSS}
C {bitcell_6t.sym} 4600 6600 0 0 {name=Xr33c23}
N 4560 6640 4540 6640 {}
C {lab_pin.sym} 4540 6640 0 0 {name=l5396 lab=BL23}
N 4560 6600 4540 6600 {}
C {lab_pin.sym} 4540 6600 0 0 {name=l5397 lab=BLB23}
N 4560 6560 4540 6560 {}
C {lab_pin.sym} 4540 6560 0 0 {name=l5398 lab=WL33}
N 4640 6640 4660 6640 {}
C {lab_pin.sym} 4660 6640 0 0 {name=l5399 lab=VDD}
N 4640 6560 4660 6560 {}
C {lab_pin.sym} 4660 6560 0 0 {name=l5400 lab=VSS}
C {bitcell_6t.sym} 4800 6600 0 0 {name=Xr33c24}
N 4760 6640 4740 6640 {}
C {lab_pin.sym} 4740 6640 0 0 {name=l5401 lab=BL24}
N 4760 6600 4740 6600 {}
C {lab_pin.sym} 4740 6600 0 0 {name=l5402 lab=BLB24}
N 4760 6560 4740 6560 {}
C {lab_pin.sym} 4740 6560 0 0 {name=l5403 lab=WL33}
N 4840 6640 4860 6640 {}
C {lab_pin.sym} 4860 6640 0 0 {name=l5404 lab=VDD}
N 4840 6560 4860 6560 {}
C {lab_pin.sym} 4860 6560 0 0 {name=l5405 lab=VSS}
C {bitcell_6t.sym} 5000 6600 0 0 {name=Xr33c25}
N 4960 6640 4940 6640 {}
C {lab_pin.sym} 4940 6640 0 0 {name=l5406 lab=BL25}
N 4960 6600 4940 6600 {}
C {lab_pin.sym} 4940 6600 0 0 {name=l5407 lab=BLB25}
N 4960 6560 4940 6560 {}
C {lab_pin.sym} 4940 6560 0 0 {name=l5408 lab=WL33}
N 5040 6640 5060 6640 {}
C {lab_pin.sym} 5060 6640 0 0 {name=l5409 lab=VDD}
N 5040 6560 5060 6560 {}
C {lab_pin.sym} 5060 6560 0 0 {name=l5410 lab=VSS}
C {bitcell_6t.sym} 5200 6600 0 0 {name=Xr33c26}
N 5160 6640 5140 6640 {}
C {lab_pin.sym} 5140 6640 0 0 {name=l5411 lab=BL26}
N 5160 6600 5140 6600 {}
C {lab_pin.sym} 5140 6600 0 0 {name=l5412 lab=BLB26}
N 5160 6560 5140 6560 {}
C {lab_pin.sym} 5140 6560 0 0 {name=l5413 lab=WL33}
N 5240 6640 5260 6640 {}
C {lab_pin.sym} 5260 6640 0 0 {name=l5414 lab=VDD}
N 5240 6560 5260 6560 {}
C {lab_pin.sym} 5260 6560 0 0 {name=l5415 lab=VSS}
C {bitcell_6t.sym} 5400 6600 0 0 {name=Xr33c27}
N 5360 6640 5340 6640 {}
C {lab_pin.sym} 5340 6640 0 0 {name=l5416 lab=BL27}
N 5360 6600 5340 6600 {}
C {lab_pin.sym} 5340 6600 0 0 {name=l5417 lab=BLB27}
N 5360 6560 5340 6560 {}
C {lab_pin.sym} 5340 6560 0 0 {name=l5418 lab=WL33}
N 5440 6640 5460 6640 {}
C {lab_pin.sym} 5460 6640 0 0 {name=l5419 lab=VDD}
N 5440 6560 5460 6560 {}
C {lab_pin.sym} 5460 6560 0 0 {name=l5420 lab=VSS}
C {bitcell_6t.sym} 5600 6600 0 0 {name=Xr33c28}
N 5560 6640 5540 6640 {}
C {lab_pin.sym} 5540 6640 0 0 {name=l5421 lab=BL28}
N 5560 6600 5540 6600 {}
C {lab_pin.sym} 5540 6600 0 0 {name=l5422 lab=BLB28}
N 5560 6560 5540 6560 {}
C {lab_pin.sym} 5540 6560 0 0 {name=l5423 lab=WL33}
N 5640 6640 5660 6640 {}
C {lab_pin.sym} 5660 6640 0 0 {name=l5424 lab=VDD}
N 5640 6560 5660 6560 {}
C {lab_pin.sym} 5660 6560 0 0 {name=l5425 lab=VSS}
C {bitcell_6t.sym} 5800 6600 0 0 {name=Xr33c29}
N 5760 6640 5740 6640 {}
C {lab_pin.sym} 5740 6640 0 0 {name=l5426 lab=BL29}
N 5760 6600 5740 6600 {}
C {lab_pin.sym} 5740 6600 0 0 {name=l5427 lab=BLB29}
N 5760 6560 5740 6560 {}
C {lab_pin.sym} 5740 6560 0 0 {name=l5428 lab=WL33}
N 5840 6640 5860 6640 {}
C {lab_pin.sym} 5860 6640 0 0 {name=l5429 lab=VDD}
N 5840 6560 5860 6560 {}
C {lab_pin.sym} 5860 6560 0 0 {name=l5430 lab=VSS}
C {bitcell_6t.sym} 6000 6600 0 0 {name=Xr33c30}
N 5960 6640 5940 6640 {}
C {lab_pin.sym} 5940 6640 0 0 {name=l5431 lab=BL30}
N 5960 6600 5940 6600 {}
C {lab_pin.sym} 5940 6600 0 0 {name=l5432 lab=BLB30}
N 5960 6560 5940 6560 {}
C {lab_pin.sym} 5940 6560 0 0 {name=l5433 lab=WL33}
N 6040 6640 6060 6640 {}
C {lab_pin.sym} 6060 6640 0 0 {name=l5434 lab=VDD}
N 6040 6560 6060 6560 {}
C {lab_pin.sym} 6060 6560 0 0 {name=l5435 lab=VSS}
C {bitcell_6t.sym} 6200 6600 0 0 {name=Xr33c31}
N 6160 6640 6140 6640 {}
C {lab_pin.sym} 6140 6640 0 0 {name=l5436 lab=BL31}
N 6160 6600 6140 6600 {}
C {lab_pin.sym} 6140 6600 0 0 {name=l5437 lab=BLB31}
N 6160 6560 6140 6560 {}
C {lab_pin.sym} 6140 6560 0 0 {name=l5438 lab=WL33}
N 6240 6640 6260 6640 {}
C {lab_pin.sym} 6260 6640 0 0 {name=l5439 lab=VDD}
N 6240 6560 6260 6560 {}
C {lab_pin.sym} 6260 6560 0 0 {name=l5440 lab=VSS}
C {bitcell_6t.sym} 0 6800 0 0 {name=Xr34c0}
N -40 6840 -60 6840 {}
C {lab_pin.sym} -60 6840 0 0 {name=l5441 lab=BL0}
N -40 6800 -60 6800 {}
C {lab_pin.sym} -60 6800 0 0 {name=l5442 lab=BLB0}
N -40 6760 -60 6760 {}
C {lab_pin.sym} -60 6760 0 0 {name=l5443 lab=WL34}
N 40 6840 60 6840 {}
C {lab_pin.sym} 60 6840 0 0 {name=l5444 lab=VDD}
N 40 6760 60 6760 {}
C {lab_pin.sym} 60 6760 0 0 {name=l5445 lab=VSS}
C {bitcell_6t.sym} 200 6800 0 0 {name=Xr34c1}
N 160 6840 140 6840 {}
C {lab_pin.sym} 140 6840 0 0 {name=l5446 lab=BL1}
N 160 6800 140 6800 {}
C {lab_pin.sym} 140 6800 0 0 {name=l5447 lab=BLB1}
N 160 6760 140 6760 {}
C {lab_pin.sym} 140 6760 0 0 {name=l5448 lab=WL34}
N 240 6840 260 6840 {}
C {lab_pin.sym} 260 6840 0 0 {name=l5449 lab=VDD}
N 240 6760 260 6760 {}
C {lab_pin.sym} 260 6760 0 0 {name=l5450 lab=VSS}
C {bitcell_6t.sym} 400 6800 0 0 {name=Xr34c2}
N 360 6840 340 6840 {}
C {lab_pin.sym} 340 6840 0 0 {name=l5451 lab=BL2}
N 360 6800 340 6800 {}
C {lab_pin.sym} 340 6800 0 0 {name=l5452 lab=BLB2}
N 360 6760 340 6760 {}
C {lab_pin.sym} 340 6760 0 0 {name=l5453 lab=WL34}
N 440 6840 460 6840 {}
C {lab_pin.sym} 460 6840 0 0 {name=l5454 lab=VDD}
N 440 6760 460 6760 {}
C {lab_pin.sym} 460 6760 0 0 {name=l5455 lab=VSS}
C {bitcell_6t.sym} 600 6800 0 0 {name=Xr34c3}
N 560 6840 540 6840 {}
C {lab_pin.sym} 540 6840 0 0 {name=l5456 lab=BL3}
N 560 6800 540 6800 {}
C {lab_pin.sym} 540 6800 0 0 {name=l5457 lab=BLB3}
N 560 6760 540 6760 {}
C {lab_pin.sym} 540 6760 0 0 {name=l5458 lab=WL34}
N 640 6840 660 6840 {}
C {lab_pin.sym} 660 6840 0 0 {name=l5459 lab=VDD}
N 640 6760 660 6760 {}
C {lab_pin.sym} 660 6760 0 0 {name=l5460 lab=VSS}
C {bitcell_6t.sym} 800 6800 0 0 {name=Xr34c4}
N 760 6840 740 6840 {}
C {lab_pin.sym} 740 6840 0 0 {name=l5461 lab=BL4}
N 760 6800 740 6800 {}
C {lab_pin.sym} 740 6800 0 0 {name=l5462 lab=BLB4}
N 760 6760 740 6760 {}
C {lab_pin.sym} 740 6760 0 0 {name=l5463 lab=WL34}
N 840 6840 860 6840 {}
C {lab_pin.sym} 860 6840 0 0 {name=l5464 lab=VDD}
N 840 6760 860 6760 {}
C {lab_pin.sym} 860 6760 0 0 {name=l5465 lab=VSS}
C {bitcell_6t.sym} 1000 6800 0 0 {name=Xr34c5}
N 960 6840 940 6840 {}
C {lab_pin.sym} 940 6840 0 0 {name=l5466 lab=BL5}
N 960 6800 940 6800 {}
C {lab_pin.sym} 940 6800 0 0 {name=l5467 lab=BLB5}
N 960 6760 940 6760 {}
C {lab_pin.sym} 940 6760 0 0 {name=l5468 lab=WL34}
N 1040 6840 1060 6840 {}
C {lab_pin.sym} 1060 6840 0 0 {name=l5469 lab=VDD}
N 1040 6760 1060 6760 {}
C {lab_pin.sym} 1060 6760 0 0 {name=l5470 lab=VSS}
C {bitcell_6t.sym} 1200 6800 0 0 {name=Xr34c6}
N 1160 6840 1140 6840 {}
C {lab_pin.sym} 1140 6840 0 0 {name=l5471 lab=BL6}
N 1160 6800 1140 6800 {}
C {lab_pin.sym} 1140 6800 0 0 {name=l5472 lab=BLB6}
N 1160 6760 1140 6760 {}
C {lab_pin.sym} 1140 6760 0 0 {name=l5473 lab=WL34}
N 1240 6840 1260 6840 {}
C {lab_pin.sym} 1260 6840 0 0 {name=l5474 lab=VDD}
N 1240 6760 1260 6760 {}
C {lab_pin.sym} 1260 6760 0 0 {name=l5475 lab=VSS}
C {bitcell_6t.sym} 1400 6800 0 0 {name=Xr34c7}
N 1360 6840 1340 6840 {}
C {lab_pin.sym} 1340 6840 0 0 {name=l5476 lab=BL7}
N 1360 6800 1340 6800 {}
C {lab_pin.sym} 1340 6800 0 0 {name=l5477 lab=BLB7}
N 1360 6760 1340 6760 {}
C {lab_pin.sym} 1340 6760 0 0 {name=l5478 lab=WL34}
N 1440 6840 1460 6840 {}
C {lab_pin.sym} 1460 6840 0 0 {name=l5479 lab=VDD}
N 1440 6760 1460 6760 {}
C {lab_pin.sym} 1460 6760 0 0 {name=l5480 lab=VSS}
C {bitcell_6t.sym} 1600 6800 0 0 {name=Xr34c8}
N 1560 6840 1540 6840 {}
C {lab_pin.sym} 1540 6840 0 0 {name=l5481 lab=BL8}
N 1560 6800 1540 6800 {}
C {lab_pin.sym} 1540 6800 0 0 {name=l5482 lab=BLB8}
N 1560 6760 1540 6760 {}
C {lab_pin.sym} 1540 6760 0 0 {name=l5483 lab=WL34}
N 1640 6840 1660 6840 {}
C {lab_pin.sym} 1660 6840 0 0 {name=l5484 lab=VDD}
N 1640 6760 1660 6760 {}
C {lab_pin.sym} 1660 6760 0 0 {name=l5485 lab=VSS}
C {bitcell_6t.sym} 1800 6800 0 0 {name=Xr34c9}
N 1760 6840 1740 6840 {}
C {lab_pin.sym} 1740 6840 0 0 {name=l5486 lab=BL9}
N 1760 6800 1740 6800 {}
C {lab_pin.sym} 1740 6800 0 0 {name=l5487 lab=BLB9}
N 1760 6760 1740 6760 {}
C {lab_pin.sym} 1740 6760 0 0 {name=l5488 lab=WL34}
N 1840 6840 1860 6840 {}
C {lab_pin.sym} 1860 6840 0 0 {name=l5489 lab=VDD}
N 1840 6760 1860 6760 {}
C {lab_pin.sym} 1860 6760 0 0 {name=l5490 lab=VSS}
C {bitcell_6t.sym} 2000 6800 0 0 {name=Xr34c10}
N 1960 6840 1940 6840 {}
C {lab_pin.sym} 1940 6840 0 0 {name=l5491 lab=BL10}
N 1960 6800 1940 6800 {}
C {lab_pin.sym} 1940 6800 0 0 {name=l5492 lab=BLB10}
N 1960 6760 1940 6760 {}
C {lab_pin.sym} 1940 6760 0 0 {name=l5493 lab=WL34}
N 2040 6840 2060 6840 {}
C {lab_pin.sym} 2060 6840 0 0 {name=l5494 lab=VDD}
N 2040 6760 2060 6760 {}
C {lab_pin.sym} 2060 6760 0 0 {name=l5495 lab=VSS}
C {bitcell_6t.sym} 2200 6800 0 0 {name=Xr34c11}
N 2160 6840 2140 6840 {}
C {lab_pin.sym} 2140 6840 0 0 {name=l5496 lab=BL11}
N 2160 6800 2140 6800 {}
C {lab_pin.sym} 2140 6800 0 0 {name=l5497 lab=BLB11}
N 2160 6760 2140 6760 {}
C {lab_pin.sym} 2140 6760 0 0 {name=l5498 lab=WL34}
N 2240 6840 2260 6840 {}
C {lab_pin.sym} 2260 6840 0 0 {name=l5499 lab=VDD}
N 2240 6760 2260 6760 {}
C {lab_pin.sym} 2260 6760 0 0 {name=l5500 lab=VSS}
C {bitcell_6t.sym} 2400 6800 0 0 {name=Xr34c12}
N 2360 6840 2340 6840 {}
C {lab_pin.sym} 2340 6840 0 0 {name=l5501 lab=BL12}
N 2360 6800 2340 6800 {}
C {lab_pin.sym} 2340 6800 0 0 {name=l5502 lab=BLB12}
N 2360 6760 2340 6760 {}
C {lab_pin.sym} 2340 6760 0 0 {name=l5503 lab=WL34}
N 2440 6840 2460 6840 {}
C {lab_pin.sym} 2460 6840 0 0 {name=l5504 lab=VDD}
N 2440 6760 2460 6760 {}
C {lab_pin.sym} 2460 6760 0 0 {name=l5505 lab=VSS}
C {bitcell_6t.sym} 2600 6800 0 0 {name=Xr34c13}
N 2560 6840 2540 6840 {}
C {lab_pin.sym} 2540 6840 0 0 {name=l5506 lab=BL13}
N 2560 6800 2540 6800 {}
C {lab_pin.sym} 2540 6800 0 0 {name=l5507 lab=BLB13}
N 2560 6760 2540 6760 {}
C {lab_pin.sym} 2540 6760 0 0 {name=l5508 lab=WL34}
N 2640 6840 2660 6840 {}
C {lab_pin.sym} 2660 6840 0 0 {name=l5509 lab=VDD}
N 2640 6760 2660 6760 {}
C {lab_pin.sym} 2660 6760 0 0 {name=l5510 lab=VSS}
C {bitcell_6t.sym} 2800 6800 0 0 {name=Xr34c14}
N 2760 6840 2740 6840 {}
C {lab_pin.sym} 2740 6840 0 0 {name=l5511 lab=BL14}
N 2760 6800 2740 6800 {}
C {lab_pin.sym} 2740 6800 0 0 {name=l5512 lab=BLB14}
N 2760 6760 2740 6760 {}
C {lab_pin.sym} 2740 6760 0 0 {name=l5513 lab=WL34}
N 2840 6840 2860 6840 {}
C {lab_pin.sym} 2860 6840 0 0 {name=l5514 lab=VDD}
N 2840 6760 2860 6760 {}
C {lab_pin.sym} 2860 6760 0 0 {name=l5515 lab=VSS}
C {bitcell_6t.sym} 3000 6800 0 0 {name=Xr34c15}
N 2960 6840 2940 6840 {}
C {lab_pin.sym} 2940 6840 0 0 {name=l5516 lab=BL15}
N 2960 6800 2940 6800 {}
C {lab_pin.sym} 2940 6800 0 0 {name=l5517 lab=BLB15}
N 2960 6760 2940 6760 {}
C {lab_pin.sym} 2940 6760 0 0 {name=l5518 lab=WL34}
N 3040 6840 3060 6840 {}
C {lab_pin.sym} 3060 6840 0 0 {name=l5519 lab=VDD}
N 3040 6760 3060 6760 {}
C {lab_pin.sym} 3060 6760 0 0 {name=l5520 lab=VSS}
C {bitcell_6t.sym} 3200 6800 0 0 {name=Xr34c16}
N 3160 6840 3140 6840 {}
C {lab_pin.sym} 3140 6840 0 0 {name=l5521 lab=BL16}
N 3160 6800 3140 6800 {}
C {lab_pin.sym} 3140 6800 0 0 {name=l5522 lab=BLB16}
N 3160 6760 3140 6760 {}
C {lab_pin.sym} 3140 6760 0 0 {name=l5523 lab=WL34}
N 3240 6840 3260 6840 {}
C {lab_pin.sym} 3260 6840 0 0 {name=l5524 lab=VDD}
N 3240 6760 3260 6760 {}
C {lab_pin.sym} 3260 6760 0 0 {name=l5525 lab=VSS}
C {bitcell_6t.sym} 3400 6800 0 0 {name=Xr34c17}
N 3360 6840 3340 6840 {}
C {lab_pin.sym} 3340 6840 0 0 {name=l5526 lab=BL17}
N 3360 6800 3340 6800 {}
C {lab_pin.sym} 3340 6800 0 0 {name=l5527 lab=BLB17}
N 3360 6760 3340 6760 {}
C {lab_pin.sym} 3340 6760 0 0 {name=l5528 lab=WL34}
N 3440 6840 3460 6840 {}
C {lab_pin.sym} 3460 6840 0 0 {name=l5529 lab=VDD}
N 3440 6760 3460 6760 {}
C {lab_pin.sym} 3460 6760 0 0 {name=l5530 lab=VSS}
C {bitcell_6t.sym} 3600 6800 0 0 {name=Xr34c18}
N 3560 6840 3540 6840 {}
C {lab_pin.sym} 3540 6840 0 0 {name=l5531 lab=BL18}
N 3560 6800 3540 6800 {}
C {lab_pin.sym} 3540 6800 0 0 {name=l5532 lab=BLB18}
N 3560 6760 3540 6760 {}
C {lab_pin.sym} 3540 6760 0 0 {name=l5533 lab=WL34}
N 3640 6840 3660 6840 {}
C {lab_pin.sym} 3660 6840 0 0 {name=l5534 lab=VDD}
N 3640 6760 3660 6760 {}
C {lab_pin.sym} 3660 6760 0 0 {name=l5535 lab=VSS}
C {bitcell_6t.sym} 3800 6800 0 0 {name=Xr34c19}
N 3760 6840 3740 6840 {}
C {lab_pin.sym} 3740 6840 0 0 {name=l5536 lab=BL19}
N 3760 6800 3740 6800 {}
C {lab_pin.sym} 3740 6800 0 0 {name=l5537 lab=BLB19}
N 3760 6760 3740 6760 {}
C {lab_pin.sym} 3740 6760 0 0 {name=l5538 lab=WL34}
N 3840 6840 3860 6840 {}
C {lab_pin.sym} 3860 6840 0 0 {name=l5539 lab=VDD}
N 3840 6760 3860 6760 {}
C {lab_pin.sym} 3860 6760 0 0 {name=l5540 lab=VSS}
C {bitcell_6t.sym} 4000 6800 0 0 {name=Xr34c20}
N 3960 6840 3940 6840 {}
C {lab_pin.sym} 3940 6840 0 0 {name=l5541 lab=BL20}
N 3960 6800 3940 6800 {}
C {lab_pin.sym} 3940 6800 0 0 {name=l5542 lab=BLB20}
N 3960 6760 3940 6760 {}
C {lab_pin.sym} 3940 6760 0 0 {name=l5543 lab=WL34}
N 4040 6840 4060 6840 {}
C {lab_pin.sym} 4060 6840 0 0 {name=l5544 lab=VDD}
N 4040 6760 4060 6760 {}
C {lab_pin.sym} 4060 6760 0 0 {name=l5545 lab=VSS}
C {bitcell_6t.sym} 4200 6800 0 0 {name=Xr34c21}
N 4160 6840 4140 6840 {}
C {lab_pin.sym} 4140 6840 0 0 {name=l5546 lab=BL21}
N 4160 6800 4140 6800 {}
C {lab_pin.sym} 4140 6800 0 0 {name=l5547 lab=BLB21}
N 4160 6760 4140 6760 {}
C {lab_pin.sym} 4140 6760 0 0 {name=l5548 lab=WL34}
N 4240 6840 4260 6840 {}
C {lab_pin.sym} 4260 6840 0 0 {name=l5549 lab=VDD}
N 4240 6760 4260 6760 {}
C {lab_pin.sym} 4260 6760 0 0 {name=l5550 lab=VSS}
C {bitcell_6t.sym} 4400 6800 0 0 {name=Xr34c22}
N 4360 6840 4340 6840 {}
C {lab_pin.sym} 4340 6840 0 0 {name=l5551 lab=BL22}
N 4360 6800 4340 6800 {}
C {lab_pin.sym} 4340 6800 0 0 {name=l5552 lab=BLB22}
N 4360 6760 4340 6760 {}
C {lab_pin.sym} 4340 6760 0 0 {name=l5553 lab=WL34}
N 4440 6840 4460 6840 {}
C {lab_pin.sym} 4460 6840 0 0 {name=l5554 lab=VDD}
N 4440 6760 4460 6760 {}
C {lab_pin.sym} 4460 6760 0 0 {name=l5555 lab=VSS}
C {bitcell_6t.sym} 4600 6800 0 0 {name=Xr34c23}
N 4560 6840 4540 6840 {}
C {lab_pin.sym} 4540 6840 0 0 {name=l5556 lab=BL23}
N 4560 6800 4540 6800 {}
C {lab_pin.sym} 4540 6800 0 0 {name=l5557 lab=BLB23}
N 4560 6760 4540 6760 {}
C {lab_pin.sym} 4540 6760 0 0 {name=l5558 lab=WL34}
N 4640 6840 4660 6840 {}
C {lab_pin.sym} 4660 6840 0 0 {name=l5559 lab=VDD}
N 4640 6760 4660 6760 {}
C {lab_pin.sym} 4660 6760 0 0 {name=l5560 lab=VSS}
C {bitcell_6t.sym} 4800 6800 0 0 {name=Xr34c24}
N 4760 6840 4740 6840 {}
C {lab_pin.sym} 4740 6840 0 0 {name=l5561 lab=BL24}
N 4760 6800 4740 6800 {}
C {lab_pin.sym} 4740 6800 0 0 {name=l5562 lab=BLB24}
N 4760 6760 4740 6760 {}
C {lab_pin.sym} 4740 6760 0 0 {name=l5563 lab=WL34}
N 4840 6840 4860 6840 {}
C {lab_pin.sym} 4860 6840 0 0 {name=l5564 lab=VDD}
N 4840 6760 4860 6760 {}
C {lab_pin.sym} 4860 6760 0 0 {name=l5565 lab=VSS}
C {bitcell_6t.sym} 5000 6800 0 0 {name=Xr34c25}
N 4960 6840 4940 6840 {}
C {lab_pin.sym} 4940 6840 0 0 {name=l5566 lab=BL25}
N 4960 6800 4940 6800 {}
C {lab_pin.sym} 4940 6800 0 0 {name=l5567 lab=BLB25}
N 4960 6760 4940 6760 {}
C {lab_pin.sym} 4940 6760 0 0 {name=l5568 lab=WL34}
N 5040 6840 5060 6840 {}
C {lab_pin.sym} 5060 6840 0 0 {name=l5569 lab=VDD}
N 5040 6760 5060 6760 {}
C {lab_pin.sym} 5060 6760 0 0 {name=l5570 lab=VSS}
C {bitcell_6t.sym} 5200 6800 0 0 {name=Xr34c26}
N 5160 6840 5140 6840 {}
C {lab_pin.sym} 5140 6840 0 0 {name=l5571 lab=BL26}
N 5160 6800 5140 6800 {}
C {lab_pin.sym} 5140 6800 0 0 {name=l5572 lab=BLB26}
N 5160 6760 5140 6760 {}
C {lab_pin.sym} 5140 6760 0 0 {name=l5573 lab=WL34}
N 5240 6840 5260 6840 {}
C {lab_pin.sym} 5260 6840 0 0 {name=l5574 lab=VDD}
N 5240 6760 5260 6760 {}
C {lab_pin.sym} 5260 6760 0 0 {name=l5575 lab=VSS}
C {bitcell_6t.sym} 5400 6800 0 0 {name=Xr34c27}
N 5360 6840 5340 6840 {}
C {lab_pin.sym} 5340 6840 0 0 {name=l5576 lab=BL27}
N 5360 6800 5340 6800 {}
C {lab_pin.sym} 5340 6800 0 0 {name=l5577 lab=BLB27}
N 5360 6760 5340 6760 {}
C {lab_pin.sym} 5340 6760 0 0 {name=l5578 lab=WL34}
N 5440 6840 5460 6840 {}
C {lab_pin.sym} 5460 6840 0 0 {name=l5579 lab=VDD}
N 5440 6760 5460 6760 {}
C {lab_pin.sym} 5460 6760 0 0 {name=l5580 lab=VSS}
C {bitcell_6t.sym} 5600 6800 0 0 {name=Xr34c28}
N 5560 6840 5540 6840 {}
C {lab_pin.sym} 5540 6840 0 0 {name=l5581 lab=BL28}
N 5560 6800 5540 6800 {}
C {lab_pin.sym} 5540 6800 0 0 {name=l5582 lab=BLB28}
N 5560 6760 5540 6760 {}
C {lab_pin.sym} 5540 6760 0 0 {name=l5583 lab=WL34}
N 5640 6840 5660 6840 {}
C {lab_pin.sym} 5660 6840 0 0 {name=l5584 lab=VDD}
N 5640 6760 5660 6760 {}
C {lab_pin.sym} 5660 6760 0 0 {name=l5585 lab=VSS}
C {bitcell_6t.sym} 5800 6800 0 0 {name=Xr34c29}
N 5760 6840 5740 6840 {}
C {lab_pin.sym} 5740 6840 0 0 {name=l5586 lab=BL29}
N 5760 6800 5740 6800 {}
C {lab_pin.sym} 5740 6800 0 0 {name=l5587 lab=BLB29}
N 5760 6760 5740 6760 {}
C {lab_pin.sym} 5740 6760 0 0 {name=l5588 lab=WL34}
N 5840 6840 5860 6840 {}
C {lab_pin.sym} 5860 6840 0 0 {name=l5589 lab=VDD}
N 5840 6760 5860 6760 {}
C {lab_pin.sym} 5860 6760 0 0 {name=l5590 lab=VSS}
C {bitcell_6t.sym} 6000 6800 0 0 {name=Xr34c30}
N 5960 6840 5940 6840 {}
C {lab_pin.sym} 5940 6840 0 0 {name=l5591 lab=BL30}
N 5960 6800 5940 6800 {}
C {lab_pin.sym} 5940 6800 0 0 {name=l5592 lab=BLB30}
N 5960 6760 5940 6760 {}
C {lab_pin.sym} 5940 6760 0 0 {name=l5593 lab=WL34}
N 6040 6840 6060 6840 {}
C {lab_pin.sym} 6060 6840 0 0 {name=l5594 lab=VDD}
N 6040 6760 6060 6760 {}
C {lab_pin.sym} 6060 6760 0 0 {name=l5595 lab=VSS}
C {bitcell_6t.sym} 6200 6800 0 0 {name=Xr34c31}
N 6160 6840 6140 6840 {}
C {lab_pin.sym} 6140 6840 0 0 {name=l5596 lab=BL31}
N 6160 6800 6140 6800 {}
C {lab_pin.sym} 6140 6800 0 0 {name=l5597 lab=BLB31}
N 6160 6760 6140 6760 {}
C {lab_pin.sym} 6140 6760 0 0 {name=l5598 lab=WL34}
N 6240 6840 6260 6840 {}
C {lab_pin.sym} 6260 6840 0 0 {name=l5599 lab=VDD}
N 6240 6760 6260 6760 {}
C {lab_pin.sym} 6260 6760 0 0 {name=l5600 lab=VSS}
C {bitcell_6t.sym} 0 7000 0 0 {name=Xr35c0}
N -40 7040 -60 7040 {}
C {lab_pin.sym} -60 7040 0 0 {name=l5601 lab=BL0}
N -40 7000 -60 7000 {}
C {lab_pin.sym} -60 7000 0 0 {name=l5602 lab=BLB0}
N -40 6960 -60 6960 {}
C {lab_pin.sym} -60 6960 0 0 {name=l5603 lab=WL35}
N 40 7040 60 7040 {}
C {lab_pin.sym} 60 7040 0 0 {name=l5604 lab=VDD}
N 40 6960 60 6960 {}
C {lab_pin.sym} 60 6960 0 0 {name=l5605 lab=VSS}
C {bitcell_6t.sym} 200 7000 0 0 {name=Xr35c1}
N 160 7040 140 7040 {}
C {lab_pin.sym} 140 7040 0 0 {name=l5606 lab=BL1}
N 160 7000 140 7000 {}
C {lab_pin.sym} 140 7000 0 0 {name=l5607 lab=BLB1}
N 160 6960 140 6960 {}
C {lab_pin.sym} 140 6960 0 0 {name=l5608 lab=WL35}
N 240 7040 260 7040 {}
C {lab_pin.sym} 260 7040 0 0 {name=l5609 lab=VDD}
N 240 6960 260 6960 {}
C {lab_pin.sym} 260 6960 0 0 {name=l5610 lab=VSS}
C {bitcell_6t.sym} 400 7000 0 0 {name=Xr35c2}
N 360 7040 340 7040 {}
C {lab_pin.sym} 340 7040 0 0 {name=l5611 lab=BL2}
N 360 7000 340 7000 {}
C {lab_pin.sym} 340 7000 0 0 {name=l5612 lab=BLB2}
N 360 6960 340 6960 {}
C {lab_pin.sym} 340 6960 0 0 {name=l5613 lab=WL35}
N 440 7040 460 7040 {}
C {lab_pin.sym} 460 7040 0 0 {name=l5614 lab=VDD}
N 440 6960 460 6960 {}
C {lab_pin.sym} 460 6960 0 0 {name=l5615 lab=VSS}
C {bitcell_6t.sym} 600 7000 0 0 {name=Xr35c3}
N 560 7040 540 7040 {}
C {lab_pin.sym} 540 7040 0 0 {name=l5616 lab=BL3}
N 560 7000 540 7000 {}
C {lab_pin.sym} 540 7000 0 0 {name=l5617 lab=BLB3}
N 560 6960 540 6960 {}
C {lab_pin.sym} 540 6960 0 0 {name=l5618 lab=WL35}
N 640 7040 660 7040 {}
C {lab_pin.sym} 660 7040 0 0 {name=l5619 lab=VDD}
N 640 6960 660 6960 {}
C {lab_pin.sym} 660 6960 0 0 {name=l5620 lab=VSS}
C {bitcell_6t.sym} 800 7000 0 0 {name=Xr35c4}
N 760 7040 740 7040 {}
C {lab_pin.sym} 740 7040 0 0 {name=l5621 lab=BL4}
N 760 7000 740 7000 {}
C {lab_pin.sym} 740 7000 0 0 {name=l5622 lab=BLB4}
N 760 6960 740 6960 {}
C {lab_pin.sym} 740 6960 0 0 {name=l5623 lab=WL35}
N 840 7040 860 7040 {}
C {lab_pin.sym} 860 7040 0 0 {name=l5624 lab=VDD}
N 840 6960 860 6960 {}
C {lab_pin.sym} 860 6960 0 0 {name=l5625 lab=VSS}
C {bitcell_6t.sym} 1000 7000 0 0 {name=Xr35c5}
N 960 7040 940 7040 {}
C {lab_pin.sym} 940 7040 0 0 {name=l5626 lab=BL5}
N 960 7000 940 7000 {}
C {lab_pin.sym} 940 7000 0 0 {name=l5627 lab=BLB5}
N 960 6960 940 6960 {}
C {lab_pin.sym} 940 6960 0 0 {name=l5628 lab=WL35}
N 1040 7040 1060 7040 {}
C {lab_pin.sym} 1060 7040 0 0 {name=l5629 lab=VDD}
N 1040 6960 1060 6960 {}
C {lab_pin.sym} 1060 6960 0 0 {name=l5630 lab=VSS}
C {bitcell_6t.sym} 1200 7000 0 0 {name=Xr35c6}
N 1160 7040 1140 7040 {}
C {lab_pin.sym} 1140 7040 0 0 {name=l5631 lab=BL6}
N 1160 7000 1140 7000 {}
C {lab_pin.sym} 1140 7000 0 0 {name=l5632 lab=BLB6}
N 1160 6960 1140 6960 {}
C {lab_pin.sym} 1140 6960 0 0 {name=l5633 lab=WL35}
N 1240 7040 1260 7040 {}
C {lab_pin.sym} 1260 7040 0 0 {name=l5634 lab=VDD}
N 1240 6960 1260 6960 {}
C {lab_pin.sym} 1260 6960 0 0 {name=l5635 lab=VSS}
C {bitcell_6t.sym} 1400 7000 0 0 {name=Xr35c7}
N 1360 7040 1340 7040 {}
C {lab_pin.sym} 1340 7040 0 0 {name=l5636 lab=BL7}
N 1360 7000 1340 7000 {}
C {lab_pin.sym} 1340 7000 0 0 {name=l5637 lab=BLB7}
N 1360 6960 1340 6960 {}
C {lab_pin.sym} 1340 6960 0 0 {name=l5638 lab=WL35}
N 1440 7040 1460 7040 {}
C {lab_pin.sym} 1460 7040 0 0 {name=l5639 lab=VDD}
N 1440 6960 1460 6960 {}
C {lab_pin.sym} 1460 6960 0 0 {name=l5640 lab=VSS}
C {bitcell_6t.sym} 1600 7000 0 0 {name=Xr35c8}
N 1560 7040 1540 7040 {}
C {lab_pin.sym} 1540 7040 0 0 {name=l5641 lab=BL8}
N 1560 7000 1540 7000 {}
C {lab_pin.sym} 1540 7000 0 0 {name=l5642 lab=BLB8}
N 1560 6960 1540 6960 {}
C {lab_pin.sym} 1540 6960 0 0 {name=l5643 lab=WL35}
N 1640 7040 1660 7040 {}
C {lab_pin.sym} 1660 7040 0 0 {name=l5644 lab=VDD}
N 1640 6960 1660 6960 {}
C {lab_pin.sym} 1660 6960 0 0 {name=l5645 lab=VSS}
C {bitcell_6t.sym} 1800 7000 0 0 {name=Xr35c9}
N 1760 7040 1740 7040 {}
C {lab_pin.sym} 1740 7040 0 0 {name=l5646 lab=BL9}
N 1760 7000 1740 7000 {}
C {lab_pin.sym} 1740 7000 0 0 {name=l5647 lab=BLB9}
N 1760 6960 1740 6960 {}
C {lab_pin.sym} 1740 6960 0 0 {name=l5648 lab=WL35}
N 1840 7040 1860 7040 {}
C {lab_pin.sym} 1860 7040 0 0 {name=l5649 lab=VDD}
N 1840 6960 1860 6960 {}
C {lab_pin.sym} 1860 6960 0 0 {name=l5650 lab=VSS}
C {bitcell_6t.sym} 2000 7000 0 0 {name=Xr35c10}
N 1960 7040 1940 7040 {}
C {lab_pin.sym} 1940 7040 0 0 {name=l5651 lab=BL10}
N 1960 7000 1940 7000 {}
C {lab_pin.sym} 1940 7000 0 0 {name=l5652 lab=BLB10}
N 1960 6960 1940 6960 {}
C {lab_pin.sym} 1940 6960 0 0 {name=l5653 lab=WL35}
N 2040 7040 2060 7040 {}
C {lab_pin.sym} 2060 7040 0 0 {name=l5654 lab=VDD}
N 2040 6960 2060 6960 {}
C {lab_pin.sym} 2060 6960 0 0 {name=l5655 lab=VSS}
C {bitcell_6t.sym} 2200 7000 0 0 {name=Xr35c11}
N 2160 7040 2140 7040 {}
C {lab_pin.sym} 2140 7040 0 0 {name=l5656 lab=BL11}
N 2160 7000 2140 7000 {}
C {lab_pin.sym} 2140 7000 0 0 {name=l5657 lab=BLB11}
N 2160 6960 2140 6960 {}
C {lab_pin.sym} 2140 6960 0 0 {name=l5658 lab=WL35}
N 2240 7040 2260 7040 {}
C {lab_pin.sym} 2260 7040 0 0 {name=l5659 lab=VDD}
N 2240 6960 2260 6960 {}
C {lab_pin.sym} 2260 6960 0 0 {name=l5660 lab=VSS}
C {bitcell_6t.sym} 2400 7000 0 0 {name=Xr35c12}
N 2360 7040 2340 7040 {}
C {lab_pin.sym} 2340 7040 0 0 {name=l5661 lab=BL12}
N 2360 7000 2340 7000 {}
C {lab_pin.sym} 2340 7000 0 0 {name=l5662 lab=BLB12}
N 2360 6960 2340 6960 {}
C {lab_pin.sym} 2340 6960 0 0 {name=l5663 lab=WL35}
N 2440 7040 2460 7040 {}
C {lab_pin.sym} 2460 7040 0 0 {name=l5664 lab=VDD}
N 2440 6960 2460 6960 {}
C {lab_pin.sym} 2460 6960 0 0 {name=l5665 lab=VSS}
C {bitcell_6t.sym} 2600 7000 0 0 {name=Xr35c13}
N 2560 7040 2540 7040 {}
C {lab_pin.sym} 2540 7040 0 0 {name=l5666 lab=BL13}
N 2560 7000 2540 7000 {}
C {lab_pin.sym} 2540 7000 0 0 {name=l5667 lab=BLB13}
N 2560 6960 2540 6960 {}
C {lab_pin.sym} 2540 6960 0 0 {name=l5668 lab=WL35}
N 2640 7040 2660 7040 {}
C {lab_pin.sym} 2660 7040 0 0 {name=l5669 lab=VDD}
N 2640 6960 2660 6960 {}
C {lab_pin.sym} 2660 6960 0 0 {name=l5670 lab=VSS}
C {bitcell_6t.sym} 2800 7000 0 0 {name=Xr35c14}
N 2760 7040 2740 7040 {}
C {lab_pin.sym} 2740 7040 0 0 {name=l5671 lab=BL14}
N 2760 7000 2740 7000 {}
C {lab_pin.sym} 2740 7000 0 0 {name=l5672 lab=BLB14}
N 2760 6960 2740 6960 {}
C {lab_pin.sym} 2740 6960 0 0 {name=l5673 lab=WL35}
N 2840 7040 2860 7040 {}
C {lab_pin.sym} 2860 7040 0 0 {name=l5674 lab=VDD}
N 2840 6960 2860 6960 {}
C {lab_pin.sym} 2860 6960 0 0 {name=l5675 lab=VSS}
C {bitcell_6t.sym} 3000 7000 0 0 {name=Xr35c15}
N 2960 7040 2940 7040 {}
C {lab_pin.sym} 2940 7040 0 0 {name=l5676 lab=BL15}
N 2960 7000 2940 7000 {}
C {lab_pin.sym} 2940 7000 0 0 {name=l5677 lab=BLB15}
N 2960 6960 2940 6960 {}
C {lab_pin.sym} 2940 6960 0 0 {name=l5678 lab=WL35}
N 3040 7040 3060 7040 {}
C {lab_pin.sym} 3060 7040 0 0 {name=l5679 lab=VDD}
N 3040 6960 3060 6960 {}
C {lab_pin.sym} 3060 6960 0 0 {name=l5680 lab=VSS}
C {bitcell_6t.sym} 3200 7000 0 0 {name=Xr35c16}
N 3160 7040 3140 7040 {}
C {lab_pin.sym} 3140 7040 0 0 {name=l5681 lab=BL16}
N 3160 7000 3140 7000 {}
C {lab_pin.sym} 3140 7000 0 0 {name=l5682 lab=BLB16}
N 3160 6960 3140 6960 {}
C {lab_pin.sym} 3140 6960 0 0 {name=l5683 lab=WL35}
N 3240 7040 3260 7040 {}
C {lab_pin.sym} 3260 7040 0 0 {name=l5684 lab=VDD}
N 3240 6960 3260 6960 {}
C {lab_pin.sym} 3260 6960 0 0 {name=l5685 lab=VSS}
C {bitcell_6t.sym} 3400 7000 0 0 {name=Xr35c17}
N 3360 7040 3340 7040 {}
C {lab_pin.sym} 3340 7040 0 0 {name=l5686 lab=BL17}
N 3360 7000 3340 7000 {}
C {lab_pin.sym} 3340 7000 0 0 {name=l5687 lab=BLB17}
N 3360 6960 3340 6960 {}
C {lab_pin.sym} 3340 6960 0 0 {name=l5688 lab=WL35}
N 3440 7040 3460 7040 {}
C {lab_pin.sym} 3460 7040 0 0 {name=l5689 lab=VDD}
N 3440 6960 3460 6960 {}
C {lab_pin.sym} 3460 6960 0 0 {name=l5690 lab=VSS}
C {bitcell_6t.sym} 3600 7000 0 0 {name=Xr35c18}
N 3560 7040 3540 7040 {}
C {lab_pin.sym} 3540 7040 0 0 {name=l5691 lab=BL18}
N 3560 7000 3540 7000 {}
C {lab_pin.sym} 3540 7000 0 0 {name=l5692 lab=BLB18}
N 3560 6960 3540 6960 {}
C {lab_pin.sym} 3540 6960 0 0 {name=l5693 lab=WL35}
N 3640 7040 3660 7040 {}
C {lab_pin.sym} 3660 7040 0 0 {name=l5694 lab=VDD}
N 3640 6960 3660 6960 {}
C {lab_pin.sym} 3660 6960 0 0 {name=l5695 lab=VSS}
C {bitcell_6t.sym} 3800 7000 0 0 {name=Xr35c19}
N 3760 7040 3740 7040 {}
C {lab_pin.sym} 3740 7040 0 0 {name=l5696 lab=BL19}
N 3760 7000 3740 7000 {}
C {lab_pin.sym} 3740 7000 0 0 {name=l5697 lab=BLB19}
N 3760 6960 3740 6960 {}
C {lab_pin.sym} 3740 6960 0 0 {name=l5698 lab=WL35}
N 3840 7040 3860 7040 {}
C {lab_pin.sym} 3860 7040 0 0 {name=l5699 lab=VDD}
N 3840 6960 3860 6960 {}
C {lab_pin.sym} 3860 6960 0 0 {name=l5700 lab=VSS}
C {bitcell_6t.sym} 4000 7000 0 0 {name=Xr35c20}
N 3960 7040 3940 7040 {}
C {lab_pin.sym} 3940 7040 0 0 {name=l5701 lab=BL20}
N 3960 7000 3940 7000 {}
C {lab_pin.sym} 3940 7000 0 0 {name=l5702 lab=BLB20}
N 3960 6960 3940 6960 {}
C {lab_pin.sym} 3940 6960 0 0 {name=l5703 lab=WL35}
N 4040 7040 4060 7040 {}
C {lab_pin.sym} 4060 7040 0 0 {name=l5704 lab=VDD}
N 4040 6960 4060 6960 {}
C {lab_pin.sym} 4060 6960 0 0 {name=l5705 lab=VSS}
C {bitcell_6t.sym} 4200 7000 0 0 {name=Xr35c21}
N 4160 7040 4140 7040 {}
C {lab_pin.sym} 4140 7040 0 0 {name=l5706 lab=BL21}
N 4160 7000 4140 7000 {}
C {lab_pin.sym} 4140 7000 0 0 {name=l5707 lab=BLB21}
N 4160 6960 4140 6960 {}
C {lab_pin.sym} 4140 6960 0 0 {name=l5708 lab=WL35}
N 4240 7040 4260 7040 {}
C {lab_pin.sym} 4260 7040 0 0 {name=l5709 lab=VDD}
N 4240 6960 4260 6960 {}
C {lab_pin.sym} 4260 6960 0 0 {name=l5710 lab=VSS}
C {bitcell_6t.sym} 4400 7000 0 0 {name=Xr35c22}
N 4360 7040 4340 7040 {}
C {lab_pin.sym} 4340 7040 0 0 {name=l5711 lab=BL22}
N 4360 7000 4340 7000 {}
C {lab_pin.sym} 4340 7000 0 0 {name=l5712 lab=BLB22}
N 4360 6960 4340 6960 {}
C {lab_pin.sym} 4340 6960 0 0 {name=l5713 lab=WL35}
N 4440 7040 4460 7040 {}
C {lab_pin.sym} 4460 7040 0 0 {name=l5714 lab=VDD}
N 4440 6960 4460 6960 {}
C {lab_pin.sym} 4460 6960 0 0 {name=l5715 lab=VSS}
C {bitcell_6t.sym} 4600 7000 0 0 {name=Xr35c23}
N 4560 7040 4540 7040 {}
C {lab_pin.sym} 4540 7040 0 0 {name=l5716 lab=BL23}
N 4560 7000 4540 7000 {}
C {lab_pin.sym} 4540 7000 0 0 {name=l5717 lab=BLB23}
N 4560 6960 4540 6960 {}
C {lab_pin.sym} 4540 6960 0 0 {name=l5718 lab=WL35}
N 4640 7040 4660 7040 {}
C {lab_pin.sym} 4660 7040 0 0 {name=l5719 lab=VDD}
N 4640 6960 4660 6960 {}
C {lab_pin.sym} 4660 6960 0 0 {name=l5720 lab=VSS}
C {bitcell_6t.sym} 4800 7000 0 0 {name=Xr35c24}
N 4760 7040 4740 7040 {}
C {lab_pin.sym} 4740 7040 0 0 {name=l5721 lab=BL24}
N 4760 7000 4740 7000 {}
C {lab_pin.sym} 4740 7000 0 0 {name=l5722 lab=BLB24}
N 4760 6960 4740 6960 {}
C {lab_pin.sym} 4740 6960 0 0 {name=l5723 lab=WL35}
N 4840 7040 4860 7040 {}
C {lab_pin.sym} 4860 7040 0 0 {name=l5724 lab=VDD}
N 4840 6960 4860 6960 {}
C {lab_pin.sym} 4860 6960 0 0 {name=l5725 lab=VSS}
C {bitcell_6t.sym} 5000 7000 0 0 {name=Xr35c25}
N 4960 7040 4940 7040 {}
C {lab_pin.sym} 4940 7040 0 0 {name=l5726 lab=BL25}
N 4960 7000 4940 7000 {}
C {lab_pin.sym} 4940 7000 0 0 {name=l5727 lab=BLB25}
N 4960 6960 4940 6960 {}
C {lab_pin.sym} 4940 6960 0 0 {name=l5728 lab=WL35}
N 5040 7040 5060 7040 {}
C {lab_pin.sym} 5060 7040 0 0 {name=l5729 lab=VDD}
N 5040 6960 5060 6960 {}
C {lab_pin.sym} 5060 6960 0 0 {name=l5730 lab=VSS}
C {bitcell_6t.sym} 5200 7000 0 0 {name=Xr35c26}
N 5160 7040 5140 7040 {}
C {lab_pin.sym} 5140 7040 0 0 {name=l5731 lab=BL26}
N 5160 7000 5140 7000 {}
C {lab_pin.sym} 5140 7000 0 0 {name=l5732 lab=BLB26}
N 5160 6960 5140 6960 {}
C {lab_pin.sym} 5140 6960 0 0 {name=l5733 lab=WL35}
N 5240 7040 5260 7040 {}
C {lab_pin.sym} 5260 7040 0 0 {name=l5734 lab=VDD}
N 5240 6960 5260 6960 {}
C {lab_pin.sym} 5260 6960 0 0 {name=l5735 lab=VSS}
C {bitcell_6t.sym} 5400 7000 0 0 {name=Xr35c27}
N 5360 7040 5340 7040 {}
C {lab_pin.sym} 5340 7040 0 0 {name=l5736 lab=BL27}
N 5360 7000 5340 7000 {}
C {lab_pin.sym} 5340 7000 0 0 {name=l5737 lab=BLB27}
N 5360 6960 5340 6960 {}
C {lab_pin.sym} 5340 6960 0 0 {name=l5738 lab=WL35}
N 5440 7040 5460 7040 {}
C {lab_pin.sym} 5460 7040 0 0 {name=l5739 lab=VDD}
N 5440 6960 5460 6960 {}
C {lab_pin.sym} 5460 6960 0 0 {name=l5740 lab=VSS}
C {bitcell_6t.sym} 5600 7000 0 0 {name=Xr35c28}
N 5560 7040 5540 7040 {}
C {lab_pin.sym} 5540 7040 0 0 {name=l5741 lab=BL28}
N 5560 7000 5540 7000 {}
C {lab_pin.sym} 5540 7000 0 0 {name=l5742 lab=BLB28}
N 5560 6960 5540 6960 {}
C {lab_pin.sym} 5540 6960 0 0 {name=l5743 lab=WL35}
N 5640 7040 5660 7040 {}
C {lab_pin.sym} 5660 7040 0 0 {name=l5744 lab=VDD}
N 5640 6960 5660 6960 {}
C {lab_pin.sym} 5660 6960 0 0 {name=l5745 lab=VSS}
C {bitcell_6t.sym} 5800 7000 0 0 {name=Xr35c29}
N 5760 7040 5740 7040 {}
C {lab_pin.sym} 5740 7040 0 0 {name=l5746 lab=BL29}
N 5760 7000 5740 7000 {}
C {lab_pin.sym} 5740 7000 0 0 {name=l5747 lab=BLB29}
N 5760 6960 5740 6960 {}
C {lab_pin.sym} 5740 6960 0 0 {name=l5748 lab=WL35}
N 5840 7040 5860 7040 {}
C {lab_pin.sym} 5860 7040 0 0 {name=l5749 lab=VDD}
N 5840 6960 5860 6960 {}
C {lab_pin.sym} 5860 6960 0 0 {name=l5750 lab=VSS}
C {bitcell_6t.sym} 6000 7000 0 0 {name=Xr35c30}
N 5960 7040 5940 7040 {}
C {lab_pin.sym} 5940 7040 0 0 {name=l5751 lab=BL30}
N 5960 7000 5940 7000 {}
C {lab_pin.sym} 5940 7000 0 0 {name=l5752 lab=BLB30}
N 5960 6960 5940 6960 {}
C {lab_pin.sym} 5940 6960 0 0 {name=l5753 lab=WL35}
N 6040 7040 6060 7040 {}
C {lab_pin.sym} 6060 7040 0 0 {name=l5754 lab=VDD}
N 6040 6960 6060 6960 {}
C {lab_pin.sym} 6060 6960 0 0 {name=l5755 lab=VSS}
C {bitcell_6t.sym} 6200 7000 0 0 {name=Xr35c31}
N 6160 7040 6140 7040 {}
C {lab_pin.sym} 6140 7040 0 0 {name=l5756 lab=BL31}
N 6160 7000 6140 7000 {}
C {lab_pin.sym} 6140 7000 0 0 {name=l5757 lab=BLB31}
N 6160 6960 6140 6960 {}
C {lab_pin.sym} 6140 6960 0 0 {name=l5758 lab=WL35}
N 6240 7040 6260 7040 {}
C {lab_pin.sym} 6260 7040 0 0 {name=l5759 lab=VDD}
N 6240 6960 6260 6960 {}
C {lab_pin.sym} 6260 6960 0 0 {name=l5760 lab=VSS}
C {bitcell_6t.sym} 0 7200 0 0 {name=Xr36c0}
N -40 7240 -60 7240 {}
C {lab_pin.sym} -60 7240 0 0 {name=l5761 lab=BL0}
N -40 7200 -60 7200 {}
C {lab_pin.sym} -60 7200 0 0 {name=l5762 lab=BLB0}
N -40 7160 -60 7160 {}
C {lab_pin.sym} -60 7160 0 0 {name=l5763 lab=WL36}
N 40 7240 60 7240 {}
C {lab_pin.sym} 60 7240 0 0 {name=l5764 lab=VDD}
N 40 7160 60 7160 {}
C {lab_pin.sym} 60 7160 0 0 {name=l5765 lab=VSS}
C {bitcell_6t.sym} 200 7200 0 0 {name=Xr36c1}
N 160 7240 140 7240 {}
C {lab_pin.sym} 140 7240 0 0 {name=l5766 lab=BL1}
N 160 7200 140 7200 {}
C {lab_pin.sym} 140 7200 0 0 {name=l5767 lab=BLB1}
N 160 7160 140 7160 {}
C {lab_pin.sym} 140 7160 0 0 {name=l5768 lab=WL36}
N 240 7240 260 7240 {}
C {lab_pin.sym} 260 7240 0 0 {name=l5769 lab=VDD}
N 240 7160 260 7160 {}
C {lab_pin.sym} 260 7160 0 0 {name=l5770 lab=VSS}
C {bitcell_6t.sym} 400 7200 0 0 {name=Xr36c2}
N 360 7240 340 7240 {}
C {lab_pin.sym} 340 7240 0 0 {name=l5771 lab=BL2}
N 360 7200 340 7200 {}
C {lab_pin.sym} 340 7200 0 0 {name=l5772 lab=BLB2}
N 360 7160 340 7160 {}
C {lab_pin.sym} 340 7160 0 0 {name=l5773 lab=WL36}
N 440 7240 460 7240 {}
C {lab_pin.sym} 460 7240 0 0 {name=l5774 lab=VDD}
N 440 7160 460 7160 {}
C {lab_pin.sym} 460 7160 0 0 {name=l5775 lab=VSS}
C {bitcell_6t.sym} 600 7200 0 0 {name=Xr36c3}
N 560 7240 540 7240 {}
C {lab_pin.sym} 540 7240 0 0 {name=l5776 lab=BL3}
N 560 7200 540 7200 {}
C {lab_pin.sym} 540 7200 0 0 {name=l5777 lab=BLB3}
N 560 7160 540 7160 {}
C {lab_pin.sym} 540 7160 0 0 {name=l5778 lab=WL36}
N 640 7240 660 7240 {}
C {lab_pin.sym} 660 7240 0 0 {name=l5779 lab=VDD}
N 640 7160 660 7160 {}
C {lab_pin.sym} 660 7160 0 0 {name=l5780 lab=VSS}
C {bitcell_6t.sym} 800 7200 0 0 {name=Xr36c4}
N 760 7240 740 7240 {}
C {lab_pin.sym} 740 7240 0 0 {name=l5781 lab=BL4}
N 760 7200 740 7200 {}
C {lab_pin.sym} 740 7200 0 0 {name=l5782 lab=BLB4}
N 760 7160 740 7160 {}
C {lab_pin.sym} 740 7160 0 0 {name=l5783 lab=WL36}
N 840 7240 860 7240 {}
C {lab_pin.sym} 860 7240 0 0 {name=l5784 lab=VDD}
N 840 7160 860 7160 {}
C {lab_pin.sym} 860 7160 0 0 {name=l5785 lab=VSS}
C {bitcell_6t.sym} 1000 7200 0 0 {name=Xr36c5}
N 960 7240 940 7240 {}
C {lab_pin.sym} 940 7240 0 0 {name=l5786 lab=BL5}
N 960 7200 940 7200 {}
C {lab_pin.sym} 940 7200 0 0 {name=l5787 lab=BLB5}
N 960 7160 940 7160 {}
C {lab_pin.sym} 940 7160 0 0 {name=l5788 lab=WL36}
N 1040 7240 1060 7240 {}
C {lab_pin.sym} 1060 7240 0 0 {name=l5789 lab=VDD}
N 1040 7160 1060 7160 {}
C {lab_pin.sym} 1060 7160 0 0 {name=l5790 lab=VSS}
C {bitcell_6t.sym} 1200 7200 0 0 {name=Xr36c6}
N 1160 7240 1140 7240 {}
C {lab_pin.sym} 1140 7240 0 0 {name=l5791 lab=BL6}
N 1160 7200 1140 7200 {}
C {lab_pin.sym} 1140 7200 0 0 {name=l5792 lab=BLB6}
N 1160 7160 1140 7160 {}
C {lab_pin.sym} 1140 7160 0 0 {name=l5793 lab=WL36}
N 1240 7240 1260 7240 {}
C {lab_pin.sym} 1260 7240 0 0 {name=l5794 lab=VDD}
N 1240 7160 1260 7160 {}
C {lab_pin.sym} 1260 7160 0 0 {name=l5795 lab=VSS}
C {bitcell_6t.sym} 1400 7200 0 0 {name=Xr36c7}
N 1360 7240 1340 7240 {}
C {lab_pin.sym} 1340 7240 0 0 {name=l5796 lab=BL7}
N 1360 7200 1340 7200 {}
C {lab_pin.sym} 1340 7200 0 0 {name=l5797 lab=BLB7}
N 1360 7160 1340 7160 {}
C {lab_pin.sym} 1340 7160 0 0 {name=l5798 lab=WL36}
N 1440 7240 1460 7240 {}
C {lab_pin.sym} 1460 7240 0 0 {name=l5799 lab=VDD}
N 1440 7160 1460 7160 {}
C {lab_pin.sym} 1460 7160 0 0 {name=l5800 lab=VSS}
C {bitcell_6t.sym} 1600 7200 0 0 {name=Xr36c8}
N 1560 7240 1540 7240 {}
C {lab_pin.sym} 1540 7240 0 0 {name=l5801 lab=BL8}
N 1560 7200 1540 7200 {}
C {lab_pin.sym} 1540 7200 0 0 {name=l5802 lab=BLB8}
N 1560 7160 1540 7160 {}
C {lab_pin.sym} 1540 7160 0 0 {name=l5803 lab=WL36}
N 1640 7240 1660 7240 {}
C {lab_pin.sym} 1660 7240 0 0 {name=l5804 lab=VDD}
N 1640 7160 1660 7160 {}
C {lab_pin.sym} 1660 7160 0 0 {name=l5805 lab=VSS}
C {bitcell_6t.sym} 1800 7200 0 0 {name=Xr36c9}
N 1760 7240 1740 7240 {}
C {lab_pin.sym} 1740 7240 0 0 {name=l5806 lab=BL9}
N 1760 7200 1740 7200 {}
C {lab_pin.sym} 1740 7200 0 0 {name=l5807 lab=BLB9}
N 1760 7160 1740 7160 {}
C {lab_pin.sym} 1740 7160 0 0 {name=l5808 lab=WL36}
N 1840 7240 1860 7240 {}
C {lab_pin.sym} 1860 7240 0 0 {name=l5809 lab=VDD}
N 1840 7160 1860 7160 {}
C {lab_pin.sym} 1860 7160 0 0 {name=l5810 lab=VSS}
C {bitcell_6t.sym} 2000 7200 0 0 {name=Xr36c10}
N 1960 7240 1940 7240 {}
C {lab_pin.sym} 1940 7240 0 0 {name=l5811 lab=BL10}
N 1960 7200 1940 7200 {}
C {lab_pin.sym} 1940 7200 0 0 {name=l5812 lab=BLB10}
N 1960 7160 1940 7160 {}
C {lab_pin.sym} 1940 7160 0 0 {name=l5813 lab=WL36}
N 2040 7240 2060 7240 {}
C {lab_pin.sym} 2060 7240 0 0 {name=l5814 lab=VDD}
N 2040 7160 2060 7160 {}
C {lab_pin.sym} 2060 7160 0 0 {name=l5815 lab=VSS}
C {bitcell_6t.sym} 2200 7200 0 0 {name=Xr36c11}
N 2160 7240 2140 7240 {}
C {lab_pin.sym} 2140 7240 0 0 {name=l5816 lab=BL11}
N 2160 7200 2140 7200 {}
C {lab_pin.sym} 2140 7200 0 0 {name=l5817 lab=BLB11}
N 2160 7160 2140 7160 {}
C {lab_pin.sym} 2140 7160 0 0 {name=l5818 lab=WL36}
N 2240 7240 2260 7240 {}
C {lab_pin.sym} 2260 7240 0 0 {name=l5819 lab=VDD}
N 2240 7160 2260 7160 {}
C {lab_pin.sym} 2260 7160 0 0 {name=l5820 lab=VSS}
C {bitcell_6t.sym} 2400 7200 0 0 {name=Xr36c12}
N 2360 7240 2340 7240 {}
C {lab_pin.sym} 2340 7240 0 0 {name=l5821 lab=BL12}
N 2360 7200 2340 7200 {}
C {lab_pin.sym} 2340 7200 0 0 {name=l5822 lab=BLB12}
N 2360 7160 2340 7160 {}
C {lab_pin.sym} 2340 7160 0 0 {name=l5823 lab=WL36}
N 2440 7240 2460 7240 {}
C {lab_pin.sym} 2460 7240 0 0 {name=l5824 lab=VDD}
N 2440 7160 2460 7160 {}
C {lab_pin.sym} 2460 7160 0 0 {name=l5825 lab=VSS}
C {bitcell_6t.sym} 2600 7200 0 0 {name=Xr36c13}
N 2560 7240 2540 7240 {}
C {lab_pin.sym} 2540 7240 0 0 {name=l5826 lab=BL13}
N 2560 7200 2540 7200 {}
C {lab_pin.sym} 2540 7200 0 0 {name=l5827 lab=BLB13}
N 2560 7160 2540 7160 {}
C {lab_pin.sym} 2540 7160 0 0 {name=l5828 lab=WL36}
N 2640 7240 2660 7240 {}
C {lab_pin.sym} 2660 7240 0 0 {name=l5829 lab=VDD}
N 2640 7160 2660 7160 {}
C {lab_pin.sym} 2660 7160 0 0 {name=l5830 lab=VSS}
C {bitcell_6t.sym} 2800 7200 0 0 {name=Xr36c14}
N 2760 7240 2740 7240 {}
C {lab_pin.sym} 2740 7240 0 0 {name=l5831 lab=BL14}
N 2760 7200 2740 7200 {}
C {lab_pin.sym} 2740 7200 0 0 {name=l5832 lab=BLB14}
N 2760 7160 2740 7160 {}
C {lab_pin.sym} 2740 7160 0 0 {name=l5833 lab=WL36}
N 2840 7240 2860 7240 {}
C {lab_pin.sym} 2860 7240 0 0 {name=l5834 lab=VDD}
N 2840 7160 2860 7160 {}
C {lab_pin.sym} 2860 7160 0 0 {name=l5835 lab=VSS}
C {bitcell_6t.sym} 3000 7200 0 0 {name=Xr36c15}
N 2960 7240 2940 7240 {}
C {lab_pin.sym} 2940 7240 0 0 {name=l5836 lab=BL15}
N 2960 7200 2940 7200 {}
C {lab_pin.sym} 2940 7200 0 0 {name=l5837 lab=BLB15}
N 2960 7160 2940 7160 {}
C {lab_pin.sym} 2940 7160 0 0 {name=l5838 lab=WL36}
N 3040 7240 3060 7240 {}
C {lab_pin.sym} 3060 7240 0 0 {name=l5839 lab=VDD}
N 3040 7160 3060 7160 {}
C {lab_pin.sym} 3060 7160 0 0 {name=l5840 lab=VSS}
C {bitcell_6t.sym} 3200 7200 0 0 {name=Xr36c16}
N 3160 7240 3140 7240 {}
C {lab_pin.sym} 3140 7240 0 0 {name=l5841 lab=BL16}
N 3160 7200 3140 7200 {}
C {lab_pin.sym} 3140 7200 0 0 {name=l5842 lab=BLB16}
N 3160 7160 3140 7160 {}
C {lab_pin.sym} 3140 7160 0 0 {name=l5843 lab=WL36}
N 3240 7240 3260 7240 {}
C {lab_pin.sym} 3260 7240 0 0 {name=l5844 lab=VDD}
N 3240 7160 3260 7160 {}
C {lab_pin.sym} 3260 7160 0 0 {name=l5845 lab=VSS}
C {bitcell_6t.sym} 3400 7200 0 0 {name=Xr36c17}
N 3360 7240 3340 7240 {}
C {lab_pin.sym} 3340 7240 0 0 {name=l5846 lab=BL17}
N 3360 7200 3340 7200 {}
C {lab_pin.sym} 3340 7200 0 0 {name=l5847 lab=BLB17}
N 3360 7160 3340 7160 {}
C {lab_pin.sym} 3340 7160 0 0 {name=l5848 lab=WL36}
N 3440 7240 3460 7240 {}
C {lab_pin.sym} 3460 7240 0 0 {name=l5849 lab=VDD}
N 3440 7160 3460 7160 {}
C {lab_pin.sym} 3460 7160 0 0 {name=l5850 lab=VSS}
C {bitcell_6t.sym} 3600 7200 0 0 {name=Xr36c18}
N 3560 7240 3540 7240 {}
C {lab_pin.sym} 3540 7240 0 0 {name=l5851 lab=BL18}
N 3560 7200 3540 7200 {}
C {lab_pin.sym} 3540 7200 0 0 {name=l5852 lab=BLB18}
N 3560 7160 3540 7160 {}
C {lab_pin.sym} 3540 7160 0 0 {name=l5853 lab=WL36}
N 3640 7240 3660 7240 {}
C {lab_pin.sym} 3660 7240 0 0 {name=l5854 lab=VDD}
N 3640 7160 3660 7160 {}
C {lab_pin.sym} 3660 7160 0 0 {name=l5855 lab=VSS}
C {bitcell_6t.sym} 3800 7200 0 0 {name=Xr36c19}
N 3760 7240 3740 7240 {}
C {lab_pin.sym} 3740 7240 0 0 {name=l5856 lab=BL19}
N 3760 7200 3740 7200 {}
C {lab_pin.sym} 3740 7200 0 0 {name=l5857 lab=BLB19}
N 3760 7160 3740 7160 {}
C {lab_pin.sym} 3740 7160 0 0 {name=l5858 lab=WL36}
N 3840 7240 3860 7240 {}
C {lab_pin.sym} 3860 7240 0 0 {name=l5859 lab=VDD}
N 3840 7160 3860 7160 {}
C {lab_pin.sym} 3860 7160 0 0 {name=l5860 lab=VSS}
C {bitcell_6t.sym} 4000 7200 0 0 {name=Xr36c20}
N 3960 7240 3940 7240 {}
C {lab_pin.sym} 3940 7240 0 0 {name=l5861 lab=BL20}
N 3960 7200 3940 7200 {}
C {lab_pin.sym} 3940 7200 0 0 {name=l5862 lab=BLB20}
N 3960 7160 3940 7160 {}
C {lab_pin.sym} 3940 7160 0 0 {name=l5863 lab=WL36}
N 4040 7240 4060 7240 {}
C {lab_pin.sym} 4060 7240 0 0 {name=l5864 lab=VDD}
N 4040 7160 4060 7160 {}
C {lab_pin.sym} 4060 7160 0 0 {name=l5865 lab=VSS}
C {bitcell_6t.sym} 4200 7200 0 0 {name=Xr36c21}
N 4160 7240 4140 7240 {}
C {lab_pin.sym} 4140 7240 0 0 {name=l5866 lab=BL21}
N 4160 7200 4140 7200 {}
C {lab_pin.sym} 4140 7200 0 0 {name=l5867 lab=BLB21}
N 4160 7160 4140 7160 {}
C {lab_pin.sym} 4140 7160 0 0 {name=l5868 lab=WL36}
N 4240 7240 4260 7240 {}
C {lab_pin.sym} 4260 7240 0 0 {name=l5869 lab=VDD}
N 4240 7160 4260 7160 {}
C {lab_pin.sym} 4260 7160 0 0 {name=l5870 lab=VSS}
C {bitcell_6t.sym} 4400 7200 0 0 {name=Xr36c22}
N 4360 7240 4340 7240 {}
C {lab_pin.sym} 4340 7240 0 0 {name=l5871 lab=BL22}
N 4360 7200 4340 7200 {}
C {lab_pin.sym} 4340 7200 0 0 {name=l5872 lab=BLB22}
N 4360 7160 4340 7160 {}
C {lab_pin.sym} 4340 7160 0 0 {name=l5873 lab=WL36}
N 4440 7240 4460 7240 {}
C {lab_pin.sym} 4460 7240 0 0 {name=l5874 lab=VDD}
N 4440 7160 4460 7160 {}
C {lab_pin.sym} 4460 7160 0 0 {name=l5875 lab=VSS}
C {bitcell_6t.sym} 4600 7200 0 0 {name=Xr36c23}
N 4560 7240 4540 7240 {}
C {lab_pin.sym} 4540 7240 0 0 {name=l5876 lab=BL23}
N 4560 7200 4540 7200 {}
C {lab_pin.sym} 4540 7200 0 0 {name=l5877 lab=BLB23}
N 4560 7160 4540 7160 {}
C {lab_pin.sym} 4540 7160 0 0 {name=l5878 lab=WL36}
N 4640 7240 4660 7240 {}
C {lab_pin.sym} 4660 7240 0 0 {name=l5879 lab=VDD}
N 4640 7160 4660 7160 {}
C {lab_pin.sym} 4660 7160 0 0 {name=l5880 lab=VSS}
C {bitcell_6t.sym} 4800 7200 0 0 {name=Xr36c24}
N 4760 7240 4740 7240 {}
C {lab_pin.sym} 4740 7240 0 0 {name=l5881 lab=BL24}
N 4760 7200 4740 7200 {}
C {lab_pin.sym} 4740 7200 0 0 {name=l5882 lab=BLB24}
N 4760 7160 4740 7160 {}
C {lab_pin.sym} 4740 7160 0 0 {name=l5883 lab=WL36}
N 4840 7240 4860 7240 {}
C {lab_pin.sym} 4860 7240 0 0 {name=l5884 lab=VDD}
N 4840 7160 4860 7160 {}
C {lab_pin.sym} 4860 7160 0 0 {name=l5885 lab=VSS}
C {bitcell_6t.sym} 5000 7200 0 0 {name=Xr36c25}
N 4960 7240 4940 7240 {}
C {lab_pin.sym} 4940 7240 0 0 {name=l5886 lab=BL25}
N 4960 7200 4940 7200 {}
C {lab_pin.sym} 4940 7200 0 0 {name=l5887 lab=BLB25}
N 4960 7160 4940 7160 {}
C {lab_pin.sym} 4940 7160 0 0 {name=l5888 lab=WL36}
N 5040 7240 5060 7240 {}
C {lab_pin.sym} 5060 7240 0 0 {name=l5889 lab=VDD}
N 5040 7160 5060 7160 {}
C {lab_pin.sym} 5060 7160 0 0 {name=l5890 lab=VSS}
C {bitcell_6t.sym} 5200 7200 0 0 {name=Xr36c26}
N 5160 7240 5140 7240 {}
C {lab_pin.sym} 5140 7240 0 0 {name=l5891 lab=BL26}
N 5160 7200 5140 7200 {}
C {lab_pin.sym} 5140 7200 0 0 {name=l5892 lab=BLB26}
N 5160 7160 5140 7160 {}
C {lab_pin.sym} 5140 7160 0 0 {name=l5893 lab=WL36}
N 5240 7240 5260 7240 {}
C {lab_pin.sym} 5260 7240 0 0 {name=l5894 lab=VDD}
N 5240 7160 5260 7160 {}
C {lab_pin.sym} 5260 7160 0 0 {name=l5895 lab=VSS}
C {bitcell_6t.sym} 5400 7200 0 0 {name=Xr36c27}
N 5360 7240 5340 7240 {}
C {lab_pin.sym} 5340 7240 0 0 {name=l5896 lab=BL27}
N 5360 7200 5340 7200 {}
C {lab_pin.sym} 5340 7200 0 0 {name=l5897 lab=BLB27}
N 5360 7160 5340 7160 {}
C {lab_pin.sym} 5340 7160 0 0 {name=l5898 lab=WL36}
N 5440 7240 5460 7240 {}
C {lab_pin.sym} 5460 7240 0 0 {name=l5899 lab=VDD}
N 5440 7160 5460 7160 {}
C {lab_pin.sym} 5460 7160 0 0 {name=l5900 lab=VSS}
C {bitcell_6t.sym} 5600 7200 0 0 {name=Xr36c28}
N 5560 7240 5540 7240 {}
C {lab_pin.sym} 5540 7240 0 0 {name=l5901 lab=BL28}
N 5560 7200 5540 7200 {}
C {lab_pin.sym} 5540 7200 0 0 {name=l5902 lab=BLB28}
N 5560 7160 5540 7160 {}
C {lab_pin.sym} 5540 7160 0 0 {name=l5903 lab=WL36}
N 5640 7240 5660 7240 {}
C {lab_pin.sym} 5660 7240 0 0 {name=l5904 lab=VDD}
N 5640 7160 5660 7160 {}
C {lab_pin.sym} 5660 7160 0 0 {name=l5905 lab=VSS}
C {bitcell_6t.sym} 5800 7200 0 0 {name=Xr36c29}
N 5760 7240 5740 7240 {}
C {lab_pin.sym} 5740 7240 0 0 {name=l5906 lab=BL29}
N 5760 7200 5740 7200 {}
C {lab_pin.sym} 5740 7200 0 0 {name=l5907 lab=BLB29}
N 5760 7160 5740 7160 {}
C {lab_pin.sym} 5740 7160 0 0 {name=l5908 lab=WL36}
N 5840 7240 5860 7240 {}
C {lab_pin.sym} 5860 7240 0 0 {name=l5909 lab=VDD}
N 5840 7160 5860 7160 {}
C {lab_pin.sym} 5860 7160 0 0 {name=l5910 lab=VSS}
C {bitcell_6t.sym} 6000 7200 0 0 {name=Xr36c30}
N 5960 7240 5940 7240 {}
C {lab_pin.sym} 5940 7240 0 0 {name=l5911 lab=BL30}
N 5960 7200 5940 7200 {}
C {lab_pin.sym} 5940 7200 0 0 {name=l5912 lab=BLB30}
N 5960 7160 5940 7160 {}
C {lab_pin.sym} 5940 7160 0 0 {name=l5913 lab=WL36}
N 6040 7240 6060 7240 {}
C {lab_pin.sym} 6060 7240 0 0 {name=l5914 lab=VDD}
N 6040 7160 6060 7160 {}
C {lab_pin.sym} 6060 7160 0 0 {name=l5915 lab=VSS}
C {bitcell_6t.sym} 6200 7200 0 0 {name=Xr36c31}
N 6160 7240 6140 7240 {}
C {lab_pin.sym} 6140 7240 0 0 {name=l5916 lab=BL31}
N 6160 7200 6140 7200 {}
C {lab_pin.sym} 6140 7200 0 0 {name=l5917 lab=BLB31}
N 6160 7160 6140 7160 {}
C {lab_pin.sym} 6140 7160 0 0 {name=l5918 lab=WL36}
N 6240 7240 6260 7240 {}
C {lab_pin.sym} 6260 7240 0 0 {name=l5919 lab=VDD}
N 6240 7160 6260 7160 {}
C {lab_pin.sym} 6260 7160 0 0 {name=l5920 lab=VSS}
C {bitcell_6t.sym} 0 7400 0 0 {name=Xr37c0}
N -40 7440 -60 7440 {}
C {lab_pin.sym} -60 7440 0 0 {name=l5921 lab=BL0}
N -40 7400 -60 7400 {}
C {lab_pin.sym} -60 7400 0 0 {name=l5922 lab=BLB0}
N -40 7360 -60 7360 {}
C {lab_pin.sym} -60 7360 0 0 {name=l5923 lab=WL37}
N 40 7440 60 7440 {}
C {lab_pin.sym} 60 7440 0 0 {name=l5924 lab=VDD}
N 40 7360 60 7360 {}
C {lab_pin.sym} 60 7360 0 0 {name=l5925 lab=VSS}
C {bitcell_6t.sym} 200 7400 0 0 {name=Xr37c1}
N 160 7440 140 7440 {}
C {lab_pin.sym} 140 7440 0 0 {name=l5926 lab=BL1}
N 160 7400 140 7400 {}
C {lab_pin.sym} 140 7400 0 0 {name=l5927 lab=BLB1}
N 160 7360 140 7360 {}
C {lab_pin.sym} 140 7360 0 0 {name=l5928 lab=WL37}
N 240 7440 260 7440 {}
C {lab_pin.sym} 260 7440 0 0 {name=l5929 lab=VDD}
N 240 7360 260 7360 {}
C {lab_pin.sym} 260 7360 0 0 {name=l5930 lab=VSS}
C {bitcell_6t.sym} 400 7400 0 0 {name=Xr37c2}
N 360 7440 340 7440 {}
C {lab_pin.sym} 340 7440 0 0 {name=l5931 lab=BL2}
N 360 7400 340 7400 {}
C {lab_pin.sym} 340 7400 0 0 {name=l5932 lab=BLB2}
N 360 7360 340 7360 {}
C {lab_pin.sym} 340 7360 0 0 {name=l5933 lab=WL37}
N 440 7440 460 7440 {}
C {lab_pin.sym} 460 7440 0 0 {name=l5934 lab=VDD}
N 440 7360 460 7360 {}
C {lab_pin.sym} 460 7360 0 0 {name=l5935 lab=VSS}
C {bitcell_6t.sym} 600 7400 0 0 {name=Xr37c3}
N 560 7440 540 7440 {}
C {lab_pin.sym} 540 7440 0 0 {name=l5936 lab=BL3}
N 560 7400 540 7400 {}
C {lab_pin.sym} 540 7400 0 0 {name=l5937 lab=BLB3}
N 560 7360 540 7360 {}
C {lab_pin.sym} 540 7360 0 0 {name=l5938 lab=WL37}
N 640 7440 660 7440 {}
C {lab_pin.sym} 660 7440 0 0 {name=l5939 lab=VDD}
N 640 7360 660 7360 {}
C {lab_pin.sym} 660 7360 0 0 {name=l5940 lab=VSS}
C {bitcell_6t.sym} 800 7400 0 0 {name=Xr37c4}
N 760 7440 740 7440 {}
C {lab_pin.sym} 740 7440 0 0 {name=l5941 lab=BL4}
N 760 7400 740 7400 {}
C {lab_pin.sym} 740 7400 0 0 {name=l5942 lab=BLB4}
N 760 7360 740 7360 {}
C {lab_pin.sym} 740 7360 0 0 {name=l5943 lab=WL37}
N 840 7440 860 7440 {}
C {lab_pin.sym} 860 7440 0 0 {name=l5944 lab=VDD}
N 840 7360 860 7360 {}
C {lab_pin.sym} 860 7360 0 0 {name=l5945 lab=VSS}
C {bitcell_6t.sym} 1000 7400 0 0 {name=Xr37c5}
N 960 7440 940 7440 {}
C {lab_pin.sym} 940 7440 0 0 {name=l5946 lab=BL5}
N 960 7400 940 7400 {}
C {lab_pin.sym} 940 7400 0 0 {name=l5947 lab=BLB5}
N 960 7360 940 7360 {}
C {lab_pin.sym} 940 7360 0 0 {name=l5948 lab=WL37}
N 1040 7440 1060 7440 {}
C {lab_pin.sym} 1060 7440 0 0 {name=l5949 lab=VDD}
N 1040 7360 1060 7360 {}
C {lab_pin.sym} 1060 7360 0 0 {name=l5950 lab=VSS}
C {bitcell_6t.sym} 1200 7400 0 0 {name=Xr37c6}
N 1160 7440 1140 7440 {}
C {lab_pin.sym} 1140 7440 0 0 {name=l5951 lab=BL6}
N 1160 7400 1140 7400 {}
C {lab_pin.sym} 1140 7400 0 0 {name=l5952 lab=BLB6}
N 1160 7360 1140 7360 {}
C {lab_pin.sym} 1140 7360 0 0 {name=l5953 lab=WL37}
N 1240 7440 1260 7440 {}
C {lab_pin.sym} 1260 7440 0 0 {name=l5954 lab=VDD}
N 1240 7360 1260 7360 {}
C {lab_pin.sym} 1260 7360 0 0 {name=l5955 lab=VSS}
C {bitcell_6t.sym} 1400 7400 0 0 {name=Xr37c7}
N 1360 7440 1340 7440 {}
C {lab_pin.sym} 1340 7440 0 0 {name=l5956 lab=BL7}
N 1360 7400 1340 7400 {}
C {lab_pin.sym} 1340 7400 0 0 {name=l5957 lab=BLB7}
N 1360 7360 1340 7360 {}
C {lab_pin.sym} 1340 7360 0 0 {name=l5958 lab=WL37}
N 1440 7440 1460 7440 {}
C {lab_pin.sym} 1460 7440 0 0 {name=l5959 lab=VDD}
N 1440 7360 1460 7360 {}
C {lab_pin.sym} 1460 7360 0 0 {name=l5960 lab=VSS}
C {bitcell_6t.sym} 1600 7400 0 0 {name=Xr37c8}
N 1560 7440 1540 7440 {}
C {lab_pin.sym} 1540 7440 0 0 {name=l5961 lab=BL8}
N 1560 7400 1540 7400 {}
C {lab_pin.sym} 1540 7400 0 0 {name=l5962 lab=BLB8}
N 1560 7360 1540 7360 {}
C {lab_pin.sym} 1540 7360 0 0 {name=l5963 lab=WL37}
N 1640 7440 1660 7440 {}
C {lab_pin.sym} 1660 7440 0 0 {name=l5964 lab=VDD}
N 1640 7360 1660 7360 {}
C {lab_pin.sym} 1660 7360 0 0 {name=l5965 lab=VSS}
C {bitcell_6t.sym} 1800 7400 0 0 {name=Xr37c9}
N 1760 7440 1740 7440 {}
C {lab_pin.sym} 1740 7440 0 0 {name=l5966 lab=BL9}
N 1760 7400 1740 7400 {}
C {lab_pin.sym} 1740 7400 0 0 {name=l5967 lab=BLB9}
N 1760 7360 1740 7360 {}
C {lab_pin.sym} 1740 7360 0 0 {name=l5968 lab=WL37}
N 1840 7440 1860 7440 {}
C {lab_pin.sym} 1860 7440 0 0 {name=l5969 lab=VDD}
N 1840 7360 1860 7360 {}
C {lab_pin.sym} 1860 7360 0 0 {name=l5970 lab=VSS}
C {bitcell_6t.sym} 2000 7400 0 0 {name=Xr37c10}
N 1960 7440 1940 7440 {}
C {lab_pin.sym} 1940 7440 0 0 {name=l5971 lab=BL10}
N 1960 7400 1940 7400 {}
C {lab_pin.sym} 1940 7400 0 0 {name=l5972 lab=BLB10}
N 1960 7360 1940 7360 {}
C {lab_pin.sym} 1940 7360 0 0 {name=l5973 lab=WL37}
N 2040 7440 2060 7440 {}
C {lab_pin.sym} 2060 7440 0 0 {name=l5974 lab=VDD}
N 2040 7360 2060 7360 {}
C {lab_pin.sym} 2060 7360 0 0 {name=l5975 lab=VSS}
C {bitcell_6t.sym} 2200 7400 0 0 {name=Xr37c11}
N 2160 7440 2140 7440 {}
C {lab_pin.sym} 2140 7440 0 0 {name=l5976 lab=BL11}
N 2160 7400 2140 7400 {}
C {lab_pin.sym} 2140 7400 0 0 {name=l5977 lab=BLB11}
N 2160 7360 2140 7360 {}
C {lab_pin.sym} 2140 7360 0 0 {name=l5978 lab=WL37}
N 2240 7440 2260 7440 {}
C {lab_pin.sym} 2260 7440 0 0 {name=l5979 lab=VDD}
N 2240 7360 2260 7360 {}
C {lab_pin.sym} 2260 7360 0 0 {name=l5980 lab=VSS}
C {bitcell_6t.sym} 2400 7400 0 0 {name=Xr37c12}
N 2360 7440 2340 7440 {}
C {lab_pin.sym} 2340 7440 0 0 {name=l5981 lab=BL12}
N 2360 7400 2340 7400 {}
C {lab_pin.sym} 2340 7400 0 0 {name=l5982 lab=BLB12}
N 2360 7360 2340 7360 {}
C {lab_pin.sym} 2340 7360 0 0 {name=l5983 lab=WL37}
N 2440 7440 2460 7440 {}
C {lab_pin.sym} 2460 7440 0 0 {name=l5984 lab=VDD}
N 2440 7360 2460 7360 {}
C {lab_pin.sym} 2460 7360 0 0 {name=l5985 lab=VSS}
C {bitcell_6t.sym} 2600 7400 0 0 {name=Xr37c13}
N 2560 7440 2540 7440 {}
C {lab_pin.sym} 2540 7440 0 0 {name=l5986 lab=BL13}
N 2560 7400 2540 7400 {}
C {lab_pin.sym} 2540 7400 0 0 {name=l5987 lab=BLB13}
N 2560 7360 2540 7360 {}
C {lab_pin.sym} 2540 7360 0 0 {name=l5988 lab=WL37}
N 2640 7440 2660 7440 {}
C {lab_pin.sym} 2660 7440 0 0 {name=l5989 lab=VDD}
N 2640 7360 2660 7360 {}
C {lab_pin.sym} 2660 7360 0 0 {name=l5990 lab=VSS}
C {bitcell_6t.sym} 2800 7400 0 0 {name=Xr37c14}
N 2760 7440 2740 7440 {}
C {lab_pin.sym} 2740 7440 0 0 {name=l5991 lab=BL14}
N 2760 7400 2740 7400 {}
C {lab_pin.sym} 2740 7400 0 0 {name=l5992 lab=BLB14}
N 2760 7360 2740 7360 {}
C {lab_pin.sym} 2740 7360 0 0 {name=l5993 lab=WL37}
N 2840 7440 2860 7440 {}
C {lab_pin.sym} 2860 7440 0 0 {name=l5994 lab=VDD}
N 2840 7360 2860 7360 {}
C {lab_pin.sym} 2860 7360 0 0 {name=l5995 lab=VSS}
C {bitcell_6t.sym} 3000 7400 0 0 {name=Xr37c15}
N 2960 7440 2940 7440 {}
C {lab_pin.sym} 2940 7440 0 0 {name=l5996 lab=BL15}
N 2960 7400 2940 7400 {}
C {lab_pin.sym} 2940 7400 0 0 {name=l5997 lab=BLB15}
N 2960 7360 2940 7360 {}
C {lab_pin.sym} 2940 7360 0 0 {name=l5998 lab=WL37}
N 3040 7440 3060 7440 {}
C {lab_pin.sym} 3060 7440 0 0 {name=l5999 lab=VDD}
N 3040 7360 3060 7360 {}
C {lab_pin.sym} 3060 7360 0 0 {name=l6000 lab=VSS}
C {bitcell_6t.sym} 3200 7400 0 0 {name=Xr37c16}
N 3160 7440 3140 7440 {}
C {lab_pin.sym} 3140 7440 0 0 {name=l6001 lab=BL16}
N 3160 7400 3140 7400 {}
C {lab_pin.sym} 3140 7400 0 0 {name=l6002 lab=BLB16}
N 3160 7360 3140 7360 {}
C {lab_pin.sym} 3140 7360 0 0 {name=l6003 lab=WL37}
N 3240 7440 3260 7440 {}
C {lab_pin.sym} 3260 7440 0 0 {name=l6004 lab=VDD}
N 3240 7360 3260 7360 {}
C {lab_pin.sym} 3260 7360 0 0 {name=l6005 lab=VSS}
C {bitcell_6t.sym} 3400 7400 0 0 {name=Xr37c17}
N 3360 7440 3340 7440 {}
C {lab_pin.sym} 3340 7440 0 0 {name=l6006 lab=BL17}
N 3360 7400 3340 7400 {}
C {lab_pin.sym} 3340 7400 0 0 {name=l6007 lab=BLB17}
N 3360 7360 3340 7360 {}
C {lab_pin.sym} 3340 7360 0 0 {name=l6008 lab=WL37}
N 3440 7440 3460 7440 {}
C {lab_pin.sym} 3460 7440 0 0 {name=l6009 lab=VDD}
N 3440 7360 3460 7360 {}
C {lab_pin.sym} 3460 7360 0 0 {name=l6010 lab=VSS}
C {bitcell_6t.sym} 3600 7400 0 0 {name=Xr37c18}
N 3560 7440 3540 7440 {}
C {lab_pin.sym} 3540 7440 0 0 {name=l6011 lab=BL18}
N 3560 7400 3540 7400 {}
C {lab_pin.sym} 3540 7400 0 0 {name=l6012 lab=BLB18}
N 3560 7360 3540 7360 {}
C {lab_pin.sym} 3540 7360 0 0 {name=l6013 lab=WL37}
N 3640 7440 3660 7440 {}
C {lab_pin.sym} 3660 7440 0 0 {name=l6014 lab=VDD}
N 3640 7360 3660 7360 {}
C {lab_pin.sym} 3660 7360 0 0 {name=l6015 lab=VSS}
C {bitcell_6t.sym} 3800 7400 0 0 {name=Xr37c19}
N 3760 7440 3740 7440 {}
C {lab_pin.sym} 3740 7440 0 0 {name=l6016 lab=BL19}
N 3760 7400 3740 7400 {}
C {lab_pin.sym} 3740 7400 0 0 {name=l6017 lab=BLB19}
N 3760 7360 3740 7360 {}
C {lab_pin.sym} 3740 7360 0 0 {name=l6018 lab=WL37}
N 3840 7440 3860 7440 {}
C {lab_pin.sym} 3860 7440 0 0 {name=l6019 lab=VDD}
N 3840 7360 3860 7360 {}
C {lab_pin.sym} 3860 7360 0 0 {name=l6020 lab=VSS}
C {bitcell_6t.sym} 4000 7400 0 0 {name=Xr37c20}
N 3960 7440 3940 7440 {}
C {lab_pin.sym} 3940 7440 0 0 {name=l6021 lab=BL20}
N 3960 7400 3940 7400 {}
C {lab_pin.sym} 3940 7400 0 0 {name=l6022 lab=BLB20}
N 3960 7360 3940 7360 {}
C {lab_pin.sym} 3940 7360 0 0 {name=l6023 lab=WL37}
N 4040 7440 4060 7440 {}
C {lab_pin.sym} 4060 7440 0 0 {name=l6024 lab=VDD}
N 4040 7360 4060 7360 {}
C {lab_pin.sym} 4060 7360 0 0 {name=l6025 lab=VSS}
C {bitcell_6t.sym} 4200 7400 0 0 {name=Xr37c21}
N 4160 7440 4140 7440 {}
C {lab_pin.sym} 4140 7440 0 0 {name=l6026 lab=BL21}
N 4160 7400 4140 7400 {}
C {lab_pin.sym} 4140 7400 0 0 {name=l6027 lab=BLB21}
N 4160 7360 4140 7360 {}
C {lab_pin.sym} 4140 7360 0 0 {name=l6028 lab=WL37}
N 4240 7440 4260 7440 {}
C {lab_pin.sym} 4260 7440 0 0 {name=l6029 lab=VDD}
N 4240 7360 4260 7360 {}
C {lab_pin.sym} 4260 7360 0 0 {name=l6030 lab=VSS}
C {bitcell_6t.sym} 4400 7400 0 0 {name=Xr37c22}
N 4360 7440 4340 7440 {}
C {lab_pin.sym} 4340 7440 0 0 {name=l6031 lab=BL22}
N 4360 7400 4340 7400 {}
C {lab_pin.sym} 4340 7400 0 0 {name=l6032 lab=BLB22}
N 4360 7360 4340 7360 {}
C {lab_pin.sym} 4340 7360 0 0 {name=l6033 lab=WL37}
N 4440 7440 4460 7440 {}
C {lab_pin.sym} 4460 7440 0 0 {name=l6034 lab=VDD}
N 4440 7360 4460 7360 {}
C {lab_pin.sym} 4460 7360 0 0 {name=l6035 lab=VSS}
C {bitcell_6t.sym} 4600 7400 0 0 {name=Xr37c23}
N 4560 7440 4540 7440 {}
C {lab_pin.sym} 4540 7440 0 0 {name=l6036 lab=BL23}
N 4560 7400 4540 7400 {}
C {lab_pin.sym} 4540 7400 0 0 {name=l6037 lab=BLB23}
N 4560 7360 4540 7360 {}
C {lab_pin.sym} 4540 7360 0 0 {name=l6038 lab=WL37}
N 4640 7440 4660 7440 {}
C {lab_pin.sym} 4660 7440 0 0 {name=l6039 lab=VDD}
N 4640 7360 4660 7360 {}
C {lab_pin.sym} 4660 7360 0 0 {name=l6040 lab=VSS}
C {bitcell_6t.sym} 4800 7400 0 0 {name=Xr37c24}
N 4760 7440 4740 7440 {}
C {lab_pin.sym} 4740 7440 0 0 {name=l6041 lab=BL24}
N 4760 7400 4740 7400 {}
C {lab_pin.sym} 4740 7400 0 0 {name=l6042 lab=BLB24}
N 4760 7360 4740 7360 {}
C {lab_pin.sym} 4740 7360 0 0 {name=l6043 lab=WL37}
N 4840 7440 4860 7440 {}
C {lab_pin.sym} 4860 7440 0 0 {name=l6044 lab=VDD}
N 4840 7360 4860 7360 {}
C {lab_pin.sym} 4860 7360 0 0 {name=l6045 lab=VSS}
C {bitcell_6t.sym} 5000 7400 0 0 {name=Xr37c25}
N 4960 7440 4940 7440 {}
C {lab_pin.sym} 4940 7440 0 0 {name=l6046 lab=BL25}
N 4960 7400 4940 7400 {}
C {lab_pin.sym} 4940 7400 0 0 {name=l6047 lab=BLB25}
N 4960 7360 4940 7360 {}
C {lab_pin.sym} 4940 7360 0 0 {name=l6048 lab=WL37}
N 5040 7440 5060 7440 {}
C {lab_pin.sym} 5060 7440 0 0 {name=l6049 lab=VDD}
N 5040 7360 5060 7360 {}
C {lab_pin.sym} 5060 7360 0 0 {name=l6050 lab=VSS}
C {bitcell_6t.sym} 5200 7400 0 0 {name=Xr37c26}
N 5160 7440 5140 7440 {}
C {lab_pin.sym} 5140 7440 0 0 {name=l6051 lab=BL26}
N 5160 7400 5140 7400 {}
C {lab_pin.sym} 5140 7400 0 0 {name=l6052 lab=BLB26}
N 5160 7360 5140 7360 {}
C {lab_pin.sym} 5140 7360 0 0 {name=l6053 lab=WL37}
N 5240 7440 5260 7440 {}
C {lab_pin.sym} 5260 7440 0 0 {name=l6054 lab=VDD}
N 5240 7360 5260 7360 {}
C {lab_pin.sym} 5260 7360 0 0 {name=l6055 lab=VSS}
C {bitcell_6t.sym} 5400 7400 0 0 {name=Xr37c27}
N 5360 7440 5340 7440 {}
C {lab_pin.sym} 5340 7440 0 0 {name=l6056 lab=BL27}
N 5360 7400 5340 7400 {}
C {lab_pin.sym} 5340 7400 0 0 {name=l6057 lab=BLB27}
N 5360 7360 5340 7360 {}
C {lab_pin.sym} 5340 7360 0 0 {name=l6058 lab=WL37}
N 5440 7440 5460 7440 {}
C {lab_pin.sym} 5460 7440 0 0 {name=l6059 lab=VDD}
N 5440 7360 5460 7360 {}
C {lab_pin.sym} 5460 7360 0 0 {name=l6060 lab=VSS}
C {bitcell_6t.sym} 5600 7400 0 0 {name=Xr37c28}
N 5560 7440 5540 7440 {}
C {lab_pin.sym} 5540 7440 0 0 {name=l6061 lab=BL28}
N 5560 7400 5540 7400 {}
C {lab_pin.sym} 5540 7400 0 0 {name=l6062 lab=BLB28}
N 5560 7360 5540 7360 {}
C {lab_pin.sym} 5540 7360 0 0 {name=l6063 lab=WL37}
N 5640 7440 5660 7440 {}
C {lab_pin.sym} 5660 7440 0 0 {name=l6064 lab=VDD}
N 5640 7360 5660 7360 {}
C {lab_pin.sym} 5660 7360 0 0 {name=l6065 lab=VSS}
C {bitcell_6t.sym} 5800 7400 0 0 {name=Xr37c29}
N 5760 7440 5740 7440 {}
C {lab_pin.sym} 5740 7440 0 0 {name=l6066 lab=BL29}
N 5760 7400 5740 7400 {}
C {lab_pin.sym} 5740 7400 0 0 {name=l6067 lab=BLB29}
N 5760 7360 5740 7360 {}
C {lab_pin.sym} 5740 7360 0 0 {name=l6068 lab=WL37}
N 5840 7440 5860 7440 {}
C {lab_pin.sym} 5860 7440 0 0 {name=l6069 lab=VDD}
N 5840 7360 5860 7360 {}
C {lab_pin.sym} 5860 7360 0 0 {name=l6070 lab=VSS}
C {bitcell_6t.sym} 6000 7400 0 0 {name=Xr37c30}
N 5960 7440 5940 7440 {}
C {lab_pin.sym} 5940 7440 0 0 {name=l6071 lab=BL30}
N 5960 7400 5940 7400 {}
C {lab_pin.sym} 5940 7400 0 0 {name=l6072 lab=BLB30}
N 5960 7360 5940 7360 {}
C {lab_pin.sym} 5940 7360 0 0 {name=l6073 lab=WL37}
N 6040 7440 6060 7440 {}
C {lab_pin.sym} 6060 7440 0 0 {name=l6074 lab=VDD}
N 6040 7360 6060 7360 {}
C {lab_pin.sym} 6060 7360 0 0 {name=l6075 lab=VSS}
C {bitcell_6t.sym} 6200 7400 0 0 {name=Xr37c31}
N 6160 7440 6140 7440 {}
C {lab_pin.sym} 6140 7440 0 0 {name=l6076 lab=BL31}
N 6160 7400 6140 7400 {}
C {lab_pin.sym} 6140 7400 0 0 {name=l6077 lab=BLB31}
N 6160 7360 6140 7360 {}
C {lab_pin.sym} 6140 7360 0 0 {name=l6078 lab=WL37}
N 6240 7440 6260 7440 {}
C {lab_pin.sym} 6260 7440 0 0 {name=l6079 lab=VDD}
N 6240 7360 6260 7360 {}
C {lab_pin.sym} 6260 7360 0 0 {name=l6080 lab=VSS}
C {bitcell_6t.sym} 0 7600 0 0 {name=Xr38c0}
N -40 7640 -60 7640 {}
C {lab_pin.sym} -60 7640 0 0 {name=l6081 lab=BL0}
N -40 7600 -60 7600 {}
C {lab_pin.sym} -60 7600 0 0 {name=l6082 lab=BLB0}
N -40 7560 -60 7560 {}
C {lab_pin.sym} -60 7560 0 0 {name=l6083 lab=WL38}
N 40 7640 60 7640 {}
C {lab_pin.sym} 60 7640 0 0 {name=l6084 lab=VDD}
N 40 7560 60 7560 {}
C {lab_pin.sym} 60 7560 0 0 {name=l6085 lab=VSS}
C {bitcell_6t.sym} 200 7600 0 0 {name=Xr38c1}
N 160 7640 140 7640 {}
C {lab_pin.sym} 140 7640 0 0 {name=l6086 lab=BL1}
N 160 7600 140 7600 {}
C {lab_pin.sym} 140 7600 0 0 {name=l6087 lab=BLB1}
N 160 7560 140 7560 {}
C {lab_pin.sym} 140 7560 0 0 {name=l6088 lab=WL38}
N 240 7640 260 7640 {}
C {lab_pin.sym} 260 7640 0 0 {name=l6089 lab=VDD}
N 240 7560 260 7560 {}
C {lab_pin.sym} 260 7560 0 0 {name=l6090 lab=VSS}
C {bitcell_6t.sym} 400 7600 0 0 {name=Xr38c2}
N 360 7640 340 7640 {}
C {lab_pin.sym} 340 7640 0 0 {name=l6091 lab=BL2}
N 360 7600 340 7600 {}
C {lab_pin.sym} 340 7600 0 0 {name=l6092 lab=BLB2}
N 360 7560 340 7560 {}
C {lab_pin.sym} 340 7560 0 0 {name=l6093 lab=WL38}
N 440 7640 460 7640 {}
C {lab_pin.sym} 460 7640 0 0 {name=l6094 lab=VDD}
N 440 7560 460 7560 {}
C {lab_pin.sym} 460 7560 0 0 {name=l6095 lab=VSS}
C {bitcell_6t.sym} 600 7600 0 0 {name=Xr38c3}
N 560 7640 540 7640 {}
C {lab_pin.sym} 540 7640 0 0 {name=l6096 lab=BL3}
N 560 7600 540 7600 {}
C {lab_pin.sym} 540 7600 0 0 {name=l6097 lab=BLB3}
N 560 7560 540 7560 {}
C {lab_pin.sym} 540 7560 0 0 {name=l6098 lab=WL38}
N 640 7640 660 7640 {}
C {lab_pin.sym} 660 7640 0 0 {name=l6099 lab=VDD}
N 640 7560 660 7560 {}
C {lab_pin.sym} 660 7560 0 0 {name=l6100 lab=VSS}
C {bitcell_6t.sym} 800 7600 0 0 {name=Xr38c4}
N 760 7640 740 7640 {}
C {lab_pin.sym} 740 7640 0 0 {name=l6101 lab=BL4}
N 760 7600 740 7600 {}
C {lab_pin.sym} 740 7600 0 0 {name=l6102 lab=BLB4}
N 760 7560 740 7560 {}
C {lab_pin.sym} 740 7560 0 0 {name=l6103 lab=WL38}
N 840 7640 860 7640 {}
C {lab_pin.sym} 860 7640 0 0 {name=l6104 lab=VDD}
N 840 7560 860 7560 {}
C {lab_pin.sym} 860 7560 0 0 {name=l6105 lab=VSS}
C {bitcell_6t.sym} 1000 7600 0 0 {name=Xr38c5}
N 960 7640 940 7640 {}
C {lab_pin.sym} 940 7640 0 0 {name=l6106 lab=BL5}
N 960 7600 940 7600 {}
C {lab_pin.sym} 940 7600 0 0 {name=l6107 lab=BLB5}
N 960 7560 940 7560 {}
C {lab_pin.sym} 940 7560 0 0 {name=l6108 lab=WL38}
N 1040 7640 1060 7640 {}
C {lab_pin.sym} 1060 7640 0 0 {name=l6109 lab=VDD}
N 1040 7560 1060 7560 {}
C {lab_pin.sym} 1060 7560 0 0 {name=l6110 lab=VSS}
C {bitcell_6t.sym} 1200 7600 0 0 {name=Xr38c6}
N 1160 7640 1140 7640 {}
C {lab_pin.sym} 1140 7640 0 0 {name=l6111 lab=BL6}
N 1160 7600 1140 7600 {}
C {lab_pin.sym} 1140 7600 0 0 {name=l6112 lab=BLB6}
N 1160 7560 1140 7560 {}
C {lab_pin.sym} 1140 7560 0 0 {name=l6113 lab=WL38}
N 1240 7640 1260 7640 {}
C {lab_pin.sym} 1260 7640 0 0 {name=l6114 lab=VDD}
N 1240 7560 1260 7560 {}
C {lab_pin.sym} 1260 7560 0 0 {name=l6115 lab=VSS}
C {bitcell_6t.sym} 1400 7600 0 0 {name=Xr38c7}
N 1360 7640 1340 7640 {}
C {lab_pin.sym} 1340 7640 0 0 {name=l6116 lab=BL7}
N 1360 7600 1340 7600 {}
C {lab_pin.sym} 1340 7600 0 0 {name=l6117 lab=BLB7}
N 1360 7560 1340 7560 {}
C {lab_pin.sym} 1340 7560 0 0 {name=l6118 lab=WL38}
N 1440 7640 1460 7640 {}
C {lab_pin.sym} 1460 7640 0 0 {name=l6119 lab=VDD}
N 1440 7560 1460 7560 {}
C {lab_pin.sym} 1460 7560 0 0 {name=l6120 lab=VSS}
C {bitcell_6t.sym} 1600 7600 0 0 {name=Xr38c8}
N 1560 7640 1540 7640 {}
C {lab_pin.sym} 1540 7640 0 0 {name=l6121 lab=BL8}
N 1560 7600 1540 7600 {}
C {lab_pin.sym} 1540 7600 0 0 {name=l6122 lab=BLB8}
N 1560 7560 1540 7560 {}
C {lab_pin.sym} 1540 7560 0 0 {name=l6123 lab=WL38}
N 1640 7640 1660 7640 {}
C {lab_pin.sym} 1660 7640 0 0 {name=l6124 lab=VDD}
N 1640 7560 1660 7560 {}
C {lab_pin.sym} 1660 7560 0 0 {name=l6125 lab=VSS}
C {bitcell_6t.sym} 1800 7600 0 0 {name=Xr38c9}
N 1760 7640 1740 7640 {}
C {lab_pin.sym} 1740 7640 0 0 {name=l6126 lab=BL9}
N 1760 7600 1740 7600 {}
C {lab_pin.sym} 1740 7600 0 0 {name=l6127 lab=BLB9}
N 1760 7560 1740 7560 {}
C {lab_pin.sym} 1740 7560 0 0 {name=l6128 lab=WL38}
N 1840 7640 1860 7640 {}
C {lab_pin.sym} 1860 7640 0 0 {name=l6129 lab=VDD}
N 1840 7560 1860 7560 {}
C {lab_pin.sym} 1860 7560 0 0 {name=l6130 lab=VSS}
C {bitcell_6t.sym} 2000 7600 0 0 {name=Xr38c10}
N 1960 7640 1940 7640 {}
C {lab_pin.sym} 1940 7640 0 0 {name=l6131 lab=BL10}
N 1960 7600 1940 7600 {}
C {lab_pin.sym} 1940 7600 0 0 {name=l6132 lab=BLB10}
N 1960 7560 1940 7560 {}
C {lab_pin.sym} 1940 7560 0 0 {name=l6133 lab=WL38}
N 2040 7640 2060 7640 {}
C {lab_pin.sym} 2060 7640 0 0 {name=l6134 lab=VDD}
N 2040 7560 2060 7560 {}
C {lab_pin.sym} 2060 7560 0 0 {name=l6135 lab=VSS}
C {bitcell_6t.sym} 2200 7600 0 0 {name=Xr38c11}
N 2160 7640 2140 7640 {}
C {lab_pin.sym} 2140 7640 0 0 {name=l6136 lab=BL11}
N 2160 7600 2140 7600 {}
C {lab_pin.sym} 2140 7600 0 0 {name=l6137 lab=BLB11}
N 2160 7560 2140 7560 {}
C {lab_pin.sym} 2140 7560 0 0 {name=l6138 lab=WL38}
N 2240 7640 2260 7640 {}
C {lab_pin.sym} 2260 7640 0 0 {name=l6139 lab=VDD}
N 2240 7560 2260 7560 {}
C {lab_pin.sym} 2260 7560 0 0 {name=l6140 lab=VSS}
C {bitcell_6t.sym} 2400 7600 0 0 {name=Xr38c12}
N 2360 7640 2340 7640 {}
C {lab_pin.sym} 2340 7640 0 0 {name=l6141 lab=BL12}
N 2360 7600 2340 7600 {}
C {lab_pin.sym} 2340 7600 0 0 {name=l6142 lab=BLB12}
N 2360 7560 2340 7560 {}
C {lab_pin.sym} 2340 7560 0 0 {name=l6143 lab=WL38}
N 2440 7640 2460 7640 {}
C {lab_pin.sym} 2460 7640 0 0 {name=l6144 lab=VDD}
N 2440 7560 2460 7560 {}
C {lab_pin.sym} 2460 7560 0 0 {name=l6145 lab=VSS}
C {bitcell_6t.sym} 2600 7600 0 0 {name=Xr38c13}
N 2560 7640 2540 7640 {}
C {lab_pin.sym} 2540 7640 0 0 {name=l6146 lab=BL13}
N 2560 7600 2540 7600 {}
C {lab_pin.sym} 2540 7600 0 0 {name=l6147 lab=BLB13}
N 2560 7560 2540 7560 {}
C {lab_pin.sym} 2540 7560 0 0 {name=l6148 lab=WL38}
N 2640 7640 2660 7640 {}
C {lab_pin.sym} 2660 7640 0 0 {name=l6149 lab=VDD}
N 2640 7560 2660 7560 {}
C {lab_pin.sym} 2660 7560 0 0 {name=l6150 lab=VSS}
C {bitcell_6t.sym} 2800 7600 0 0 {name=Xr38c14}
N 2760 7640 2740 7640 {}
C {lab_pin.sym} 2740 7640 0 0 {name=l6151 lab=BL14}
N 2760 7600 2740 7600 {}
C {lab_pin.sym} 2740 7600 0 0 {name=l6152 lab=BLB14}
N 2760 7560 2740 7560 {}
C {lab_pin.sym} 2740 7560 0 0 {name=l6153 lab=WL38}
N 2840 7640 2860 7640 {}
C {lab_pin.sym} 2860 7640 0 0 {name=l6154 lab=VDD}
N 2840 7560 2860 7560 {}
C {lab_pin.sym} 2860 7560 0 0 {name=l6155 lab=VSS}
C {bitcell_6t.sym} 3000 7600 0 0 {name=Xr38c15}
N 2960 7640 2940 7640 {}
C {lab_pin.sym} 2940 7640 0 0 {name=l6156 lab=BL15}
N 2960 7600 2940 7600 {}
C {lab_pin.sym} 2940 7600 0 0 {name=l6157 lab=BLB15}
N 2960 7560 2940 7560 {}
C {lab_pin.sym} 2940 7560 0 0 {name=l6158 lab=WL38}
N 3040 7640 3060 7640 {}
C {lab_pin.sym} 3060 7640 0 0 {name=l6159 lab=VDD}
N 3040 7560 3060 7560 {}
C {lab_pin.sym} 3060 7560 0 0 {name=l6160 lab=VSS}
C {bitcell_6t.sym} 3200 7600 0 0 {name=Xr38c16}
N 3160 7640 3140 7640 {}
C {lab_pin.sym} 3140 7640 0 0 {name=l6161 lab=BL16}
N 3160 7600 3140 7600 {}
C {lab_pin.sym} 3140 7600 0 0 {name=l6162 lab=BLB16}
N 3160 7560 3140 7560 {}
C {lab_pin.sym} 3140 7560 0 0 {name=l6163 lab=WL38}
N 3240 7640 3260 7640 {}
C {lab_pin.sym} 3260 7640 0 0 {name=l6164 lab=VDD}
N 3240 7560 3260 7560 {}
C {lab_pin.sym} 3260 7560 0 0 {name=l6165 lab=VSS}
C {bitcell_6t.sym} 3400 7600 0 0 {name=Xr38c17}
N 3360 7640 3340 7640 {}
C {lab_pin.sym} 3340 7640 0 0 {name=l6166 lab=BL17}
N 3360 7600 3340 7600 {}
C {lab_pin.sym} 3340 7600 0 0 {name=l6167 lab=BLB17}
N 3360 7560 3340 7560 {}
C {lab_pin.sym} 3340 7560 0 0 {name=l6168 lab=WL38}
N 3440 7640 3460 7640 {}
C {lab_pin.sym} 3460 7640 0 0 {name=l6169 lab=VDD}
N 3440 7560 3460 7560 {}
C {lab_pin.sym} 3460 7560 0 0 {name=l6170 lab=VSS}
C {bitcell_6t.sym} 3600 7600 0 0 {name=Xr38c18}
N 3560 7640 3540 7640 {}
C {lab_pin.sym} 3540 7640 0 0 {name=l6171 lab=BL18}
N 3560 7600 3540 7600 {}
C {lab_pin.sym} 3540 7600 0 0 {name=l6172 lab=BLB18}
N 3560 7560 3540 7560 {}
C {lab_pin.sym} 3540 7560 0 0 {name=l6173 lab=WL38}
N 3640 7640 3660 7640 {}
C {lab_pin.sym} 3660 7640 0 0 {name=l6174 lab=VDD}
N 3640 7560 3660 7560 {}
C {lab_pin.sym} 3660 7560 0 0 {name=l6175 lab=VSS}
C {bitcell_6t.sym} 3800 7600 0 0 {name=Xr38c19}
N 3760 7640 3740 7640 {}
C {lab_pin.sym} 3740 7640 0 0 {name=l6176 lab=BL19}
N 3760 7600 3740 7600 {}
C {lab_pin.sym} 3740 7600 0 0 {name=l6177 lab=BLB19}
N 3760 7560 3740 7560 {}
C {lab_pin.sym} 3740 7560 0 0 {name=l6178 lab=WL38}
N 3840 7640 3860 7640 {}
C {lab_pin.sym} 3860 7640 0 0 {name=l6179 lab=VDD}
N 3840 7560 3860 7560 {}
C {lab_pin.sym} 3860 7560 0 0 {name=l6180 lab=VSS}
C {bitcell_6t.sym} 4000 7600 0 0 {name=Xr38c20}
N 3960 7640 3940 7640 {}
C {lab_pin.sym} 3940 7640 0 0 {name=l6181 lab=BL20}
N 3960 7600 3940 7600 {}
C {lab_pin.sym} 3940 7600 0 0 {name=l6182 lab=BLB20}
N 3960 7560 3940 7560 {}
C {lab_pin.sym} 3940 7560 0 0 {name=l6183 lab=WL38}
N 4040 7640 4060 7640 {}
C {lab_pin.sym} 4060 7640 0 0 {name=l6184 lab=VDD}
N 4040 7560 4060 7560 {}
C {lab_pin.sym} 4060 7560 0 0 {name=l6185 lab=VSS}
C {bitcell_6t.sym} 4200 7600 0 0 {name=Xr38c21}
N 4160 7640 4140 7640 {}
C {lab_pin.sym} 4140 7640 0 0 {name=l6186 lab=BL21}
N 4160 7600 4140 7600 {}
C {lab_pin.sym} 4140 7600 0 0 {name=l6187 lab=BLB21}
N 4160 7560 4140 7560 {}
C {lab_pin.sym} 4140 7560 0 0 {name=l6188 lab=WL38}
N 4240 7640 4260 7640 {}
C {lab_pin.sym} 4260 7640 0 0 {name=l6189 lab=VDD}
N 4240 7560 4260 7560 {}
C {lab_pin.sym} 4260 7560 0 0 {name=l6190 lab=VSS}
C {bitcell_6t.sym} 4400 7600 0 0 {name=Xr38c22}
N 4360 7640 4340 7640 {}
C {lab_pin.sym} 4340 7640 0 0 {name=l6191 lab=BL22}
N 4360 7600 4340 7600 {}
C {lab_pin.sym} 4340 7600 0 0 {name=l6192 lab=BLB22}
N 4360 7560 4340 7560 {}
C {lab_pin.sym} 4340 7560 0 0 {name=l6193 lab=WL38}
N 4440 7640 4460 7640 {}
C {lab_pin.sym} 4460 7640 0 0 {name=l6194 lab=VDD}
N 4440 7560 4460 7560 {}
C {lab_pin.sym} 4460 7560 0 0 {name=l6195 lab=VSS}
C {bitcell_6t.sym} 4600 7600 0 0 {name=Xr38c23}
N 4560 7640 4540 7640 {}
C {lab_pin.sym} 4540 7640 0 0 {name=l6196 lab=BL23}
N 4560 7600 4540 7600 {}
C {lab_pin.sym} 4540 7600 0 0 {name=l6197 lab=BLB23}
N 4560 7560 4540 7560 {}
C {lab_pin.sym} 4540 7560 0 0 {name=l6198 lab=WL38}
N 4640 7640 4660 7640 {}
C {lab_pin.sym} 4660 7640 0 0 {name=l6199 lab=VDD}
N 4640 7560 4660 7560 {}
C {lab_pin.sym} 4660 7560 0 0 {name=l6200 lab=VSS}
C {bitcell_6t.sym} 4800 7600 0 0 {name=Xr38c24}
N 4760 7640 4740 7640 {}
C {lab_pin.sym} 4740 7640 0 0 {name=l6201 lab=BL24}
N 4760 7600 4740 7600 {}
C {lab_pin.sym} 4740 7600 0 0 {name=l6202 lab=BLB24}
N 4760 7560 4740 7560 {}
C {lab_pin.sym} 4740 7560 0 0 {name=l6203 lab=WL38}
N 4840 7640 4860 7640 {}
C {lab_pin.sym} 4860 7640 0 0 {name=l6204 lab=VDD}
N 4840 7560 4860 7560 {}
C {lab_pin.sym} 4860 7560 0 0 {name=l6205 lab=VSS}
C {bitcell_6t.sym} 5000 7600 0 0 {name=Xr38c25}
N 4960 7640 4940 7640 {}
C {lab_pin.sym} 4940 7640 0 0 {name=l6206 lab=BL25}
N 4960 7600 4940 7600 {}
C {lab_pin.sym} 4940 7600 0 0 {name=l6207 lab=BLB25}
N 4960 7560 4940 7560 {}
C {lab_pin.sym} 4940 7560 0 0 {name=l6208 lab=WL38}
N 5040 7640 5060 7640 {}
C {lab_pin.sym} 5060 7640 0 0 {name=l6209 lab=VDD}
N 5040 7560 5060 7560 {}
C {lab_pin.sym} 5060 7560 0 0 {name=l6210 lab=VSS}
C {bitcell_6t.sym} 5200 7600 0 0 {name=Xr38c26}
N 5160 7640 5140 7640 {}
C {lab_pin.sym} 5140 7640 0 0 {name=l6211 lab=BL26}
N 5160 7600 5140 7600 {}
C {lab_pin.sym} 5140 7600 0 0 {name=l6212 lab=BLB26}
N 5160 7560 5140 7560 {}
C {lab_pin.sym} 5140 7560 0 0 {name=l6213 lab=WL38}
N 5240 7640 5260 7640 {}
C {lab_pin.sym} 5260 7640 0 0 {name=l6214 lab=VDD}
N 5240 7560 5260 7560 {}
C {lab_pin.sym} 5260 7560 0 0 {name=l6215 lab=VSS}
C {bitcell_6t.sym} 5400 7600 0 0 {name=Xr38c27}
N 5360 7640 5340 7640 {}
C {lab_pin.sym} 5340 7640 0 0 {name=l6216 lab=BL27}
N 5360 7600 5340 7600 {}
C {lab_pin.sym} 5340 7600 0 0 {name=l6217 lab=BLB27}
N 5360 7560 5340 7560 {}
C {lab_pin.sym} 5340 7560 0 0 {name=l6218 lab=WL38}
N 5440 7640 5460 7640 {}
C {lab_pin.sym} 5460 7640 0 0 {name=l6219 lab=VDD}
N 5440 7560 5460 7560 {}
C {lab_pin.sym} 5460 7560 0 0 {name=l6220 lab=VSS}
C {bitcell_6t.sym} 5600 7600 0 0 {name=Xr38c28}
N 5560 7640 5540 7640 {}
C {lab_pin.sym} 5540 7640 0 0 {name=l6221 lab=BL28}
N 5560 7600 5540 7600 {}
C {lab_pin.sym} 5540 7600 0 0 {name=l6222 lab=BLB28}
N 5560 7560 5540 7560 {}
C {lab_pin.sym} 5540 7560 0 0 {name=l6223 lab=WL38}
N 5640 7640 5660 7640 {}
C {lab_pin.sym} 5660 7640 0 0 {name=l6224 lab=VDD}
N 5640 7560 5660 7560 {}
C {lab_pin.sym} 5660 7560 0 0 {name=l6225 lab=VSS}
C {bitcell_6t.sym} 5800 7600 0 0 {name=Xr38c29}
N 5760 7640 5740 7640 {}
C {lab_pin.sym} 5740 7640 0 0 {name=l6226 lab=BL29}
N 5760 7600 5740 7600 {}
C {lab_pin.sym} 5740 7600 0 0 {name=l6227 lab=BLB29}
N 5760 7560 5740 7560 {}
C {lab_pin.sym} 5740 7560 0 0 {name=l6228 lab=WL38}
N 5840 7640 5860 7640 {}
C {lab_pin.sym} 5860 7640 0 0 {name=l6229 lab=VDD}
N 5840 7560 5860 7560 {}
C {lab_pin.sym} 5860 7560 0 0 {name=l6230 lab=VSS}
C {bitcell_6t.sym} 6000 7600 0 0 {name=Xr38c30}
N 5960 7640 5940 7640 {}
C {lab_pin.sym} 5940 7640 0 0 {name=l6231 lab=BL30}
N 5960 7600 5940 7600 {}
C {lab_pin.sym} 5940 7600 0 0 {name=l6232 lab=BLB30}
N 5960 7560 5940 7560 {}
C {lab_pin.sym} 5940 7560 0 0 {name=l6233 lab=WL38}
N 6040 7640 6060 7640 {}
C {lab_pin.sym} 6060 7640 0 0 {name=l6234 lab=VDD}
N 6040 7560 6060 7560 {}
C {lab_pin.sym} 6060 7560 0 0 {name=l6235 lab=VSS}
C {bitcell_6t.sym} 6200 7600 0 0 {name=Xr38c31}
N 6160 7640 6140 7640 {}
C {lab_pin.sym} 6140 7640 0 0 {name=l6236 lab=BL31}
N 6160 7600 6140 7600 {}
C {lab_pin.sym} 6140 7600 0 0 {name=l6237 lab=BLB31}
N 6160 7560 6140 7560 {}
C {lab_pin.sym} 6140 7560 0 0 {name=l6238 lab=WL38}
N 6240 7640 6260 7640 {}
C {lab_pin.sym} 6260 7640 0 0 {name=l6239 lab=VDD}
N 6240 7560 6260 7560 {}
C {lab_pin.sym} 6260 7560 0 0 {name=l6240 lab=VSS}
C {bitcell_6t.sym} 0 7800 0 0 {name=Xr39c0}
N -40 7840 -60 7840 {}
C {lab_pin.sym} -60 7840 0 0 {name=l6241 lab=BL0}
N -40 7800 -60 7800 {}
C {lab_pin.sym} -60 7800 0 0 {name=l6242 lab=BLB0}
N -40 7760 -60 7760 {}
C {lab_pin.sym} -60 7760 0 0 {name=l6243 lab=WL39}
N 40 7840 60 7840 {}
C {lab_pin.sym} 60 7840 0 0 {name=l6244 lab=VDD}
N 40 7760 60 7760 {}
C {lab_pin.sym} 60 7760 0 0 {name=l6245 lab=VSS}
C {bitcell_6t.sym} 200 7800 0 0 {name=Xr39c1}
N 160 7840 140 7840 {}
C {lab_pin.sym} 140 7840 0 0 {name=l6246 lab=BL1}
N 160 7800 140 7800 {}
C {lab_pin.sym} 140 7800 0 0 {name=l6247 lab=BLB1}
N 160 7760 140 7760 {}
C {lab_pin.sym} 140 7760 0 0 {name=l6248 lab=WL39}
N 240 7840 260 7840 {}
C {lab_pin.sym} 260 7840 0 0 {name=l6249 lab=VDD}
N 240 7760 260 7760 {}
C {lab_pin.sym} 260 7760 0 0 {name=l6250 lab=VSS}
C {bitcell_6t.sym} 400 7800 0 0 {name=Xr39c2}
N 360 7840 340 7840 {}
C {lab_pin.sym} 340 7840 0 0 {name=l6251 lab=BL2}
N 360 7800 340 7800 {}
C {lab_pin.sym} 340 7800 0 0 {name=l6252 lab=BLB2}
N 360 7760 340 7760 {}
C {lab_pin.sym} 340 7760 0 0 {name=l6253 lab=WL39}
N 440 7840 460 7840 {}
C {lab_pin.sym} 460 7840 0 0 {name=l6254 lab=VDD}
N 440 7760 460 7760 {}
C {lab_pin.sym} 460 7760 0 0 {name=l6255 lab=VSS}
C {bitcell_6t.sym} 600 7800 0 0 {name=Xr39c3}
N 560 7840 540 7840 {}
C {lab_pin.sym} 540 7840 0 0 {name=l6256 lab=BL3}
N 560 7800 540 7800 {}
C {lab_pin.sym} 540 7800 0 0 {name=l6257 lab=BLB3}
N 560 7760 540 7760 {}
C {lab_pin.sym} 540 7760 0 0 {name=l6258 lab=WL39}
N 640 7840 660 7840 {}
C {lab_pin.sym} 660 7840 0 0 {name=l6259 lab=VDD}
N 640 7760 660 7760 {}
C {lab_pin.sym} 660 7760 0 0 {name=l6260 lab=VSS}
C {bitcell_6t.sym} 800 7800 0 0 {name=Xr39c4}
N 760 7840 740 7840 {}
C {lab_pin.sym} 740 7840 0 0 {name=l6261 lab=BL4}
N 760 7800 740 7800 {}
C {lab_pin.sym} 740 7800 0 0 {name=l6262 lab=BLB4}
N 760 7760 740 7760 {}
C {lab_pin.sym} 740 7760 0 0 {name=l6263 lab=WL39}
N 840 7840 860 7840 {}
C {lab_pin.sym} 860 7840 0 0 {name=l6264 lab=VDD}
N 840 7760 860 7760 {}
C {lab_pin.sym} 860 7760 0 0 {name=l6265 lab=VSS}
C {bitcell_6t.sym} 1000 7800 0 0 {name=Xr39c5}
N 960 7840 940 7840 {}
C {lab_pin.sym} 940 7840 0 0 {name=l6266 lab=BL5}
N 960 7800 940 7800 {}
C {lab_pin.sym} 940 7800 0 0 {name=l6267 lab=BLB5}
N 960 7760 940 7760 {}
C {lab_pin.sym} 940 7760 0 0 {name=l6268 lab=WL39}
N 1040 7840 1060 7840 {}
C {lab_pin.sym} 1060 7840 0 0 {name=l6269 lab=VDD}
N 1040 7760 1060 7760 {}
C {lab_pin.sym} 1060 7760 0 0 {name=l6270 lab=VSS}
C {bitcell_6t.sym} 1200 7800 0 0 {name=Xr39c6}
N 1160 7840 1140 7840 {}
C {lab_pin.sym} 1140 7840 0 0 {name=l6271 lab=BL6}
N 1160 7800 1140 7800 {}
C {lab_pin.sym} 1140 7800 0 0 {name=l6272 lab=BLB6}
N 1160 7760 1140 7760 {}
C {lab_pin.sym} 1140 7760 0 0 {name=l6273 lab=WL39}
N 1240 7840 1260 7840 {}
C {lab_pin.sym} 1260 7840 0 0 {name=l6274 lab=VDD}
N 1240 7760 1260 7760 {}
C {lab_pin.sym} 1260 7760 0 0 {name=l6275 lab=VSS}
C {bitcell_6t.sym} 1400 7800 0 0 {name=Xr39c7}
N 1360 7840 1340 7840 {}
C {lab_pin.sym} 1340 7840 0 0 {name=l6276 lab=BL7}
N 1360 7800 1340 7800 {}
C {lab_pin.sym} 1340 7800 0 0 {name=l6277 lab=BLB7}
N 1360 7760 1340 7760 {}
C {lab_pin.sym} 1340 7760 0 0 {name=l6278 lab=WL39}
N 1440 7840 1460 7840 {}
C {lab_pin.sym} 1460 7840 0 0 {name=l6279 lab=VDD}
N 1440 7760 1460 7760 {}
C {lab_pin.sym} 1460 7760 0 0 {name=l6280 lab=VSS}
C {bitcell_6t.sym} 1600 7800 0 0 {name=Xr39c8}
N 1560 7840 1540 7840 {}
C {lab_pin.sym} 1540 7840 0 0 {name=l6281 lab=BL8}
N 1560 7800 1540 7800 {}
C {lab_pin.sym} 1540 7800 0 0 {name=l6282 lab=BLB8}
N 1560 7760 1540 7760 {}
C {lab_pin.sym} 1540 7760 0 0 {name=l6283 lab=WL39}
N 1640 7840 1660 7840 {}
C {lab_pin.sym} 1660 7840 0 0 {name=l6284 lab=VDD}
N 1640 7760 1660 7760 {}
C {lab_pin.sym} 1660 7760 0 0 {name=l6285 lab=VSS}
C {bitcell_6t.sym} 1800 7800 0 0 {name=Xr39c9}
N 1760 7840 1740 7840 {}
C {lab_pin.sym} 1740 7840 0 0 {name=l6286 lab=BL9}
N 1760 7800 1740 7800 {}
C {lab_pin.sym} 1740 7800 0 0 {name=l6287 lab=BLB9}
N 1760 7760 1740 7760 {}
C {lab_pin.sym} 1740 7760 0 0 {name=l6288 lab=WL39}
N 1840 7840 1860 7840 {}
C {lab_pin.sym} 1860 7840 0 0 {name=l6289 lab=VDD}
N 1840 7760 1860 7760 {}
C {lab_pin.sym} 1860 7760 0 0 {name=l6290 lab=VSS}
C {bitcell_6t.sym} 2000 7800 0 0 {name=Xr39c10}
N 1960 7840 1940 7840 {}
C {lab_pin.sym} 1940 7840 0 0 {name=l6291 lab=BL10}
N 1960 7800 1940 7800 {}
C {lab_pin.sym} 1940 7800 0 0 {name=l6292 lab=BLB10}
N 1960 7760 1940 7760 {}
C {lab_pin.sym} 1940 7760 0 0 {name=l6293 lab=WL39}
N 2040 7840 2060 7840 {}
C {lab_pin.sym} 2060 7840 0 0 {name=l6294 lab=VDD}
N 2040 7760 2060 7760 {}
C {lab_pin.sym} 2060 7760 0 0 {name=l6295 lab=VSS}
C {bitcell_6t.sym} 2200 7800 0 0 {name=Xr39c11}
N 2160 7840 2140 7840 {}
C {lab_pin.sym} 2140 7840 0 0 {name=l6296 lab=BL11}
N 2160 7800 2140 7800 {}
C {lab_pin.sym} 2140 7800 0 0 {name=l6297 lab=BLB11}
N 2160 7760 2140 7760 {}
C {lab_pin.sym} 2140 7760 0 0 {name=l6298 lab=WL39}
N 2240 7840 2260 7840 {}
C {lab_pin.sym} 2260 7840 0 0 {name=l6299 lab=VDD}
N 2240 7760 2260 7760 {}
C {lab_pin.sym} 2260 7760 0 0 {name=l6300 lab=VSS}
C {bitcell_6t.sym} 2400 7800 0 0 {name=Xr39c12}
N 2360 7840 2340 7840 {}
C {lab_pin.sym} 2340 7840 0 0 {name=l6301 lab=BL12}
N 2360 7800 2340 7800 {}
C {lab_pin.sym} 2340 7800 0 0 {name=l6302 lab=BLB12}
N 2360 7760 2340 7760 {}
C {lab_pin.sym} 2340 7760 0 0 {name=l6303 lab=WL39}
N 2440 7840 2460 7840 {}
C {lab_pin.sym} 2460 7840 0 0 {name=l6304 lab=VDD}
N 2440 7760 2460 7760 {}
C {lab_pin.sym} 2460 7760 0 0 {name=l6305 lab=VSS}
C {bitcell_6t.sym} 2600 7800 0 0 {name=Xr39c13}
N 2560 7840 2540 7840 {}
C {lab_pin.sym} 2540 7840 0 0 {name=l6306 lab=BL13}
N 2560 7800 2540 7800 {}
C {lab_pin.sym} 2540 7800 0 0 {name=l6307 lab=BLB13}
N 2560 7760 2540 7760 {}
C {lab_pin.sym} 2540 7760 0 0 {name=l6308 lab=WL39}
N 2640 7840 2660 7840 {}
C {lab_pin.sym} 2660 7840 0 0 {name=l6309 lab=VDD}
N 2640 7760 2660 7760 {}
C {lab_pin.sym} 2660 7760 0 0 {name=l6310 lab=VSS}
C {bitcell_6t.sym} 2800 7800 0 0 {name=Xr39c14}
N 2760 7840 2740 7840 {}
C {lab_pin.sym} 2740 7840 0 0 {name=l6311 lab=BL14}
N 2760 7800 2740 7800 {}
C {lab_pin.sym} 2740 7800 0 0 {name=l6312 lab=BLB14}
N 2760 7760 2740 7760 {}
C {lab_pin.sym} 2740 7760 0 0 {name=l6313 lab=WL39}
N 2840 7840 2860 7840 {}
C {lab_pin.sym} 2860 7840 0 0 {name=l6314 lab=VDD}
N 2840 7760 2860 7760 {}
C {lab_pin.sym} 2860 7760 0 0 {name=l6315 lab=VSS}
C {bitcell_6t.sym} 3000 7800 0 0 {name=Xr39c15}
N 2960 7840 2940 7840 {}
C {lab_pin.sym} 2940 7840 0 0 {name=l6316 lab=BL15}
N 2960 7800 2940 7800 {}
C {lab_pin.sym} 2940 7800 0 0 {name=l6317 lab=BLB15}
N 2960 7760 2940 7760 {}
C {lab_pin.sym} 2940 7760 0 0 {name=l6318 lab=WL39}
N 3040 7840 3060 7840 {}
C {lab_pin.sym} 3060 7840 0 0 {name=l6319 lab=VDD}
N 3040 7760 3060 7760 {}
C {lab_pin.sym} 3060 7760 0 0 {name=l6320 lab=VSS}
C {bitcell_6t.sym} 3200 7800 0 0 {name=Xr39c16}
N 3160 7840 3140 7840 {}
C {lab_pin.sym} 3140 7840 0 0 {name=l6321 lab=BL16}
N 3160 7800 3140 7800 {}
C {lab_pin.sym} 3140 7800 0 0 {name=l6322 lab=BLB16}
N 3160 7760 3140 7760 {}
C {lab_pin.sym} 3140 7760 0 0 {name=l6323 lab=WL39}
N 3240 7840 3260 7840 {}
C {lab_pin.sym} 3260 7840 0 0 {name=l6324 lab=VDD}
N 3240 7760 3260 7760 {}
C {lab_pin.sym} 3260 7760 0 0 {name=l6325 lab=VSS}
C {bitcell_6t.sym} 3400 7800 0 0 {name=Xr39c17}
N 3360 7840 3340 7840 {}
C {lab_pin.sym} 3340 7840 0 0 {name=l6326 lab=BL17}
N 3360 7800 3340 7800 {}
C {lab_pin.sym} 3340 7800 0 0 {name=l6327 lab=BLB17}
N 3360 7760 3340 7760 {}
C {lab_pin.sym} 3340 7760 0 0 {name=l6328 lab=WL39}
N 3440 7840 3460 7840 {}
C {lab_pin.sym} 3460 7840 0 0 {name=l6329 lab=VDD}
N 3440 7760 3460 7760 {}
C {lab_pin.sym} 3460 7760 0 0 {name=l6330 lab=VSS}
C {bitcell_6t.sym} 3600 7800 0 0 {name=Xr39c18}
N 3560 7840 3540 7840 {}
C {lab_pin.sym} 3540 7840 0 0 {name=l6331 lab=BL18}
N 3560 7800 3540 7800 {}
C {lab_pin.sym} 3540 7800 0 0 {name=l6332 lab=BLB18}
N 3560 7760 3540 7760 {}
C {lab_pin.sym} 3540 7760 0 0 {name=l6333 lab=WL39}
N 3640 7840 3660 7840 {}
C {lab_pin.sym} 3660 7840 0 0 {name=l6334 lab=VDD}
N 3640 7760 3660 7760 {}
C {lab_pin.sym} 3660 7760 0 0 {name=l6335 lab=VSS}
C {bitcell_6t.sym} 3800 7800 0 0 {name=Xr39c19}
N 3760 7840 3740 7840 {}
C {lab_pin.sym} 3740 7840 0 0 {name=l6336 lab=BL19}
N 3760 7800 3740 7800 {}
C {lab_pin.sym} 3740 7800 0 0 {name=l6337 lab=BLB19}
N 3760 7760 3740 7760 {}
C {lab_pin.sym} 3740 7760 0 0 {name=l6338 lab=WL39}
N 3840 7840 3860 7840 {}
C {lab_pin.sym} 3860 7840 0 0 {name=l6339 lab=VDD}
N 3840 7760 3860 7760 {}
C {lab_pin.sym} 3860 7760 0 0 {name=l6340 lab=VSS}
C {bitcell_6t.sym} 4000 7800 0 0 {name=Xr39c20}
N 3960 7840 3940 7840 {}
C {lab_pin.sym} 3940 7840 0 0 {name=l6341 lab=BL20}
N 3960 7800 3940 7800 {}
C {lab_pin.sym} 3940 7800 0 0 {name=l6342 lab=BLB20}
N 3960 7760 3940 7760 {}
C {lab_pin.sym} 3940 7760 0 0 {name=l6343 lab=WL39}
N 4040 7840 4060 7840 {}
C {lab_pin.sym} 4060 7840 0 0 {name=l6344 lab=VDD}
N 4040 7760 4060 7760 {}
C {lab_pin.sym} 4060 7760 0 0 {name=l6345 lab=VSS}
C {bitcell_6t.sym} 4200 7800 0 0 {name=Xr39c21}
N 4160 7840 4140 7840 {}
C {lab_pin.sym} 4140 7840 0 0 {name=l6346 lab=BL21}
N 4160 7800 4140 7800 {}
C {lab_pin.sym} 4140 7800 0 0 {name=l6347 lab=BLB21}
N 4160 7760 4140 7760 {}
C {lab_pin.sym} 4140 7760 0 0 {name=l6348 lab=WL39}
N 4240 7840 4260 7840 {}
C {lab_pin.sym} 4260 7840 0 0 {name=l6349 lab=VDD}
N 4240 7760 4260 7760 {}
C {lab_pin.sym} 4260 7760 0 0 {name=l6350 lab=VSS}
C {bitcell_6t.sym} 4400 7800 0 0 {name=Xr39c22}
N 4360 7840 4340 7840 {}
C {lab_pin.sym} 4340 7840 0 0 {name=l6351 lab=BL22}
N 4360 7800 4340 7800 {}
C {lab_pin.sym} 4340 7800 0 0 {name=l6352 lab=BLB22}
N 4360 7760 4340 7760 {}
C {lab_pin.sym} 4340 7760 0 0 {name=l6353 lab=WL39}
N 4440 7840 4460 7840 {}
C {lab_pin.sym} 4460 7840 0 0 {name=l6354 lab=VDD}
N 4440 7760 4460 7760 {}
C {lab_pin.sym} 4460 7760 0 0 {name=l6355 lab=VSS}
C {bitcell_6t.sym} 4600 7800 0 0 {name=Xr39c23}
N 4560 7840 4540 7840 {}
C {lab_pin.sym} 4540 7840 0 0 {name=l6356 lab=BL23}
N 4560 7800 4540 7800 {}
C {lab_pin.sym} 4540 7800 0 0 {name=l6357 lab=BLB23}
N 4560 7760 4540 7760 {}
C {lab_pin.sym} 4540 7760 0 0 {name=l6358 lab=WL39}
N 4640 7840 4660 7840 {}
C {lab_pin.sym} 4660 7840 0 0 {name=l6359 lab=VDD}
N 4640 7760 4660 7760 {}
C {lab_pin.sym} 4660 7760 0 0 {name=l6360 lab=VSS}
C {bitcell_6t.sym} 4800 7800 0 0 {name=Xr39c24}
N 4760 7840 4740 7840 {}
C {lab_pin.sym} 4740 7840 0 0 {name=l6361 lab=BL24}
N 4760 7800 4740 7800 {}
C {lab_pin.sym} 4740 7800 0 0 {name=l6362 lab=BLB24}
N 4760 7760 4740 7760 {}
C {lab_pin.sym} 4740 7760 0 0 {name=l6363 lab=WL39}
N 4840 7840 4860 7840 {}
C {lab_pin.sym} 4860 7840 0 0 {name=l6364 lab=VDD}
N 4840 7760 4860 7760 {}
C {lab_pin.sym} 4860 7760 0 0 {name=l6365 lab=VSS}
C {bitcell_6t.sym} 5000 7800 0 0 {name=Xr39c25}
N 4960 7840 4940 7840 {}
C {lab_pin.sym} 4940 7840 0 0 {name=l6366 lab=BL25}
N 4960 7800 4940 7800 {}
C {lab_pin.sym} 4940 7800 0 0 {name=l6367 lab=BLB25}
N 4960 7760 4940 7760 {}
C {lab_pin.sym} 4940 7760 0 0 {name=l6368 lab=WL39}
N 5040 7840 5060 7840 {}
C {lab_pin.sym} 5060 7840 0 0 {name=l6369 lab=VDD}
N 5040 7760 5060 7760 {}
C {lab_pin.sym} 5060 7760 0 0 {name=l6370 lab=VSS}
C {bitcell_6t.sym} 5200 7800 0 0 {name=Xr39c26}
N 5160 7840 5140 7840 {}
C {lab_pin.sym} 5140 7840 0 0 {name=l6371 lab=BL26}
N 5160 7800 5140 7800 {}
C {lab_pin.sym} 5140 7800 0 0 {name=l6372 lab=BLB26}
N 5160 7760 5140 7760 {}
C {lab_pin.sym} 5140 7760 0 0 {name=l6373 lab=WL39}
N 5240 7840 5260 7840 {}
C {lab_pin.sym} 5260 7840 0 0 {name=l6374 lab=VDD}
N 5240 7760 5260 7760 {}
C {lab_pin.sym} 5260 7760 0 0 {name=l6375 lab=VSS}
C {bitcell_6t.sym} 5400 7800 0 0 {name=Xr39c27}
N 5360 7840 5340 7840 {}
C {lab_pin.sym} 5340 7840 0 0 {name=l6376 lab=BL27}
N 5360 7800 5340 7800 {}
C {lab_pin.sym} 5340 7800 0 0 {name=l6377 lab=BLB27}
N 5360 7760 5340 7760 {}
C {lab_pin.sym} 5340 7760 0 0 {name=l6378 lab=WL39}
N 5440 7840 5460 7840 {}
C {lab_pin.sym} 5460 7840 0 0 {name=l6379 lab=VDD}
N 5440 7760 5460 7760 {}
C {lab_pin.sym} 5460 7760 0 0 {name=l6380 lab=VSS}
C {bitcell_6t.sym} 5600 7800 0 0 {name=Xr39c28}
N 5560 7840 5540 7840 {}
C {lab_pin.sym} 5540 7840 0 0 {name=l6381 lab=BL28}
N 5560 7800 5540 7800 {}
C {lab_pin.sym} 5540 7800 0 0 {name=l6382 lab=BLB28}
N 5560 7760 5540 7760 {}
C {lab_pin.sym} 5540 7760 0 0 {name=l6383 lab=WL39}
N 5640 7840 5660 7840 {}
C {lab_pin.sym} 5660 7840 0 0 {name=l6384 lab=VDD}
N 5640 7760 5660 7760 {}
C {lab_pin.sym} 5660 7760 0 0 {name=l6385 lab=VSS}
C {bitcell_6t.sym} 5800 7800 0 0 {name=Xr39c29}
N 5760 7840 5740 7840 {}
C {lab_pin.sym} 5740 7840 0 0 {name=l6386 lab=BL29}
N 5760 7800 5740 7800 {}
C {lab_pin.sym} 5740 7800 0 0 {name=l6387 lab=BLB29}
N 5760 7760 5740 7760 {}
C {lab_pin.sym} 5740 7760 0 0 {name=l6388 lab=WL39}
N 5840 7840 5860 7840 {}
C {lab_pin.sym} 5860 7840 0 0 {name=l6389 lab=VDD}
N 5840 7760 5860 7760 {}
C {lab_pin.sym} 5860 7760 0 0 {name=l6390 lab=VSS}
C {bitcell_6t.sym} 6000 7800 0 0 {name=Xr39c30}
N 5960 7840 5940 7840 {}
C {lab_pin.sym} 5940 7840 0 0 {name=l6391 lab=BL30}
N 5960 7800 5940 7800 {}
C {lab_pin.sym} 5940 7800 0 0 {name=l6392 lab=BLB30}
N 5960 7760 5940 7760 {}
C {lab_pin.sym} 5940 7760 0 0 {name=l6393 lab=WL39}
N 6040 7840 6060 7840 {}
C {lab_pin.sym} 6060 7840 0 0 {name=l6394 lab=VDD}
N 6040 7760 6060 7760 {}
C {lab_pin.sym} 6060 7760 0 0 {name=l6395 lab=VSS}
C {bitcell_6t.sym} 6200 7800 0 0 {name=Xr39c31}
N 6160 7840 6140 7840 {}
C {lab_pin.sym} 6140 7840 0 0 {name=l6396 lab=BL31}
N 6160 7800 6140 7800 {}
C {lab_pin.sym} 6140 7800 0 0 {name=l6397 lab=BLB31}
N 6160 7760 6140 7760 {}
C {lab_pin.sym} 6140 7760 0 0 {name=l6398 lab=WL39}
N 6240 7840 6260 7840 {}
C {lab_pin.sym} 6260 7840 0 0 {name=l6399 lab=VDD}
N 6240 7760 6260 7760 {}
C {lab_pin.sym} 6260 7760 0 0 {name=l6400 lab=VSS}
C {bitcell_6t.sym} 0 8000 0 0 {name=Xr40c0}
N -40 8040 -60 8040 {}
C {lab_pin.sym} -60 8040 0 0 {name=l6401 lab=BL0}
N -40 8000 -60 8000 {}
C {lab_pin.sym} -60 8000 0 0 {name=l6402 lab=BLB0}
N -40 7960 -60 7960 {}
C {lab_pin.sym} -60 7960 0 0 {name=l6403 lab=WL40}
N 40 8040 60 8040 {}
C {lab_pin.sym} 60 8040 0 0 {name=l6404 lab=VDD}
N 40 7960 60 7960 {}
C {lab_pin.sym} 60 7960 0 0 {name=l6405 lab=VSS}
C {bitcell_6t.sym} 200 8000 0 0 {name=Xr40c1}
N 160 8040 140 8040 {}
C {lab_pin.sym} 140 8040 0 0 {name=l6406 lab=BL1}
N 160 8000 140 8000 {}
C {lab_pin.sym} 140 8000 0 0 {name=l6407 lab=BLB1}
N 160 7960 140 7960 {}
C {lab_pin.sym} 140 7960 0 0 {name=l6408 lab=WL40}
N 240 8040 260 8040 {}
C {lab_pin.sym} 260 8040 0 0 {name=l6409 lab=VDD}
N 240 7960 260 7960 {}
C {lab_pin.sym} 260 7960 0 0 {name=l6410 lab=VSS}
C {bitcell_6t.sym} 400 8000 0 0 {name=Xr40c2}
N 360 8040 340 8040 {}
C {lab_pin.sym} 340 8040 0 0 {name=l6411 lab=BL2}
N 360 8000 340 8000 {}
C {lab_pin.sym} 340 8000 0 0 {name=l6412 lab=BLB2}
N 360 7960 340 7960 {}
C {lab_pin.sym} 340 7960 0 0 {name=l6413 lab=WL40}
N 440 8040 460 8040 {}
C {lab_pin.sym} 460 8040 0 0 {name=l6414 lab=VDD}
N 440 7960 460 7960 {}
C {lab_pin.sym} 460 7960 0 0 {name=l6415 lab=VSS}
C {bitcell_6t.sym} 600 8000 0 0 {name=Xr40c3}
N 560 8040 540 8040 {}
C {lab_pin.sym} 540 8040 0 0 {name=l6416 lab=BL3}
N 560 8000 540 8000 {}
C {lab_pin.sym} 540 8000 0 0 {name=l6417 lab=BLB3}
N 560 7960 540 7960 {}
C {lab_pin.sym} 540 7960 0 0 {name=l6418 lab=WL40}
N 640 8040 660 8040 {}
C {lab_pin.sym} 660 8040 0 0 {name=l6419 lab=VDD}
N 640 7960 660 7960 {}
C {lab_pin.sym} 660 7960 0 0 {name=l6420 lab=VSS}
C {bitcell_6t.sym} 800 8000 0 0 {name=Xr40c4}
N 760 8040 740 8040 {}
C {lab_pin.sym} 740 8040 0 0 {name=l6421 lab=BL4}
N 760 8000 740 8000 {}
C {lab_pin.sym} 740 8000 0 0 {name=l6422 lab=BLB4}
N 760 7960 740 7960 {}
C {lab_pin.sym} 740 7960 0 0 {name=l6423 lab=WL40}
N 840 8040 860 8040 {}
C {lab_pin.sym} 860 8040 0 0 {name=l6424 lab=VDD}
N 840 7960 860 7960 {}
C {lab_pin.sym} 860 7960 0 0 {name=l6425 lab=VSS}
C {bitcell_6t.sym} 1000 8000 0 0 {name=Xr40c5}
N 960 8040 940 8040 {}
C {lab_pin.sym} 940 8040 0 0 {name=l6426 lab=BL5}
N 960 8000 940 8000 {}
C {lab_pin.sym} 940 8000 0 0 {name=l6427 lab=BLB5}
N 960 7960 940 7960 {}
C {lab_pin.sym} 940 7960 0 0 {name=l6428 lab=WL40}
N 1040 8040 1060 8040 {}
C {lab_pin.sym} 1060 8040 0 0 {name=l6429 lab=VDD}
N 1040 7960 1060 7960 {}
C {lab_pin.sym} 1060 7960 0 0 {name=l6430 lab=VSS}
C {bitcell_6t.sym} 1200 8000 0 0 {name=Xr40c6}
N 1160 8040 1140 8040 {}
C {lab_pin.sym} 1140 8040 0 0 {name=l6431 lab=BL6}
N 1160 8000 1140 8000 {}
C {lab_pin.sym} 1140 8000 0 0 {name=l6432 lab=BLB6}
N 1160 7960 1140 7960 {}
C {lab_pin.sym} 1140 7960 0 0 {name=l6433 lab=WL40}
N 1240 8040 1260 8040 {}
C {lab_pin.sym} 1260 8040 0 0 {name=l6434 lab=VDD}
N 1240 7960 1260 7960 {}
C {lab_pin.sym} 1260 7960 0 0 {name=l6435 lab=VSS}
C {bitcell_6t.sym} 1400 8000 0 0 {name=Xr40c7}
N 1360 8040 1340 8040 {}
C {lab_pin.sym} 1340 8040 0 0 {name=l6436 lab=BL7}
N 1360 8000 1340 8000 {}
C {lab_pin.sym} 1340 8000 0 0 {name=l6437 lab=BLB7}
N 1360 7960 1340 7960 {}
C {lab_pin.sym} 1340 7960 0 0 {name=l6438 lab=WL40}
N 1440 8040 1460 8040 {}
C {lab_pin.sym} 1460 8040 0 0 {name=l6439 lab=VDD}
N 1440 7960 1460 7960 {}
C {lab_pin.sym} 1460 7960 0 0 {name=l6440 lab=VSS}
C {bitcell_6t.sym} 1600 8000 0 0 {name=Xr40c8}
N 1560 8040 1540 8040 {}
C {lab_pin.sym} 1540 8040 0 0 {name=l6441 lab=BL8}
N 1560 8000 1540 8000 {}
C {lab_pin.sym} 1540 8000 0 0 {name=l6442 lab=BLB8}
N 1560 7960 1540 7960 {}
C {lab_pin.sym} 1540 7960 0 0 {name=l6443 lab=WL40}
N 1640 8040 1660 8040 {}
C {lab_pin.sym} 1660 8040 0 0 {name=l6444 lab=VDD}
N 1640 7960 1660 7960 {}
C {lab_pin.sym} 1660 7960 0 0 {name=l6445 lab=VSS}
C {bitcell_6t.sym} 1800 8000 0 0 {name=Xr40c9}
N 1760 8040 1740 8040 {}
C {lab_pin.sym} 1740 8040 0 0 {name=l6446 lab=BL9}
N 1760 8000 1740 8000 {}
C {lab_pin.sym} 1740 8000 0 0 {name=l6447 lab=BLB9}
N 1760 7960 1740 7960 {}
C {lab_pin.sym} 1740 7960 0 0 {name=l6448 lab=WL40}
N 1840 8040 1860 8040 {}
C {lab_pin.sym} 1860 8040 0 0 {name=l6449 lab=VDD}
N 1840 7960 1860 7960 {}
C {lab_pin.sym} 1860 7960 0 0 {name=l6450 lab=VSS}
C {bitcell_6t.sym} 2000 8000 0 0 {name=Xr40c10}
N 1960 8040 1940 8040 {}
C {lab_pin.sym} 1940 8040 0 0 {name=l6451 lab=BL10}
N 1960 8000 1940 8000 {}
C {lab_pin.sym} 1940 8000 0 0 {name=l6452 lab=BLB10}
N 1960 7960 1940 7960 {}
C {lab_pin.sym} 1940 7960 0 0 {name=l6453 lab=WL40}
N 2040 8040 2060 8040 {}
C {lab_pin.sym} 2060 8040 0 0 {name=l6454 lab=VDD}
N 2040 7960 2060 7960 {}
C {lab_pin.sym} 2060 7960 0 0 {name=l6455 lab=VSS}
C {bitcell_6t.sym} 2200 8000 0 0 {name=Xr40c11}
N 2160 8040 2140 8040 {}
C {lab_pin.sym} 2140 8040 0 0 {name=l6456 lab=BL11}
N 2160 8000 2140 8000 {}
C {lab_pin.sym} 2140 8000 0 0 {name=l6457 lab=BLB11}
N 2160 7960 2140 7960 {}
C {lab_pin.sym} 2140 7960 0 0 {name=l6458 lab=WL40}
N 2240 8040 2260 8040 {}
C {lab_pin.sym} 2260 8040 0 0 {name=l6459 lab=VDD}
N 2240 7960 2260 7960 {}
C {lab_pin.sym} 2260 7960 0 0 {name=l6460 lab=VSS}
C {bitcell_6t.sym} 2400 8000 0 0 {name=Xr40c12}
N 2360 8040 2340 8040 {}
C {lab_pin.sym} 2340 8040 0 0 {name=l6461 lab=BL12}
N 2360 8000 2340 8000 {}
C {lab_pin.sym} 2340 8000 0 0 {name=l6462 lab=BLB12}
N 2360 7960 2340 7960 {}
C {lab_pin.sym} 2340 7960 0 0 {name=l6463 lab=WL40}
N 2440 8040 2460 8040 {}
C {lab_pin.sym} 2460 8040 0 0 {name=l6464 lab=VDD}
N 2440 7960 2460 7960 {}
C {lab_pin.sym} 2460 7960 0 0 {name=l6465 lab=VSS}
C {bitcell_6t.sym} 2600 8000 0 0 {name=Xr40c13}
N 2560 8040 2540 8040 {}
C {lab_pin.sym} 2540 8040 0 0 {name=l6466 lab=BL13}
N 2560 8000 2540 8000 {}
C {lab_pin.sym} 2540 8000 0 0 {name=l6467 lab=BLB13}
N 2560 7960 2540 7960 {}
C {lab_pin.sym} 2540 7960 0 0 {name=l6468 lab=WL40}
N 2640 8040 2660 8040 {}
C {lab_pin.sym} 2660 8040 0 0 {name=l6469 lab=VDD}
N 2640 7960 2660 7960 {}
C {lab_pin.sym} 2660 7960 0 0 {name=l6470 lab=VSS}
C {bitcell_6t.sym} 2800 8000 0 0 {name=Xr40c14}
N 2760 8040 2740 8040 {}
C {lab_pin.sym} 2740 8040 0 0 {name=l6471 lab=BL14}
N 2760 8000 2740 8000 {}
C {lab_pin.sym} 2740 8000 0 0 {name=l6472 lab=BLB14}
N 2760 7960 2740 7960 {}
C {lab_pin.sym} 2740 7960 0 0 {name=l6473 lab=WL40}
N 2840 8040 2860 8040 {}
C {lab_pin.sym} 2860 8040 0 0 {name=l6474 lab=VDD}
N 2840 7960 2860 7960 {}
C {lab_pin.sym} 2860 7960 0 0 {name=l6475 lab=VSS}
C {bitcell_6t.sym} 3000 8000 0 0 {name=Xr40c15}
N 2960 8040 2940 8040 {}
C {lab_pin.sym} 2940 8040 0 0 {name=l6476 lab=BL15}
N 2960 8000 2940 8000 {}
C {lab_pin.sym} 2940 8000 0 0 {name=l6477 lab=BLB15}
N 2960 7960 2940 7960 {}
C {lab_pin.sym} 2940 7960 0 0 {name=l6478 lab=WL40}
N 3040 8040 3060 8040 {}
C {lab_pin.sym} 3060 8040 0 0 {name=l6479 lab=VDD}
N 3040 7960 3060 7960 {}
C {lab_pin.sym} 3060 7960 0 0 {name=l6480 lab=VSS}
C {bitcell_6t.sym} 3200 8000 0 0 {name=Xr40c16}
N 3160 8040 3140 8040 {}
C {lab_pin.sym} 3140 8040 0 0 {name=l6481 lab=BL16}
N 3160 8000 3140 8000 {}
C {lab_pin.sym} 3140 8000 0 0 {name=l6482 lab=BLB16}
N 3160 7960 3140 7960 {}
C {lab_pin.sym} 3140 7960 0 0 {name=l6483 lab=WL40}
N 3240 8040 3260 8040 {}
C {lab_pin.sym} 3260 8040 0 0 {name=l6484 lab=VDD}
N 3240 7960 3260 7960 {}
C {lab_pin.sym} 3260 7960 0 0 {name=l6485 lab=VSS}
C {bitcell_6t.sym} 3400 8000 0 0 {name=Xr40c17}
N 3360 8040 3340 8040 {}
C {lab_pin.sym} 3340 8040 0 0 {name=l6486 lab=BL17}
N 3360 8000 3340 8000 {}
C {lab_pin.sym} 3340 8000 0 0 {name=l6487 lab=BLB17}
N 3360 7960 3340 7960 {}
C {lab_pin.sym} 3340 7960 0 0 {name=l6488 lab=WL40}
N 3440 8040 3460 8040 {}
C {lab_pin.sym} 3460 8040 0 0 {name=l6489 lab=VDD}
N 3440 7960 3460 7960 {}
C {lab_pin.sym} 3460 7960 0 0 {name=l6490 lab=VSS}
C {bitcell_6t.sym} 3600 8000 0 0 {name=Xr40c18}
N 3560 8040 3540 8040 {}
C {lab_pin.sym} 3540 8040 0 0 {name=l6491 lab=BL18}
N 3560 8000 3540 8000 {}
C {lab_pin.sym} 3540 8000 0 0 {name=l6492 lab=BLB18}
N 3560 7960 3540 7960 {}
C {lab_pin.sym} 3540 7960 0 0 {name=l6493 lab=WL40}
N 3640 8040 3660 8040 {}
C {lab_pin.sym} 3660 8040 0 0 {name=l6494 lab=VDD}
N 3640 7960 3660 7960 {}
C {lab_pin.sym} 3660 7960 0 0 {name=l6495 lab=VSS}
C {bitcell_6t.sym} 3800 8000 0 0 {name=Xr40c19}
N 3760 8040 3740 8040 {}
C {lab_pin.sym} 3740 8040 0 0 {name=l6496 lab=BL19}
N 3760 8000 3740 8000 {}
C {lab_pin.sym} 3740 8000 0 0 {name=l6497 lab=BLB19}
N 3760 7960 3740 7960 {}
C {lab_pin.sym} 3740 7960 0 0 {name=l6498 lab=WL40}
N 3840 8040 3860 8040 {}
C {lab_pin.sym} 3860 8040 0 0 {name=l6499 lab=VDD}
N 3840 7960 3860 7960 {}
C {lab_pin.sym} 3860 7960 0 0 {name=l6500 lab=VSS}
C {bitcell_6t.sym} 4000 8000 0 0 {name=Xr40c20}
N 3960 8040 3940 8040 {}
C {lab_pin.sym} 3940 8040 0 0 {name=l6501 lab=BL20}
N 3960 8000 3940 8000 {}
C {lab_pin.sym} 3940 8000 0 0 {name=l6502 lab=BLB20}
N 3960 7960 3940 7960 {}
C {lab_pin.sym} 3940 7960 0 0 {name=l6503 lab=WL40}
N 4040 8040 4060 8040 {}
C {lab_pin.sym} 4060 8040 0 0 {name=l6504 lab=VDD}
N 4040 7960 4060 7960 {}
C {lab_pin.sym} 4060 7960 0 0 {name=l6505 lab=VSS}
C {bitcell_6t.sym} 4200 8000 0 0 {name=Xr40c21}
N 4160 8040 4140 8040 {}
C {lab_pin.sym} 4140 8040 0 0 {name=l6506 lab=BL21}
N 4160 8000 4140 8000 {}
C {lab_pin.sym} 4140 8000 0 0 {name=l6507 lab=BLB21}
N 4160 7960 4140 7960 {}
C {lab_pin.sym} 4140 7960 0 0 {name=l6508 lab=WL40}
N 4240 8040 4260 8040 {}
C {lab_pin.sym} 4260 8040 0 0 {name=l6509 lab=VDD}
N 4240 7960 4260 7960 {}
C {lab_pin.sym} 4260 7960 0 0 {name=l6510 lab=VSS}
C {bitcell_6t.sym} 4400 8000 0 0 {name=Xr40c22}
N 4360 8040 4340 8040 {}
C {lab_pin.sym} 4340 8040 0 0 {name=l6511 lab=BL22}
N 4360 8000 4340 8000 {}
C {lab_pin.sym} 4340 8000 0 0 {name=l6512 lab=BLB22}
N 4360 7960 4340 7960 {}
C {lab_pin.sym} 4340 7960 0 0 {name=l6513 lab=WL40}
N 4440 8040 4460 8040 {}
C {lab_pin.sym} 4460 8040 0 0 {name=l6514 lab=VDD}
N 4440 7960 4460 7960 {}
C {lab_pin.sym} 4460 7960 0 0 {name=l6515 lab=VSS}
C {bitcell_6t.sym} 4600 8000 0 0 {name=Xr40c23}
N 4560 8040 4540 8040 {}
C {lab_pin.sym} 4540 8040 0 0 {name=l6516 lab=BL23}
N 4560 8000 4540 8000 {}
C {lab_pin.sym} 4540 8000 0 0 {name=l6517 lab=BLB23}
N 4560 7960 4540 7960 {}
C {lab_pin.sym} 4540 7960 0 0 {name=l6518 lab=WL40}
N 4640 8040 4660 8040 {}
C {lab_pin.sym} 4660 8040 0 0 {name=l6519 lab=VDD}
N 4640 7960 4660 7960 {}
C {lab_pin.sym} 4660 7960 0 0 {name=l6520 lab=VSS}
C {bitcell_6t.sym} 4800 8000 0 0 {name=Xr40c24}
N 4760 8040 4740 8040 {}
C {lab_pin.sym} 4740 8040 0 0 {name=l6521 lab=BL24}
N 4760 8000 4740 8000 {}
C {lab_pin.sym} 4740 8000 0 0 {name=l6522 lab=BLB24}
N 4760 7960 4740 7960 {}
C {lab_pin.sym} 4740 7960 0 0 {name=l6523 lab=WL40}
N 4840 8040 4860 8040 {}
C {lab_pin.sym} 4860 8040 0 0 {name=l6524 lab=VDD}
N 4840 7960 4860 7960 {}
C {lab_pin.sym} 4860 7960 0 0 {name=l6525 lab=VSS}
C {bitcell_6t.sym} 5000 8000 0 0 {name=Xr40c25}
N 4960 8040 4940 8040 {}
C {lab_pin.sym} 4940 8040 0 0 {name=l6526 lab=BL25}
N 4960 8000 4940 8000 {}
C {lab_pin.sym} 4940 8000 0 0 {name=l6527 lab=BLB25}
N 4960 7960 4940 7960 {}
C {lab_pin.sym} 4940 7960 0 0 {name=l6528 lab=WL40}
N 5040 8040 5060 8040 {}
C {lab_pin.sym} 5060 8040 0 0 {name=l6529 lab=VDD}
N 5040 7960 5060 7960 {}
C {lab_pin.sym} 5060 7960 0 0 {name=l6530 lab=VSS}
C {bitcell_6t.sym} 5200 8000 0 0 {name=Xr40c26}
N 5160 8040 5140 8040 {}
C {lab_pin.sym} 5140 8040 0 0 {name=l6531 lab=BL26}
N 5160 8000 5140 8000 {}
C {lab_pin.sym} 5140 8000 0 0 {name=l6532 lab=BLB26}
N 5160 7960 5140 7960 {}
C {lab_pin.sym} 5140 7960 0 0 {name=l6533 lab=WL40}
N 5240 8040 5260 8040 {}
C {lab_pin.sym} 5260 8040 0 0 {name=l6534 lab=VDD}
N 5240 7960 5260 7960 {}
C {lab_pin.sym} 5260 7960 0 0 {name=l6535 lab=VSS}
C {bitcell_6t.sym} 5400 8000 0 0 {name=Xr40c27}
N 5360 8040 5340 8040 {}
C {lab_pin.sym} 5340 8040 0 0 {name=l6536 lab=BL27}
N 5360 8000 5340 8000 {}
C {lab_pin.sym} 5340 8000 0 0 {name=l6537 lab=BLB27}
N 5360 7960 5340 7960 {}
C {lab_pin.sym} 5340 7960 0 0 {name=l6538 lab=WL40}
N 5440 8040 5460 8040 {}
C {lab_pin.sym} 5460 8040 0 0 {name=l6539 lab=VDD}
N 5440 7960 5460 7960 {}
C {lab_pin.sym} 5460 7960 0 0 {name=l6540 lab=VSS}
C {bitcell_6t.sym} 5600 8000 0 0 {name=Xr40c28}
N 5560 8040 5540 8040 {}
C {lab_pin.sym} 5540 8040 0 0 {name=l6541 lab=BL28}
N 5560 8000 5540 8000 {}
C {lab_pin.sym} 5540 8000 0 0 {name=l6542 lab=BLB28}
N 5560 7960 5540 7960 {}
C {lab_pin.sym} 5540 7960 0 0 {name=l6543 lab=WL40}
N 5640 8040 5660 8040 {}
C {lab_pin.sym} 5660 8040 0 0 {name=l6544 lab=VDD}
N 5640 7960 5660 7960 {}
C {lab_pin.sym} 5660 7960 0 0 {name=l6545 lab=VSS}
C {bitcell_6t.sym} 5800 8000 0 0 {name=Xr40c29}
N 5760 8040 5740 8040 {}
C {lab_pin.sym} 5740 8040 0 0 {name=l6546 lab=BL29}
N 5760 8000 5740 8000 {}
C {lab_pin.sym} 5740 8000 0 0 {name=l6547 lab=BLB29}
N 5760 7960 5740 7960 {}
C {lab_pin.sym} 5740 7960 0 0 {name=l6548 lab=WL40}
N 5840 8040 5860 8040 {}
C {lab_pin.sym} 5860 8040 0 0 {name=l6549 lab=VDD}
N 5840 7960 5860 7960 {}
C {lab_pin.sym} 5860 7960 0 0 {name=l6550 lab=VSS}
C {bitcell_6t.sym} 6000 8000 0 0 {name=Xr40c30}
N 5960 8040 5940 8040 {}
C {lab_pin.sym} 5940 8040 0 0 {name=l6551 lab=BL30}
N 5960 8000 5940 8000 {}
C {lab_pin.sym} 5940 8000 0 0 {name=l6552 lab=BLB30}
N 5960 7960 5940 7960 {}
C {lab_pin.sym} 5940 7960 0 0 {name=l6553 lab=WL40}
N 6040 8040 6060 8040 {}
C {lab_pin.sym} 6060 8040 0 0 {name=l6554 lab=VDD}
N 6040 7960 6060 7960 {}
C {lab_pin.sym} 6060 7960 0 0 {name=l6555 lab=VSS}
C {bitcell_6t.sym} 6200 8000 0 0 {name=Xr40c31}
N 6160 8040 6140 8040 {}
C {lab_pin.sym} 6140 8040 0 0 {name=l6556 lab=BL31}
N 6160 8000 6140 8000 {}
C {lab_pin.sym} 6140 8000 0 0 {name=l6557 lab=BLB31}
N 6160 7960 6140 7960 {}
C {lab_pin.sym} 6140 7960 0 0 {name=l6558 lab=WL40}
N 6240 8040 6260 8040 {}
C {lab_pin.sym} 6260 8040 0 0 {name=l6559 lab=VDD}
N 6240 7960 6260 7960 {}
C {lab_pin.sym} 6260 7960 0 0 {name=l6560 lab=VSS}
C {bitcell_6t.sym} 0 8200 0 0 {name=Xr41c0}
N -40 8240 -60 8240 {}
C {lab_pin.sym} -60 8240 0 0 {name=l6561 lab=BL0}
N -40 8200 -60 8200 {}
C {lab_pin.sym} -60 8200 0 0 {name=l6562 lab=BLB0}
N -40 8160 -60 8160 {}
C {lab_pin.sym} -60 8160 0 0 {name=l6563 lab=WL41}
N 40 8240 60 8240 {}
C {lab_pin.sym} 60 8240 0 0 {name=l6564 lab=VDD}
N 40 8160 60 8160 {}
C {lab_pin.sym} 60 8160 0 0 {name=l6565 lab=VSS}
C {bitcell_6t.sym} 200 8200 0 0 {name=Xr41c1}
N 160 8240 140 8240 {}
C {lab_pin.sym} 140 8240 0 0 {name=l6566 lab=BL1}
N 160 8200 140 8200 {}
C {lab_pin.sym} 140 8200 0 0 {name=l6567 lab=BLB1}
N 160 8160 140 8160 {}
C {lab_pin.sym} 140 8160 0 0 {name=l6568 lab=WL41}
N 240 8240 260 8240 {}
C {lab_pin.sym} 260 8240 0 0 {name=l6569 lab=VDD}
N 240 8160 260 8160 {}
C {lab_pin.sym} 260 8160 0 0 {name=l6570 lab=VSS}
C {bitcell_6t.sym} 400 8200 0 0 {name=Xr41c2}
N 360 8240 340 8240 {}
C {lab_pin.sym} 340 8240 0 0 {name=l6571 lab=BL2}
N 360 8200 340 8200 {}
C {lab_pin.sym} 340 8200 0 0 {name=l6572 lab=BLB2}
N 360 8160 340 8160 {}
C {lab_pin.sym} 340 8160 0 0 {name=l6573 lab=WL41}
N 440 8240 460 8240 {}
C {lab_pin.sym} 460 8240 0 0 {name=l6574 lab=VDD}
N 440 8160 460 8160 {}
C {lab_pin.sym} 460 8160 0 0 {name=l6575 lab=VSS}
C {bitcell_6t.sym} 600 8200 0 0 {name=Xr41c3}
N 560 8240 540 8240 {}
C {lab_pin.sym} 540 8240 0 0 {name=l6576 lab=BL3}
N 560 8200 540 8200 {}
C {lab_pin.sym} 540 8200 0 0 {name=l6577 lab=BLB3}
N 560 8160 540 8160 {}
C {lab_pin.sym} 540 8160 0 0 {name=l6578 lab=WL41}
N 640 8240 660 8240 {}
C {lab_pin.sym} 660 8240 0 0 {name=l6579 lab=VDD}
N 640 8160 660 8160 {}
C {lab_pin.sym} 660 8160 0 0 {name=l6580 lab=VSS}
C {bitcell_6t.sym} 800 8200 0 0 {name=Xr41c4}
N 760 8240 740 8240 {}
C {lab_pin.sym} 740 8240 0 0 {name=l6581 lab=BL4}
N 760 8200 740 8200 {}
C {lab_pin.sym} 740 8200 0 0 {name=l6582 lab=BLB4}
N 760 8160 740 8160 {}
C {lab_pin.sym} 740 8160 0 0 {name=l6583 lab=WL41}
N 840 8240 860 8240 {}
C {lab_pin.sym} 860 8240 0 0 {name=l6584 lab=VDD}
N 840 8160 860 8160 {}
C {lab_pin.sym} 860 8160 0 0 {name=l6585 lab=VSS}
C {bitcell_6t.sym} 1000 8200 0 0 {name=Xr41c5}
N 960 8240 940 8240 {}
C {lab_pin.sym} 940 8240 0 0 {name=l6586 lab=BL5}
N 960 8200 940 8200 {}
C {lab_pin.sym} 940 8200 0 0 {name=l6587 lab=BLB5}
N 960 8160 940 8160 {}
C {lab_pin.sym} 940 8160 0 0 {name=l6588 lab=WL41}
N 1040 8240 1060 8240 {}
C {lab_pin.sym} 1060 8240 0 0 {name=l6589 lab=VDD}
N 1040 8160 1060 8160 {}
C {lab_pin.sym} 1060 8160 0 0 {name=l6590 lab=VSS}
C {bitcell_6t.sym} 1200 8200 0 0 {name=Xr41c6}
N 1160 8240 1140 8240 {}
C {lab_pin.sym} 1140 8240 0 0 {name=l6591 lab=BL6}
N 1160 8200 1140 8200 {}
C {lab_pin.sym} 1140 8200 0 0 {name=l6592 lab=BLB6}
N 1160 8160 1140 8160 {}
C {lab_pin.sym} 1140 8160 0 0 {name=l6593 lab=WL41}
N 1240 8240 1260 8240 {}
C {lab_pin.sym} 1260 8240 0 0 {name=l6594 lab=VDD}
N 1240 8160 1260 8160 {}
C {lab_pin.sym} 1260 8160 0 0 {name=l6595 lab=VSS}
C {bitcell_6t.sym} 1400 8200 0 0 {name=Xr41c7}
N 1360 8240 1340 8240 {}
C {lab_pin.sym} 1340 8240 0 0 {name=l6596 lab=BL7}
N 1360 8200 1340 8200 {}
C {lab_pin.sym} 1340 8200 0 0 {name=l6597 lab=BLB7}
N 1360 8160 1340 8160 {}
C {lab_pin.sym} 1340 8160 0 0 {name=l6598 lab=WL41}
N 1440 8240 1460 8240 {}
C {lab_pin.sym} 1460 8240 0 0 {name=l6599 lab=VDD}
N 1440 8160 1460 8160 {}
C {lab_pin.sym} 1460 8160 0 0 {name=l6600 lab=VSS}
C {bitcell_6t.sym} 1600 8200 0 0 {name=Xr41c8}
N 1560 8240 1540 8240 {}
C {lab_pin.sym} 1540 8240 0 0 {name=l6601 lab=BL8}
N 1560 8200 1540 8200 {}
C {lab_pin.sym} 1540 8200 0 0 {name=l6602 lab=BLB8}
N 1560 8160 1540 8160 {}
C {lab_pin.sym} 1540 8160 0 0 {name=l6603 lab=WL41}
N 1640 8240 1660 8240 {}
C {lab_pin.sym} 1660 8240 0 0 {name=l6604 lab=VDD}
N 1640 8160 1660 8160 {}
C {lab_pin.sym} 1660 8160 0 0 {name=l6605 lab=VSS}
C {bitcell_6t.sym} 1800 8200 0 0 {name=Xr41c9}
N 1760 8240 1740 8240 {}
C {lab_pin.sym} 1740 8240 0 0 {name=l6606 lab=BL9}
N 1760 8200 1740 8200 {}
C {lab_pin.sym} 1740 8200 0 0 {name=l6607 lab=BLB9}
N 1760 8160 1740 8160 {}
C {lab_pin.sym} 1740 8160 0 0 {name=l6608 lab=WL41}
N 1840 8240 1860 8240 {}
C {lab_pin.sym} 1860 8240 0 0 {name=l6609 lab=VDD}
N 1840 8160 1860 8160 {}
C {lab_pin.sym} 1860 8160 0 0 {name=l6610 lab=VSS}
C {bitcell_6t.sym} 2000 8200 0 0 {name=Xr41c10}
N 1960 8240 1940 8240 {}
C {lab_pin.sym} 1940 8240 0 0 {name=l6611 lab=BL10}
N 1960 8200 1940 8200 {}
C {lab_pin.sym} 1940 8200 0 0 {name=l6612 lab=BLB10}
N 1960 8160 1940 8160 {}
C {lab_pin.sym} 1940 8160 0 0 {name=l6613 lab=WL41}
N 2040 8240 2060 8240 {}
C {lab_pin.sym} 2060 8240 0 0 {name=l6614 lab=VDD}
N 2040 8160 2060 8160 {}
C {lab_pin.sym} 2060 8160 0 0 {name=l6615 lab=VSS}
C {bitcell_6t.sym} 2200 8200 0 0 {name=Xr41c11}
N 2160 8240 2140 8240 {}
C {lab_pin.sym} 2140 8240 0 0 {name=l6616 lab=BL11}
N 2160 8200 2140 8200 {}
C {lab_pin.sym} 2140 8200 0 0 {name=l6617 lab=BLB11}
N 2160 8160 2140 8160 {}
C {lab_pin.sym} 2140 8160 0 0 {name=l6618 lab=WL41}
N 2240 8240 2260 8240 {}
C {lab_pin.sym} 2260 8240 0 0 {name=l6619 lab=VDD}
N 2240 8160 2260 8160 {}
C {lab_pin.sym} 2260 8160 0 0 {name=l6620 lab=VSS}
C {bitcell_6t.sym} 2400 8200 0 0 {name=Xr41c12}
N 2360 8240 2340 8240 {}
C {lab_pin.sym} 2340 8240 0 0 {name=l6621 lab=BL12}
N 2360 8200 2340 8200 {}
C {lab_pin.sym} 2340 8200 0 0 {name=l6622 lab=BLB12}
N 2360 8160 2340 8160 {}
C {lab_pin.sym} 2340 8160 0 0 {name=l6623 lab=WL41}
N 2440 8240 2460 8240 {}
C {lab_pin.sym} 2460 8240 0 0 {name=l6624 lab=VDD}
N 2440 8160 2460 8160 {}
C {lab_pin.sym} 2460 8160 0 0 {name=l6625 lab=VSS}
C {bitcell_6t.sym} 2600 8200 0 0 {name=Xr41c13}
N 2560 8240 2540 8240 {}
C {lab_pin.sym} 2540 8240 0 0 {name=l6626 lab=BL13}
N 2560 8200 2540 8200 {}
C {lab_pin.sym} 2540 8200 0 0 {name=l6627 lab=BLB13}
N 2560 8160 2540 8160 {}
C {lab_pin.sym} 2540 8160 0 0 {name=l6628 lab=WL41}
N 2640 8240 2660 8240 {}
C {lab_pin.sym} 2660 8240 0 0 {name=l6629 lab=VDD}
N 2640 8160 2660 8160 {}
C {lab_pin.sym} 2660 8160 0 0 {name=l6630 lab=VSS}
C {bitcell_6t.sym} 2800 8200 0 0 {name=Xr41c14}
N 2760 8240 2740 8240 {}
C {lab_pin.sym} 2740 8240 0 0 {name=l6631 lab=BL14}
N 2760 8200 2740 8200 {}
C {lab_pin.sym} 2740 8200 0 0 {name=l6632 lab=BLB14}
N 2760 8160 2740 8160 {}
C {lab_pin.sym} 2740 8160 0 0 {name=l6633 lab=WL41}
N 2840 8240 2860 8240 {}
C {lab_pin.sym} 2860 8240 0 0 {name=l6634 lab=VDD}
N 2840 8160 2860 8160 {}
C {lab_pin.sym} 2860 8160 0 0 {name=l6635 lab=VSS}
C {bitcell_6t.sym} 3000 8200 0 0 {name=Xr41c15}
N 2960 8240 2940 8240 {}
C {lab_pin.sym} 2940 8240 0 0 {name=l6636 lab=BL15}
N 2960 8200 2940 8200 {}
C {lab_pin.sym} 2940 8200 0 0 {name=l6637 lab=BLB15}
N 2960 8160 2940 8160 {}
C {lab_pin.sym} 2940 8160 0 0 {name=l6638 lab=WL41}
N 3040 8240 3060 8240 {}
C {lab_pin.sym} 3060 8240 0 0 {name=l6639 lab=VDD}
N 3040 8160 3060 8160 {}
C {lab_pin.sym} 3060 8160 0 0 {name=l6640 lab=VSS}
C {bitcell_6t.sym} 3200 8200 0 0 {name=Xr41c16}
N 3160 8240 3140 8240 {}
C {lab_pin.sym} 3140 8240 0 0 {name=l6641 lab=BL16}
N 3160 8200 3140 8200 {}
C {lab_pin.sym} 3140 8200 0 0 {name=l6642 lab=BLB16}
N 3160 8160 3140 8160 {}
C {lab_pin.sym} 3140 8160 0 0 {name=l6643 lab=WL41}
N 3240 8240 3260 8240 {}
C {lab_pin.sym} 3260 8240 0 0 {name=l6644 lab=VDD}
N 3240 8160 3260 8160 {}
C {lab_pin.sym} 3260 8160 0 0 {name=l6645 lab=VSS}
C {bitcell_6t.sym} 3400 8200 0 0 {name=Xr41c17}
N 3360 8240 3340 8240 {}
C {lab_pin.sym} 3340 8240 0 0 {name=l6646 lab=BL17}
N 3360 8200 3340 8200 {}
C {lab_pin.sym} 3340 8200 0 0 {name=l6647 lab=BLB17}
N 3360 8160 3340 8160 {}
C {lab_pin.sym} 3340 8160 0 0 {name=l6648 lab=WL41}
N 3440 8240 3460 8240 {}
C {lab_pin.sym} 3460 8240 0 0 {name=l6649 lab=VDD}
N 3440 8160 3460 8160 {}
C {lab_pin.sym} 3460 8160 0 0 {name=l6650 lab=VSS}
C {bitcell_6t.sym} 3600 8200 0 0 {name=Xr41c18}
N 3560 8240 3540 8240 {}
C {lab_pin.sym} 3540 8240 0 0 {name=l6651 lab=BL18}
N 3560 8200 3540 8200 {}
C {lab_pin.sym} 3540 8200 0 0 {name=l6652 lab=BLB18}
N 3560 8160 3540 8160 {}
C {lab_pin.sym} 3540 8160 0 0 {name=l6653 lab=WL41}
N 3640 8240 3660 8240 {}
C {lab_pin.sym} 3660 8240 0 0 {name=l6654 lab=VDD}
N 3640 8160 3660 8160 {}
C {lab_pin.sym} 3660 8160 0 0 {name=l6655 lab=VSS}
C {bitcell_6t.sym} 3800 8200 0 0 {name=Xr41c19}
N 3760 8240 3740 8240 {}
C {lab_pin.sym} 3740 8240 0 0 {name=l6656 lab=BL19}
N 3760 8200 3740 8200 {}
C {lab_pin.sym} 3740 8200 0 0 {name=l6657 lab=BLB19}
N 3760 8160 3740 8160 {}
C {lab_pin.sym} 3740 8160 0 0 {name=l6658 lab=WL41}
N 3840 8240 3860 8240 {}
C {lab_pin.sym} 3860 8240 0 0 {name=l6659 lab=VDD}
N 3840 8160 3860 8160 {}
C {lab_pin.sym} 3860 8160 0 0 {name=l6660 lab=VSS}
C {bitcell_6t.sym} 4000 8200 0 0 {name=Xr41c20}
N 3960 8240 3940 8240 {}
C {lab_pin.sym} 3940 8240 0 0 {name=l6661 lab=BL20}
N 3960 8200 3940 8200 {}
C {lab_pin.sym} 3940 8200 0 0 {name=l6662 lab=BLB20}
N 3960 8160 3940 8160 {}
C {lab_pin.sym} 3940 8160 0 0 {name=l6663 lab=WL41}
N 4040 8240 4060 8240 {}
C {lab_pin.sym} 4060 8240 0 0 {name=l6664 lab=VDD}
N 4040 8160 4060 8160 {}
C {lab_pin.sym} 4060 8160 0 0 {name=l6665 lab=VSS}
C {bitcell_6t.sym} 4200 8200 0 0 {name=Xr41c21}
N 4160 8240 4140 8240 {}
C {lab_pin.sym} 4140 8240 0 0 {name=l6666 lab=BL21}
N 4160 8200 4140 8200 {}
C {lab_pin.sym} 4140 8200 0 0 {name=l6667 lab=BLB21}
N 4160 8160 4140 8160 {}
C {lab_pin.sym} 4140 8160 0 0 {name=l6668 lab=WL41}
N 4240 8240 4260 8240 {}
C {lab_pin.sym} 4260 8240 0 0 {name=l6669 lab=VDD}
N 4240 8160 4260 8160 {}
C {lab_pin.sym} 4260 8160 0 0 {name=l6670 lab=VSS}
C {bitcell_6t.sym} 4400 8200 0 0 {name=Xr41c22}
N 4360 8240 4340 8240 {}
C {lab_pin.sym} 4340 8240 0 0 {name=l6671 lab=BL22}
N 4360 8200 4340 8200 {}
C {lab_pin.sym} 4340 8200 0 0 {name=l6672 lab=BLB22}
N 4360 8160 4340 8160 {}
C {lab_pin.sym} 4340 8160 0 0 {name=l6673 lab=WL41}
N 4440 8240 4460 8240 {}
C {lab_pin.sym} 4460 8240 0 0 {name=l6674 lab=VDD}
N 4440 8160 4460 8160 {}
C {lab_pin.sym} 4460 8160 0 0 {name=l6675 lab=VSS}
C {bitcell_6t.sym} 4600 8200 0 0 {name=Xr41c23}
N 4560 8240 4540 8240 {}
C {lab_pin.sym} 4540 8240 0 0 {name=l6676 lab=BL23}
N 4560 8200 4540 8200 {}
C {lab_pin.sym} 4540 8200 0 0 {name=l6677 lab=BLB23}
N 4560 8160 4540 8160 {}
C {lab_pin.sym} 4540 8160 0 0 {name=l6678 lab=WL41}
N 4640 8240 4660 8240 {}
C {lab_pin.sym} 4660 8240 0 0 {name=l6679 lab=VDD}
N 4640 8160 4660 8160 {}
C {lab_pin.sym} 4660 8160 0 0 {name=l6680 lab=VSS}
C {bitcell_6t.sym} 4800 8200 0 0 {name=Xr41c24}
N 4760 8240 4740 8240 {}
C {lab_pin.sym} 4740 8240 0 0 {name=l6681 lab=BL24}
N 4760 8200 4740 8200 {}
C {lab_pin.sym} 4740 8200 0 0 {name=l6682 lab=BLB24}
N 4760 8160 4740 8160 {}
C {lab_pin.sym} 4740 8160 0 0 {name=l6683 lab=WL41}
N 4840 8240 4860 8240 {}
C {lab_pin.sym} 4860 8240 0 0 {name=l6684 lab=VDD}
N 4840 8160 4860 8160 {}
C {lab_pin.sym} 4860 8160 0 0 {name=l6685 lab=VSS}
C {bitcell_6t.sym} 5000 8200 0 0 {name=Xr41c25}
N 4960 8240 4940 8240 {}
C {lab_pin.sym} 4940 8240 0 0 {name=l6686 lab=BL25}
N 4960 8200 4940 8200 {}
C {lab_pin.sym} 4940 8200 0 0 {name=l6687 lab=BLB25}
N 4960 8160 4940 8160 {}
C {lab_pin.sym} 4940 8160 0 0 {name=l6688 lab=WL41}
N 5040 8240 5060 8240 {}
C {lab_pin.sym} 5060 8240 0 0 {name=l6689 lab=VDD}
N 5040 8160 5060 8160 {}
C {lab_pin.sym} 5060 8160 0 0 {name=l6690 lab=VSS}
C {bitcell_6t.sym} 5200 8200 0 0 {name=Xr41c26}
N 5160 8240 5140 8240 {}
C {lab_pin.sym} 5140 8240 0 0 {name=l6691 lab=BL26}
N 5160 8200 5140 8200 {}
C {lab_pin.sym} 5140 8200 0 0 {name=l6692 lab=BLB26}
N 5160 8160 5140 8160 {}
C {lab_pin.sym} 5140 8160 0 0 {name=l6693 lab=WL41}
N 5240 8240 5260 8240 {}
C {lab_pin.sym} 5260 8240 0 0 {name=l6694 lab=VDD}
N 5240 8160 5260 8160 {}
C {lab_pin.sym} 5260 8160 0 0 {name=l6695 lab=VSS}
C {bitcell_6t.sym} 5400 8200 0 0 {name=Xr41c27}
N 5360 8240 5340 8240 {}
C {lab_pin.sym} 5340 8240 0 0 {name=l6696 lab=BL27}
N 5360 8200 5340 8200 {}
C {lab_pin.sym} 5340 8200 0 0 {name=l6697 lab=BLB27}
N 5360 8160 5340 8160 {}
C {lab_pin.sym} 5340 8160 0 0 {name=l6698 lab=WL41}
N 5440 8240 5460 8240 {}
C {lab_pin.sym} 5460 8240 0 0 {name=l6699 lab=VDD}
N 5440 8160 5460 8160 {}
C {lab_pin.sym} 5460 8160 0 0 {name=l6700 lab=VSS}
C {bitcell_6t.sym} 5600 8200 0 0 {name=Xr41c28}
N 5560 8240 5540 8240 {}
C {lab_pin.sym} 5540 8240 0 0 {name=l6701 lab=BL28}
N 5560 8200 5540 8200 {}
C {lab_pin.sym} 5540 8200 0 0 {name=l6702 lab=BLB28}
N 5560 8160 5540 8160 {}
C {lab_pin.sym} 5540 8160 0 0 {name=l6703 lab=WL41}
N 5640 8240 5660 8240 {}
C {lab_pin.sym} 5660 8240 0 0 {name=l6704 lab=VDD}
N 5640 8160 5660 8160 {}
C {lab_pin.sym} 5660 8160 0 0 {name=l6705 lab=VSS}
C {bitcell_6t.sym} 5800 8200 0 0 {name=Xr41c29}
N 5760 8240 5740 8240 {}
C {lab_pin.sym} 5740 8240 0 0 {name=l6706 lab=BL29}
N 5760 8200 5740 8200 {}
C {lab_pin.sym} 5740 8200 0 0 {name=l6707 lab=BLB29}
N 5760 8160 5740 8160 {}
C {lab_pin.sym} 5740 8160 0 0 {name=l6708 lab=WL41}
N 5840 8240 5860 8240 {}
C {lab_pin.sym} 5860 8240 0 0 {name=l6709 lab=VDD}
N 5840 8160 5860 8160 {}
C {lab_pin.sym} 5860 8160 0 0 {name=l6710 lab=VSS}
C {bitcell_6t.sym} 6000 8200 0 0 {name=Xr41c30}
N 5960 8240 5940 8240 {}
C {lab_pin.sym} 5940 8240 0 0 {name=l6711 lab=BL30}
N 5960 8200 5940 8200 {}
C {lab_pin.sym} 5940 8200 0 0 {name=l6712 lab=BLB30}
N 5960 8160 5940 8160 {}
C {lab_pin.sym} 5940 8160 0 0 {name=l6713 lab=WL41}
N 6040 8240 6060 8240 {}
C {lab_pin.sym} 6060 8240 0 0 {name=l6714 lab=VDD}
N 6040 8160 6060 8160 {}
C {lab_pin.sym} 6060 8160 0 0 {name=l6715 lab=VSS}
C {bitcell_6t.sym} 6200 8200 0 0 {name=Xr41c31}
N 6160 8240 6140 8240 {}
C {lab_pin.sym} 6140 8240 0 0 {name=l6716 lab=BL31}
N 6160 8200 6140 8200 {}
C {lab_pin.sym} 6140 8200 0 0 {name=l6717 lab=BLB31}
N 6160 8160 6140 8160 {}
C {lab_pin.sym} 6140 8160 0 0 {name=l6718 lab=WL41}
N 6240 8240 6260 8240 {}
C {lab_pin.sym} 6260 8240 0 0 {name=l6719 lab=VDD}
N 6240 8160 6260 8160 {}
C {lab_pin.sym} 6260 8160 0 0 {name=l6720 lab=VSS}
C {bitcell_6t.sym} 0 8400 0 0 {name=Xr42c0}
N -40 8440 -60 8440 {}
C {lab_pin.sym} -60 8440 0 0 {name=l6721 lab=BL0}
N -40 8400 -60 8400 {}
C {lab_pin.sym} -60 8400 0 0 {name=l6722 lab=BLB0}
N -40 8360 -60 8360 {}
C {lab_pin.sym} -60 8360 0 0 {name=l6723 lab=WL42}
N 40 8440 60 8440 {}
C {lab_pin.sym} 60 8440 0 0 {name=l6724 lab=VDD}
N 40 8360 60 8360 {}
C {lab_pin.sym} 60 8360 0 0 {name=l6725 lab=VSS}
C {bitcell_6t.sym} 200 8400 0 0 {name=Xr42c1}
N 160 8440 140 8440 {}
C {lab_pin.sym} 140 8440 0 0 {name=l6726 lab=BL1}
N 160 8400 140 8400 {}
C {lab_pin.sym} 140 8400 0 0 {name=l6727 lab=BLB1}
N 160 8360 140 8360 {}
C {lab_pin.sym} 140 8360 0 0 {name=l6728 lab=WL42}
N 240 8440 260 8440 {}
C {lab_pin.sym} 260 8440 0 0 {name=l6729 lab=VDD}
N 240 8360 260 8360 {}
C {lab_pin.sym} 260 8360 0 0 {name=l6730 lab=VSS}
C {bitcell_6t.sym} 400 8400 0 0 {name=Xr42c2}
N 360 8440 340 8440 {}
C {lab_pin.sym} 340 8440 0 0 {name=l6731 lab=BL2}
N 360 8400 340 8400 {}
C {lab_pin.sym} 340 8400 0 0 {name=l6732 lab=BLB2}
N 360 8360 340 8360 {}
C {lab_pin.sym} 340 8360 0 0 {name=l6733 lab=WL42}
N 440 8440 460 8440 {}
C {lab_pin.sym} 460 8440 0 0 {name=l6734 lab=VDD}
N 440 8360 460 8360 {}
C {lab_pin.sym} 460 8360 0 0 {name=l6735 lab=VSS}
C {bitcell_6t.sym} 600 8400 0 0 {name=Xr42c3}
N 560 8440 540 8440 {}
C {lab_pin.sym} 540 8440 0 0 {name=l6736 lab=BL3}
N 560 8400 540 8400 {}
C {lab_pin.sym} 540 8400 0 0 {name=l6737 lab=BLB3}
N 560 8360 540 8360 {}
C {lab_pin.sym} 540 8360 0 0 {name=l6738 lab=WL42}
N 640 8440 660 8440 {}
C {lab_pin.sym} 660 8440 0 0 {name=l6739 lab=VDD}
N 640 8360 660 8360 {}
C {lab_pin.sym} 660 8360 0 0 {name=l6740 lab=VSS}
C {bitcell_6t.sym} 800 8400 0 0 {name=Xr42c4}
N 760 8440 740 8440 {}
C {lab_pin.sym} 740 8440 0 0 {name=l6741 lab=BL4}
N 760 8400 740 8400 {}
C {lab_pin.sym} 740 8400 0 0 {name=l6742 lab=BLB4}
N 760 8360 740 8360 {}
C {lab_pin.sym} 740 8360 0 0 {name=l6743 lab=WL42}
N 840 8440 860 8440 {}
C {lab_pin.sym} 860 8440 0 0 {name=l6744 lab=VDD}
N 840 8360 860 8360 {}
C {lab_pin.sym} 860 8360 0 0 {name=l6745 lab=VSS}
C {bitcell_6t.sym} 1000 8400 0 0 {name=Xr42c5}
N 960 8440 940 8440 {}
C {lab_pin.sym} 940 8440 0 0 {name=l6746 lab=BL5}
N 960 8400 940 8400 {}
C {lab_pin.sym} 940 8400 0 0 {name=l6747 lab=BLB5}
N 960 8360 940 8360 {}
C {lab_pin.sym} 940 8360 0 0 {name=l6748 lab=WL42}
N 1040 8440 1060 8440 {}
C {lab_pin.sym} 1060 8440 0 0 {name=l6749 lab=VDD}
N 1040 8360 1060 8360 {}
C {lab_pin.sym} 1060 8360 0 0 {name=l6750 lab=VSS}
C {bitcell_6t.sym} 1200 8400 0 0 {name=Xr42c6}
N 1160 8440 1140 8440 {}
C {lab_pin.sym} 1140 8440 0 0 {name=l6751 lab=BL6}
N 1160 8400 1140 8400 {}
C {lab_pin.sym} 1140 8400 0 0 {name=l6752 lab=BLB6}
N 1160 8360 1140 8360 {}
C {lab_pin.sym} 1140 8360 0 0 {name=l6753 lab=WL42}
N 1240 8440 1260 8440 {}
C {lab_pin.sym} 1260 8440 0 0 {name=l6754 lab=VDD}
N 1240 8360 1260 8360 {}
C {lab_pin.sym} 1260 8360 0 0 {name=l6755 lab=VSS}
C {bitcell_6t.sym} 1400 8400 0 0 {name=Xr42c7}
N 1360 8440 1340 8440 {}
C {lab_pin.sym} 1340 8440 0 0 {name=l6756 lab=BL7}
N 1360 8400 1340 8400 {}
C {lab_pin.sym} 1340 8400 0 0 {name=l6757 lab=BLB7}
N 1360 8360 1340 8360 {}
C {lab_pin.sym} 1340 8360 0 0 {name=l6758 lab=WL42}
N 1440 8440 1460 8440 {}
C {lab_pin.sym} 1460 8440 0 0 {name=l6759 lab=VDD}
N 1440 8360 1460 8360 {}
C {lab_pin.sym} 1460 8360 0 0 {name=l6760 lab=VSS}
C {bitcell_6t.sym} 1600 8400 0 0 {name=Xr42c8}
N 1560 8440 1540 8440 {}
C {lab_pin.sym} 1540 8440 0 0 {name=l6761 lab=BL8}
N 1560 8400 1540 8400 {}
C {lab_pin.sym} 1540 8400 0 0 {name=l6762 lab=BLB8}
N 1560 8360 1540 8360 {}
C {lab_pin.sym} 1540 8360 0 0 {name=l6763 lab=WL42}
N 1640 8440 1660 8440 {}
C {lab_pin.sym} 1660 8440 0 0 {name=l6764 lab=VDD}
N 1640 8360 1660 8360 {}
C {lab_pin.sym} 1660 8360 0 0 {name=l6765 lab=VSS}
C {bitcell_6t.sym} 1800 8400 0 0 {name=Xr42c9}
N 1760 8440 1740 8440 {}
C {lab_pin.sym} 1740 8440 0 0 {name=l6766 lab=BL9}
N 1760 8400 1740 8400 {}
C {lab_pin.sym} 1740 8400 0 0 {name=l6767 lab=BLB9}
N 1760 8360 1740 8360 {}
C {lab_pin.sym} 1740 8360 0 0 {name=l6768 lab=WL42}
N 1840 8440 1860 8440 {}
C {lab_pin.sym} 1860 8440 0 0 {name=l6769 lab=VDD}
N 1840 8360 1860 8360 {}
C {lab_pin.sym} 1860 8360 0 0 {name=l6770 lab=VSS}
C {bitcell_6t.sym} 2000 8400 0 0 {name=Xr42c10}
N 1960 8440 1940 8440 {}
C {lab_pin.sym} 1940 8440 0 0 {name=l6771 lab=BL10}
N 1960 8400 1940 8400 {}
C {lab_pin.sym} 1940 8400 0 0 {name=l6772 lab=BLB10}
N 1960 8360 1940 8360 {}
C {lab_pin.sym} 1940 8360 0 0 {name=l6773 lab=WL42}
N 2040 8440 2060 8440 {}
C {lab_pin.sym} 2060 8440 0 0 {name=l6774 lab=VDD}
N 2040 8360 2060 8360 {}
C {lab_pin.sym} 2060 8360 0 0 {name=l6775 lab=VSS}
C {bitcell_6t.sym} 2200 8400 0 0 {name=Xr42c11}
N 2160 8440 2140 8440 {}
C {lab_pin.sym} 2140 8440 0 0 {name=l6776 lab=BL11}
N 2160 8400 2140 8400 {}
C {lab_pin.sym} 2140 8400 0 0 {name=l6777 lab=BLB11}
N 2160 8360 2140 8360 {}
C {lab_pin.sym} 2140 8360 0 0 {name=l6778 lab=WL42}
N 2240 8440 2260 8440 {}
C {lab_pin.sym} 2260 8440 0 0 {name=l6779 lab=VDD}
N 2240 8360 2260 8360 {}
C {lab_pin.sym} 2260 8360 0 0 {name=l6780 lab=VSS}
C {bitcell_6t.sym} 2400 8400 0 0 {name=Xr42c12}
N 2360 8440 2340 8440 {}
C {lab_pin.sym} 2340 8440 0 0 {name=l6781 lab=BL12}
N 2360 8400 2340 8400 {}
C {lab_pin.sym} 2340 8400 0 0 {name=l6782 lab=BLB12}
N 2360 8360 2340 8360 {}
C {lab_pin.sym} 2340 8360 0 0 {name=l6783 lab=WL42}
N 2440 8440 2460 8440 {}
C {lab_pin.sym} 2460 8440 0 0 {name=l6784 lab=VDD}
N 2440 8360 2460 8360 {}
C {lab_pin.sym} 2460 8360 0 0 {name=l6785 lab=VSS}
C {bitcell_6t.sym} 2600 8400 0 0 {name=Xr42c13}
N 2560 8440 2540 8440 {}
C {lab_pin.sym} 2540 8440 0 0 {name=l6786 lab=BL13}
N 2560 8400 2540 8400 {}
C {lab_pin.sym} 2540 8400 0 0 {name=l6787 lab=BLB13}
N 2560 8360 2540 8360 {}
C {lab_pin.sym} 2540 8360 0 0 {name=l6788 lab=WL42}
N 2640 8440 2660 8440 {}
C {lab_pin.sym} 2660 8440 0 0 {name=l6789 lab=VDD}
N 2640 8360 2660 8360 {}
C {lab_pin.sym} 2660 8360 0 0 {name=l6790 lab=VSS}
C {bitcell_6t.sym} 2800 8400 0 0 {name=Xr42c14}
N 2760 8440 2740 8440 {}
C {lab_pin.sym} 2740 8440 0 0 {name=l6791 lab=BL14}
N 2760 8400 2740 8400 {}
C {lab_pin.sym} 2740 8400 0 0 {name=l6792 lab=BLB14}
N 2760 8360 2740 8360 {}
C {lab_pin.sym} 2740 8360 0 0 {name=l6793 lab=WL42}
N 2840 8440 2860 8440 {}
C {lab_pin.sym} 2860 8440 0 0 {name=l6794 lab=VDD}
N 2840 8360 2860 8360 {}
C {lab_pin.sym} 2860 8360 0 0 {name=l6795 lab=VSS}
C {bitcell_6t.sym} 3000 8400 0 0 {name=Xr42c15}
N 2960 8440 2940 8440 {}
C {lab_pin.sym} 2940 8440 0 0 {name=l6796 lab=BL15}
N 2960 8400 2940 8400 {}
C {lab_pin.sym} 2940 8400 0 0 {name=l6797 lab=BLB15}
N 2960 8360 2940 8360 {}
C {lab_pin.sym} 2940 8360 0 0 {name=l6798 lab=WL42}
N 3040 8440 3060 8440 {}
C {lab_pin.sym} 3060 8440 0 0 {name=l6799 lab=VDD}
N 3040 8360 3060 8360 {}
C {lab_pin.sym} 3060 8360 0 0 {name=l6800 lab=VSS}
C {bitcell_6t.sym} 3200 8400 0 0 {name=Xr42c16}
N 3160 8440 3140 8440 {}
C {lab_pin.sym} 3140 8440 0 0 {name=l6801 lab=BL16}
N 3160 8400 3140 8400 {}
C {lab_pin.sym} 3140 8400 0 0 {name=l6802 lab=BLB16}
N 3160 8360 3140 8360 {}
C {lab_pin.sym} 3140 8360 0 0 {name=l6803 lab=WL42}
N 3240 8440 3260 8440 {}
C {lab_pin.sym} 3260 8440 0 0 {name=l6804 lab=VDD}
N 3240 8360 3260 8360 {}
C {lab_pin.sym} 3260 8360 0 0 {name=l6805 lab=VSS}
C {bitcell_6t.sym} 3400 8400 0 0 {name=Xr42c17}
N 3360 8440 3340 8440 {}
C {lab_pin.sym} 3340 8440 0 0 {name=l6806 lab=BL17}
N 3360 8400 3340 8400 {}
C {lab_pin.sym} 3340 8400 0 0 {name=l6807 lab=BLB17}
N 3360 8360 3340 8360 {}
C {lab_pin.sym} 3340 8360 0 0 {name=l6808 lab=WL42}
N 3440 8440 3460 8440 {}
C {lab_pin.sym} 3460 8440 0 0 {name=l6809 lab=VDD}
N 3440 8360 3460 8360 {}
C {lab_pin.sym} 3460 8360 0 0 {name=l6810 lab=VSS}
C {bitcell_6t.sym} 3600 8400 0 0 {name=Xr42c18}
N 3560 8440 3540 8440 {}
C {lab_pin.sym} 3540 8440 0 0 {name=l6811 lab=BL18}
N 3560 8400 3540 8400 {}
C {lab_pin.sym} 3540 8400 0 0 {name=l6812 lab=BLB18}
N 3560 8360 3540 8360 {}
C {lab_pin.sym} 3540 8360 0 0 {name=l6813 lab=WL42}
N 3640 8440 3660 8440 {}
C {lab_pin.sym} 3660 8440 0 0 {name=l6814 lab=VDD}
N 3640 8360 3660 8360 {}
C {lab_pin.sym} 3660 8360 0 0 {name=l6815 lab=VSS}
C {bitcell_6t.sym} 3800 8400 0 0 {name=Xr42c19}
N 3760 8440 3740 8440 {}
C {lab_pin.sym} 3740 8440 0 0 {name=l6816 lab=BL19}
N 3760 8400 3740 8400 {}
C {lab_pin.sym} 3740 8400 0 0 {name=l6817 lab=BLB19}
N 3760 8360 3740 8360 {}
C {lab_pin.sym} 3740 8360 0 0 {name=l6818 lab=WL42}
N 3840 8440 3860 8440 {}
C {lab_pin.sym} 3860 8440 0 0 {name=l6819 lab=VDD}
N 3840 8360 3860 8360 {}
C {lab_pin.sym} 3860 8360 0 0 {name=l6820 lab=VSS}
C {bitcell_6t.sym} 4000 8400 0 0 {name=Xr42c20}
N 3960 8440 3940 8440 {}
C {lab_pin.sym} 3940 8440 0 0 {name=l6821 lab=BL20}
N 3960 8400 3940 8400 {}
C {lab_pin.sym} 3940 8400 0 0 {name=l6822 lab=BLB20}
N 3960 8360 3940 8360 {}
C {lab_pin.sym} 3940 8360 0 0 {name=l6823 lab=WL42}
N 4040 8440 4060 8440 {}
C {lab_pin.sym} 4060 8440 0 0 {name=l6824 lab=VDD}
N 4040 8360 4060 8360 {}
C {lab_pin.sym} 4060 8360 0 0 {name=l6825 lab=VSS}
C {bitcell_6t.sym} 4200 8400 0 0 {name=Xr42c21}
N 4160 8440 4140 8440 {}
C {lab_pin.sym} 4140 8440 0 0 {name=l6826 lab=BL21}
N 4160 8400 4140 8400 {}
C {lab_pin.sym} 4140 8400 0 0 {name=l6827 lab=BLB21}
N 4160 8360 4140 8360 {}
C {lab_pin.sym} 4140 8360 0 0 {name=l6828 lab=WL42}
N 4240 8440 4260 8440 {}
C {lab_pin.sym} 4260 8440 0 0 {name=l6829 lab=VDD}
N 4240 8360 4260 8360 {}
C {lab_pin.sym} 4260 8360 0 0 {name=l6830 lab=VSS}
C {bitcell_6t.sym} 4400 8400 0 0 {name=Xr42c22}
N 4360 8440 4340 8440 {}
C {lab_pin.sym} 4340 8440 0 0 {name=l6831 lab=BL22}
N 4360 8400 4340 8400 {}
C {lab_pin.sym} 4340 8400 0 0 {name=l6832 lab=BLB22}
N 4360 8360 4340 8360 {}
C {lab_pin.sym} 4340 8360 0 0 {name=l6833 lab=WL42}
N 4440 8440 4460 8440 {}
C {lab_pin.sym} 4460 8440 0 0 {name=l6834 lab=VDD}
N 4440 8360 4460 8360 {}
C {lab_pin.sym} 4460 8360 0 0 {name=l6835 lab=VSS}
C {bitcell_6t.sym} 4600 8400 0 0 {name=Xr42c23}
N 4560 8440 4540 8440 {}
C {lab_pin.sym} 4540 8440 0 0 {name=l6836 lab=BL23}
N 4560 8400 4540 8400 {}
C {lab_pin.sym} 4540 8400 0 0 {name=l6837 lab=BLB23}
N 4560 8360 4540 8360 {}
C {lab_pin.sym} 4540 8360 0 0 {name=l6838 lab=WL42}
N 4640 8440 4660 8440 {}
C {lab_pin.sym} 4660 8440 0 0 {name=l6839 lab=VDD}
N 4640 8360 4660 8360 {}
C {lab_pin.sym} 4660 8360 0 0 {name=l6840 lab=VSS}
C {bitcell_6t.sym} 4800 8400 0 0 {name=Xr42c24}
N 4760 8440 4740 8440 {}
C {lab_pin.sym} 4740 8440 0 0 {name=l6841 lab=BL24}
N 4760 8400 4740 8400 {}
C {lab_pin.sym} 4740 8400 0 0 {name=l6842 lab=BLB24}
N 4760 8360 4740 8360 {}
C {lab_pin.sym} 4740 8360 0 0 {name=l6843 lab=WL42}
N 4840 8440 4860 8440 {}
C {lab_pin.sym} 4860 8440 0 0 {name=l6844 lab=VDD}
N 4840 8360 4860 8360 {}
C {lab_pin.sym} 4860 8360 0 0 {name=l6845 lab=VSS}
C {bitcell_6t.sym} 5000 8400 0 0 {name=Xr42c25}
N 4960 8440 4940 8440 {}
C {lab_pin.sym} 4940 8440 0 0 {name=l6846 lab=BL25}
N 4960 8400 4940 8400 {}
C {lab_pin.sym} 4940 8400 0 0 {name=l6847 lab=BLB25}
N 4960 8360 4940 8360 {}
C {lab_pin.sym} 4940 8360 0 0 {name=l6848 lab=WL42}
N 5040 8440 5060 8440 {}
C {lab_pin.sym} 5060 8440 0 0 {name=l6849 lab=VDD}
N 5040 8360 5060 8360 {}
C {lab_pin.sym} 5060 8360 0 0 {name=l6850 lab=VSS}
C {bitcell_6t.sym} 5200 8400 0 0 {name=Xr42c26}
N 5160 8440 5140 8440 {}
C {lab_pin.sym} 5140 8440 0 0 {name=l6851 lab=BL26}
N 5160 8400 5140 8400 {}
C {lab_pin.sym} 5140 8400 0 0 {name=l6852 lab=BLB26}
N 5160 8360 5140 8360 {}
C {lab_pin.sym} 5140 8360 0 0 {name=l6853 lab=WL42}
N 5240 8440 5260 8440 {}
C {lab_pin.sym} 5260 8440 0 0 {name=l6854 lab=VDD}
N 5240 8360 5260 8360 {}
C {lab_pin.sym} 5260 8360 0 0 {name=l6855 lab=VSS}
C {bitcell_6t.sym} 5400 8400 0 0 {name=Xr42c27}
N 5360 8440 5340 8440 {}
C {lab_pin.sym} 5340 8440 0 0 {name=l6856 lab=BL27}
N 5360 8400 5340 8400 {}
C {lab_pin.sym} 5340 8400 0 0 {name=l6857 lab=BLB27}
N 5360 8360 5340 8360 {}
C {lab_pin.sym} 5340 8360 0 0 {name=l6858 lab=WL42}
N 5440 8440 5460 8440 {}
C {lab_pin.sym} 5460 8440 0 0 {name=l6859 lab=VDD}
N 5440 8360 5460 8360 {}
C {lab_pin.sym} 5460 8360 0 0 {name=l6860 lab=VSS}
C {bitcell_6t.sym} 5600 8400 0 0 {name=Xr42c28}
N 5560 8440 5540 8440 {}
C {lab_pin.sym} 5540 8440 0 0 {name=l6861 lab=BL28}
N 5560 8400 5540 8400 {}
C {lab_pin.sym} 5540 8400 0 0 {name=l6862 lab=BLB28}
N 5560 8360 5540 8360 {}
C {lab_pin.sym} 5540 8360 0 0 {name=l6863 lab=WL42}
N 5640 8440 5660 8440 {}
C {lab_pin.sym} 5660 8440 0 0 {name=l6864 lab=VDD}
N 5640 8360 5660 8360 {}
C {lab_pin.sym} 5660 8360 0 0 {name=l6865 lab=VSS}
C {bitcell_6t.sym} 5800 8400 0 0 {name=Xr42c29}
N 5760 8440 5740 8440 {}
C {lab_pin.sym} 5740 8440 0 0 {name=l6866 lab=BL29}
N 5760 8400 5740 8400 {}
C {lab_pin.sym} 5740 8400 0 0 {name=l6867 lab=BLB29}
N 5760 8360 5740 8360 {}
C {lab_pin.sym} 5740 8360 0 0 {name=l6868 lab=WL42}
N 5840 8440 5860 8440 {}
C {lab_pin.sym} 5860 8440 0 0 {name=l6869 lab=VDD}
N 5840 8360 5860 8360 {}
C {lab_pin.sym} 5860 8360 0 0 {name=l6870 lab=VSS}
C {bitcell_6t.sym} 6000 8400 0 0 {name=Xr42c30}
N 5960 8440 5940 8440 {}
C {lab_pin.sym} 5940 8440 0 0 {name=l6871 lab=BL30}
N 5960 8400 5940 8400 {}
C {lab_pin.sym} 5940 8400 0 0 {name=l6872 lab=BLB30}
N 5960 8360 5940 8360 {}
C {lab_pin.sym} 5940 8360 0 0 {name=l6873 lab=WL42}
N 6040 8440 6060 8440 {}
C {lab_pin.sym} 6060 8440 0 0 {name=l6874 lab=VDD}
N 6040 8360 6060 8360 {}
C {lab_pin.sym} 6060 8360 0 0 {name=l6875 lab=VSS}
C {bitcell_6t.sym} 6200 8400 0 0 {name=Xr42c31}
N 6160 8440 6140 8440 {}
C {lab_pin.sym} 6140 8440 0 0 {name=l6876 lab=BL31}
N 6160 8400 6140 8400 {}
C {lab_pin.sym} 6140 8400 0 0 {name=l6877 lab=BLB31}
N 6160 8360 6140 8360 {}
C {lab_pin.sym} 6140 8360 0 0 {name=l6878 lab=WL42}
N 6240 8440 6260 8440 {}
C {lab_pin.sym} 6260 8440 0 0 {name=l6879 lab=VDD}
N 6240 8360 6260 8360 {}
C {lab_pin.sym} 6260 8360 0 0 {name=l6880 lab=VSS}
C {bitcell_6t.sym} 0 8600 0 0 {name=Xr43c0}
N -40 8640 -60 8640 {}
C {lab_pin.sym} -60 8640 0 0 {name=l6881 lab=BL0}
N -40 8600 -60 8600 {}
C {lab_pin.sym} -60 8600 0 0 {name=l6882 lab=BLB0}
N -40 8560 -60 8560 {}
C {lab_pin.sym} -60 8560 0 0 {name=l6883 lab=WL43}
N 40 8640 60 8640 {}
C {lab_pin.sym} 60 8640 0 0 {name=l6884 lab=VDD}
N 40 8560 60 8560 {}
C {lab_pin.sym} 60 8560 0 0 {name=l6885 lab=VSS}
C {bitcell_6t.sym} 200 8600 0 0 {name=Xr43c1}
N 160 8640 140 8640 {}
C {lab_pin.sym} 140 8640 0 0 {name=l6886 lab=BL1}
N 160 8600 140 8600 {}
C {lab_pin.sym} 140 8600 0 0 {name=l6887 lab=BLB1}
N 160 8560 140 8560 {}
C {lab_pin.sym} 140 8560 0 0 {name=l6888 lab=WL43}
N 240 8640 260 8640 {}
C {lab_pin.sym} 260 8640 0 0 {name=l6889 lab=VDD}
N 240 8560 260 8560 {}
C {lab_pin.sym} 260 8560 0 0 {name=l6890 lab=VSS}
C {bitcell_6t.sym} 400 8600 0 0 {name=Xr43c2}
N 360 8640 340 8640 {}
C {lab_pin.sym} 340 8640 0 0 {name=l6891 lab=BL2}
N 360 8600 340 8600 {}
C {lab_pin.sym} 340 8600 0 0 {name=l6892 lab=BLB2}
N 360 8560 340 8560 {}
C {lab_pin.sym} 340 8560 0 0 {name=l6893 lab=WL43}
N 440 8640 460 8640 {}
C {lab_pin.sym} 460 8640 0 0 {name=l6894 lab=VDD}
N 440 8560 460 8560 {}
C {lab_pin.sym} 460 8560 0 0 {name=l6895 lab=VSS}
C {bitcell_6t.sym} 600 8600 0 0 {name=Xr43c3}
N 560 8640 540 8640 {}
C {lab_pin.sym} 540 8640 0 0 {name=l6896 lab=BL3}
N 560 8600 540 8600 {}
C {lab_pin.sym} 540 8600 0 0 {name=l6897 lab=BLB3}
N 560 8560 540 8560 {}
C {lab_pin.sym} 540 8560 0 0 {name=l6898 lab=WL43}
N 640 8640 660 8640 {}
C {lab_pin.sym} 660 8640 0 0 {name=l6899 lab=VDD}
N 640 8560 660 8560 {}
C {lab_pin.sym} 660 8560 0 0 {name=l6900 lab=VSS}
C {bitcell_6t.sym} 800 8600 0 0 {name=Xr43c4}
N 760 8640 740 8640 {}
C {lab_pin.sym} 740 8640 0 0 {name=l6901 lab=BL4}
N 760 8600 740 8600 {}
C {lab_pin.sym} 740 8600 0 0 {name=l6902 lab=BLB4}
N 760 8560 740 8560 {}
C {lab_pin.sym} 740 8560 0 0 {name=l6903 lab=WL43}
N 840 8640 860 8640 {}
C {lab_pin.sym} 860 8640 0 0 {name=l6904 lab=VDD}
N 840 8560 860 8560 {}
C {lab_pin.sym} 860 8560 0 0 {name=l6905 lab=VSS}
C {bitcell_6t.sym} 1000 8600 0 0 {name=Xr43c5}
N 960 8640 940 8640 {}
C {lab_pin.sym} 940 8640 0 0 {name=l6906 lab=BL5}
N 960 8600 940 8600 {}
C {lab_pin.sym} 940 8600 0 0 {name=l6907 lab=BLB5}
N 960 8560 940 8560 {}
C {lab_pin.sym} 940 8560 0 0 {name=l6908 lab=WL43}
N 1040 8640 1060 8640 {}
C {lab_pin.sym} 1060 8640 0 0 {name=l6909 lab=VDD}
N 1040 8560 1060 8560 {}
C {lab_pin.sym} 1060 8560 0 0 {name=l6910 lab=VSS}
C {bitcell_6t.sym} 1200 8600 0 0 {name=Xr43c6}
N 1160 8640 1140 8640 {}
C {lab_pin.sym} 1140 8640 0 0 {name=l6911 lab=BL6}
N 1160 8600 1140 8600 {}
C {lab_pin.sym} 1140 8600 0 0 {name=l6912 lab=BLB6}
N 1160 8560 1140 8560 {}
C {lab_pin.sym} 1140 8560 0 0 {name=l6913 lab=WL43}
N 1240 8640 1260 8640 {}
C {lab_pin.sym} 1260 8640 0 0 {name=l6914 lab=VDD}
N 1240 8560 1260 8560 {}
C {lab_pin.sym} 1260 8560 0 0 {name=l6915 lab=VSS}
C {bitcell_6t.sym} 1400 8600 0 0 {name=Xr43c7}
N 1360 8640 1340 8640 {}
C {lab_pin.sym} 1340 8640 0 0 {name=l6916 lab=BL7}
N 1360 8600 1340 8600 {}
C {lab_pin.sym} 1340 8600 0 0 {name=l6917 lab=BLB7}
N 1360 8560 1340 8560 {}
C {lab_pin.sym} 1340 8560 0 0 {name=l6918 lab=WL43}
N 1440 8640 1460 8640 {}
C {lab_pin.sym} 1460 8640 0 0 {name=l6919 lab=VDD}
N 1440 8560 1460 8560 {}
C {lab_pin.sym} 1460 8560 0 0 {name=l6920 lab=VSS}
C {bitcell_6t.sym} 1600 8600 0 0 {name=Xr43c8}
N 1560 8640 1540 8640 {}
C {lab_pin.sym} 1540 8640 0 0 {name=l6921 lab=BL8}
N 1560 8600 1540 8600 {}
C {lab_pin.sym} 1540 8600 0 0 {name=l6922 lab=BLB8}
N 1560 8560 1540 8560 {}
C {lab_pin.sym} 1540 8560 0 0 {name=l6923 lab=WL43}
N 1640 8640 1660 8640 {}
C {lab_pin.sym} 1660 8640 0 0 {name=l6924 lab=VDD}
N 1640 8560 1660 8560 {}
C {lab_pin.sym} 1660 8560 0 0 {name=l6925 lab=VSS}
C {bitcell_6t.sym} 1800 8600 0 0 {name=Xr43c9}
N 1760 8640 1740 8640 {}
C {lab_pin.sym} 1740 8640 0 0 {name=l6926 lab=BL9}
N 1760 8600 1740 8600 {}
C {lab_pin.sym} 1740 8600 0 0 {name=l6927 lab=BLB9}
N 1760 8560 1740 8560 {}
C {lab_pin.sym} 1740 8560 0 0 {name=l6928 lab=WL43}
N 1840 8640 1860 8640 {}
C {lab_pin.sym} 1860 8640 0 0 {name=l6929 lab=VDD}
N 1840 8560 1860 8560 {}
C {lab_pin.sym} 1860 8560 0 0 {name=l6930 lab=VSS}
C {bitcell_6t.sym} 2000 8600 0 0 {name=Xr43c10}
N 1960 8640 1940 8640 {}
C {lab_pin.sym} 1940 8640 0 0 {name=l6931 lab=BL10}
N 1960 8600 1940 8600 {}
C {lab_pin.sym} 1940 8600 0 0 {name=l6932 lab=BLB10}
N 1960 8560 1940 8560 {}
C {lab_pin.sym} 1940 8560 0 0 {name=l6933 lab=WL43}
N 2040 8640 2060 8640 {}
C {lab_pin.sym} 2060 8640 0 0 {name=l6934 lab=VDD}
N 2040 8560 2060 8560 {}
C {lab_pin.sym} 2060 8560 0 0 {name=l6935 lab=VSS}
C {bitcell_6t.sym} 2200 8600 0 0 {name=Xr43c11}
N 2160 8640 2140 8640 {}
C {lab_pin.sym} 2140 8640 0 0 {name=l6936 lab=BL11}
N 2160 8600 2140 8600 {}
C {lab_pin.sym} 2140 8600 0 0 {name=l6937 lab=BLB11}
N 2160 8560 2140 8560 {}
C {lab_pin.sym} 2140 8560 0 0 {name=l6938 lab=WL43}
N 2240 8640 2260 8640 {}
C {lab_pin.sym} 2260 8640 0 0 {name=l6939 lab=VDD}
N 2240 8560 2260 8560 {}
C {lab_pin.sym} 2260 8560 0 0 {name=l6940 lab=VSS}
C {bitcell_6t.sym} 2400 8600 0 0 {name=Xr43c12}
N 2360 8640 2340 8640 {}
C {lab_pin.sym} 2340 8640 0 0 {name=l6941 lab=BL12}
N 2360 8600 2340 8600 {}
C {lab_pin.sym} 2340 8600 0 0 {name=l6942 lab=BLB12}
N 2360 8560 2340 8560 {}
C {lab_pin.sym} 2340 8560 0 0 {name=l6943 lab=WL43}
N 2440 8640 2460 8640 {}
C {lab_pin.sym} 2460 8640 0 0 {name=l6944 lab=VDD}
N 2440 8560 2460 8560 {}
C {lab_pin.sym} 2460 8560 0 0 {name=l6945 lab=VSS}
C {bitcell_6t.sym} 2600 8600 0 0 {name=Xr43c13}
N 2560 8640 2540 8640 {}
C {lab_pin.sym} 2540 8640 0 0 {name=l6946 lab=BL13}
N 2560 8600 2540 8600 {}
C {lab_pin.sym} 2540 8600 0 0 {name=l6947 lab=BLB13}
N 2560 8560 2540 8560 {}
C {lab_pin.sym} 2540 8560 0 0 {name=l6948 lab=WL43}
N 2640 8640 2660 8640 {}
C {lab_pin.sym} 2660 8640 0 0 {name=l6949 lab=VDD}
N 2640 8560 2660 8560 {}
C {lab_pin.sym} 2660 8560 0 0 {name=l6950 lab=VSS}
C {bitcell_6t.sym} 2800 8600 0 0 {name=Xr43c14}
N 2760 8640 2740 8640 {}
C {lab_pin.sym} 2740 8640 0 0 {name=l6951 lab=BL14}
N 2760 8600 2740 8600 {}
C {lab_pin.sym} 2740 8600 0 0 {name=l6952 lab=BLB14}
N 2760 8560 2740 8560 {}
C {lab_pin.sym} 2740 8560 0 0 {name=l6953 lab=WL43}
N 2840 8640 2860 8640 {}
C {lab_pin.sym} 2860 8640 0 0 {name=l6954 lab=VDD}
N 2840 8560 2860 8560 {}
C {lab_pin.sym} 2860 8560 0 0 {name=l6955 lab=VSS}
C {bitcell_6t.sym} 3000 8600 0 0 {name=Xr43c15}
N 2960 8640 2940 8640 {}
C {lab_pin.sym} 2940 8640 0 0 {name=l6956 lab=BL15}
N 2960 8600 2940 8600 {}
C {lab_pin.sym} 2940 8600 0 0 {name=l6957 lab=BLB15}
N 2960 8560 2940 8560 {}
C {lab_pin.sym} 2940 8560 0 0 {name=l6958 lab=WL43}
N 3040 8640 3060 8640 {}
C {lab_pin.sym} 3060 8640 0 0 {name=l6959 lab=VDD}
N 3040 8560 3060 8560 {}
C {lab_pin.sym} 3060 8560 0 0 {name=l6960 lab=VSS}
C {bitcell_6t.sym} 3200 8600 0 0 {name=Xr43c16}
N 3160 8640 3140 8640 {}
C {lab_pin.sym} 3140 8640 0 0 {name=l6961 lab=BL16}
N 3160 8600 3140 8600 {}
C {lab_pin.sym} 3140 8600 0 0 {name=l6962 lab=BLB16}
N 3160 8560 3140 8560 {}
C {lab_pin.sym} 3140 8560 0 0 {name=l6963 lab=WL43}
N 3240 8640 3260 8640 {}
C {lab_pin.sym} 3260 8640 0 0 {name=l6964 lab=VDD}
N 3240 8560 3260 8560 {}
C {lab_pin.sym} 3260 8560 0 0 {name=l6965 lab=VSS}
C {bitcell_6t.sym} 3400 8600 0 0 {name=Xr43c17}
N 3360 8640 3340 8640 {}
C {lab_pin.sym} 3340 8640 0 0 {name=l6966 lab=BL17}
N 3360 8600 3340 8600 {}
C {lab_pin.sym} 3340 8600 0 0 {name=l6967 lab=BLB17}
N 3360 8560 3340 8560 {}
C {lab_pin.sym} 3340 8560 0 0 {name=l6968 lab=WL43}
N 3440 8640 3460 8640 {}
C {lab_pin.sym} 3460 8640 0 0 {name=l6969 lab=VDD}
N 3440 8560 3460 8560 {}
C {lab_pin.sym} 3460 8560 0 0 {name=l6970 lab=VSS}
C {bitcell_6t.sym} 3600 8600 0 0 {name=Xr43c18}
N 3560 8640 3540 8640 {}
C {lab_pin.sym} 3540 8640 0 0 {name=l6971 lab=BL18}
N 3560 8600 3540 8600 {}
C {lab_pin.sym} 3540 8600 0 0 {name=l6972 lab=BLB18}
N 3560 8560 3540 8560 {}
C {lab_pin.sym} 3540 8560 0 0 {name=l6973 lab=WL43}
N 3640 8640 3660 8640 {}
C {lab_pin.sym} 3660 8640 0 0 {name=l6974 lab=VDD}
N 3640 8560 3660 8560 {}
C {lab_pin.sym} 3660 8560 0 0 {name=l6975 lab=VSS}
C {bitcell_6t.sym} 3800 8600 0 0 {name=Xr43c19}
N 3760 8640 3740 8640 {}
C {lab_pin.sym} 3740 8640 0 0 {name=l6976 lab=BL19}
N 3760 8600 3740 8600 {}
C {lab_pin.sym} 3740 8600 0 0 {name=l6977 lab=BLB19}
N 3760 8560 3740 8560 {}
C {lab_pin.sym} 3740 8560 0 0 {name=l6978 lab=WL43}
N 3840 8640 3860 8640 {}
C {lab_pin.sym} 3860 8640 0 0 {name=l6979 lab=VDD}
N 3840 8560 3860 8560 {}
C {lab_pin.sym} 3860 8560 0 0 {name=l6980 lab=VSS}
C {bitcell_6t.sym} 4000 8600 0 0 {name=Xr43c20}
N 3960 8640 3940 8640 {}
C {lab_pin.sym} 3940 8640 0 0 {name=l6981 lab=BL20}
N 3960 8600 3940 8600 {}
C {lab_pin.sym} 3940 8600 0 0 {name=l6982 lab=BLB20}
N 3960 8560 3940 8560 {}
C {lab_pin.sym} 3940 8560 0 0 {name=l6983 lab=WL43}
N 4040 8640 4060 8640 {}
C {lab_pin.sym} 4060 8640 0 0 {name=l6984 lab=VDD}
N 4040 8560 4060 8560 {}
C {lab_pin.sym} 4060 8560 0 0 {name=l6985 lab=VSS}
C {bitcell_6t.sym} 4200 8600 0 0 {name=Xr43c21}
N 4160 8640 4140 8640 {}
C {lab_pin.sym} 4140 8640 0 0 {name=l6986 lab=BL21}
N 4160 8600 4140 8600 {}
C {lab_pin.sym} 4140 8600 0 0 {name=l6987 lab=BLB21}
N 4160 8560 4140 8560 {}
C {lab_pin.sym} 4140 8560 0 0 {name=l6988 lab=WL43}
N 4240 8640 4260 8640 {}
C {lab_pin.sym} 4260 8640 0 0 {name=l6989 lab=VDD}
N 4240 8560 4260 8560 {}
C {lab_pin.sym} 4260 8560 0 0 {name=l6990 lab=VSS}
C {bitcell_6t.sym} 4400 8600 0 0 {name=Xr43c22}
N 4360 8640 4340 8640 {}
C {lab_pin.sym} 4340 8640 0 0 {name=l6991 lab=BL22}
N 4360 8600 4340 8600 {}
C {lab_pin.sym} 4340 8600 0 0 {name=l6992 lab=BLB22}
N 4360 8560 4340 8560 {}
C {lab_pin.sym} 4340 8560 0 0 {name=l6993 lab=WL43}
N 4440 8640 4460 8640 {}
C {lab_pin.sym} 4460 8640 0 0 {name=l6994 lab=VDD}
N 4440 8560 4460 8560 {}
C {lab_pin.sym} 4460 8560 0 0 {name=l6995 lab=VSS}
C {bitcell_6t.sym} 4600 8600 0 0 {name=Xr43c23}
N 4560 8640 4540 8640 {}
C {lab_pin.sym} 4540 8640 0 0 {name=l6996 lab=BL23}
N 4560 8600 4540 8600 {}
C {lab_pin.sym} 4540 8600 0 0 {name=l6997 lab=BLB23}
N 4560 8560 4540 8560 {}
C {lab_pin.sym} 4540 8560 0 0 {name=l6998 lab=WL43}
N 4640 8640 4660 8640 {}
C {lab_pin.sym} 4660 8640 0 0 {name=l6999 lab=VDD}
N 4640 8560 4660 8560 {}
C {lab_pin.sym} 4660 8560 0 0 {name=l7000 lab=VSS}
C {bitcell_6t.sym} 4800 8600 0 0 {name=Xr43c24}
N 4760 8640 4740 8640 {}
C {lab_pin.sym} 4740 8640 0 0 {name=l7001 lab=BL24}
N 4760 8600 4740 8600 {}
C {lab_pin.sym} 4740 8600 0 0 {name=l7002 lab=BLB24}
N 4760 8560 4740 8560 {}
C {lab_pin.sym} 4740 8560 0 0 {name=l7003 lab=WL43}
N 4840 8640 4860 8640 {}
C {lab_pin.sym} 4860 8640 0 0 {name=l7004 lab=VDD}
N 4840 8560 4860 8560 {}
C {lab_pin.sym} 4860 8560 0 0 {name=l7005 lab=VSS}
C {bitcell_6t.sym} 5000 8600 0 0 {name=Xr43c25}
N 4960 8640 4940 8640 {}
C {lab_pin.sym} 4940 8640 0 0 {name=l7006 lab=BL25}
N 4960 8600 4940 8600 {}
C {lab_pin.sym} 4940 8600 0 0 {name=l7007 lab=BLB25}
N 4960 8560 4940 8560 {}
C {lab_pin.sym} 4940 8560 0 0 {name=l7008 lab=WL43}
N 5040 8640 5060 8640 {}
C {lab_pin.sym} 5060 8640 0 0 {name=l7009 lab=VDD}
N 5040 8560 5060 8560 {}
C {lab_pin.sym} 5060 8560 0 0 {name=l7010 lab=VSS}
C {bitcell_6t.sym} 5200 8600 0 0 {name=Xr43c26}
N 5160 8640 5140 8640 {}
C {lab_pin.sym} 5140 8640 0 0 {name=l7011 lab=BL26}
N 5160 8600 5140 8600 {}
C {lab_pin.sym} 5140 8600 0 0 {name=l7012 lab=BLB26}
N 5160 8560 5140 8560 {}
C {lab_pin.sym} 5140 8560 0 0 {name=l7013 lab=WL43}
N 5240 8640 5260 8640 {}
C {lab_pin.sym} 5260 8640 0 0 {name=l7014 lab=VDD}
N 5240 8560 5260 8560 {}
C {lab_pin.sym} 5260 8560 0 0 {name=l7015 lab=VSS}
C {bitcell_6t.sym} 5400 8600 0 0 {name=Xr43c27}
N 5360 8640 5340 8640 {}
C {lab_pin.sym} 5340 8640 0 0 {name=l7016 lab=BL27}
N 5360 8600 5340 8600 {}
C {lab_pin.sym} 5340 8600 0 0 {name=l7017 lab=BLB27}
N 5360 8560 5340 8560 {}
C {lab_pin.sym} 5340 8560 0 0 {name=l7018 lab=WL43}
N 5440 8640 5460 8640 {}
C {lab_pin.sym} 5460 8640 0 0 {name=l7019 lab=VDD}
N 5440 8560 5460 8560 {}
C {lab_pin.sym} 5460 8560 0 0 {name=l7020 lab=VSS}
C {bitcell_6t.sym} 5600 8600 0 0 {name=Xr43c28}
N 5560 8640 5540 8640 {}
C {lab_pin.sym} 5540 8640 0 0 {name=l7021 lab=BL28}
N 5560 8600 5540 8600 {}
C {lab_pin.sym} 5540 8600 0 0 {name=l7022 lab=BLB28}
N 5560 8560 5540 8560 {}
C {lab_pin.sym} 5540 8560 0 0 {name=l7023 lab=WL43}
N 5640 8640 5660 8640 {}
C {lab_pin.sym} 5660 8640 0 0 {name=l7024 lab=VDD}
N 5640 8560 5660 8560 {}
C {lab_pin.sym} 5660 8560 0 0 {name=l7025 lab=VSS}
C {bitcell_6t.sym} 5800 8600 0 0 {name=Xr43c29}
N 5760 8640 5740 8640 {}
C {lab_pin.sym} 5740 8640 0 0 {name=l7026 lab=BL29}
N 5760 8600 5740 8600 {}
C {lab_pin.sym} 5740 8600 0 0 {name=l7027 lab=BLB29}
N 5760 8560 5740 8560 {}
C {lab_pin.sym} 5740 8560 0 0 {name=l7028 lab=WL43}
N 5840 8640 5860 8640 {}
C {lab_pin.sym} 5860 8640 0 0 {name=l7029 lab=VDD}
N 5840 8560 5860 8560 {}
C {lab_pin.sym} 5860 8560 0 0 {name=l7030 lab=VSS}
C {bitcell_6t.sym} 6000 8600 0 0 {name=Xr43c30}
N 5960 8640 5940 8640 {}
C {lab_pin.sym} 5940 8640 0 0 {name=l7031 lab=BL30}
N 5960 8600 5940 8600 {}
C {lab_pin.sym} 5940 8600 0 0 {name=l7032 lab=BLB30}
N 5960 8560 5940 8560 {}
C {lab_pin.sym} 5940 8560 0 0 {name=l7033 lab=WL43}
N 6040 8640 6060 8640 {}
C {lab_pin.sym} 6060 8640 0 0 {name=l7034 lab=VDD}
N 6040 8560 6060 8560 {}
C {lab_pin.sym} 6060 8560 0 0 {name=l7035 lab=VSS}
C {bitcell_6t.sym} 6200 8600 0 0 {name=Xr43c31}
N 6160 8640 6140 8640 {}
C {lab_pin.sym} 6140 8640 0 0 {name=l7036 lab=BL31}
N 6160 8600 6140 8600 {}
C {lab_pin.sym} 6140 8600 0 0 {name=l7037 lab=BLB31}
N 6160 8560 6140 8560 {}
C {lab_pin.sym} 6140 8560 0 0 {name=l7038 lab=WL43}
N 6240 8640 6260 8640 {}
C {lab_pin.sym} 6260 8640 0 0 {name=l7039 lab=VDD}
N 6240 8560 6260 8560 {}
C {lab_pin.sym} 6260 8560 0 0 {name=l7040 lab=VSS}
C {bitcell_6t.sym} 0 8800 0 0 {name=Xr44c0}
N -40 8840 -60 8840 {}
C {lab_pin.sym} -60 8840 0 0 {name=l7041 lab=BL0}
N -40 8800 -60 8800 {}
C {lab_pin.sym} -60 8800 0 0 {name=l7042 lab=BLB0}
N -40 8760 -60 8760 {}
C {lab_pin.sym} -60 8760 0 0 {name=l7043 lab=WL44}
N 40 8840 60 8840 {}
C {lab_pin.sym} 60 8840 0 0 {name=l7044 lab=VDD}
N 40 8760 60 8760 {}
C {lab_pin.sym} 60 8760 0 0 {name=l7045 lab=VSS}
C {bitcell_6t.sym} 200 8800 0 0 {name=Xr44c1}
N 160 8840 140 8840 {}
C {lab_pin.sym} 140 8840 0 0 {name=l7046 lab=BL1}
N 160 8800 140 8800 {}
C {lab_pin.sym} 140 8800 0 0 {name=l7047 lab=BLB1}
N 160 8760 140 8760 {}
C {lab_pin.sym} 140 8760 0 0 {name=l7048 lab=WL44}
N 240 8840 260 8840 {}
C {lab_pin.sym} 260 8840 0 0 {name=l7049 lab=VDD}
N 240 8760 260 8760 {}
C {lab_pin.sym} 260 8760 0 0 {name=l7050 lab=VSS}
C {bitcell_6t.sym} 400 8800 0 0 {name=Xr44c2}
N 360 8840 340 8840 {}
C {lab_pin.sym} 340 8840 0 0 {name=l7051 lab=BL2}
N 360 8800 340 8800 {}
C {lab_pin.sym} 340 8800 0 0 {name=l7052 lab=BLB2}
N 360 8760 340 8760 {}
C {lab_pin.sym} 340 8760 0 0 {name=l7053 lab=WL44}
N 440 8840 460 8840 {}
C {lab_pin.sym} 460 8840 0 0 {name=l7054 lab=VDD}
N 440 8760 460 8760 {}
C {lab_pin.sym} 460 8760 0 0 {name=l7055 lab=VSS}
C {bitcell_6t.sym} 600 8800 0 0 {name=Xr44c3}
N 560 8840 540 8840 {}
C {lab_pin.sym} 540 8840 0 0 {name=l7056 lab=BL3}
N 560 8800 540 8800 {}
C {lab_pin.sym} 540 8800 0 0 {name=l7057 lab=BLB3}
N 560 8760 540 8760 {}
C {lab_pin.sym} 540 8760 0 0 {name=l7058 lab=WL44}
N 640 8840 660 8840 {}
C {lab_pin.sym} 660 8840 0 0 {name=l7059 lab=VDD}
N 640 8760 660 8760 {}
C {lab_pin.sym} 660 8760 0 0 {name=l7060 lab=VSS}
C {bitcell_6t.sym} 800 8800 0 0 {name=Xr44c4}
N 760 8840 740 8840 {}
C {lab_pin.sym} 740 8840 0 0 {name=l7061 lab=BL4}
N 760 8800 740 8800 {}
C {lab_pin.sym} 740 8800 0 0 {name=l7062 lab=BLB4}
N 760 8760 740 8760 {}
C {lab_pin.sym} 740 8760 0 0 {name=l7063 lab=WL44}
N 840 8840 860 8840 {}
C {lab_pin.sym} 860 8840 0 0 {name=l7064 lab=VDD}
N 840 8760 860 8760 {}
C {lab_pin.sym} 860 8760 0 0 {name=l7065 lab=VSS}
C {bitcell_6t.sym} 1000 8800 0 0 {name=Xr44c5}
N 960 8840 940 8840 {}
C {lab_pin.sym} 940 8840 0 0 {name=l7066 lab=BL5}
N 960 8800 940 8800 {}
C {lab_pin.sym} 940 8800 0 0 {name=l7067 lab=BLB5}
N 960 8760 940 8760 {}
C {lab_pin.sym} 940 8760 0 0 {name=l7068 lab=WL44}
N 1040 8840 1060 8840 {}
C {lab_pin.sym} 1060 8840 0 0 {name=l7069 lab=VDD}
N 1040 8760 1060 8760 {}
C {lab_pin.sym} 1060 8760 0 0 {name=l7070 lab=VSS}
C {bitcell_6t.sym} 1200 8800 0 0 {name=Xr44c6}
N 1160 8840 1140 8840 {}
C {lab_pin.sym} 1140 8840 0 0 {name=l7071 lab=BL6}
N 1160 8800 1140 8800 {}
C {lab_pin.sym} 1140 8800 0 0 {name=l7072 lab=BLB6}
N 1160 8760 1140 8760 {}
C {lab_pin.sym} 1140 8760 0 0 {name=l7073 lab=WL44}
N 1240 8840 1260 8840 {}
C {lab_pin.sym} 1260 8840 0 0 {name=l7074 lab=VDD}
N 1240 8760 1260 8760 {}
C {lab_pin.sym} 1260 8760 0 0 {name=l7075 lab=VSS}
C {bitcell_6t.sym} 1400 8800 0 0 {name=Xr44c7}
N 1360 8840 1340 8840 {}
C {lab_pin.sym} 1340 8840 0 0 {name=l7076 lab=BL7}
N 1360 8800 1340 8800 {}
C {lab_pin.sym} 1340 8800 0 0 {name=l7077 lab=BLB7}
N 1360 8760 1340 8760 {}
C {lab_pin.sym} 1340 8760 0 0 {name=l7078 lab=WL44}
N 1440 8840 1460 8840 {}
C {lab_pin.sym} 1460 8840 0 0 {name=l7079 lab=VDD}
N 1440 8760 1460 8760 {}
C {lab_pin.sym} 1460 8760 0 0 {name=l7080 lab=VSS}
C {bitcell_6t.sym} 1600 8800 0 0 {name=Xr44c8}
N 1560 8840 1540 8840 {}
C {lab_pin.sym} 1540 8840 0 0 {name=l7081 lab=BL8}
N 1560 8800 1540 8800 {}
C {lab_pin.sym} 1540 8800 0 0 {name=l7082 lab=BLB8}
N 1560 8760 1540 8760 {}
C {lab_pin.sym} 1540 8760 0 0 {name=l7083 lab=WL44}
N 1640 8840 1660 8840 {}
C {lab_pin.sym} 1660 8840 0 0 {name=l7084 lab=VDD}
N 1640 8760 1660 8760 {}
C {lab_pin.sym} 1660 8760 0 0 {name=l7085 lab=VSS}
C {bitcell_6t.sym} 1800 8800 0 0 {name=Xr44c9}
N 1760 8840 1740 8840 {}
C {lab_pin.sym} 1740 8840 0 0 {name=l7086 lab=BL9}
N 1760 8800 1740 8800 {}
C {lab_pin.sym} 1740 8800 0 0 {name=l7087 lab=BLB9}
N 1760 8760 1740 8760 {}
C {lab_pin.sym} 1740 8760 0 0 {name=l7088 lab=WL44}
N 1840 8840 1860 8840 {}
C {lab_pin.sym} 1860 8840 0 0 {name=l7089 lab=VDD}
N 1840 8760 1860 8760 {}
C {lab_pin.sym} 1860 8760 0 0 {name=l7090 lab=VSS}
C {bitcell_6t.sym} 2000 8800 0 0 {name=Xr44c10}
N 1960 8840 1940 8840 {}
C {lab_pin.sym} 1940 8840 0 0 {name=l7091 lab=BL10}
N 1960 8800 1940 8800 {}
C {lab_pin.sym} 1940 8800 0 0 {name=l7092 lab=BLB10}
N 1960 8760 1940 8760 {}
C {lab_pin.sym} 1940 8760 0 0 {name=l7093 lab=WL44}
N 2040 8840 2060 8840 {}
C {lab_pin.sym} 2060 8840 0 0 {name=l7094 lab=VDD}
N 2040 8760 2060 8760 {}
C {lab_pin.sym} 2060 8760 0 0 {name=l7095 lab=VSS}
C {bitcell_6t.sym} 2200 8800 0 0 {name=Xr44c11}
N 2160 8840 2140 8840 {}
C {lab_pin.sym} 2140 8840 0 0 {name=l7096 lab=BL11}
N 2160 8800 2140 8800 {}
C {lab_pin.sym} 2140 8800 0 0 {name=l7097 lab=BLB11}
N 2160 8760 2140 8760 {}
C {lab_pin.sym} 2140 8760 0 0 {name=l7098 lab=WL44}
N 2240 8840 2260 8840 {}
C {lab_pin.sym} 2260 8840 0 0 {name=l7099 lab=VDD}
N 2240 8760 2260 8760 {}
C {lab_pin.sym} 2260 8760 0 0 {name=l7100 lab=VSS}
C {bitcell_6t.sym} 2400 8800 0 0 {name=Xr44c12}
N 2360 8840 2340 8840 {}
C {lab_pin.sym} 2340 8840 0 0 {name=l7101 lab=BL12}
N 2360 8800 2340 8800 {}
C {lab_pin.sym} 2340 8800 0 0 {name=l7102 lab=BLB12}
N 2360 8760 2340 8760 {}
C {lab_pin.sym} 2340 8760 0 0 {name=l7103 lab=WL44}
N 2440 8840 2460 8840 {}
C {lab_pin.sym} 2460 8840 0 0 {name=l7104 lab=VDD}
N 2440 8760 2460 8760 {}
C {lab_pin.sym} 2460 8760 0 0 {name=l7105 lab=VSS}
C {bitcell_6t.sym} 2600 8800 0 0 {name=Xr44c13}
N 2560 8840 2540 8840 {}
C {lab_pin.sym} 2540 8840 0 0 {name=l7106 lab=BL13}
N 2560 8800 2540 8800 {}
C {lab_pin.sym} 2540 8800 0 0 {name=l7107 lab=BLB13}
N 2560 8760 2540 8760 {}
C {lab_pin.sym} 2540 8760 0 0 {name=l7108 lab=WL44}
N 2640 8840 2660 8840 {}
C {lab_pin.sym} 2660 8840 0 0 {name=l7109 lab=VDD}
N 2640 8760 2660 8760 {}
C {lab_pin.sym} 2660 8760 0 0 {name=l7110 lab=VSS}
C {bitcell_6t.sym} 2800 8800 0 0 {name=Xr44c14}
N 2760 8840 2740 8840 {}
C {lab_pin.sym} 2740 8840 0 0 {name=l7111 lab=BL14}
N 2760 8800 2740 8800 {}
C {lab_pin.sym} 2740 8800 0 0 {name=l7112 lab=BLB14}
N 2760 8760 2740 8760 {}
C {lab_pin.sym} 2740 8760 0 0 {name=l7113 lab=WL44}
N 2840 8840 2860 8840 {}
C {lab_pin.sym} 2860 8840 0 0 {name=l7114 lab=VDD}
N 2840 8760 2860 8760 {}
C {lab_pin.sym} 2860 8760 0 0 {name=l7115 lab=VSS}
C {bitcell_6t.sym} 3000 8800 0 0 {name=Xr44c15}
N 2960 8840 2940 8840 {}
C {lab_pin.sym} 2940 8840 0 0 {name=l7116 lab=BL15}
N 2960 8800 2940 8800 {}
C {lab_pin.sym} 2940 8800 0 0 {name=l7117 lab=BLB15}
N 2960 8760 2940 8760 {}
C {lab_pin.sym} 2940 8760 0 0 {name=l7118 lab=WL44}
N 3040 8840 3060 8840 {}
C {lab_pin.sym} 3060 8840 0 0 {name=l7119 lab=VDD}
N 3040 8760 3060 8760 {}
C {lab_pin.sym} 3060 8760 0 0 {name=l7120 lab=VSS}
C {bitcell_6t.sym} 3200 8800 0 0 {name=Xr44c16}
N 3160 8840 3140 8840 {}
C {lab_pin.sym} 3140 8840 0 0 {name=l7121 lab=BL16}
N 3160 8800 3140 8800 {}
C {lab_pin.sym} 3140 8800 0 0 {name=l7122 lab=BLB16}
N 3160 8760 3140 8760 {}
C {lab_pin.sym} 3140 8760 0 0 {name=l7123 lab=WL44}
N 3240 8840 3260 8840 {}
C {lab_pin.sym} 3260 8840 0 0 {name=l7124 lab=VDD}
N 3240 8760 3260 8760 {}
C {lab_pin.sym} 3260 8760 0 0 {name=l7125 lab=VSS}
C {bitcell_6t.sym} 3400 8800 0 0 {name=Xr44c17}
N 3360 8840 3340 8840 {}
C {lab_pin.sym} 3340 8840 0 0 {name=l7126 lab=BL17}
N 3360 8800 3340 8800 {}
C {lab_pin.sym} 3340 8800 0 0 {name=l7127 lab=BLB17}
N 3360 8760 3340 8760 {}
C {lab_pin.sym} 3340 8760 0 0 {name=l7128 lab=WL44}
N 3440 8840 3460 8840 {}
C {lab_pin.sym} 3460 8840 0 0 {name=l7129 lab=VDD}
N 3440 8760 3460 8760 {}
C {lab_pin.sym} 3460 8760 0 0 {name=l7130 lab=VSS}
C {bitcell_6t.sym} 3600 8800 0 0 {name=Xr44c18}
N 3560 8840 3540 8840 {}
C {lab_pin.sym} 3540 8840 0 0 {name=l7131 lab=BL18}
N 3560 8800 3540 8800 {}
C {lab_pin.sym} 3540 8800 0 0 {name=l7132 lab=BLB18}
N 3560 8760 3540 8760 {}
C {lab_pin.sym} 3540 8760 0 0 {name=l7133 lab=WL44}
N 3640 8840 3660 8840 {}
C {lab_pin.sym} 3660 8840 0 0 {name=l7134 lab=VDD}
N 3640 8760 3660 8760 {}
C {lab_pin.sym} 3660 8760 0 0 {name=l7135 lab=VSS}
C {bitcell_6t.sym} 3800 8800 0 0 {name=Xr44c19}
N 3760 8840 3740 8840 {}
C {lab_pin.sym} 3740 8840 0 0 {name=l7136 lab=BL19}
N 3760 8800 3740 8800 {}
C {lab_pin.sym} 3740 8800 0 0 {name=l7137 lab=BLB19}
N 3760 8760 3740 8760 {}
C {lab_pin.sym} 3740 8760 0 0 {name=l7138 lab=WL44}
N 3840 8840 3860 8840 {}
C {lab_pin.sym} 3860 8840 0 0 {name=l7139 lab=VDD}
N 3840 8760 3860 8760 {}
C {lab_pin.sym} 3860 8760 0 0 {name=l7140 lab=VSS}
C {bitcell_6t.sym} 4000 8800 0 0 {name=Xr44c20}
N 3960 8840 3940 8840 {}
C {lab_pin.sym} 3940 8840 0 0 {name=l7141 lab=BL20}
N 3960 8800 3940 8800 {}
C {lab_pin.sym} 3940 8800 0 0 {name=l7142 lab=BLB20}
N 3960 8760 3940 8760 {}
C {lab_pin.sym} 3940 8760 0 0 {name=l7143 lab=WL44}
N 4040 8840 4060 8840 {}
C {lab_pin.sym} 4060 8840 0 0 {name=l7144 lab=VDD}
N 4040 8760 4060 8760 {}
C {lab_pin.sym} 4060 8760 0 0 {name=l7145 lab=VSS}
C {bitcell_6t.sym} 4200 8800 0 0 {name=Xr44c21}
N 4160 8840 4140 8840 {}
C {lab_pin.sym} 4140 8840 0 0 {name=l7146 lab=BL21}
N 4160 8800 4140 8800 {}
C {lab_pin.sym} 4140 8800 0 0 {name=l7147 lab=BLB21}
N 4160 8760 4140 8760 {}
C {lab_pin.sym} 4140 8760 0 0 {name=l7148 lab=WL44}
N 4240 8840 4260 8840 {}
C {lab_pin.sym} 4260 8840 0 0 {name=l7149 lab=VDD}
N 4240 8760 4260 8760 {}
C {lab_pin.sym} 4260 8760 0 0 {name=l7150 lab=VSS}
C {bitcell_6t.sym} 4400 8800 0 0 {name=Xr44c22}
N 4360 8840 4340 8840 {}
C {lab_pin.sym} 4340 8840 0 0 {name=l7151 lab=BL22}
N 4360 8800 4340 8800 {}
C {lab_pin.sym} 4340 8800 0 0 {name=l7152 lab=BLB22}
N 4360 8760 4340 8760 {}
C {lab_pin.sym} 4340 8760 0 0 {name=l7153 lab=WL44}
N 4440 8840 4460 8840 {}
C {lab_pin.sym} 4460 8840 0 0 {name=l7154 lab=VDD}
N 4440 8760 4460 8760 {}
C {lab_pin.sym} 4460 8760 0 0 {name=l7155 lab=VSS}
C {bitcell_6t.sym} 4600 8800 0 0 {name=Xr44c23}
N 4560 8840 4540 8840 {}
C {lab_pin.sym} 4540 8840 0 0 {name=l7156 lab=BL23}
N 4560 8800 4540 8800 {}
C {lab_pin.sym} 4540 8800 0 0 {name=l7157 lab=BLB23}
N 4560 8760 4540 8760 {}
C {lab_pin.sym} 4540 8760 0 0 {name=l7158 lab=WL44}
N 4640 8840 4660 8840 {}
C {lab_pin.sym} 4660 8840 0 0 {name=l7159 lab=VDD}
N 4640 8760 4660 8760 {}
C {lab_pin.sym} 4660 8760 0 0 {name=l7160 lab=VSS}
C {bitcell_6t.sym} 4800 8800 0 0 {name=Xr44c24}
N 4760 8840 4740 8840 {}
C {lab_pin.sym} 4740 8840 0 0 {name=l7161 lab=BL24}
N 4760 8800 4740 8800 {}
C {lab_pin.sym} 4740 8800 0 0 {name=l7162 lab=BLB24}
N 4760 8760 4740 8760 {}
C {lab_pin.sym} 4740 8760 0 0 {name=l7163 lab=WL44}
N 4840 8840 4860 8840 {}
C {lab_pin.sym} 4860 8840 0 0 {name=l7164 lab=VDD}
N 4840 8760 4860 8760 {}
C {lab_pin.sym} 4860 8760 0 0 {name=l7165 lab=VSS}
C {bitcell_6t.sym} 5000 8800 0 0 {name=Xr44c25}
N 4960 8840 4940 8840 {}
C {lab_pin.sym} 4940 8840 0 0 {name=l7166 lab=BL25}
N 4960 8800 4940 8800 {}
C {lab_pin.sym} 4940 8800 0 0 {name=l7167 lab=BLB25}
N 4960 8760 4940 8760 {}
C {lab_pin.sym} 4940 8760 0 0 {name=l7168 lab=WL44}
N 5040 8840 5060 8840 {}
C {lab_pin.sym} 5060 8840 0 0 {name=l7169 lab=VDD}
N 5040 8760 5060 8760 {}
C {lab_pin.sym} 5060 8760 0 0 {name=l7170 lab=VSS}
C {bitcell_6t.sym} 5200 8800 0 0 {name=Xr44c26}
N 5160 8840 5140 8840 {}
C {lab_pin.sym} 5140 8840 0 0 {name=l7171 lab=BL26}
N 5160 8800 5140 8800 {}
C {lab_pin.sym} 5140 8800 0 0 {name=l7172 lab=BLB26}
N 5160 8760 5140 8760 {}
C {lab_pin.sym} 5140 8760 0 0 {name=l7173 lab=WL44}
N 5240 8840 5260 8840 {}
C {lab_pin.sym} 5260 8840 0 0 {name=l7174 lab=VDD}
N 5240 8760 5260 8760 {}
C {lab_pin.sym} 5260 8760 0 0 {name=l7175 lab=VSS}
C {bitcell_6t.sym} 5400 8800 0 0 {name=Xr44c27}
N 5360 8840 5340 8840 {}
C {lab_pin.sym} 5340 8840 0 0 {name=l7176 lab=BL27}
N 5360 8800 5340 8800 {}
C {lab_pin.sym} 5340 8800 0 0 {name=l7177 lab=BLB27}
N 5360 8760 5340 8760 {}
C {lab_pin.sym} 5340 8760 0 0 {name=l7178 lab=WL44}
N 5440 8840 5460 8840 {}
C {lab_pin.sym} 5460 8840 0 0 {name=l7179 lab=VDD}
N 5440 8760 5460 8760 {}
C {lab_pin.sym} 5460 8760 0 0 {name=l7180 lab=VSS}
C {bitcell_6t.sym} 5600 8800 0 0 {name=Xr44c28}
N 5560 8840 5540 8840 {}
C {lab_pin.sym} 5540 8840 0 0 {name=l7181 lab=BL28}
N 5560 8800 5540 8800 {}
C {lab_pin.sym} 5540 8800 0 0 {name=l7182 lab=BLB28}
N 5560 8760 5540 8760 {}
C {lab_pin.sym} 5540 8760 0 0 {name=l7183 lab=WL44}
N 5640 8840 5660 8840 {}
C {lab_pin.sym} 5660 8840 0 0 {name=l7184 lab=VDD}
N 5640 8760 5660 8760 {}
C {lab_pin.sym} 5660 8760 0 0 {name=l7185 lab=VSS}
C {bitcell_6t.sym} 5800 8800 0 0 {name=Xr44c29}
N 5760 8840 5740 8840 {}
C {lab_pin.sym} 5740 8840 0 0 {name=l7186 lab=BL29}
N 5760 8800 5740 8800 {}
C {lab_pin.sym} 5740 8800 0 0 {name=l7187 lab=BLB29}
N 5760 8760 5740 8760 {}
C {lab_pin.sym} 5740 8760 0 0 {name=l7188 lab=WL44}
N 5840 8840 5860 8840 {}
C {lab_pin.sym} 5860 8840 0 0 {name=l7189 lab=VDD}
N 5840 8760 5860 8760 {}
C {lab_pin.sym} 5860 8760 0 0 {name=l7190 lab=VSS}
C {bitcell_6t.sym} 6000 8800 0 0 {name=Xr44c30}
N 5960 8840 5940 8840 {}
C {lab_pin.sym} 5940 8840 0 0 {name=l7191 lab=BL30}
N 5960 8800 5940 8800 {}
C {lab_pin.sym} 5940 8800 0 0 {name=l7192 lab=BLB30}
N 5960 8760 5940 8760 {}
C {lab_pin.sym} 5940 8760 0 0 {name=l7193 lab=WL44}
N 6040 8840 6060 8840 {}
C {lab_pin.sym} 6060 8840 0 0 {name=l7194 lab=VDD}
N 6040 8760 6060 8760 {}
C {lab_pin.sym} 6060 8760 0 0 {name=l7195 lab=VSS}
C {bitcell_6t.sym} 6200 8800 0 0 {name=Xr44c31}
N 6160 8840 6140 8840 {}
C {lab_pin.sym} 6140 8840 0 0 {name=l7196 lab=BL31}
N 6160 8800 6140 8800 {}
C {lab_pin.sym} 6140 8800 0 0 {name=l7197 lab=BLB31}
N 6160 8760 6140 8760 {}
C {lab_pin.sym} 6140 8760 0 0 {name=l7198 lab=WL44}
N 6240 8840 6260 8840 {}
C {lab_pin.sym} 6260 8840 0 0 {name=l7199 lab=VDD}
N 6240 8760 6260 8760 {}
C {lab_pin.sym} 6260 8760 0 0 {name=l7200 lab=VSS}
C {bitcell_6t.sym} 0 9000 0 0 {name=Xr45c0}
N -40 9040 -60 9040 {}
C {lab_pin.sym} -60 9040 0 0 {name=l7201 lab=BL0}
N -40 9000 -60 9000 {}
C {lab_pin.sym} -60 9000 0 0 {name=l7202 lab=BLB0}
N -40 8960 -60 8960 {}
C {lab_pin.sym} -60 8960 0 0 {name=l7203 lab=WL45}
N 40 9040 60 9040 {}
C {lab_pin.sym} 60 9040 0 0 {name=l7204 lab=VDD}
N 40 8960 60 8960 {}
C {lab_pin.sym} 60 8960 0 0 {name=l7205 lab=VSS}
C {bitcell_6t.sym} 200 9000 0 0 {name=Xr45c1}
N 160 9040 140 9040 {}
C {lab_pin.sym} 140 9040 0 0 {name=l7206 lab=BL1}
N 160 9000 140 9000 {}
C {lab_pin.sym} 140 9000 0 0 {name=l7207 lab=BLB1}
N 160 8960 140 8960 {}
C {lab_pin.sym} 140 8960 0 0 {name=l7208 lab=WL45}
N 240 9040 260 9040 {}
C {lab_pin.sym} 260 9040 0 0 {name=l7209 lab=VDD}
N 240 8960 260 8960 {}
C {lab_pin.sym} 260 8960 0 0 {name=l7210 lab=VSS}
C {bitcell_6t.sym} 400 9000 0 0 {name=Xr45c2}
N 360 9040 340 9040 {}
C {lab_pin.sym} 340 9040 0 0 {name=l7211 lab=BL2}
N 360 9000 340 9000 {}
C {lab_pin.sym} 340 9000 0 0 {name=l7212 lab=BLB2}
N 360 8960 340 8960 {}
C {lab_pin.sym} 340 8960 0 0 {name=l7213 lab=WL45}
N 440 9040 460 9040 {}
C {lab_pin.sym} 460 9040 0 0 {name=l7214 lab=VDD}
N 440 8960 460 8960 {}
C {lab_pin.sym} 460 8960 0 0 {name=l7215 lab=VSS}
C {bitcell_6t.sym} 600 9000 0 0 {name=Xr45c3}
N 560 9040 540 9040 {}
C {lab_pin.sym} 540 9040 0 0 {name=l7216 lab=BL3}
N 560 9000 540 9000 {}
C {lab_pin.sym} 540 9000 0 0 {name=l7217 lab=BLB3}
N 560 8960 540 8960 {}
C {lab_pin.sym} 540 8960 0 0 {name=l7218 lab=WL45}
N 640 9040 660 9040 {}
C {lab_pin.sym} 660 9040 0 0 {name=l7219 lab=VDD}
N 640 8960 660 8960 {}
C {lab_pin.sym} 660 8960 0 0 {name=l7220 lab=VSS}
C {bitcell_6t.sym} 800 9000 0 0 {name=Xr45c4}
N 760 9040 740 9040 {}
C {lab_pin.sym} 740 9040 0 0 {name=l7221 lab=BL4}
N 760 9000 740 9000 {}
C {lab_pin.sym} 740 9000 0 0 {name=l7222 lab=BLB4}
N 760 8960 740 8960 {}
C {lab_pin.sym} 740 8960 0 0 {name=l7223 lab=WL45}
N 840 9040 860 9040 {}
C {lab_pin.sym} 860 9040 0 0 {name=l7224 lab=VDD}
N 840 8960 860 8960 {}
C {lab_pin.sym} 860 8960 0 0 {name=l7225 lab=VSS}
C {bitcell_6t.sym} 1000 9000 0 0 {name=Xr45c5}
N 960 9040 940 9040 {}
C {lab_pin.sym} 940 9040 0 0 {name=l7226 lab=BL5}
N 960 9000 940 9000 {}
C {lab_pin.sym} 940 9000 0 0 {name=l7227 lab=BLB5}
N 960 8960 940 8960 {}
C {lab_pin.sym} 940 8960 0 0 {name=l7228 lab=WL45}
N 1040 9040 1060 9040 {}
C {lab_pin.sym} 1060 9040 0 0 {name=l7229 lab=VDD}
N 1040 8960 1060 8960 {}
C {lab_pin.sym} 1060 8960 0 0 {name=l7230 lab=VSS}
C {bitcell_6t.sym} 1200 9000 0 0 {name=Xr45c6}
N 1160 9040 1140 9040 {}
C {lab_pin.sym} 1140 9040 0 0 {name=l7231 lab=BL6}
N 1160 9000 1140 9000 {}
C {lab_pin.sym} 1140 9000 0 0 {name=l7232 lab=BLB6}
N 1160 8960 1140 8960 {}
C {lab_pin.sym} 1140 8960 0 0 {name=l7233 lab=WL45}
N 1240 9040 1260 9040 {}
C {lab_pin.sym} 1260 9040 0 0 {name=l7234 lab=VDD}
N 1240 8960 1260 8960 {}
C {lab_pin.sym} 1260 8960 0 0 {name=l7235 lab=VSS}
C {bitcell_6t.sym} 1400 9000 0 0 {name=Xr45c7}
N 1360 9040 1340 9040 {}
C {lab_pin.sym} 1340 9040 0 0 {name=l7236 lab=BL7}
N 1360 9000 1340 9000 {}
C {lab_pin.sym} 1340 9000 0 0 {name=l7237 lab=BLB7}
N 1360 8960 1340 8960 {}
C {lab_pin.sym} 1340 8960 0 0 {name=l7238 lab=WL45}
N 1440 9040 1460 9040 {}
C {lab_pin.sym} 1460 9040 0 0 {name=l7239 lab=VDD}
N 1440 8960 1460 8960 {}
C {lab_pin.sym} 1460 8960 0 0 {name=l7240 lab=VSS}
C {bitcell_6t.sym} 1600 9000 0 0 {name=Xr45c8}
N 1560 9040 1540 9040 {}
C {lab_pin.sym} 1540 9040 0 0 {name=l7241 lab=BL8}
N 1560 9000 1540 9000 {}
C {lab_pin.sym} 1540 9000 0 0 {name=l7242 lab=BLB8}
N 1560 8960 1540 8960 {}
C {lab_pin.sym} 1540 8960 0 0 {name=l7243 lab=WL45}
N 1640 9040 1660 9040 {}
C {lab_pin.sym} 1660 9040 0 0 {name=l7244 lab=VDD}
N 1640 8960 1660 8960 {}
C {lab_pin.sym} 1660 8960 0 0 {name=l7245 lab=VSS}
C {bitcell_6t.sym} 1800 9000 0 0 {name=Xr45c9}
N 1760 9040 1740 9040 {}
C {lab_pin.sym} 1740 9040 0 0 {name=l7246 lab=BL9}
N 1760 9000 1740 9000 {}
C {lab_pin.sym} 1740 9000 0 0 {name=l7247 lab=BLB9}
N 1760 8960 1740 8960 {}
C {lab_pin.sym} 1740 8960 0 0 {name=l7248 lab=WL45}
N 1840 9040 1860 9040 {}
C {lab_pin.sym} 1860 9040 0 0 {name=l7249 lab=VDD}
N 1840 8960 1860 8960 {}
C {lab_pin.sym} 1860 8960 0 0 {name=l7250 lab=VSS}
C {bitcell_6t.sym} 2000 9000 0 0 {name=Xr45c10}
N 1960 9040 1940 9040 {}
C {lab_pin.sym} 1940 9040 0 0 {name=l7251 lab=BL10}
N 1960 9000 1940 9000 {}
C {lab_pin.sym} 1940 9000 0 0 {name=l7252 lab=BLB10}
N 1960 8960 1940 8960 {}
C {lab_pin.sym} 1940 8960 0 0 {name=l7253 lab=WL45}
N 2040 9040 2060 9040 {}
C {lab_pin.sym} 2060 9040 0 0 {name=l7254 lab=VDD}
N 2040 8960 2060 8960 {}
C {lab_pin.sym} 2060 8960 0 0 {name=l7255 lab=VSS}
C {bitcell_6t.sym} 2200 9000 0 0 {name=Xr45c11}
N 2160 9040 2140 9040 {}
C {lab_pin.sym} 2140 9040 0 0 {name=l7256 lab=BL11}
N 2160 9000 2140 9000 {}
C {lab_pin.sym} 2140 9000 0 0 {name=l7257 lab=BLB11}
N 2160 8960 2140 8960 {}
C {lab_pin.sym} 2140 8960 0 0 {name=l7258 lab=WL45}
N 2240 9040 2260 9040 {}
C {lab_pin.sym} 2260 9040 0 0 {name=l7259 lab=VDD}
N 2240 8960 2260 8960 {}
C {lab_pin.sym} 2260 8960 0 0 {name=l7260 lab=VSS}
C {bitcell_6t.sym} 2400 9000 0 0 {name=Xr45c12}
N 2360 9040 2340 9040 {}
C {lab_pin.sym} 2340 9040 0 0 {name=l7261 lab=BL12}
N 2360 9000 2340 9000 {}
C {lab_pin.sym} 2340 9000 0 0 {name=l7262 lab=BLB12}
N 2360 8960 2340 8960 {}
C {lab_pin.sym} 2340 8960 0 0 {name=l7263 lab=WL45}
N 2440 9040 2460 9040 {}
C {lab_pin.sym} 2460 9040 0 0 {name=l7264 lab=VDD}
N 2440 8960 2460 8960 {}
C {lab_pin.sym} 2460 8960 0 0 {name=l7265 lab=VSS}
C {bitcell_6t.sym} 2600 9000 0 0 {name=Xr45c13}
N 2560 9040 2540 9040 {}
C {lab_pin.sym} 2540 9040 0 0 {name=l7266 lab=BL13}
N 2560 9000 2540 9000 {}
C {lab_pin.sym} 2540 9000 0 0 {name=l7267 lab=BLB13}
N 2560 8960 2540 8960 {}
C {lab_pin.sym} 2540 8960 0 0 {name=l7268 lab=WL45}
N 2640 9040 2660 9040 {}
C {lab_pin.sym} 2660 9040 0 0 {name=l7269 lab=VDD}
N 2640 8960 2660 8960 {}
C {lab_pin.sym} 2660 8960 0 0 {name=l7270 lab=VSS}
C {bitcell_6t.sym} 2800 9000 0 0 {name=Xr45c14}
N 2760 9040 2740 9040 {}
C {lab_pin.sym} 2740 9040 0 0 {name=l7271 lab=BL14}
N 2760 9000 2740 9000 {}
C {lab_pin.sym} 2740 9000 0 0 {name=l7272 lab=BLB14}
N 2760 8960 2740 8960 {}
C {lab_pin.sym} 2740 8960 0 0 {name=l7273 lab=WL45}
N 2840 9040 2860 9040 {}
C {lab_pin.sym} 2860 9040 0 0 {name=l7274 lab=VDD}
N 2840 8960 2860 8960 {}
C {lab_pin.sym} 2860 8960 0 0 {name=l7275 lab=VSS}
C {bitcell_6t.sym} 3000 9000 0 0 {name=Xr45c15}
N 2960 9040 2940 9040 {}
C {lab_pin.sym} 2940 9040 0 0 {name=l7276 lab=BL15}
N 2960 9000 2940 9000 {}
C {lab_pin.sym} 2940 9000 0 0 {name=l7277 lab=BLB15}
N 2960 8960 2940 8960 {}
C {lab_pin.sym} 2940 8960 0 0 {name=l7278 lab=WL45}
N 3040 9040 3060 9040 {}
C {lab_pin.sym} 3060 9040 0 0 {name=l7279 lab=VDD}
N 3040 8960 3060 8960 {}
C {lab_pin.sym} 3060 8960 0 0 {name=l7280 lab=VSS}
C {bitcell_6t.sym} 3200 9000 0 0 {name=Xr45c16}
N 3160 9040 3140 9040 {}
C {lab_pin.sym} 3140 9040 0 0 {name=l7281 lab=BL16}
N 3160 9000 3140 9000 {}
C {lab_pin.sym} 3140 9000 0 0 {name=l7282 lab=BLB16}
N 3160 8960 3140 8960 {}
C {lab_pin.sym} 3140 8960 0 0 {name=l7283 lab=WL45}
N 3240 9040 3260 9040 {}
C {lab_pin.sym} 3260 9040 0 0 {name=l7284 lab=VDD}
N 3240 8960 3260 8960 {}
C {lab_pin.sym} 3260 8960 0 0 {name=l7285 lab=VSS}
C {bitcell_6t.sym} 3400 9000 0 0 {name=Xr45c17}
N 3360 9040 3340 9040 {}
C {lab_pin.sym} 3340 9040 0 0 {name=l7286 lab=BL17}
N 3360 9000 3340 9000 {}
C {lab_pin.sym} 3340 9000 0 0 {name=l7287 lab=BLB17}
N 3360 8960 3340 8960 {}
C {lab_pin.sym} 3340 8960 0 0 {name=l7288 lab=WL45}
N 3440 9040 3460 9040 {}
C {lab_pin.sym} 3460 9040 0 0 {name=l7289 lab=VDD}
N 3440 8960 3460 8960 {}
C {lab_pin.sym} 3460 8960 0 0 {name=l7290 lab=VSS}
C {bitcell_6t.sym} 3600 9000 0 0 {name=Xr45c18}
N 3560 9040 3540 9040 {}
C {lab_pin.sym} 3540 9040 0 0 {name=l7291 lab=BL18}
N 3560 9000 3540 9000 {}
C {lab_pin.sym} 3540 9000 0 0 {name=l7292 lab=BLB18}
N 3560 8960 3540 8960 {}
C {lab_pin.sym} 3540 8960 0 0 {name=l7293 lab=WL45}
N 3640 9040 3660 9040 {}
C {lab_pin.sym} 3660 9040 0 0 {name=l7294 lab=VDD}
N 3640 8960 3660 8960 {}
C {lab_pin.sym} 3660 8960 0 0 {name=l7295 lab=VSS}
C {bitcell_6t.sym} 3800 9000 0 0 {name=Xr45c19}
N 3760 9040 3740 9040 {}
C {lab_pin.sym} 3740 9040 0 0 {name=l7296 lab=BL19}
N 3760 9000 3740 9000 {}
C {lab_pin.sym} 3740 9000 0 0 {name=l7297 lab=BLB19}
N 3760 8960 3740 8960 {}
C {lab_pin.sym} 3740 8960 0 0 {name=l7298 lab=WL45}
N 3840 9040 3860 9040 {}
C {lab_pin.sym} 3860 9040 0 0 {name=l7299 lab=VDD}
N 3840 8960 3860 8960 {}
C {lab_pin.sym} 3860 8960 0 0 {name=l7300 lab=VSS}
C {bitcell_6t.sym} 4000 9000 0 0 {name=Xr45c20}
N 3960 9040 3940 9040 {}
C {lab_pin.sym} 3940 9040 0 0 {name=l7301 lab=BL20}
N 3960 9000 3940 9000 {}
C {lab_pin.sym} 3940 9000 0 0 {name=l7302 lab=BLB20}
N 3960 8960 3940 8960 {}
C {lab_pin.sym} 3940 8960 0 0 {name=l7303 lab=WL45}
N 4040 9040 4060 9040 {}
C {lab_pin.sym} 4060 9040 0 0 {name=l7304 lab=VDD}
N 4040 8960 4060 8960 {}
C {lab_pin.sym} 4060 8960 0 0 {name=l7305 lab=VSS}
C {bitcell_6t.sym} 4200 9000 0 0 {name=Xr45c21}
N 4160 9040 4140 9040 {}
C {lab_pin.sym} 4140 9040 0 0 {name=l7306 lab=BL21}
N 4160 9000 4140 9000 {}
C {lab_pin.sym} 4140 9000 0 0 {name=l7307 lab=BLB21}
N 4160 8960 4140 8960 {}
C {lab_pin.sym} 4140 8960 0 0 {name=l7308 lab=WL45}
N 4240 9040 4260 9040 {}
C {lab_pin.sym} 4260 9040 0 0 {name=l7309 lab=VDD}
N 4240 8960 4260 8960 {}
C {lab_pin.sym} 4260 8960 0 0 {name=l7310 lab=VSS}
C {bitcell_6t.sym} 4400 9000 0 0 {name=Xr45c22}
N 4360 9040 4340 9040 {}
C {lab_pin.sym} 4340 9040 0 0 {name=l7311 lab=BL22}
N 4360 9000 4340 9000 {}
C {lab_pin.sym} 4340 9000 0 0 {name=l7312 lab=BLB22}
N 4360 8960 4340 8960 {}
C {lab_pin.sym} 4340 8960 0 0 {name=l7313 lab=WL45}
N 4440 9040 4460 9040 {}
C {lab_pin.sym} 4460 9040 0 0 {name=l7314 lab=VDD}
N 4440 8960 4460 8960 {}
C {lab_pin.sym} 4460 8960 0 0 {name=l7315 lab=VSS}
C {bitcell_6t.sym} 4600 9000 0 0 {name=Xr45c23}
N 4560 9040 4540 9040 {}
C {lab_pin.sym} 4540 9040 0 0 {name=l7316 lab=BL23}
N 4560 9000 4540 9000 {}
C {lab_pin.sym} 4540 9000 0 0 {name=l7317 lab=BLB23}
N 4560 8960 4540 8960 {}
C {lab_pin.sym} 4540 8960 0 0 {name=l7318 lab=WL45}
N 4640 9040 4660 9040 {}
C {lab_pin.sym} 4660 9040 0 0 {name=l7319 lab=VDD}
N 4640 8960 4660 8960 {}
C {lab_pin.sym} 4660 8960 0 0 {name=l7320 lab=VSS}
C {bitcell_6t.sym} 4800 9000 0 0 {name=Xr45c24}
N 4760 9040 4740 9040 {}
C {lab_pin.sym} 4740 9040 0 0 {name=l7321 lab=BL24}
N 4760 9000 4740 9000 {}
C {lab_pin.sym} 4740 9000 0 0 {name=l7322 lab=BLB24}
N 4760 8960 4740 8960 {}
C {lab_pin.sym} 4740 8960 0 0 {name=l7323 lab=WL45}
N 4840 9040 4860 9040 {}
C {lab_pin.sym} 4860 9040 0 0 {name=l7324 lab=VDD}
N 4840 8960 4860 8960 {}
C {lab_pin.sym} 4860 8960 0 0 {name=l7325 lab=VSS}
C {bitcell_6t.sym} 5000 9000 0 0 {name=Xr45c25}
N 4960 9040 4940 9040 {}
C {lab_pin.sym} 4940 9040 0 0 {name=l7326 lab=BL25}
N 4960 9000 4940 9000 {}
C {lab_pin.sym} 4940 9000 0 0 {name=l7327 lab=BLB25}
N 4960 8960 4940 8960 {}
C {lab_pin.sym} 4940 8960 0 0 {name=l7328 lab=WL45}
N 5040 9040 5060 9040 {}
C {lab_pin.sym} 5060 9040 0 0 {name=l7329 lab=VDD}
N 5040 8960 5060 8960 {}
C {lab_pin.sym} 5060 8960 0 0 {name=l7330 lab=VSS}
C {bitcell_6t.sym} 5200 9000 0 0 {name=Xr45c26}
N 5160 9040 5140 9040 {}
C {lab_pin.sym} 5140 9040 0 0 {name=l7331 lab=BL26}
N 5160 9000 5140 9000 {}
C {lab_pin.sym} 5140 9000 0 0 {name=l7332 lab=BLB26}
N 5160 8960 5140 8960 {}
C {lab_pin.sym} 5140 8960 0 0 {name=l7333 lab=WL45}
N 5240 9040 5260 9040 {}
C {lab_pin.sym} 5260 9040 0 0 {name=l7334 lab=VDD}
N 5240 8960 5260 8960 {}
C {lab_pin.sym} 5260 8960 0 0 {name=l7335 lab=VSS}
C {bitcell_6t.sym} 5400 9000 0 0 {name=Xr45c27}
N 5360 9040 5340 9040 {}
C {lab_pin.sym} 5340 9040 0 0 {name=l7336 lab=BL27}
N 5360 9000 5340 9000 {}
C {lab_pin.sym} 5340 9000 0 0 {name=l7337 lab=BLB27}
N 5360 8960 5340 8960 {}
C {lab_pin.sym} 5340 8960 0 0 {name=l7338 lab=WL45}
N 5440 9040 5460 9040 {}
C {lab_pin.sym} 5460 9040 0 0 {name=l7339 lab=VDD}
N 5440 8960 5460 8960 {}
C {lab_pin.sym} 5460 8960 0 0 {name=l7340 lab=VSS}
C {bitcell_6t.sym} 5600 9000 0 0 {name=Xr45c28}
N 5560 9040 5540 9040 {}
C {lab_pin.sym} 5540 9040 0 0 {name=l7341 lab=BL28}
N 5560 9000 5540 9000 {}
C {lab_pin.sym} 5540 9000 0 0 {name=l7342 lab=BLB28}
N 5560 8960 5540 8960 {}
C {lab_pin.sym} 5540 8960 0 0 {name=l7343 lab=WL45}
N 5640 9040 5660 9040 {}
C {lab_pin.sym} 5660 9040 0 0 {name=l7344 lab=VDD}
N 5640 8960 5660 8960 {}
C {lab_pin.sym} 5660 8960 0 0 {name=l7345 lab=VSS}
C {bitcell_6t.sym} 5800 9000 0 0 {name=Xr45c29}
N 5760 9040 5740 9040 {}
C {lab_pin.sym} 5740 9040 0 0 {name=l7346 lab=BL29}
N 5760 9000 5740 9000 {}
C {lab_pin.sym} 5740 9000 0 0 {name=l7347 lab=BLB29}
N 5760 8960 5740 8960 {}
C {lab_pin.sym} 5740 8960 0 0 {name=l7348 lab=WL45}
N 5840 9040 5860 9040 {}
C {lab_pin.sym} 5860 9040 0 0 {name=l7349 lab=VDD}
N 5840 8960 5860 8960 {}
C {lab_pin.sym} 5860 8960 0 0 {name=l7350 lab=VSS}
C {bitcell_6t.sym} 6000 9000 0 0 {name=Xr45c30}
N 5960 9040 5940 9040 {}
C {lab_pin.sym} 5940 9040 0 0 {name=l7351 lab=BL30}
N 5960 9000 5940 9000 {}
C {lab_pin.sym} 5940 9000 0 0 {name=l7352 lab=BLB30}
N 5960 8960 5940 8960 {}
C {lab_pin.sym} 5940 8960 0 0 {name=l7353 lab=WL45}
N 6040 9040 6060 9040 {}
C {lab_pin.sym} 6060 9040 0 0 {name=l7354 lab=VDD}
N 6040 8960 6060 8960 {}
C {lab_pin.sym} 6060 8960 0 0 {name=l7355 lab=VSS}
C {bitcell_6t.sym} 6200 9000 0 0 {name=Xr45c31}
N 6160 9040 6140 9040 {}
C {lab_pin.sym} 6140 9040 0 0 {name=l7356 lab=BL31}
N 6160 9000 6140 9000 {}
C {lab_pin.sym} 6140 9000 0 0 {name=l7357 lab=BLB31}
N 6160 8960 6140 8960 {}
C {lab_pin.sym} 6140 8960 0 0 {name=l7358 lab=WL45}
N 6240 9040 6260 9040 {}
C {lab_pin.sym} 6260 9040 0 0 {name=l7359 lab=VDD}
N 6240 8960 6260 8960 {}
C {lab_pin.sym} 6260 8960 0 0 {name=l7360 lab=VSS}
C {bitcell_6t.sym} 0 9200 0 0 {name=Xr46c0}
N -40 9240 -60 9240 {}
C {lab_pin.sym} -60 9240 0 0 {name=l7361 lab=BL0}
N -40 9200 -60 9200 {}
C {lab_pin.sym} -60 9200 0 0 {name=l7362 lab=BLB0}
N -40 9160 -60 9160 {}
C {lab_pin.sym} -60 9160 0 0 {name=l7363 lab=WL46}
N 40 9240 60 9240 {}
C {lab_pin.sym} 60 9240 0 0 {name=l7364 lab=VDD}
N 40 9160 60 9160 {}
C {lab_pin.sym} 60 9160 0 0 {name=l7365 lab=VSS}
C {bitcell_6t.sym} 200 9200 0 0 {name=Xr46c1}
N 160 9240 140 9240 {}
C {lab_pin.sym} 140 9240 0 0 {name=l7366 lab=BL1}
N 160 9200 140 9200 {}
C {lab_pin.sym} 140 9200 0 0 {name=l7367 lab=BLB1}
N 160 9160 140 9160 {}
C {lab_pin.sym} 140 9160 0 0 {name=l7368 lab=WL46}
N 240 9240 260 9240 {}
C {lab_pin.sym} 260 9240 0 0 {name=l7369 lab=VDD}
N 240 9160 260 9160 {}
C {lab_pin.sym} 260 9160 0 0 {name=l7370 lab=VSS}
C {bitcell_6t.sym} 400 9200 0 0 {name=Xr46c2}
N 360 9240 340 9240 {}
C {lab_pin.sym} 340 9240 0 0 {name=l7371 lab=BL2}
N 360 9200 340 9200 {}
C {lab_pin.sym} 340 9200 0 0 {name=l7372 lab=BLB2}
N 360 9160 340 9160 {}
C {lab_pin.sym} 340 9160 0 0 {name=l7373 lab=WL46}
N 440 9240 460 9240 {}
C {lab_pin.sym} 460 9240 0 0 {name=l7374 lab=VDD}
N 440 9160 460 9160 {}
C {lab_pin.sym} 460 9160 0 0 {name=l7375 lab=VSS}
C {bitcell_6t.sym} 600 9200 0 0 {name=Xr46c3}
N 560 9240 540 9240 {}
C {lab_pin.sym} 540 9240 0 0 {name=l7376 lab=BL3}
N 560 9200 540 9200 {}
C {lab_pin.sym} 540 9200 0 0 {name=l7377 lab=BLB3}
N 560 9160 540 9160 {}
C {lab_pin.sym} 540 9160 0 0 {name=l7378 lab=WL46}
N 640 9240 660 9240 {}
C {lab_pin.sym} 660 9240 0 0 {name=l7379 lab=VDD}
N 640 9160 660 9160 {}
C {lab_pin.sym} 660 9160 0 0 {name=l7380 lab=VSS}
C {bitcell_6t.sym} 800 9200 0 0 {name=Xr46c4}
N 760 9240 740 9240 {}
C {lab_pin.sym} 740 9240 0 0 {name=l7381 lab=BL4}
N 760 9200 740 9200 {}
C {lab_pin.sym} 740 9200 0 0 {name=l7382 lab=BLB4}
N 760 9160 740 9160 {}
C {lab_pin.sym} 740 9160 0 0 {name=l7383 lab=WL46}
N 840 9240 860 9240 {}
C {lab_pin.sym} 860 9240 0 0 {name=l7384 lab=VDD}
N 840 9160 860 9160 {}
C {lab_pin.sym} 860 9160 0 0 {name=l7385 lab=VSS}
C {bitcell_6t.sym} 1000 9200 0 0 {name=Xr46c5}
N 960 9240 940 9240 {}
C {lab_pin.sym} 940 9240 0 0 {name=l7386 lab=BL5}
N 960 9200 940 9200 {}
C {lab_pin.sym} 940 9200 0 0 {name=l7387 lab=BLB5}
N 960 9160 940 9160 {}
C {lab_pin.sym} 940 9160 0 0 {name=l7388 lab=WL46}
N 1040 9240 1060 9240 {}
C {lab_pin.sym} 1060 9240 0 0 {name=l7389 lab=VDD}
N 1040 9160 1060 9160 {}
C {lab_pin.sym} 1060 9160 0 0 {name=l7390 lab=VSS}
C {bitcell_6t.sym} 1200 9200 0 0 {name=Xr46c6}
N 1160 9240 1140 9240 {}
C {lab_pin.sym} 1140 9240 0 0 {name=l7391 lab=BL6}
N 1160 9200 1140 9200 {}
C {lab_pin.sym} 1140 9200 0 0 {name=l7392 lab=BLB6}
N 1160 9160 1140 9160 {}
C {lab_pin.sym} 1140 9160 0 0 {name=l7393 lab=WL46}
N 1240 9240 1260 9240 {}
C {lab_pin.sym} 1260 9240 0 0 {name=l7394 lab=VDD}
N 1240 9160 1260 9160 {}
C {lab_pin.sym} 1260 9160 0 0 {name=l7395 lab=VSS}
C {bitcell_6t.sym} 1400 9200 0 0 {name=Xr46c7}
N 1360 9240 1340 9240 {}
C {lab_pin.sym} 1340 9240 0 0 {name=l7396 lab=BL7}
N 1360 9200 1340 9200 {}
C {lab_pin.sym} 1340 9200 0 0 {name=l7397 lab=BLB7}
N 1360 9160 1340 9160 {}
C {lab_pin.sym} 1340 9160 0 0 {name=l7398 lab=WL46}
N 1440 9240 1460 9240 {}
C {lab_pin.sym} 1460 9240 0 0 {name=l7399 lab=VDD}
N 1440 9160 1460 9160 {}
C {lab_pin.sym} 1460 9160 0 0 {name=l7400 lab=VSS}
C {bitcell_6t.sym} 1600 9200 0 0 {name=Xr46c8}
N 1560 9240 1540 9240 {}
C {lab_pin.sym} 1540 9240 0 0 {name=l7401 lab=BL8}
N 1560 9200 1540 9200 {}
C {lab_pin.sym} 1540 9200 0 0 {name=l7402 lab=BLB8}
N 1560 9160 1540 9160 {}
C {lab_pin.sym} 1540 9160 0 0 {name=l7403 lab=WL46}
N 1640 9240 1660 9240 {}
C {lab_pin.sym} 1660 9240 0 0 {name=l7404 lab=VDD}
N 1640 9160 1660 9160 {}
C {lab_pin.sym} 1660 9160 0 0 {name=l7405 lab=VSS}
C {bitcell_6t.sym} 1800 9200 0 0 {name=Xr46c9}
N 1760 9240 1740 9240 {}
C {lab_pin.sym} 1740 9240 0 0 {name=l7406 lab=BL9}
N 1760 9200 1740 9200 {}
C {lab_pin.sym} 1740 9200 0 0 {name=l7407 lab=BLB9}
N 1760 9160 1740 9160 {}
C {lab_pin.sym} 1740 9160 0 0 {name=l7408 lab=WL46}
N 1840 9240 1860 9240 {}
C {lab_pin.sym} 1860 9240 0 0 {name=l7409 lab=VDD}
N 1840 9160 1860 9160 {}
C {lab_pin.sym} 1860 9160 0 0 {name=l7410 lab=VSS}
C {bitcell_6t.sym} 2000 9200 0 0 {name=Xr46c10}
N 1960 9240 1940 9240 {}
C {lab_pin.sym} 1940 9240 0 0 {name=l7411 lab=BL10}
N 1960 9200 1940 9200 {}
C {lab_pin.sym} 1940 9200 0 0 {name=l7412 lab=BLB10}
N 1960 9160 1940 9160 {}
C {lab_pin.sym} 1940 9160 0 0 {name=l7413 lab=WL46}
N 2040 9240 2060 9240 {}
C {lab_pin.sym} 2060 9240 0 0 {name=l7414 lab=VDD}
N 2040 9160 2060 9160 {}
C {lab_pin.sym} 2060 9160 0 0 {name=l7415 lab=VSS}
C {bitcell_6t.sym} 2200 9200 0 0 {name=Xr46c11}
N 2160 9240 2140 9240 {}
C {lab_pin.sym} 2140 9240 0 0 {name=l7416 lab=BL11}
N 2160 9200 2140 9200 {}
C {lab_pin.sym} 2140 9200 0 0 {name=l7417 lab=BLB11}
N 2160 9160 2140 9160 {}
C {lab_pin.sym} 2140 9160 0 0 {name=l7418 lab=WL46}
N 2240 9240 2260 9240 {}
C {lab_pin.sym} 2260 9240 0 0 {name=l7419 lab=VDD}
N 2240 9160 2260 9160 {}
C {lab_pin.sym} 2260 9160 0 0 {name=l7420 lab=VSS}
C {bitcell_6t.sym} 2400 9200 0 0 {name=Xr46c12}
N 2360 9240 2340 9240 {}
C {lab_pin.sym} 2340 9240 0 0 {name=l7421 lab=BL12}
N 2360 9200 2340 9200 {}
C {lab_pin.sym} 2340 9200 0 0 {name=l7422 lab=BLB12}
N 2360 9160 2340 9160 {}
C {lab_pin.sym} 2340 9160 0 0 {name=l7423 lab=WL46}
N 2440 9240 2460 9240 {}
C {lab_pin.sym} 2460 9240 0 0 {name=l7424 lab=VDD}
N 2440 9160 2460 9160 {}
C {lab_pin.sym} 2460 9160 0 0 {name=l7425 lab=VSS}
C {bitcell_6t.sym} 2600 9200 0 0 {name=Xr46c13}
N 2560 9240 2540 9240 {}
C {lab_pin.sym} 2540 9240 0 0 {name=l7426 lab=BL13}
N 2560 9200 2540 9200 {}
C {lab_pin.sym} 2540 9200 0 0 {name=l7427 lab=BLB13}
N 2560 9160 2540 9160 {}
C {lab_pin.sym} 2540 9160 0 0 {name=l7428 lab=WL46}
N 2640 9240 2660 9240 {}
C {lab_pin.sym} 2660 9240 0 0 {name=l7429 lab=VDD}
N 2640 9160 2660 9160 {}
C {lab_pin.sym} 2660 9160 0 0 {name=l7430 lab=VSS}
C {bitcell_6t.sym} 2800 9200 0 0 {name=Xr46c14}
N 2760 9240 2740 9240 {}
C {lab_pin.sym} 2740 9240 0 0 {name=l7431 lab=BL14}
N 2760 9200 2740 9200 {}
C {lab_pin.sym} 2740 9200 0 0 {name=l7432 lab=BLB14}
N 2760 9160 2740 9160 {}
C {lab_pin.sym} 2740 9160 0 0 {name=l7433 lab=WL46}
N 2840 9240 2860 9240 {}
C {lab_pin.sym} 2860 9240 0 0 {name=l7434 lab=VDD}
N 2840 9160 2860 9160 {}
C {lab_pin.sym} 2860 9160 0 0 {name=l7435 lab=VSS}
C {bitcell_6t.sym} 3000 9200 0 0 {name=Xr46c15}
N 2960 9240 2940 9240 {}
C {lab_pin.sym} 2940 9240 0 0 {name=l7436 lab=BL15}
N 2960 9200 2940 9200 {}
C {lab_pin.sym} 2940 9200 0 0 {name=l7437 lab=BLB15}
N 2960 9160 2940 9160 {}
C {lab_pin.sym} 2940 9160 0 0 {name=l7438 lab=WL46}
N 3040 9240 3060 9240 {}
C {lab_pin.sym} 3060 9240 0 0 {name=l7439 lab=VDD}
N 3040 9160 3060 9160 {}
C {lab_pin.sym} 3060 9160 0 0 {name=l7440 lab=VSS}
C {bitcell_6t.sym} 3200 9200 0 0 {name=Xr46c16}
N 3160 9240 3140 9240 {}
C {lab_pin.sym} 3140 9240 0 0 {name=l7441 lab=BL16}
N 3160 9200 3140 9200 {}
C {lab_pin.sym} 3140 9200 0 0 {name=l7442 lab=BLB16}
N 3160 9160 3140 9160 {}
C {lab_pin.sym} 3140 9160 0 0 {name=l7443 lab=WL46}
N 3240 9240 3260 9240 {}
C {lab_pin.sym} 3260 9240 0 0 {name=l7444 lab=VDD}
N 3240 9160 3260 9160 {}
C {lab_pin.sym} 3260 9160 0 0 {name=l7445 lab=VSS}
C {bitcell_6t.sym} 3400 9200 0 0 {name=Xr46c17}
N 3360 9240 3340 9240 {}
C {lab_pin.sym} 3340 9240 0 0 {name=l7446 lab=BL17}
N 3360 9200 3340 9200 {}
C {lab_pin.sym} 3340 9200 0 0 {name=l7447 lab=BLB17}
N 3360 9160 3340 9160 {}
C {lab_pin.sym} 3340 9160 0 0 {name=l7448 lab=WL46}
N 3440 9240 3460 9240 {}
C {lab_pin.sym} 3460 9240 0 0 {name=l7449 lab=VDD}
N 3440 9160 3460 9160 {}
C {lab_pin.sym} 3460 9160 0 0 {name=l7450 lab=VSS}
C {bitcell_6t.sym} 3600 9200 0 0 {name=Xr46c18}
N 3560 9240 3540 9240 {}
C {lab_pin.sym} 3540 9240 0 0 {name=l7451 lab=BL18}
N 3560 9200 3540 9200 {}
C {lab_pin.sym} 3540 9200 0 0 {name=l7452 lab=BLB18}
N 3560 9160 3540 9160 {}
C {lab_pin.sym} 3540 9160 0 0 {name=l7453 lab=WL46}
N 3640 9240 3660 9240 {}
C {lab_pin.sym} 3660 9240 0 0 {name=l7454 lab=VDD}
N 3640 9160 3660 9160 {}
C {lab_pin.sym} 3660 9160 0 0 {name=l7455 lab=VSS}
C {bitcell_6t.sym} 3800 9200 0 0 {name=Xr46c19}
N 3760 9240 3740 9240 {}
C {lab_pin.sym} 3740 9240 0 0 {name=l7456 lab=BL19}
N 3760 9200 3740 9200 {}
C {lab_pin.sym} 3740 9200 0 0 {name=l7457 lab=BLB19}
N 3760 9160 3740 9160 {}
C {lab_pin.sym} 3740 9160 0 0 {name=l7458 lab=WL46}
N 3840 9240 3860 9240 {}
C {lab_pin.sym} 3860 9240 0 0 {name=l7459 lab=VDD}
N 3840 9160 3860 9160 {}
C {lab_pin.sym} 3860 9160 0 0 {name=l7460 lab=VSS}
C {bitcell_6t.sym} 4000 9200 0 0 {name=Xr46c20}
N 3960 9240 3940 9240 {}
C {lab_pin.sym} 3940 9240 0 0 {name=l7461 lab=BL20}
N 3960 9200 3940 9200 {}
C {lab_pin.sym} 3940 9200 0 0 {name=l7462 lab=BLB20}
N 3960 9160 3940 9160 {}
C {lab_pin.sym} 3940 9160 0 0 {name=l7463 lab=WL46}
N 4040 9240 4060 9240 {}
C {lab_pin.sym} 4060 9240 0 0 {name=l7464 lab=VDD}
N 4040 9160 4060 9160 {}
C {lab_pin.sym} 4060 9160 0 0 {name=l7465 lab=VSS}
C {bitcell_6t.sym} 4200 9200 0 0 {name=Xr46c21}
N 4160 9240 4140 9240 {}
C {lab_pin.sym} 4140 9240 0 0 {name=l7466 lab=BL21}
N 4160 9200 4140 9200 {}
C {lab_pin.sym} 4140 9200 0 0 {name=l7467 lab=BLB21}
N 4160 9160 4140 9160 {}
C {lab_pin.sym} 4140 9160 0 0 {name=l7468 lab=WL46}
N 4240 9240 4260 9240 {}
C {lab_pin.sym} 4260 9240 0 0 {name=l7469 lab=VDD}
N 4240 9160 4260 9160 {}
C {lab_pin.sym} 4260 9160 0 0 {name=l7470 lab=VSS}
C {bitcell_6t.sym} 4400 9200 0 0 {name=Xr46c22}
N 4360 9240 4340 9240 {}
C {lab_pin.sym} 4340 9240 0 0 {name=l7471 lab=BL22}
N 4360 9200 4340 9200 {}
C {lab_pin.sym} 4340 9200 0 0 {name=l7472 lab=BLB22}
N 4360 9160 4340 9160 {}
C {lab_pin.sym} 4340 9160 0 0 {name=l7473 lab=WL46}
N 4440 9240 4460 9240 {}
C {lab_pin.sym} 4460 9240 0 0 {name=l7474 lab=VDD}
N 4440 9160 4460 9160 {}
C {lab_pin.sym} 4460 9160 0 0 {name=l7475 lab=VSS}
C {bitcell_6t.sym} 4600 9200 0 0 {name=Xr46c23}
N 4560 9240 4540 9240 {}
C {lab_pin.sym} 4540 9240 0 0 {name=l7476 lab=BL23}
N 4560 9200 4540 9200 {}
C {lab_pin.sym} 4540 9200 0 0 {name=l7477 lab=BLB23}
N 4560 9160 4540 9160 {}
C {lab_pin.sym} 4540 9160 0 0 {name=l7478 lab=WL46}
N 4640 9240 4660 9240 {}
C {lab_pin.sym} 4660 9240 0 0 {name=l7479 lab=VDD}
N 4640 9160 4660 9160 {}
C {lab_pin.sym} 4660 9160 0 0 {name=l7480 lab=VSS}
C {bitcell_6t.sym} 4800 9200 0 0 {name=Xr46c24}
N 4760 9240 4740 9240 {}
C {lab_pin.sym} 4740 9240 0 0 {name=l7481 lab=BL24}
N 4760 9200 4740 9200 {}
C {lab_pin.sym} 4740 9200 0 0 {name=l7482 lab=BLB24}
N 4760 9160 4740 9160 {}
C {lab_pin.sym} 4740 9160 0 0 {name=l7483 lab=WL46}
N 4840 9240 4860 9240 {}
C {lab_pin.sym} 4860 9240 0 0 {name=l7484 lab=VDD}
N 4840 9160 4860 9160 {}
C {lab_pin.sym} 4860 9160 0 0 {name=l7485 lab=VSS}
C {bitcell_6t.sym} 5000 9200 0 0 {name=Xr46c25}
N 4960 9240 4940 9240 {}
C {lab_pin.sym} 4940 9240 0 0 {name=l7486 lab=BL25}
N 4960 9200 4940 9200 {}
C {lab_pin.sym} 4940 9200 0 0 {name=l7487 lab=BLB25}
N 4960 9160 4940 9160 {}
C {lab_pin.sym} 4940 9160 0 0 {name=l7488 lab=WL46}
N 5040 9240 5060 9240 {}
C {lab_pin.sym} 5060 9240 0 0 {name=l7489 lab=VDD}
N 5040 9160 5060 9160 {}
C {lab_pin.sym} 5060 9160 0 0 {name=l7490 lab=VSS}
C {bitcell_6t.sym} 5200 9200 0 0 {name=Xr46c26}
N 5160 9240 5140 9240 {}
C {lab_pin.sym} 5140 9240 0 0 {name=l7491 lab=BL26}
N 5160 9200 5140 9200 {}
C {lab_pin.sym} 5140 9200 0 0 {name=l7492 lab=BLB26}
N 5160 9160 5140 9160 {}
C {lab_pin.sym} 5140 9160 0 0 {name=l7493 lab=WL46}
N 5240 9240 5260 9240 {}
C {lab_pin.sym} 5260 9240 0 0 {name=l7494 lab=VDD}
N 5240 9160 5260 9160 {}
C {lab_pin.sym} 5260 9160 0 0 {name=l7495 lab=VSS}
C {bitcell_6t.sym} 5400 9200 0 0 {name=Xr46c27}
N 5360 9240 5340 9240 {}
C {lab_pin.sym} 5340 9240 0 0 {name=l7496 lab=BL27}
N 5360 9200 5340 9200 {}
C {lab_pin.sym} 5340 9200 0 0 {name=l7497 lab=BLB27}
N 5360 9160 5340 9160 {}
C {lab_pin.sym} 5340 9160 0 0 {name=l7498 lab=WL46}
N 5440 9240 5460 9240 {}
C {lab_pin.sym} 5460 9240 0 0 {name=l7499 lab=VDD}
N 5440 9160 5460 9160 {}
C {lab_pin.sym} 5460 9160 0 0 {name=l7500 lab=VSS}
C {bitcell_6t.sym} 5600 9200 0 0 {name=Xr46c28}
N 5560 9240 5540 9240 {}
C {lab_pin.sym} 5540 9240 0 0 {name=l7501 lab=BL28}
N 5560 9200 5540 9200 {}
C {lab_pin.sym} 5540 9200 0 0 {name=l7502 lab=BLB28}
N 5560 9160 5540 9160 {}
C {lab_pin.sym} 5540 9160 0 0 {name=l7503 lab=WL46}
N 5640 9240 5660 9240 {}
C {lab_pin.sym} 5660 9240 0 0 {name=l7504 lab=VDD}
N 5640 9160 5660 9160 {}
C {lab_pin.sym} 5660 9160 0 0 {name=l7505 lab=VSS}
C {bitcell_6t.sym} 5800 9200 0 0 {name=Xr46c29}
N 5760 9240 5740 9240 {}
C {lab_pin.sym} 5740 9240 0 0 {name=l7506 lab=BL29}
N 5760 9200 5740 9200 {}
C {lab_pin.sym} 5740 9200 0 0 {name=l7507 lab=BLB29}
N 5760 9160 5740 9160 {}
C {lab_pin.sym} 5740 9160 0 0 {name=l7508 lab=WL46}
N 5840 9240 5860 9240 {}
C {lab_pin.sym} 5860 9240 0 0 {name=l7509 lab=VDD}
N 5840 9160 5860 9160 {}
C {lab_pin.sym} 5860 9160 0 0 {name=l7510 lab=VSS}
C {bitcell_6t.sym} 6000 9200 0 0 {name=Xr46c30}
N 5960 9240 5940 9240 {}
C {lab_pin.sym} 5940 9240 0 0 {name=l7511 lab=BL30}
N 5960 9200 5940 9200 {}
C {lab_pin.sym} 5940 9200 0 0 {name=l7512 lab=BLB30}
N 5960 9160 5940 9160 {}
C {lab_pin.sym} 5940 9160 0 0 {name=l7513 lab=WL46}
N 6040 9240 6060 9240 {}
C {lab_pin.sym} 6060 9240 0 0 {name=l7514 lab=VDD}
N 6040 9160 6060 9160 {}
C {lab_pin.sym} 6060 9160 0 0 {name=l7515 lab=VSS}
C {bitcell_6t.sym} 6200 9200 0 0 {name=Xr46c31}
N 6160 9240 6140 9240 {}
C {lab_pin.sym} 6140 9240 0 0 {name=l7516 lab=BL31}
N 6160 9200 6140 9200 {}
C {lab_pin.sym} 6140 9200 0 0 {name=l7517 lab=BLB31}
N 6160 9160 6140 9160 {}
C {lab_pin.sym} 6140 9160 0 0 {name=l7518 lab=WL46}
N 6240 9240 6260 9240 {}
C {lab_pin.sym} 6260 9240 0 0 {name=l7519 lab=VDD}
N 6240 9160 6260 9160 {}
C {lab_pin.sym} 6260 9160 0 0 {name=l7520 lab=VSS}
C {bitcell_6t.sym} 0 9400 0 0 {name=Xr47c0}
N -40 9440 -60 9440 {}
C {lab_pin.sym} -60 9440 0 0 {name=l7521 lab=BL0}
N -40 9400 -60 9400 {}
C {lab_pin.sym} -60 9400 0 0 {name=l7522 lab=BLB0}
N -40 9360 -60 9360 {}
C {lab_pin.sym} -60 9360 0 0 {name=l7523 lab=WL47}
N 40 9440 60 9440 {}
C {lab_pin.sym} 60 9440 0 0 {name=l7524 lab=VDD}
N 40 9360 60 9360 {}
C {lab_pin.sym} 60 9360 0 0 {name=l7525 lab=VSS}
C {bitcell_6t.sym} 200 9400 0 0 {name=Xr47c1}
N 160 9440 140 9440 {}
C {lab_pin.sym} 140 9440 0 0 {name=l7526 lab=BL1}
N 160 9400 140 9400 {}
C {lab_pin.sym} 140 9400 0 0 {name=l7527 lab=BLB1}
N 160 9360 140 9360 {}
C {lab_pin.sym} 140 9360 0 0 {name=l7528 lab=WL47}
N 240 9440 260 9440 {}
C {lab_pin.sym} 260 9440 0 0 {name=l7529 lab=VDD}
N 240 9360 260 9360 {}
C {lab_pin.sym} 260 9360 0 0 {name=l7530 lab=VSS}
C {bitcell_6t.sym} 400 9400 0 0 {name=Xr47c2}
N 360 9440 340 9440 {}
C {lab_pin.sym} 340 9440 0 0 {name=l7531 lab=BL2}
N 360 9400 340 9400 {}
C {lab_pin.sym} 340 9400 0 0 {name=l7532 lab=BLB2}
N 360 9360 340 9360 {}
C {lab_pin.sym} 340 9360 0 0 {name=l7533 lab=WL47}
N 440 9440 460 9440 {}
C {lab_pin.sym} 460 9440 0 0 {name=l7534 lab=VDD}
N 440 9360 460 9360 {}
C {lab_pin.sym} 460 9360 0 0 {name=l7535 lab=VSS}
C {bitcell_6t.sym} 600 9400 0 0 {name=Xr47c3}
N 560 9440 540 9440 {}
C {lab_pin.sym} 540 9440 0 0 {name=l7536 lab=BL3}
N 560 9400 540 9400 {}
C {lab_pin.sym} 540 9400 0 0 {name=l7537 lab=BLB3}
N 560 9360 540 9360 {}
C {lab_pin.sym} 540 9360 0 0 {name=l7538 lab=WL47}
N 640 9440 660 9440 {}
C {lab_pin.sym} 660 9440 0 0 {name=l7539 lab=VDD}
N 640 9360 660 9360 {}
C {lab_pin.sym} 660 9360 0 0 {name=l7540 lab=VSS}
C {bitcell_6t.sym} 800 9400 0 0 {name=Xr47c4}
N 760 9440 740 9440 {}
C {lab_pin.sym} 740 9440 0 0 {name=l7541 lab=BL4}
N 760 9400 740 9400 {}
C {lab_pin.sym} 740 9400 0 0 {name=l7542 lab=BLB4}
N 760 9360 740 9360 {}
C {lab_pin.sym} 740 9360 0 0 {name=l7543 lab=WL47}
N 840 9440 860 9440 {}
C {lab_pin.sym} 860 9440 0 0 {name=l7544 lab=VDD}
N 840 9360 860 9360 {}
C {lab_pin.sym} 860 9360 0 0 {name=l7545 lab=VSS}
C {bitcell_6t.sym} 1000 9400 0 0 {name=Xr47c5}
N 960 9440 940 9440 {}
C {lab_pin.sym} 940 9440 0 0 {name=l7546 lab=BL5}
N 960 9400 940 9400 {}
C {lab_pin.sym} 940 9400 0 0 {name=l7547 lab=BLB5}
N 960 9360 940 9360 {}
C {lab_pin.sym} 940 9360 0 0 {name=l7548 lab=WL47}
N 1040 9440 1060 9440 {}
C {lab_pin.sym} 1060 9440 0 0 {name=l7549 lab=VDD}
N 1040 9360 1060 9360 {}
C {lab_pin.sym} 1060 9360 0 0 {name=l7550 lab=VSS}
C {bitcell_6t.sym} 1200 9400 0 0 {name=Xr47c6}
N 1160 9440 1140 9440 {}
C {lab_pin.sym} 1140 9440 0 0 {name=l7551 lab=BL6}
N 1160 9400 1140 9400 {}
C {lab_pin.sym} 1140 9400 0 0 {name=l7552 lab=BLB6}
N 1160 9360 1140 9360 {}
C {lab_pin.sym} 1140 9360 0 0 {name=l7553 lab=WL47}
N 1240 9440 1260 9440 {}
C {lab_pin.sym} 1260 9440 0 0 {name=l7554 lab=VDD}
N 1240 9360 1260 9360 {}
C {lab_pin.sym} 1260 9360 0 0 {name=l7555 lab=VSS}
C {bitcell_6t.sym} 1400 9400 0 0 {name=Xr47c7}
N 1360 9440 1340 9440 {}
C {lab_pin.sym} 1340 9440 0 0 {name=l7556 lab=BL7}
N 1360 9400 1340 9400 {}
C {lab_pin.sym} 1340 9400 0 0 {name=l7557 lab=BLB7}
N 1360 9360 1340 9360 {}
C {lab_pin.sym} 1340 9360 0 0 {name=l7558 lab=WL47}
N 1440 9440 1460 9440 {}
C {lab_pin.sym} 1460 9440 0 0 {name=l7559 lab=VDD}
N 1440 9360 1460 9360 {}
C {lab_pin.sym} 1460 9360 0 0 {name=l7560 lab=VSS}
C {bitcell_6t.sym} 1600 9400 0 0 {name=Xr47c8}
N 1560 9440 1540 9440 {}
C {lab_pin.sym} 1540 9440 0 0 {name=l7561 lab=BL8}
N 1560 9400 1540 9400 {}
C {lab_pin.sym} 1540 9400 0 0 {name=l7562 lab=BLB8}
N 1560 9360 1540 9360 {}
C {lab_pin.sym} 1540 9360 0 0 {name=l7563 lab=WL47}
N 1640 9440 1660 9440 {}
C {lab_pin.sym} 1660 9440 0 0 {name=l7564 lab=VDD}
N 1640 9360 1660 9360 {}
C {lab_pin.sym} 1660 9360 0 0 {name=l7565 lab=VSS}
C {bitcell_6t.sym} 1800 9400 0 0 {name=Xr47c9}
N 1760 9440 1740 9440 {}
C {lab_pin.sym} 1740 9440 0 0 {name=l7566 lab=BL9}
N 1760 9400 1740 9400 {}
C {lab_pin.sym} 1740 9400 0 0 {name=l7567 lab=BLB9}
N 1760 9360 1740 9360 {}
C {lab_pin.sym} 1740 9360 0 0 {name=l7568 lab=WL47}
N 1840 9440 1860 9440 {}
C {lab_pin.sym} 1860 9440 0 0 {name=l7569 lab=VDD}
N 1840 9360 1860 9360 {}
C {lab_pin.sym} 1860 9360 0 0 {name=l7570 lab=VSS}
C {bitcell_6t.sym} 2000 9400 0 0 {name=Xr47c10}
N 1960 9440 1940 9440 {}
C {lab_pin.sym} 1940 9440 0 0 {name=l7571 lab=BL10}
N 1960 9400 1940 9400 {}
C {lab_pin.sym} 1940 9400 0 0 {name=l7572 lab=BLB10}
N 1960 9360 1940 9360 {}
C {lab_pin.sym} 1940 9360 0 0 {name=l7573 lab=WL47}
N 2040 9440 2060 9440 {}
C {lab_pin.sym} 2060 9440 0 0 {name=l7574 lab=VDD}
N 2040 9360 2060 9360 {}
C {lab_pin.sym} 2060 9360 0 0 {name=l7575 lab=VSS}
C {bitcell_6t.sym} 2200 9400 0 0 {name=Xr47c11}
N 2160 9440 2140 9440 {}
C {lab_pin.sym} 2140 9440 0 0 {name=l7576 lab=BL11}
N 2160 9400 2140 9400 {}
C {lab_pin.sym} 2140 9400 0 0 {name=l7577 lab=BLB11}
N 2160 9360 2140 9360 {}
C {lab_pin.sym} 2140 9360 0 0 {name=l7578 lab=WL47}
N 2240 9440 2260 9440 {}
C {lab_pin.sym} 2260 9440 0 0 {name=l7579 lab=VDD}
N 2240 9360 2260 9360 {}
C {lab_pin.sym} 2260 9360 0 0 {name=l7580 lab=VSS}
C {bitcell_6t.sym} 2400 9400 0 0 {name=Xr47c12}
N 2360 9440 2340 9440 {}
C {lab_pin.sym} 2340 9440 0 0 {name=l7581 lab=BL12}
N 2360 9400 2340 9400 {}
C {lab_pin.sym} 2340 9400 0 0 {name=l7582 lab=BLB12}
N 2360 9360 2340 9360 {}
C {lab_pin.sym} 2340 9360 0 0 {name=l7583 lab=WL47}
N 2440 9440 2460 9440 {}
C {lab_pin.sym} 2460 9440 0 0 {name=l7584 lab=VDD}
N 2440 9360 2460 9360 {}
C {lab_pin.sym} 2460 9360 0 0 {name=l7585 lab=VSS}
C {bitcell_6t.sym} 2600 9400 0 0 {name=Xr47c13}
N 2560 9440 2540 9440 {}
C {lab_pin.sym} 2540 9440 0 0 {name=l7586 lab=BL13}
N 2560 9400 2540 9400 {}
C {lab_pin.sym} 2540 9400 0 0 {name=l7587 lab=BLB13}
N 2560 9360 2540 9360 {}
C {lab_pin.sym} 2540 9360 0 0 {name=l7588 lab=WL47}
N 2640 9440 2660 9440 {}
C {lab_pin.sym} 2660 9440 0 0 {name=l7589 lab=VDD}
N 2640 9360 2660 9360 {}
C {lab_pin.sym} 2660 9360 0 0 {name=l7590 lab=VSS}
C {bitcell_6t.sym} 2800 9400 0 0 {name=Xr47c14}
N 2760 9440 2740 9440 {}
C {lab_pin.sym} 2740 9440 0 0 {name=l7591 lab=BL14}
N 2760 9400 2740 9400 {}
C {lab_pin.sym} 2740 9400 0 0 {name=l7592 lab=BLB14}
N 2760 9360 2740 9360 {}
C {lab_pin.sym} 2740 9360 0 0 {name=l7593 lab=WL47}
N 2840 9440 2860 9440 {}
C {lab_pin.sym} 2860 9440 0 0 {name=l7594 lab=VDD}
N 2840 9360 2860 9360 {}
C {lab_pin.sym} 2860 9360 0 0 {name=l7595 lab=VSS}
C {bitcell_6t.sym} 3000 9400 0 0 {name=Xr47c15}
N 2960 9440 2940 9440 {}
C {lab_pin.sym} 2940 9440 0 0 {name=l7596 lab=BL15}
N 2960 9400 2940 9400 {}
C {lab_pin.sym} 2940 9400 0 0 {name=l7597 lab=BLB15}
N 2960 9360 2940 9360 {}
C {lab_pin.sym} 2940 9360 0 0 {name=l7598 lab=WL47}
N 3040 9440 3060 9440 {}
C {lab_pin.sym} 3060 9440 0 0 {name=l7599 lab=VDD}
N 3040 9360 3060 9360 {}
C {lab_pin.sym} 3060 9360 0 0 {name=l7600 lab=VSS}
C {bitcell_6t.sym} 3200 9400 0 0 {name=Xr47c16}
N 3160 9440 3140 9440 {}
C {lab_pin.sym} 3140 9440 0 0 {name=l7601 lab=BL16}
N 3160 9400 3140 9400 {}
C {lab_pin.sym} 3140 9400 0 0 {name=l7602 lab=BLB16}
N 3160 9360 3140 9360 {}
C {lab_pin.sym} 3140 9360 0 0 {name=l7603 lab=WL47}
N 3240 9440 3260 9440 {}
C {lab_pin.sym} 3260 9440 0 0 {name=l7604 lab=VDD}
N 3240 9360 3260 9360 {}
C {lab_pin.sym} 3260 9360 0 0 {name=l7605 lab=VSS}
C {bitcell_6t.sym} 3400 9400 0 0 {name=Xr47c17}
N 3360 9440 3340 9440 {}
C {lab_pin.sym} 3340 9440 0 0 {name=l7606 lab=BL17}
N 3360 9400 3340 9400 {}
C {lab_pin.sym} 3340 9400 0 0 {name=l7607 lab=BLB17}
N 3360 9360 3340 9360 {}
C {lab_pin.sym} 3340 9360 0 0 {name=l7608 lab=WL47}
N 3440 9440 3460 9440 {}
C {lab_pin.sym} 3460 9440 0 0 {name=l7609 lab=VDD}
N 3440 9360 3460 9360 {}
C {lab_pin.sym} 3460 9360 0 0 {name=l7610 lab=VSS}
C {bitcell_6t.sym} 3600 9400 0 0 {name=Xr47c18}
N 3560 9440 3540 9440 {}
C {lab_pin.sym} 3540 9440 0 0 {name=l7611 lab=BL18}
N 3560 9400 3540 9400 {}
C {lab_pin.sym} 3540 9400 0 0 {name=l7612 lab=BLB18}
N 3560 9360 3540 9360 {}
C {lab_pin.sym} 3540 9360 0 0 {name=l7613 lab=WL47}
N 3640 9440 3660 9440 {}
C {lab_pin.sym} 3660 9440 0 0 {name=l7614 lab=VDD}
N 3640 9360 3660 9360 {}
C {lab_pin.sym} 3660 9360 0 0 {name=l7615 lab=VSS}
C {bitcell_6t.sym} 3800 9400 0 0 {name=Xr47c19}
N 3760 9440 3740 9440 {}
C {lab_pin.sym} 3740 9440 0 0 {name=l7616 lab=BL19}
N 3760 9400 3740 9400 {}
C {lab_pin.sym} 3740 9400 0 0 {name=l7617 lab=BLB19}
N 3760 9360 3740 9360 {}
C {lab_pin.sym} 3740 9360 0 0 {name=l7618 lab=WL47}
N 3840 9440 3860 9440 {}
C {lab_pin.sym} 3860 9440 0 0 {name=l7619 lab=VDD}
N 3840 9360 3860 9360 {}
C {lab_pin.sym} 3860 9360 0 0 {name=l7620 lab=VSS}
C {bitcell_6t.sym} 4000 9400 0 0 {name=Xr47c20}
N 3960 9440 3940 9440 {}
C {lab_pin.sym} 3940 9440 0 0 {name=l7621 lab=BL20}
N 3960 9400 3940 9400 {}
C {lab_pin.sym} 3940 9400 0 0 {name=l7622 lab=BLB20}
N 3960 9360 3940 9360 {}
C {lab_pin.sym} 3940 9360 0 0 {name=l7623 lab=WL47}
N 4040 9440 4060 9440 {}
C {lab_pin.sym} 4060 9440 0 0 {name=l7624 lab=VDD}
N 4040 9360 4060 9360 {}
C {lab_pin.sym} 4060 9360 0 0 {name=l7625 lab=VSS}
C {bitcell_6t.sym} 4200 9400 0 0 {name=Xr47c21}
N 4160 9440 4140 9440 {}
C {lab_pin.sym} 4140 9440 0 0 {name=l7626 lab=BL21}
N 4160 9400 4140 9400 {}
C {lab_pin.sym} 4140 9400 0 0 {name=l7627 lab=BLB21}
N 4160 9360 4140 9360 {}
C {lab_pin.sym} 4140 9360 0 0 {name=l7628 lab=WL47}
N 4240 9440 4260 9440 {}
C {lab_pin.sym} 4260 9440 0 0 {name=l7629 lab=VDD}
N 4240 9360 4260 9360 {}
C {lab_pin.sym} 4260 9360 0 0 {name=l7630 lab=VSS}
C {bitcell_6t.sym} 4400 9400 0 0 {name=Xr47c22}
N 4360 9440 4340 9440 {}
C {lab_pin.sym} 4340 9440 0 0 {name=l7631 lab=BL22}
N 4360 9400 4340 9400 {}
C {lab_pin.sym} 4340 9400 0 0 {name=l7632 lab=BLB22}
N 4360 9360 4340 9360 {}
C {lab_pin.sym} 4340 9360 0 0 {name=l7633 lab=WL47}
N 4440 9440 4460 9440 {}
C {lab_pin.sym} 4460 9440 0 0 {name=l7634 lab=VDD}
N 4440 9360 4460 9360 {}
C {lab_pin.sym} 4460 9360 0 0 {name=l7635 lab=VSS}
C {bitcell_6t.sym} 4600 9400 0 0 {name=Xr47c23}
N 4560 9440 4540 9440 {}
C {lab_pin.sym} 4540 9440 0 0 {name=l7636 lab=BL23}
N 4560 9400 4540 9400 {}
C {lab_pin.sym} 4540 9400 0 0 {name=l7637 lab=BLB23}
N 4560 9360 4540 9360 {}
C {lab_pin.sym} 4540 9360 0 0 {name=l7638 lab=WL47}
N 4640 9440 4660 9440 {}
C {lab_pin.sym} 4660 9440 0 0 {name=l7639 lab=VDD}
N 4640 9360 4660 9360 {}
C {lab_pin.sym} 4660 9360 0 0 {name=l7640 lab=VSS}
C {bitcell_6t.sym} 4800 9400 0 0 {name=Xr47c24}
N 4760 9440 4740 9440 {}
C {lab_pin.sym} 4740 9440 0 0 {name=l7641 lab=BL24}
N 4760 9400 4740 9400 {}
C {lab_pin.sym} 4740 9400 0 0 {name=l7642 lab=BLB24}
N 4760 9360 4740 9360 {}
C {lab_pin.sym} 4740 9360 0 0 {name=l7643 lab=WL47}
N 4840 9440 4860 9440 {}
C {lab_pin.sym} 4860 9440 0 0 {name=l7644 lab=VDD}
N 4840 9360 4860 9360 {}
C {lab_pin.sym} 4860 9360 0 0 {name=l7645 lab=VSS}
C {bitcell_6t.sym} 5000 9400 0 0 {name=Xr47c25}
N 4960 9440 4940 9440 {}
C {lab_pin.sym} 4940 9440 0 0 {name=l7646 lab=BL25}
N 4960 9400 4940 9400 {}
C {lab_pin.sym} 4940 9400 0 0 {name=l7647 lab=BLB25}
N 4960 9360 4940 9360 {}
C {lab_pin.sym} 4940 9360 0 0 {name=l7648 lab=WL47}
N 5040 9440 5060 9440 {}
C {lab_pin.sym} 5060 9440 0 0 {name=l7649 lab=VDD}
N 5040 9360 5060 9360 {}
C {lab_pin.sym} 5060 9360 0 0 {name=l7650 lab=VSS}
C {bitcell_6t.sym} 5200 9400 0 0 {name=Xr47c26}
N 5160 9440 5140 9440 {}
C {lab_pin.sym} 5140 9440 0 0 {name=l7651 lab=BL26}
N 5160 9400 5140 9400 {}
C {lab_pin.sym} 5140 9400 0 0 {name=l7652 lab=BLB26}
N 5160 9360 5140 9360 {}
C {lab_pin.sym} 5140 9360 0 0 {name=l7653 lab=WL47}
N 5240 9440 5260 9440 {}
C {lab_pin.sym} 5260 9440 0 0 {name=l7654 lab=VDD}
N 5240 9360 5260 9360 {}
C {lab_pin.sym} 5260 9360 0 0 {name=l7655 lab=VSS}
C {bitcell_6t.sym} 5400 9400 0 0 {name=Xr47c27}
N 5360 9440 5340 9440 {}
C {lab_pin.sym} 5340 9440 0 0 {name=l7656 lab=BL27}
N 5360 9400 5340 9400 {}
C {lab_pin.sym} 5340 9400 0 0 {name=l7657 lab=BLB27}
N 5360 9360 5340 9360 {}
C {lab_pin.sym} 5340 9360 0 0 {name=l7658 lab=WL47}
N 5440 9440 5460 9440 {}
C {lab_pin.sym} 5460 9440 0 0 {name=l7659 lab=VDD}
N 5440 9360 5460 9360 {}
C {lab_pin.sym} 5460 9360 0 0 {name=l7660 lab=VSS}
C {bitcell_6t.sym} 5600 9400 0 0 {name=Xr47c28}
N 5560 9440 5540 9440 {}
C {lab_pin.sym} 5540 9440 0 0 {name=l7661 lab=BL28}
N 5560 9400 5540 9400 {}
C {lab_pin.sym} 5540 9400 0 0 {name=l7662 lab=BLB28}
N 5560 9360 5540 9360 {}
C {lab_pin.sym} 5540 9360 0 0 {name=l7663 lab=WL47}
N 5640 9440 5660 9440 {}
C {lab_pin.sym} 5660 9440 0 0 {name=l7664 lab=VDD}
N 5640 9360 5660 9360 {}
C {lab_pin.sym} 5660 9360 0 0 {name=l7665 lab=VSS}
C {bitcell_6t.sym} 5800 9400 0 0 {name=Xr47c29}
N 5760 9440 5740 9440 {}
C {lab_pin.sym} 5740 9440 0 0 {name=l7666 lab=BL29}
N 5760 9400 5740 9400 {}
C {lab_pin.sym} 5740 9400 0 0 {name=l7667 lab=BLB29}
N 5760 9360 5740 9360 {}
C {lab_pin.sym} 5740 9360 0 0 {name=l7668 lab=WL47}
N 5840 9440 5860 9440 {}
C {lab_pin.sym} 5860 9440 0 0 {name=l7669 lab=VDD}
N 5840 9360 5860 9360 {}
C {lab_pin.sym} 5860 9360 0 0 {name=l7670 lab=VSS}
C {bitcell_6t.sym} 6000 9400 0 0 {name=Xr47c30}
N 5960 9440 5940 9440 {}
C {lab_pin.sym} 5940 9440 0 0 {name=l7671 lab=BL30}
N 5960 9400 5940 9400 {}
C {lab_pin.sym} 5940 9400 0 0 {name=l7672 lab=BLB30}
N 5960 9360 5940 9360 {}
C {lab_pin.sym} 5940 9360 0 0 {name=l7673 lab=WL47}
N 6040 9440 6060 9440 {}
C {lab_pin.sym} 6060 9440 0 0 {name=l7674 lab=VDD}
N 6040 9360 6060 9360 {}
C {lab_pin.sym} 6060 9360 0 0 {name=l7675 lab=VSS}
C {bitcell_6t.sym} 6200 9400 0 0 {name=Xr47c31}
N 6160 9440 6140 9440 {}
C {lab_pin.sym} 6140 9440 0 0 {name=l7676 lab=BL31}
N 6160 9400 6140 9400 {}
C {lab_pin.sym} 6140 9400 0 0 {name=l7677 lab=BLB31}
N 6160 9360 6140 9360 {}
C {lab_pin.sym} 6140 9360 0 0 {name=l7678 lab=WL47}
N 6240 9440 6260 9440 {}
C {lab_pin.sym} 6260 9440 0 0 {name=l7679 lab=VDD}
N 6240 9360 6260 9360 {}
C {lab_pin.sym} 6260 9360 0 0 {name=l7680 lab=VSS}
C {bitcell_6t.sym} 0 9600 0 0 {name=Xr48c0}
N -40 9640 -60 9640 {}
C {lab_pin.sym} -60 9640 0 0 {name=l7681 lab=BL0}
N -40 9600 -60 9600 {}
C {lab_pin.sym} -60 9600 0 0 {name=l7682 lab=BLB0}
N -40 9560 -60 9560 {}
C {lab_pin.sym} -60 9560 0 0 {name=l7683 lab=WL48}
N 40 9640 60 9640 {}
C {lab_pin.sym} 60 9640 0 0 {name=l7684 lab=VDD}
N 40 9560 60 9560 {}
C {lab_pin.sym} 60 9560 0 0 {name=l7685 lab=VSS}
C {bitcell_6t.sym} 200 9600 0 0 {name=Xr48c1}
N 160 9640 140 9640 {}
C {lab_pin.sym} 140 9640 0 0 {name=l7686 lab=BL1}
N 160 9600 140 9600 {}
C {lab_pin.sym} 140 9600 0 0 {name=l7687 lab=BLB1}
N 160 9560 140 9560 {}
C {lab_pin.sym} 140 9560 0 0 {name=l7688 lab=WL48}
N 240 9640 260 9640 {}
C {lab_pin.sym} 260 9640 0 0 {name=l7689 lab=VDD}
N 240 9560 260 9560 {}
C {lab_pin.sym} 260 9560 0 0 {name=l7690 lab=VSS}
C {bitcell_6t.sym} 400 9600 0 0 {name=Xr48c2}
N 360 9640 340 9640 {}
C {lab_pin.sym} 340 9640 0 0 {name=l7691 lab=BL2}
N 360 9600 340 9600 {}
C {lab_pin.sym} 340 9600 0 0 {name=l7692 lab=BLB2}
N 360 9560 340 9560 {}
C {lab_pin.sym} 340 9560 0 0 {name=l7693 lab=WL48}
N 440 9640 460 9640 {}
C {lab_pin.sym} 460 9640 0 0 {name=l7694 lab=VDD}
N 440 9560 460 9560 {}
C {lab_pin.sym} 460 9560 0 0 {name=l7695 lab=VSS}
C {bitcell_6t.sym} 600 9600 0 0 {name=Xr48c3}
N 560 9640 540 9640 {}
C {lab_pin.sym} 540 9640 0 0 {name=l7696 lab=BL3}
N 560 9600 540 9600 {}
C {lab_pin.sym} 540 9600 0 0 {name=l7697 lab=BLB3}
N 560 9560 540 9560 {}
C {lab_pin.sym} 540 9560 0 0 {name=l7698 lab=WL48}
N 640 9640 660 9640 {}
C {lab_pin.sym} 660 9640 0 0 {name=l7699 lab=VDD}
N 640 9560 660 9560 {}
C {lab_pin.sym} 660 9560 0 0 {name=l7700 lab=VSS}
C {bitcell_6t.sym} 800 9600 0 0 {name=Xr48c4}
N 760 9640 740 9640 {}
C {lab_pin.sym} 740 9640 0 0 {name=l7701 lab=BL4}
N 760 9600 740 9600 {}
C {lab_pin.sym} 740 9600 0 0 {name=l7702 lab=BLB4}
N 760 9560 740 9560 {}
C {lab_pin.sym} 740 9560 0 0 {name=l7703 lab=WL48}
N 840 9640 860 9640 {}
C {lab_pin.sym} 860 9640 0 0 {name=l7704 lab=VDD}
N 840 9560 860 9560 {}
C {lab_pin.sym} 860 9560 0 0 {name=l7705 lab=VSS}
C {bitcell_6t.sym} 1000 9600 0 0 {name=Xr48c5}
N 960 9640 940 9640 {}
C {lab_pin.sym} 940 9640 0 0 {name=l7706 lab=BL5}
N 960 9600 940 9600 {}
C {lab_pin.sym} 940 9600 0 0 {name=l7707 lab=BLB5}
N 960 9560 940 9560 {}
C {lab_pin.sym} 940 9560 0 0 {name=l7708 lab=WL48}
N 1040 9640 1060 9640 {}
C {lab_pin.sym} 1060 9640 0 0 {name=l7709 lab=VDD}
N 1040 9560 1060 9560 {}
C {lab_pin.sym} 1060 9560 0 0 {name=l7710 lab=VSS}
C {bitcell_6t.sym} 1200 9600 0 0 {name=Xr48c6}
N 1160 9640 1140 9640 {}
C {lab_pin.sym} 1140 9640 0 0 {name=l7711 lab=BL6}
N 1160 9600 1140 9600 {}
C {lab_pin.sym} 1140 9600 0 0 {name=l7712 lab=BLB6}
N 1160 9560 1140 9560 {}
C {lab_pin.sym} 1140 9560 0 0 {name=l7713 lab=WL48}
N 1240 9640 1260 9640 {}
C {lab_pin.sym} 1260 9640 0 0 {name=l7714 lab=VDD}
N 1240 9560 1260 9560 {}
C {lab_pin.sym} 1260 9560 0 0 {name=l7715 lab=VSS}
C {bitcell_6t.sym} 1400 9600 0 0 {name=Xr48c7}
N 1360 9640 1340 9640 {}
C {lab_pin.sym} 1340 9640 0 0 {name=l7716 lab=BL7}
N 1360 9600 1340 9600 {}
C {lab_pin.sym} 1340 9600 0 0 {name=l7717 lab=BLB7}
N 1360 9560 1340 9560 {}
C {lab_pin.sym} 1340 9560 0 0 {name=l7718 lab=WL48}
N 1440 9640 1460 9640 {}
C {lab_pin.sym} 1460 9640 0 0 {name=l7719 lab=VDD}
N 1440 9560 1460 9560 {}
C {lab_pin.sym} 1460 9560 0 0 {name=l7720 lab=VSS}
C {bitcell_6t.sym} 1600 9600 0 0 {name=Xr48c8}
N 1560 9640 1540 9640 {}
C {lab_pin.sym} 1540 9640 0 0 {name=l7721 lab=BL8}
N 1560 9600 1540 9600 {}
C {lab_pin.sym} 1540 9600 0 0 {name=l7722 lab=BLB8}
N 1560 9560 1540 9560 {}
C {lab_pin.sym} 1540 9560 0 0 {name=l7723 lab=WL48}
N 1640 9640 1660 9640 {}
C {lab_pin.sym} 1660 9640 0 0 {name=l7724 lab=VDD}
N 1640 9560 1660 9560 {}
C {lab_pin.sym} 1660 9560 0 0 {name=l7725 lab=VSS}
C {bitcell_6t.sym} 1800 9600 0 0 {name=Xr48c9}
N 1760 9640 1740 9640 {}
C {lab_pin.sym} 1740 9640 0 0 {name=l7726 lab=BL9}
N 1760 9600 1740 9600 {}
C {lab_pin.sym} 1740 9600 0 0 {name=l7727 lab=BLB9}
N 1760 9560 1740 9560 {}
C {lab_pin.sym} 1740 9560 0 0 {name=l7728 lab=WL48}
N 1840 9640 1860 9640 {}
C {lab_pin.sym} 1860 9640 0 0 {name=l7729 lab=VDD}
N 1840 9560 1860 9560 {}
C {lab_pin.sym} 1860 9560 0 0 {name=l7730 lab=VSS}
C {bitcell_6t.sym} 2000 9600 0 0 {name=Xr48c10}
N 1960 9640 1940 9640 {}
C {lab_pin.sym} 1940 9640 0 0 {name=l7731 lab=BL10}
N 1960 9600 1940 9600 {}
C {lab_pin.sym} 1940 9600 0 0 {name=l7732 lab=BLB10}
N 1960 9560 1940 9560 {}
C {lab_pin.sym} 1940 9560 0 0 {name=l7733 lab=WL48}
N 2040 9640 2060 9640 {}
C {lab_pin.sym} 2060 9640 0 0 {name=l7734 lab=VDD}
N 2040 9560 2060 9560 {}
C {lab_pin.sym} 2060 9560 0 0 {name=l7735 lab=VSS}
C {bitcell_6t.sym} 2200 9600 0 0 {name=Xr48c11}
N 2160 9640 2140 9640 {}
C {lab_pin.sym} 2140 9640 0 0 {name=l7736 lab=BL11}
N 2160 9600 2140 9600 {}
C {lab_pin.sym} 2140 9600 0 0 {name=l7737 lab=BLB11}
N 2160 9560 2140 9560 {}
C {lab_pin.sym} 2140 9560 0 0 {name=l7738 lab=WL48}
N 2240 9640 2260 9640 {}
C {lab_pin.sym} 2260 9640 0 0 {name=l7739 lab=VDD}
N 2240 9560 2260 9560 {}
C {lab_pin.sym} 2260 9560 0 0 {name=l7740 lab=VSS}
C {bitcell_6t.sym} 2400 9600 0 0 {name=Xr48c12}
N 2360 9640 2340 9640 {}
C {lab_pin.sym} 2340 9640 0 0 {name=l7741 lab=BL12}
N 2360 9600 2340 9600 {}
C {lab_pin.sym} 2340 9600 0 0 {name=l7742 lab=BLB12}
N 2360 9560 2340 9560 {}
C {lab_pin.sym} 2340 9560 0 0 {name=l7743 lab=WL48}
N 2440 9640 2460 9640 {}
C {lab_pin.sym} 2460 9640 0 0 {name=l7744 lab=VDD}
N 2440 9560 2460 9560 {}
C {lab_pin.sym} 2460 9560 0 0 {name=l7745 lab=VSS}
C {bitcell_6t.sym} 2600 9600 0 0 {name=Xr48c13}
N 2560 9640 2540 9640 {}
C {lab_pin.sym} 2540 9640 0 0 {name=l7746 lab=BL13}
N 2560 9600 2540 9600 {}
C {lab_pin.sym} 2540 9600 0 0 {name=l7747 lab=BLB13}
N 2560 9560 2540 9560 {}
C {lab_pin.sym} 2540 9560 0 0 {name=l7748 lab=WL48}
N 2640 9640 2660 9640 {}
C {lab_pin.sym} 2660 9640 0 0 {name=l7749 lab=VDD}
N 2640 9560 2660 9560 {}
C {lab_pin.sym} 2660 9560 0 0 {name=l7750 lab=VSS}
C {bitcell_6t.sym} 2800 9600 0 0 {name=Xr48c14}
N 2760 9640 2740 9640 {}
C {lab_pin.sym} 2740 9640 0 0 {name=l7751 lab=BL14}
N 2760 9600 2740 9600 {}
C {lab_pin.sym} 2740 9600 0 0 {name=l7752 lab=BLB14}
N 2760 9560 2740 9560 {}
C {lab_pin.sym} 2740 9560 0 0 {name=l7753 lab=WL48}
N 2840 9640 2860 9640 {}
C {lab_pin.sym} 2860 9640 0 0 {name=l7754 lab=VDD}
N 2840 9560 2860 9560 {}
C {lab_pin.sym} 2860 9560 0 0 {name=l7755 lab=VSS}
C {bitcell_6t.sym} 3000 9600 0 0 {name=Xr48c15}
N 2960 9640 2940 9640 {}
C {lab_pin.sym} 2940 9640 0 0 {name=l7756 lab=BL15}
N 2960 9600 2940 9600 {}
C {lab_pin.sym} 2940 9600 0 0 {name=l7757 lab=BLB15}
N 2960 9560 2940 9560 {}
C {lab_pin.sym} 2940 9560 0 0 {name=l7758 lab=WL48}
N 3040 9640 3060 9640 {}
C {lab_pin.sym} 3060 9640 0 0 {name=l7759 lab=VDD}
N 3040 9560 3060 9560 {}
C {lab_pin.sym} 3060 9560 0 0 {name=l7760 lab=VSS}
C {bitcell_6t.sym} 3200 9600 0 0 {name=Xr48c16}
N 3160 9640 3140 9640 {}
C {lab_pin.sym} 3140 9640 0 0 {name=l7761 lab=BL16}
N 3160 9600 3140 9600 {}
C {lab_pin.sym} 3140 9600 0 0 {name=l7762 lab=BLB16}
N 3160 9560 3140 9560 {}
C {lab_pin.sym} 3140 9560 0 0 {name=l7763 lab=WL48}
N 3240 9640 3260 9640 {}
C {lab_pin.sym} 3260 9640 0 0 {name=l7764 lab=VDD}
N 3240 9560 3260 9560 {}
C {lab_pin.sym} 3260 9560 0 0 {name=l7765 lab=VSS}
C {bitcell_6t.sym} 3400 9600 0 0 {name=Xr48c17}
N 3360 9640 3340 9640 {}
C {lab_pin.sym} 3340 9640 0 0 {name=l7766 lab=BL17}
N 3360 9600 3340 9600 {}
C {lab_pin.sym} 3340 9600 0 0 {name=l7767 lab=BLB17}
N 3360 9560 3340 9560 {}
C {lab_pin.sym} 3340 9560 0 0 {name=l7768 lab=WL48}
N 3440 9640 3460 9640 {}
C {lab_pin.sym} 3460 9640 0 0 {name=l7769 lab=VDD}
N 3440 9560 3460 9560 {}
C {lab_pin.sym} 3460 9560 0 0 {name=l7770 lab=VSS}
C {bitcell_6t.sym} 3600 9600 0 0 {name=Xr48c18}
N 3560 9640 3540 9640 {}
C {lab_pin.sym} 3540 9640 0 0 {name=l7771 lab=BL18}
N 3560 9600 3540 9600 {}
C {lab_pin.sym} 3540 9600 0 0 {name=l7772 lab=BLB18}
N 3560 9560 3540 9560 {}
C {lab_pin.sym} 3540 9560 0 0 {name=l7773 lab=WL48}
N 3640 9640 3660 9640 {}
C {lab_pin.sym} 3660 9640 0 0 {name=l7774 lab=VDD}
N 3640 9560 3660 9560 {}
C {lab_pin.sym} 3660 9560 0 0 {name=l7775 lab=VSS}
C {bitcell_6t.sym} 3800 9600 0 0 {name=Xr48c19}
N 3760 9640 3740 9640 {}
C {lab_pin.sym} 3740 9640 0 0 {name=l7776 lab=BL19}
N 3760 9600 3740 9600 {}
C {lab_pin.sym} 3740 9600 0 0 {name=l7777 lab=BLB19}
N 3760 9560 3740 9560 {}
C {lab_pin.sym} 3740 9560 0 0 {name=l7778 lab=WL48}
N 3840 9640 3860 9640 {}
C {lab_pin.sym} 3860 9640 0 0 {name=l7779 lab=VDD}
N 3840 9560 3860 9560 {}
C {lab_pin.sym} 3860 9560 0 0 {name=l7780 lab=VSS}
C {bitcell_6t.sym} 4000 9600 0 0 {name=Xr48c20}
N 3960 9640 3940 9640 {}
C {lab_pin.sym} 3940 9640 0 0 {name=l7781 lab=BL20}
N 3960 9600 3940 9600 {}
C {lab_pin.sym} 3940 9600 0 0 {name=l7782 lab=BLB20}
N 3960 9560 3940 9560 {}
C {lab_pin.sym} 3940 9560 0 0 {name=l7783 lab=WL48}
N 4040 9640 4060 9640 {}
C {lab_pin.sym} 4060 9640 0 0 {name=l7784 lab=VDD}
N 4040 9560 4060 9560 {}
C {lab_pin.sym} 4060 9560 0 0 {name=l7785 lab=VSS}
C {bitcell_6t.sym} 4200 9600 0 0 {name=Xr48c21}
N 4160 9640 4140 9640 {}
C {lab_pin.sym} 4140 9640 0 0 {name=l7786 lab=BL21}
N 4160 9600 4140 9600 {}
C {lab_pin.sym} 4140 9600 0 0 {name=l7787 lab=BLB21}
N 4160 9560 4140 9560 {}
C {lab_pin.sym} 4140 9560 0 0 {name=l7788 lab=WL48}
N 4240 9640 4260 9640 {}
C {lab_pin.sym} 4260 9640 0 0 {name=l7789 lab=VDD}
N 4240 9560 4260 9560 {}
C {lab_pin.sym} 4260 9560 0 0 {name=l7790 lab=VSS}
C {bitcell_6t.sym} 4400 9600 0 0 {name=Xr48c22}
N 4360 9640 4340 9640 {}
C {lab_pin.sym} 4340 9640 0 0 {name=l7791 lab=BL22}
N 4360 9600 4340 9600 {}
C {lab_pin.sym} 4340 9600 0 0 {name=l7792 lab=BLB22}
N 4360 9560 4340 9560 {}
C {lab_pin.sym} 4340 9560 0 0 {name=l7793 lab=WL48}
N 4440 9640 4460 9640 {}
C {lab_pin.sym} 4460 9640 0 0 {name=l7794 lab=VDD}
N 4440 9560 4460 9560 {}
C {lab_pin.sym} 4460 9560 0 0 {name=l7795 lab=VSS}
C {bitcell_6t.sym} 4600 9600 0 0 {name=Xr48c23}
N 4560 9640 4540 9640 {}
C {lab_pin.sym} 4540 9640 0 0 {name=l7796 lab=BL23}
N 4560 9600 4540 9600 {}
C {lab_pin.sym} 4540 9600 0 0 {name=l7797 lab=BLB23}
N 4560 9560 4540 9560 {}
C {lab_pin.sym} 4540 9560 0 0 {name=l7798 lab=WL48}
N 4640 9640 4660 9640 {}
C {lab_pin.sym} 4660 9640 0 0 {name=l7799 lab=VDD}
N 4640 9560 4660 9560 {}
C {lab_pin.sym} 4660 9560 0 0 {name=l7800 lab=VSS}
C {bitcell_6t.sym} 4800 9600 0 0 {name=Xr48c24}
N 4760 9640 4740 9640 {}
C {lab_pin.sym} 4740 9640 0 0 {name=l7801 lab=BL24}
N 4760 9600 4740 9600 {}
C {lab_pin.sym} 4740 9600 0 0 {name=l7802 lab=BLB24}
N 4760 9560 4740 9560 {}
C {lab_pin.sym} 4740 9560 0 0 {name=l7803 lab=WL48}
N 4840 9640 4860 9640 {}
C {lab_pin.sym} 4860 9640 0 0 {name=l7804 lab=VDD}
N 4840 9560 4860 9560 {}
C {lab_pin.sym} 4860 9560 0 0 {name=l7805 lab=VSS}
C {bitcell_6t.sym} 5000 9600 0 0 {name=Xr48c25}
N 4960 9640 4940 9640 {}
C {lab_pin.sym} 4940 9640 0 0 {name=l7806 lab=BL25}
N 4960 9600 4940 9600 {}
C {lab_pin.sym} 4940 9600 0 0 {name=l7807 lab=BLB25}
N 4960 9560 4940 9560 {}
C {lab_pin.sym} 4940 9560 0 0 {name=l7808 lab=WL48}
N 5040 9640 5060 9640 {}
C {lab_pin.sym} 5060 9640 0 0 {name=l7809 lab=VDD}
N 5040 9560 5060 9560 {}
C {lab_pin.sym} 5060 9560 0 0 {name=l7810 lab=VSS}
C {bitcell_6t.sym} 5200 9600 0 0 {name=Xr48c26}
N 5160 9640 5140 9640 {}
C {lab_pin.sym} 5140 9640 0 0 {name=l7811 lab=BL26}
N 5160 9600 5140 9600 {}
C {lab_pin.sym} 5140 9600 0 0 {name=l7812 lab=BLB26}
N 5160 9560 5140 9560 {}
C {lab_pin.sym} 5140 9560 0 0 {name=l7813 lab=WL48}
N 5240 9640 5260 9640 {}
C {lab_pin.sym} 5260 9640 0 0 {name=l7814 lab=VDD}
N 5240 9560 5260 9560 {}
C {lab_pin.sym} 5260 9560 0 0 {name=l7815 lab=VSS}
C {bitcell_6t.sym} 5400 9600 0 0 {name=Xr48c27}
N 5360 9640 5340 9640 {}
C {lab_pin.sym} 5340 9640 0 0 {name=l7816 lab=BL27}
N 5360 9600 5340 9600 {}
C {lab_pin.sym} 5340 9600 0 0 {name=l7817 lab=BLB27}
N 5360 9560 5340 9560 {}
C {lab_pin.sym} 5340 9560 0 0 {name=l7818 lab=WL48}
N 5440 9640 5460 9640 {}
C {lab_pin.sym} 5460 9640 0 0 {name=l7819 lab=VDD}
N 5440 9560 5460 9560 {}
C {lab_pin.sym} 5460 9560 0 0 {name=l7820 lab=VSS}
C {bitcell_6t.sym} 5600 9600 0 0 {name=Xr48c28}
N 5560 9640 5540 9640 {}
C {lab_pin.sym} 5540 9640 0 0 {name=l7821 lab=BL28}
N 5560 9600 5540 9600 {}
C {lab_pin.sym} 5540 9600 0 0 {name=l7822 lab=BLB28}
N 5560 9560 5540 9560 {}
C {lab_pin.sym} 5540 9560 0 0 {name=l7823 lab=WL48}
N 5640 9640 5660 9640 {}
C {lab_pin.sym} 5660 9640 0 0 {name=l7824 lab=VDD}
N 5640 9560 5660 9560 {}
C {lab_pin.sym} 5660 9560 0 0 {name=l7825 lab=VSS}
C {bitcell_6t.sym} 5800 9600 0 0 {name=Xr48c29}
N 5760 9640 5740 9640 {}
C {lab_pin.sym} 5740 9640 0 0 {name=l7826 lab=BL29}
N 5760 9600 5740 9600 {}
C {lab_pin.sym} 5740 9600 0 0 {name=l7827 lab=BLB29}
N 5760 9560 5740 9560 {}
C {lab_pin.sym} 5740 9560 0 0 {name=l7828 lab=WL48}
N 5840 9640 5860 9640 {}
C {lab_pin.sym} 5860 9640 0 0 {name=l7829 lab=VDD}
N 5840 9560 5860 9560 {}
C {lab_pin.sym} 5860 9560 0 0 {name=l7830 lab=VSS}
C {bitcell_6t.sym} 6000 9600 0 0 {name=Xr48c30}
N 5960 9640 5940 9640 {}
C {lab_pin.sym} 5940 9640 0 0 {name=l7831 lab=BL30}
N 5960 9600 5940 9600 {}
C {lab_pin.sym} 5940 9600 0 0 {name=l7832 lab=BLB30}
N 5960 9560 5940 9560 {}
C {lab_pin.sym} 5940 9560 0 0 {name=l7833 lab=WL48}
N 6040 9640 6060 9640 {}
C {lab_pin.sym} 6060 9640 0 0 {name=l7834 lab=VDD}
N 6040 9560 6060 9560 {}
C {lab_pin.sym} 6060 9560 0 0 {name=l7835 lab=VSS}
C {bitcell_6t.sym} 6200 9600 0 0 {name=Xr48c31}
N 6160 9640 6140 9640 {}
C {lab_pin.sym} 6140 9640 0 0 {name=l7836 lab=BL31}
N 6160 9600 6140 9600 {}
C {lab_pin.sym} 6140 9600 0 0 {name=l7837 lab=BLB31}
N 6160 9560 6140 9560 {}
C {lab_pin.sym} 6140 9560 0 0 {name=l7838 lab=WL48}
N 6240 9640 6260 9640 {}
C {lab_pin.sym} 6260 9640 0 0 {name=l7839 lab=VDD}
N 6240 9560 6260 9560 {}
C {lab_pin.sym} 6260 9560 0 0 {name=l7840 lab=VSS}
C {bitcell_6t.sym} 0 9800 0 0 {name=Xr49c0}
N -40 9840 -60 9840 {}
C {lab_pin.sym} -60 9840 0 0 {name=l7841 lab=BL0}
N -40 9800 -60 9800 {}
C {lab_pin.sym} -60 9800 0 0 {name=l7842 lab=BLB0}
N -40 9760 -60 9760 {}
C {lab_pin.sym} -60 9760 0 0 {name=l7843 lab=WL49}
N 40 9840 60 9840 {}
C {lab_pin.sym} 60 9840 0 0 {name=l7844 lab=VDD}
N 40 9760 60 9760 {}
C {lab_pin.sym} 60 9760 0 0 {name=l7845 lab=VSS}
C {bitcell_6t.sym} 200 9800 0 0 {name=Xr49c1}
N 160 9840 140 9840 {}
C {lab_pin.sym} 140 9840 0 0 {name=l7846 lab=BL1}
N 160 9800 140 9800 {}
C {lab_pin.sym} 140 9800 0 0 {name=l7847 lab=BLB1}
N 160 9760 140 9760 {}
C {lab_pin.sym} 140 9760 0 0 {name=l7848 lab=WL49}
N 240 9840 260 9840 {}
C {lab_pin.sym} 260 9840 0 0 {name=l7849 lab=VDD}
N 240 9760 260 9760 {}
C {lab_pin.sym} 260 9760 0 0 {name=l7850 lab=VSS}
C {bitcell_6t.sym} 400 9800 0 0 {name=Xr49c2}
N 360 9840 340 9840 {}
C {lab_pin.sym} 340 9840 0 0 {name=l7851 lab=BL2}
N 360 9800 340 9800 {}
C {lab_pin.sym} 340 9800 0 0 {name=l7852 lab=BLB2}
N 360 9760 340 9760 {}
C {lab_pin.sym} 340 9760 0 0 {name=l7853 lab=WL49}
N 440 9840 460 9840 {}
C {lab_pin.sym} 460 9840 0 0 {name=l7854 lab=VDD}
N 440 9760 460 9760 {}
C {lab_pin.sym} 460 9760 0 0 {name=l7855 lab=VSS}
C {bitcell_6t.sym} 600 9800 0 0 {name=Xr49c3}
N 560 9840 540 9840 {}
C {lab_pin.sym} 540 9840 0 0 {name=l7856 lab=BL3}
N 560 9800 540 9800 {}
C {lab_pin.sym} 540 9800 0 0 {name=l7857 lab=BLB3}
N 560 9760 540 9760 {}
C {lab_pin.sym} 540 9760 0 0 {name=l7858 lab=WL49}
N 640 9840 660 9840 {}
C {lab_pin.sym} 660 9840 0 0 {name=l7859 lab=VDD}
N 640 9760 660 9760 {}
C {lab_pin.sym} 660 9760 0 0 {name=l7860 lab=VSS}
C {bitcell_6t.sym} 800 9800 0 0 {name=Xr49c4}
N 760 9840 740 9840 {}
C {lab_pin.sym} 740 9840 0 0 {name=l7861 lab=BL4}
N 760 9800 740 9800 {}
C {lab_pin.sym} 740 9800 0 0 {name=l7862 lab=BLB4}
N 760 9760 740 9760 {}
C {lab_pin.sym} 740 9760 0 0 {name=l7863 lab=WL49}
N 840 9840 860 9840 {}
C {lab_pin.sym} 860 9840 0 0 {name=l7864 lab=VDD}
N 840 9760 860 9760 {}
C {lab_pin.sym} 860 9760 0 0 {name=l7865 lab=VSS}
C {bitcell_6t.sym} 1000 9800 0 0 {name=Xr49c5}
N 960 9840 940 9840 {}
C {lab_pin.sym} 940 9840 0 0 {name=l7866 lab=BL5}
N 960 9800 940 9800 {}
C {lab_pin.sym} 940 9800 0 0 {name=l7867 lab=BLB5}
N 960 9760 940 9760 {}
C {lab_pin.sym} 940 9760 0 0 {name=l7868 lab=WL49}
N 1040 9840 1060 9840 {}
C {lab_pin.sym} 1060 9840 0 0 {name=l7869 lab=VDD}
N 1040 9760 1060 9760 {}
C {lab_pin.sym} 1060 9760 0 0 {name=l7870 lab=VSS}
C {bitcell_6t.sym} 1200 9800 0 0 {name=Xr49c6}
N 1160 9840 1140 9840 {}
C {lab_pin.sym} 1140 9840 0 0 {name=l7871 lab=BL6}
N 1160 9800 1140 9800 {}
C {lab_pin.sym} 1140 9800 0 0 {name=l7872 lab=BLB6}
N 1160 9760 1140 9760 {}
C {lab_pin.sym} 1140 9760 0 0 {name=l7873 lab=WL49}
N 1240 9840 1260 9840 {}
C {lab_pin.sym} 1260 9840 0 0 {name=l7874 lab=VDD}
N 1240 9760 1260 9760 {}
C {lab_pin.sym} 1260 9760 0 0 {name=l7875 lab=VSS}
C {bitcell_6t.sym} 1400 9800 0 0 {name=Xr49c7}
N 1360 9840 1340 9840 {}
C {lab_pin.sym} 1340 9840 0 0 {name=l7876 lab=BL7}
N 1360 9800 1340 9800 {}
C {lab_pin.sym} 1340 9800 0 0 {name=l7877 lab=BLB7}
N 1360 9760 1340 9760 {}
C {lab_pin.sym} 1340 9760 0 0 {name=l7878 lab=WL49}
N 1440 9840 1460 9840 {}
C {lab_pin.sym} 1460 9840 0 0 {name=l7879 lab=VDD}
N 1440 9760 1460 9760 {}
C {lab_pin.sym} 1460 9760 0 0 {name=l7880 lab=VSS}
C {bitcell_6t.sym} 1600 9800 0 0 {name=Xr49c8}
N 1560 9840 1540 9840 {}
C {lab_pin.sym} 1540 9840 0 0 {name=l7881 lab=BL8}
N 1560 9800 1540 9800 {}
C {lab_pin.sym} 1540 9800 0 0 {name=l7882 lab=BLB8}
N 1560 9760 1540 9760 {}
C {lab_pin.sym} 1540 9760 0 0 {name=l7883 lab=WL49}
N 1640 9840 1660 9840 {}
C {lab_pin.sym} 1660 9840 0 0 {name=l7884 lab=VDD}
N 1640 9760 1660 9760 {}
C {lab_pin.sym} 1660 9760 0 0 {name=l7885 lab=VSS}
C {bitcell_6t.sym} 1800 9800 0 0 {name=Xr49c9}
N 1760 9840 1740 9840 {}
C {lab_pin.sym} 1740 9840 0 0 {name=l7886 lab=BL9}
N 1760 9800 1740 9800 {}
C {lab_pin.sym} 1740 9800 0 0 {name=l7887 lab=BLB9}
N 1760 9760 1740 9760 {}
C {lab_pin.sym} 1740 9760 0 0 {name=l7888 lab=WL49}
N 1840 9840 1860 9840 {}
C {lab_pin.sym} 1860 9840 0 0 {name=l7889 lab=VDD}
N 1840 9760 1860 9760 {}
C {lab_pin.sym} 1860 9760 0 0 {name=l7890 lab=VSS}
C {bitcell_6t.sym} 2000 9800 0 0 {name=Xr49c10}
N 1960 9840 1940 9840 {}
C {lab_pin.sym} 1940 9840 0 0 {name=l7891 lab=BL10}
N 1960 9800 1940 9800 {}
C {lab_pin.sym} 1940 9800 0 0 {name=l7892 lab=BLB10}
N 1960 9760 1940 9760 {}
C {lab_pin.sym} 1940 9760 0 0 {name=l7893 lab=WL49}
N 2040 9840 2060 9840 {}
C {lab_pin.sym} 2060 9840 0 0 {name=l7894 lab=VDD}
N 2040 9760 2060 9760 {}
C {lab_pin.sym} 2060 9760 0 0 {name=l7895 lab=VSS}
C {bitcell_6t.sym} 2200 9800 0 0 {name=Xr49c11}
N 2160 9840 2140 9840 {}
C {lab_pin.sym} 2140 9840 0 0 {name=l7896 lab=BL11}
N 2160 9800 2140 9800 {}
C {lab_pin.sym} 2140 9800 0 0 {name=l7897 lab=BLB11}
N 2160 9760 2140 9760 {}
C {lab_pin.sym} 2140 9760 0 0 {name=l7898 lab=WL49}
N 2240 9840 2260 9840 {}
C {lab_pin.sym} 2260 9840 0 0 {name=l7899 lab=VDD}
N 2240 9760 2260 9760 {}
C {lab_pin.sym} 2260 9760 0 0 {name=l7900 lab=VSS}
C {bitcell_6t.sym} 2400 9800 0 0 {name=Xr49c12}
N 2360 9840 2340 9840 {}
C {lab_pin.sym} 2340 9840 0 0 {name=l7901 lab=BL12}
N 2360 9800 2340 9800 {}
C {lab_pin.sym} 2340 9800 0 0 {name=l7902 lab=BLB12}
N 2360 9760 2340 9760 {}
C {lab_pin.sym} 2340 9760 0 0 {name=l7903 lab=WL49}
N 2440 9840 2460 9840 {}
C {lab_pin.sym} 2460 9840 0 0 {name=l7904 lab=VDD}
N 2440 9760 2460 9760 {}
C {lab_pin.sym} 2460 9760 0 0 {name=l7905 lab=VSS}
C {bitcell_6t.sym} 2600 9800 0 0 {name=Xr49c13}
N 2560 9840 2540 9840 {}
C {lab_pin.sym} 2540 9840 0 0 {name=l7906 lab=BL13}
N 2560 9800 2540 9800 {}
C {lab_pin.sym} 2540 9800 0 0 {name=l7907 lab=BLB13}
N 2560 9760 2540 9760 {}
C {lab_pin.sym} 2540 9760 0 0 {name=l7908 lab=WL49}
N 2640 9840 2660 9840 {}
C {lab_pin.sym} 2660 9840 0 0 {name=l7909 lab=VDD}
N 2640 9760 2660 9760 {}
C {lab_pin.sym} 2660 9760 0 0 {name=l7910 lab=VSS}
C {bitcell_6t.sym} 2800 9800 0 0 {name=Xr49c14}
N 2760 9840 2740 9840 {}
C {lab_pin.sym} 2740 9840 0 0 {name=l7911 lab=BL14}
N 2760 9800 2740 9800 {}
C {lab_pin.sym} 2740 9800 0 0 {name=l7912 lab=BLB14}
N 2760 9760 2740 9760 {}
C {lab_pin.sym} 2740 9760 0 0 {name=l7913 lab=WL49}
N 2840 9840 2860 9840 {}
C {lab_pin.sym} 2860 9840 0 0 {name=l7914 lab=VDD}
N 2840 9760 2860 9760 {}
C {lab_pin.sym} 2860 9760 0 0 {name=l7915 lab=VSS}
C {bitcell_6t.sym} 3000 9800 0 0 {name=Xr49c15}
N 2960 9840 2940 9840 {}
C {lab_pin.sym} 2940 9840 0 0 {name=l7916 lab=BL15}
N 2960 9800 2940 9800 {}
C {lab_pin.sym} 2940 9800 0 0 {name=l7917 lab=BLB15}
N 2960 9760 2940 9760 {}
C {lab_pin.sym} 2940 9760 0 0 {name=l7918 lab=WL49}
N 3040 9840 3060 9840 {}
C {lab_pin.sym} 3060 9840 0 0 {name=l7919 lab=VDD}
N 3040 9760 3060 9760 {}
C {lab_pin.sym} 3060 9760 0 0 {name=l7920 lab=VSS}
C {bitcell_6t.sym} 3200 9800 0 0 {name=Xr49c16}
N 3160 9840 3140 9840 {}
C {lab_pin.sym} 3140 9840 0 0 {name=l7921 lab=BL16}
N 3160 9800 3140 9800 {}
C {lab_pin.sym} 3140 9800 0 0 {name=l7922 lab=BLB16}
N 3160 9760 3140 9760 {}
C {lab_pin.sym} 3140 9760 0 0 {name=l7923 lab=WL49}
N 3240 9840 3260 9840 {}
C {lab_pin.sym} 3260 9840 0 0 {name=l7924 lab=VDD}
N 3240 9760 3260 9760 {}
C {lab_pin.sym} 3260 9760 0 0 {name=l7925 lab=VSS}
C {bitcell_6t.sym} 3400 9800 0 0 {name=Xr49c17}
N 3360 9840 3340 9840 {}
C {lab_pin.sym} 3340 9840 0 0 {name=l7926 lab=BL17}
N 3360 9800 3340 9800 {}
C {lab_pin.sym} 3340 9800 0 0 {name=l7927 lab=BLB17}
N 3360 9760 3340 9760 {}
C {lab_pin.sym} 3340 9760 0 0 {name=l7928 lab=WL49}
N 3440 9840 3460 9840 {}
C {lab_pin.sym} 3460 9840 0 0 {name=l7929 lab=VDD}
N 3440 9760 3460 9760 {}
C {lab_pin.sym} 3460 9760 0 0 {name=l7930 lab=VSS}
C {bitcell_6t.sym} 3600 9800 0 0 {name=Xr49c18}
N 3560 9840 3540 9840 {}
C {lab_pin.sym} 3540 9840 0 0 {name=l7931 lab=BL18}
N 3560 9800 3540 9800 {}
C {lab_pin.sym} 3540 9800 0 0 {name=l7932 lab=BLB18}
N 3560 9760 3540 9760 {}
C {lab_pin.sym} 3540 9760 0 0 {name=l7933 lab=WL49}
N 3640 9840 3660 9840 {}
C {lab_pin.sym} 3660 9840 0 0 {name=l7934 lab=VDD}
N 3640 9760 3660 9760 {}
C {lab_pin.sym} 3660 9760 0 0 {name=l7935 lab=VSS}
C {bitcell_6t.sym} 3800 9800 0 0 {name=Xr49c19}
N 3760 9840 3740 9840 {}
C {lab_pin.sym} 3740 9840 0 0 {name=l7936 lab=BL19}
N 3760 9800 3740 9800 {}
C {lab_pin.sym} 3740 9800 0 0 {name=l7937 lab=BLB19}
N 3760 9760 3740 9760 {}
C {lab_pin.sym} 3740 9760 0 0 {name=l7938 lab=WL49}
N 3840 9840 3860 9840 {}
C {lab_pin.sym} 3860 9840 0 0 {name=l7939 lab=VDD}
N 3840 9760 3860 9760 {}
C {lab_pin.sym} 3860 9760 0 0 {name=l7940 lab=VSS}
C {bitcell_6t.sym} 4000 9800 0 0 {name=Xr49c20}
N 3960 9840 3940 9840 {}
C {lab_pin.sym} 3940 9840 0 0 {name=l7941 lab=BL20}
N 3960 9800 3940 9800 {}
C {lab_pin.sym} 3940 9800 0 0 {name=l7942 lab=BLB20}
N 3960 9760 3940 9760 {}
C {lab_pin.sym} 3940 9760 0 0 {name=l7943 lab=WL49}
N 4040 9840 4060 9840 {}
C {lab_pin.sym} 4060 9840 0 0 {name=l7944 lab=VDD}
N 4040 9760 4060 9760 {}
C {lab_pin.sym} 4060 9760 0 0 {name=l7945 lab=VSS}
C {bitcell_6t.sym} 4200 9800 0 0 {name=Xr49c21}
N 4160 9840 4140 9840 {}
C {lab_pin.sym} 4140 9840 0 0 {name=l7946 lab=BL21}
N 4160 9800 4140 9800 {}
C {lab_pin.sym} 4140 9800 0 0 {name=l7947 lab=BLB21}
N 4160 9760 4140 9760 {}
C {lab_pin.sym} 4140 9760 0 0 {name=l7948 lab=WL49}
N 4240 9840 4260 9840 {}
C {lab_pin.sym} 4260 9840 0 0 {name=l7949 lab=VDD}
N 4240 9760 4260 9760 {}
C {lab_pin.sym} 4260 9760 0 0 {name=l7950 lab=VSS}
C {bitcell_6t.sym} 4400 9800 0 0 {name=Xr49c22}
N 4360 9840 4340 9840 {}
C {lab_pin.sym} 4340 9840 0 0 {name=l7951 lab=BL22}
N 4360 9800 4340 9800 {}
C {lab_pin.sym} 4340 9800 0 0 {name=l7952 lab=BLB22}
N 4360 9760 4340 9760 {}
C {lab_pin.sym} 4340 9760 0 0 {name=l7953 lab=WL49}
N 4440 9840 4460 9840 {}
C {lab_pin.sym} 4460 9840 0 0 {name=l7954 lab=VDD}
N 4440 9760 4460 9760 {}
C {lab_pin.sym} 4460 9760 0 0 {name=l7955 lab=VSS}
C {bitcell_6t.sym} 4600 9800 0 0 {name=Xr49c23}
N 4560 9840 4540 9840 {}
C {lab_pin.sym} 4540 9840 0 0 {name=l7956 lab=BL23}
N 4560 9800 4540 9800 {}
C {lab_pin.sym} 4540 9800 0 0 {name=l7957 lab=BLB23}
N 4560 9760 4540 9760 {}
C {lab_pin.sym} 4540 9760 0 0 {name=l7958 lab=WL49}
N 4640 9840 4660 9840 {}
C {lab_pin.sym} 4660 9840 0 0 {name=l7959 lab=VDD}
N 4640 9760 4660 9760 {}
C {lab_pin.sym} 4660 9760 0 0 {name=l7960 lab=VSS}
C {bitcell_6t.sym} 4800 9800 0 0 {name=Xr49c24}
N 4760 9840 4740 9840 {}
C {lab_pin.sym} 4740 9840 0 0 {name=l7961 lab=BL24}
N 4760 9800 4740 9800 {}
C {lab_pin.sym} 4740 9800 0 0 {name=l7962 lab=BLB24}
N 4760 9760 4740 9760 {}
C {lab_pin.sym} 4740 9760 0 0 {name=l7963 lab=WL49}
N 4840 9840 4860 9840 {}
C {lab_pin.sym} 4860 9840 0 0 {name=l7964 lab=VDD}
N 4840 9760 4860 9760 {}
C {lab_pin.sym} 4860 9760 0 0 {name=l7965 lab=VSS}
C {bitcell_6t.sym} 5000 9800 0 0 {name=Xr49c25}
N 4960 9840 4940 9840 {}
C {lab_pin.sym} 4940 9840 0 0 {name=l7966 lab=BL25}
N 4960 9800 4940 9800 {}
C {lab_pin.sym} 4940 9800 0 0 {name=l7967 lab=BLB25}
N 4960 9760 4940 9760 {}
C {lab_pin.sym} 4940 9760 0 0 {name=l7968 lab=WL49}
N 5040 9840 5060 9840 {}
C {lab_pin.sym} 5060 9840 0 0 {name=l7969 lab=VDD}
N 5040 9760 5060 9760 {}
C {lab_pin.sym} 5060 9760 0 0 {name=l7970 lab=VSS}
C {bitcell_6t.sym} 5200 9800 0 0 {name=Xr49c26}
N 5160 9840 5140 9840 {}
C {lab_pin.sym} 5140 9840 0 0 {name=l7971 lab=BL26}
N 5160 9800 5140 9800 {}
C {lab_pin.sym} 5140 9800 0 0 {name=l7972 lab=BLB26}
N 5160 9760 5140 9760 {}
C {lab_pin.sym} 5140 9760 0 0 {name=l7973 lab=WL49}
N 5240 9840 5260 9840 {}
C {lab_pin.sym} 5260 9840 0 0 {name=l7974 lab=VDD}
N 5240 9760 5260 9760 {}
C {lab_pin.sym} 5260 9760 0 0 {name=l7975 lab=VSS}
C {bitcell_6t.sym} 5400 9800 0 0 {name=Xr49c27}
N 5360 9840 5340 9840 {}
C {lab_pin.sym} 5340 9840 0 0 {name=l7976 lab=BL27}
N 5360 9800 5340 9800 {}
C {lab_pin.sym} 5340 9800 0 0 {name=l7977 lab=BLB27}
N 5360 9760 5340 9760 {}
C {lab_pin.sym} 5340 9760 0 0 {name=l7978 lab=WL49}
N 5440 9840 5460 9840 {}
C {lab_pin.sym} 5460 9840 0 0 {name=l7979 lab=VDD}
N 5440 9760 5460 9760 {}
C {lab_pin.sym} 5460 9760 0 0 {name=l7980 lab=VSS}
C {bitcell_6t.sym} 5600 9800 0 0 {name=Xr49c28}
N 5560 9840 5540 9840 {}
C {lab_pin.sym} 5540 9840 0 0 {name=l7981 lab=BL28}
N 5560 9800 5540 9800 {}
C {lab_pin.sym} 5540 9800 0 0 {name=l7982 lab=BLB28}
N 5560 9760 5540 9760 {}
C {lab_pin.sym} 5540 9760 0 0 {name=l7983 lab=WL49}
N 5640 9840 5660 9840 {}
C {lab_pin.sym} 5660 9840 0 0 {name=l7984 lab=VDD}
N 5640 9760 5660 9760 {}
C {lab_pin.sym} 5660 9760 0 0 {name=l7985 lab=VSS}
C {bitcell_6t.sym} 5800 9800 0 0 {name=Xr49c29}
N 5760 9840 5740 9840 {}
C {lab_pin.sym} 5740 9840 0 0 {name=l7986 lab=BL29}
N 5760 9800 5740 9800 {}
C {lab_pin.sym} 5740 9800 0 0 {name=l7987 lab=BLB29}
N 5760 9760 5740 9760 {}
C {lab_pin.sym} 5740 9760 0 0 {name=l7988 lab=WL49}
N 5840 9840 5860 9840 {}
C {lab_pin.sym} 5860 9840 0 0 {name=l7989 lab=VDD}
N 5840 9760 5860 9760 {}
C {lab_pin.sym} 5860 9760 0 0 {name=l7990 lab=VSS}
C {bitcell_6t.sym} 6000 9800 0 0 {name=Xr49c30}
N 5960 9840 5940 9840 {}
C {lab_pin.sym} 5940 9840 0 0 {name=l7991 lab=BL30}
N 5960 9800 5940 9800 {}
C {lab_pin.sym} 5940 9800 0 0 {name=l7992 lab=BLB30}
N 5960 9760 5940 9760 {}
C {lab_pin.sym} 5940 9760 0 0 {name=l7993 lab=WL49}
N 6040 9840 6060 9840 {}
C {lab_pin.sym} 6060 9840 0 0 {name=l7994 lab=VDD}
N 6040 9760 6060 9760 {}
C {lab_pin.sym} 6060 9760 0 0 {name=l7995 lab=VSS}
C {bitcell_6t.sym} 6200 9800 0 0 {name=Xr49c31}
N 6160 9840 6140 9840 {}
C {lab_pin.sym} 6140 9840 0 0 {name=l7996 lab=BL31}
N 6160 9800 6140 9800 {}
C {lab_pin.sym} 6140 9800 0 0 {name=l7997 lab=BLB31}
N 6160 9760 6140 9760 {}
C {lab_pin.sym} 6140 9760 0 0 {name=l7998 lab=WL49}
N 6240 9840 6260 9840 {}
C {lab_pin.sym} 6260 9840 0 0 {name=l7999 lab=VDD}
N 6240 9760 6260 9760 {}
C {lab_pin.sym} 6260 9760 0 0 {name=l8000 lab=VSS}
C {bitcell_6t.sym} 0 10000 0 0 {name=Xr50c0}
N -40 10040 -60 10040 {}
C {lab_pin.sym} -60 10040 0 0 {name=l8001 lab=BL0}
N -40 10000 -60 10000 {}
C {lab_pin.sym} -60 10000 0 0 {name=l8002 lab=BLB0}
N -40 9960 -60 9960 {}
C {lab_pin.sym} -60 9960 0 0 {name=l8003 lab=WL50}
N 40 10040 60 10040 {}
C {lab_pin.sym} 60 10040 0 0 {name=l8004 lab=VDD}
N 40 9960 60 9960 {}
C {lab_pin.sym} 60 9960 0 0 {name=l8005 lab=VSS}
C {bitcell_6t.sym} 200 10000 0 0 {name=Xr50c1}
N 160 10040 140 10040 {}
C {lab_pin.sym} 140 10040 0 0 {name=l8006 lab=BL1}
N 160 10000 140 10000 {}
C {lab_pin.sym} 140 10000 0 0 {name=l8007 lab=BLB1}
N 160 9960 140 9960 {}
C {lab_pin.sym} 140 9960 0 0 {name=l8008 lab=WL50}
N 240 10040 260 10040 {}
C {lab_pin.sym} 260 10040 0 0 {name=l8009 lab=VDD}
N 240 9960 260 9960 {}
C {lab_pin.sym} 260 9960 0 0 {name=l8010 lab=VSS}
C {bitcell_6t.sym} 400 10000 0 0 {name=Xr50c2}
N 360 10040 340 10040 {}
C {lab_pin.sym} 340 10040 0 0 {name=l8011 lab=BL2}
N 360 10000 340 10000 {}
C {lab_pin.sym} 340 10000 0 0 {name=l8012 lab=BLB2}
N 360 9960 340 9960 {}
C {lab_pin.sym} 340 9960 0 0 {name=l8013 lab=WL50}
N 440 10040 460 10040 {}
C {lab_pin.sym} 460 10040 0 0 {name=l8014 lab=VDD}
N 440 9960 460 9960 {}
C {lab_pin.sym} 460 9960 0 0 {name=l8015 lab=VSS}
C {bitcell_6t.sym} 600 10000 0 0 {name=Xr50c3}
N 560 10040 540 10040 {}
C {lab_pin.sym} 540 10040 0 0 {name=l8016 lab=BL3}
N 560 10000 540 10000 {}
C {lab_pin.sym} 540 10000 0 0 {name=l8017 lab=BLB3}
N 560 9960 540 9960 {}
C {lab_pin.sym} 540 9960 0 0 {name=l8018 lab=WL50}
N 640 10040 660 10040 {}
C {lab_pin.sym} 660 10040 0 0 {name=l8019 lab=VDD}
N 640 9960 660 9960 {}
C {lab_pin.sym} 660 9960 0 0 {name=l8020 lab=VSS}
C {bitcell_6t.sym} 800 10000 0 0 {name=Xr50c4}
N 760 10040 740 10040 {}
C {lab_pin.sym} 740 10040 0 0 {name=l8021 lab=BL4}
N 760 10000 740 10000 {}
C {lab_pin.sym} 740 10000 0 0 {name=l8022 lab=BLB4}
N 760 9960 740 9960 {}
C {lab_pin.sym} 740 9960 0 0 {name=l8023 lab=WL50}
N 840 10040 860 10040 {}
C {lab_pin.sym} 860 10040 0 0 {name=l8024 lab=VDD}
N 840 9960 860 9960 {}
C {lab_pin.sym} 860 9960 0 0 {name=l8025 lab=VSS}
C {bitcell_6t.sym} 1000 10000 0 0 {name=Xr50c5}
N 960 10040 940 10040 {}
C {lab_pin.sym} 940 10040 0 0 {name=l8026 lab=BL5}
N 960 10000 940 10000 {}
C {lab_pin.sym} 940 10000 0 0 {name=l8027 lab=BLB5}
N 960 9960 940 9960 {}
C {lab_pin.sym} 940 9960 0 0 {name=l8028 lab=WL50}
N 1040 10040 1060 10040 {}
C {lab_pin.sym} 1060 10040 0 0 {name=l8029 lab=VDD}
N 1040 9960 1060 9960 {}
C {lab_pin.sym} 1060 9960 0 0 {name=l8030 lab=VSS}
C {bitcell_6t.sym} 1200 10000 0 0 {name=Xr50c6}
N 1160 10040 1140 10040 {}
C {lab_pin.sym} 1140 10040 0 0 {name=l8031 lab=BL6}
N 1160 10000 1140 10000 {}
C {lab_pin.sym} 1140 10000 0 0 {name=l8032 lab=BLB6}
N 1160 9960 1140 9960 {}
C {lab_pin.sym} 1140 9960 0 0 {name=l8033 lab=WL50}
N 1240 10040 1260 10040 {}
C {lab_pin.sym} 1260 10040 0 0 {name=l8034 lab=VDD}
N 1240 9960 1260 9960 {}
C {lab_pin.sym} 1260 9960 0 0 {name=l8035 lab=VSS}
C {bitcell_6t.sym} 1400 10000 0 0 {name=Xr50c7}
N 1360 10040 1340 10040 {}
C {lab_pin.sym} 1340 10040 0 0 {name=l8036 lab=BL7}
N 1360 10000 1340 10000 {}
C {lab_pin.sym} 1340 10000 0 0 {name=l8037 lab=BLB7}
N 1360 9960 1340 9960 {}
C {lab_pin.sym} 1340 9960 0 0 {name=l8038 lab=WL50}
N 1440 10040 1460 10040 {}
C {lab_pin.sym} 1460 10040 0 0 {name=l8039 lab=VDD}
N 1440 9960 1460 9960 {}
C {lab_pin.sym} 1460 9960 0 0 {name=l8040 lab=VSS}
C {bitcell_6t.sym} 1600 10000 0 0 {name=Xr50c8}
N 1560 10040 1540 10040 {}
C {lab_pin.sym} 1540 10040 0 0 {name=l8041 lab=BL8}
N 1560 10000 1540 10000 {}
C {lab_pin.sym} 1540 10000 0 0 {name=l8042 lab=BLB8}
N 1560 9960 1540 9960 {}
C {lab_pin.sym} 1540 9960 0 0 {name=l8043 lab=WL50}
N 1640 10040 1660 10040 {}
C {lab_pin.sym} 1660 10040 0 0 {name=l8044 lab=VDD}
N 1640 9960 1660 9960 {}
C {lab_pin.sym} 1660 9960 0 0 {name=l8045 lab=VSS}
C {bitcell_6t.sym} 1800 10000 0 0 {name=Xr50c9}
N 1760 10040 1740 10040 {}
C {lab_pin.sym} 1740 10040 0 0 {name=l8046 lab=BL9}
N 1760 10000 1740 10000 {}
C {lab_pin.sym} 1740 10000 0 0 {name=l8047 lab=BLB9}
N 1760 9960 1740 9960 {}
C {lab_pin.sym} 1740 9960 0 0 {name=l8048 lab=WL50}
N 1840 10040 1860 10040 {}
C {lab_pin.sym} 1860 10040 0 0 {name=l8049 lab=VDD}
N 1840 9960 1860 9960 {}
C {lab_pin.sym} 1860 9960 0 0 {name=l8050 lab=VSS}
C {bitcell_6t.sym} 2000 10000 0 0 {name=Xr50c10}
N 1960 10040 1940 10040 {}
C {lab_pin.sym} 1940 10040 0 0 {name=l8051 lab=BL10}
N 1960 10000 1940 10000 {}
C {lab_pin.sym} 1940 10000 0 0 {name=l8052 lab=BLB10}
N 1960 9960 1940 9960 {}
C {lab_pin.sym} 1940 9960 0 0 {name=l8053 lab=WL50}
N 2040 10040 2060 10040 {}
C {lab_pin.sym} 2060 10040 0 0 {name=l8054 lab=VDD}
N 2040 9960 2060 9960 {}
C {lab_pin.sym} 2060 9960 0 0 {name=l8055 lab=VSS}
C {bitcell_6t.sym} 2200 10000 0 0 {name=Xr50c11}
N 2160 10040 2140 10040 {}
C {lab_pin.sym} 2140 10040 0 0 {name=l8056 lab=BL11}
N 2160 10000 2140 10000 {}
C {lab_pin.sym} 2140 10000 0 0 {name=l8057 lab=BLB11}
N 2160 9960 2140 9960 {}
C {lab_pin.sym} 2140 9960 0 0 {name=l8058 lab=WL50}
N 2240 10040 2260 10040 {}
C {lab_pin.sym} 2260 10040 0 0 {name=l8059 lab=VDD}
N 2240 9960 2260 9960 {}
C {lab_pin.sym} 2260 9960 0 0 {name=l8060 lab=VSS}
C {bitcell_6t.sym} 2400 10000 0 0 {name=Xr50c12}
N 2360 10040 2340 10040 {}
C {lab_pin.sym} 2340 10040 0 0 {name=l8061 lab=BL12}
N 2360 10000 2340 10000 {}
C {lab_pin.sym} 2340 10000 0 0 {name=l8062 lab=BLB12}
N 2360 9960 2340 9960 {}
C {lab_pin.sym} 2340 9960 0 0 {name=l8063 lab=WL50}
N 2440 10040 2460 10040 {}
C {lab_pin.sym} 2460 10040 0 0 {name=l8064 lab=VDD}
N 2440 9960 2460 9960 {}
C {lab_pin.sym} 2460 9960 0 0 {name=l8065 lab=VSS}
C {bitcell_6t.sym} 2600 10000 0 0 {name=Xr50c13}
N 2560 10040 2540 10040 {}
C {lab_pin.sym} 2540 10040 0 0 {name=l8066 lab=BL13}
N 2560 10000 2540 10000 {}
C {lab_pin.sym} 2540 10000 0 0 {name=l8067 lab=BLB13}
N 2560 9960 2540 9960 {}
C {lab_pin.sym} 2540 9960 0 0 {name=l8068 lab=WL50}
N 2640 10040 2660 10040 {}
C {lab_pin.sym} 2660 10040 0 0 {name=l8069 lab=VDD}
N 2640 9960 2660 9960 {}
C {lab_pin.sym} 2660 9960 0 0 {name=l8070 lab=VSS}
C {bitcell_6t.sym} 2800 10000 0 0 {name=Xr50c14}
N 2760 10040 2740 10040 {}
C {lab_pin.sym} 2740 10040 0 0 {name=l8071 lab=BL14}
N 2760 10000 2740 10000 {}
C {lab_pin.sym} 2740 10000 0 0 {name=l8072 lab=BLB14}
N 2760 9960 2740 9960 {}
C {lab_pin.sym} 2740 9960 0 0 {name=l8073 lab=WL50}
N 2840 10040 2860 10040 {}
C {lab_pin.sym} 2860 10040 0 0 {name=l8074 lab=VDD}
N 2840 9960 2860 9960 {}
C {lab_pin.sym} 2860 9960 0 0 {name=l8075 lab=VSS}
C {bitcell_6t.sym} 3000 10000 0 0 {name=Xr50c15}
N 2960 10040 2940 10040 {}
C {lab_pin.sym} 2940 10040 0 0 {name=l8076 lab=BL15}
N 2960 10000 2940 10000 {}
C {lab_pin.sym} 2940 10000 0 0 {name=l8077 lab=BLB15}
N 2960 9960 2940 9960 {}
C {lab_pin.sym} 2940 9960 0 0 {name=l8078 lab=WL50}
N 3040 10040 3060 10040 {}
C {lab_pin.sym} 3060 10040 0 0 {name=l8079 lab=VDD}
N 3040 9960 3060 9960 {}
C {lab_pin.sym} 3060 9960 0 0 {name=l8080 lab=VSS}
C {bitcell_6t.sym} 3200 10000 0 0 {name=Xr50c16}
N 3160 10040 3140 10040 {}
C {lab_pin.sym} 3140 10040 0 0 {name=l8081 lab=BL16}
N 3160 10000 3140 10000 {}
C {lab_pin.sym} 3140 10000 0 0 {name=l8082 lab=BLB16}
N 3160 9960 3140 9960 {}
C {lab_pin.sym} 3140 9960 0 0 {name=l8083 lab=WL50}
N 3240 10040 3260 10040 {}
C {lab_pin.sym} 3260 10040 0 0 {name=l8084 lab=VDD}
N 3240 9960 3260 9960 {}
C {lab_pin.sym} 3260 9960 0 0 {name=l8085 lab=VSS}
C {bitcell_6t.sym} 3400 10000 0 0 {name=Xr50c17}
N 3360 10040 3340 10040 {}
C {lab_pin.sym} 3340 10040 0 0 {name=l8086 lab=BL17}
N 3360 10000 3340 10000 {}
C {lab_pin.sym} 3340 10000 0 0 {name=l8087 lab=BLB17}
N 3360 9960 3340 9960 {}
C {lab_pin.sym} 3340 9960 0 0 {name=l8088 lab=WL50}
N 3440 10040 3460 10040 {}
C {lab_pin.sym} 3460 10040 0 0 {name=l8089 lab=VDD}
N 3440 9960 3460 9960 {}
C {lab_pin.sym} 3460 9960 0 0 {name=l8090 lab=VSS}
C {bitcell_6t.sym} 3600 10000 0 0 {name=Xr50c18}
N 3560 10040 3540 10040 {}
C {lab_pin.sym} 3540 10040 0 0 {name=l8091 lab=BL18}
N 3560 10000 3540 10000 {}
C {lab_pin.sym} 3540 10000 0 0 {name=l8092 lab=BLB18}
N 3560 9960 3540 9960 {}
C {lab_pin.sym} 3540 9960 0 0 {name=l8093 lab=WL50}
N 3640 10040 3660 10040 {}
C {lab_pin.sym} 3660 10040 0 0 {name=l8094 lab=VDD}
N 3640 9960 3660 9960 {}
C {lab_pin.sym} 3660 9960 0 0 {name=l8095 lab=VSS}
C {bitcell_6t.sym} 3800 10000 0 0 {name=Xr50c19}
N 3760 10040 3740 10040 {}
C {lab_pin.sym} 3740 10040 0 0 {name=l8096 lab=BL19}
N 3760 10000 3740 10000 {}
C {lab_pin.sym} 3740 10000 0 0 {name=l8097 lab=BLB19}
N 3760 9960 3740 9960 {}
C {lab_pin.sym} 3740 9960 0 0 {name=l8098 lab=WL50}
N 3840 10040 3860 10040 {}
C {lab_pin.sym} 3860 10040 0 0 {name=l8099 lab=VDD}
N 3840 9960 3860 9960 {}
C {lab_pin.sym} 3860 9960 0 0 {name=l8100 lab=VSS}
C {bitcell_6t.sym} 4000 10000 0 0 {name=Xr50c20}
N 3960 10040 3940 10040 {}
C {lab_pin.sym} 3940 10040 0 0 {name=l8101 lab=BL20}
N 3960 10000 3940 10000 {}
C {lab_pin.sym} 3940 10000 0 0 {name=l8102 lab=BLB20}
N 3960 9960 3940 9960 {}
C {lab_pin.sym} 3940 9960 0 0 {name=l8103 lab=WL50}
N 4040 10040 4060 10040 {}
C {lab_pin.sym} 4060 10040 0 0 {name=l8104 lab=VDD}
N 4040 9960 4060 9960 {}
C {lab_pin.sym} 4060 9960 0 0 {name=l8105 lab=VSS}
C {bitcell_6t.sym} 4200 10000 0 0 {name=Xr50c21}
N 4160 10040 4140 10040 {}
C {lab_pin.sym} 4140 10040 0 0 {name=l8106 lab=BL21}
N 4160 10000 4140 10000 {}
C {lab_pin.sym} 4140 10000 0 0 {name=l8107 lab=BLB21}
N 4160 9960 4140 9960 {}
C {lab_pin.sym} 4140 9960 0 0 {name=l8108 lab=WL50}
N 4240 10040 4260 10040 {}
C {lab_pin.sym} 4260 10040 0 0 {name=l8109 lab=VDD}
N 4240 9960 4260 9960 {}
C {lab_pin.sym} 4260 9960 0 0 {name=l8110 lab=VSS}
C {bitcell_6t.sym} 4400 10000 0 0 {name=Xr50c22}
N 4360 10040 4340 10040 {}
C {lab_pin.sym} 4340 10040 0 0 {name=l8111 lab=BL22}
N 4360 10000 4340 10000 {}
C {lab_pin.sym} 4340 10000 0 0 {name=l8112 lab=BLB22}
N 4360 9960 4340 9960 {}
C {lab_pin.sym} 4340 9960 0 0 {name=l8113 lab=WL50}
N 4440 10040 4460 10040 {}
C {lab_pin.sym} 4460 10040 0 0 {name=l8114 lab=VDD}
N 4440 9960 4460 9960 {}
C {lab_pin.sym} 4460 9960 0 0 {name=l8115 lab=VSS}
C {bitcell_6t.sym} 4600 10000 0 0 {name=Xr50c23}
N 4560 10040 4540 10040 {}
C {lab_pin.sym} 4540 10040 0 0 {name=l8116 lab=BL23}
N 4560 10000 4540 10000 {}
C {lab_pin.sym} 4540 10000 0 0 {name=l8117 lab=BLB23}
N 4560 9960 4540 9960 {}
C {lab_pin.sym} 4540 9960 0 0 {name=l8118 lab=WL50}
N 4640 10040 4660 10040 {}
C {lab_pin.sym} 4660 10040 0 0 {name=l8119 lab=VDD}
N 4640 9960 4660 9960 {}
C {lab_pin.sym} 4660 9960 0 0 {name=l8120 lab=VSS}
C {bitcell_6t.sym} 4800 10000 0 0 {name=Xr50c24}
N 4760 10040 4740 10040 {}
C {lab_pin.sym} 4740 10040 0 0 {name=l8121 lab=BL24}
N 4760 10000 4740 10000 {}
C {lab_pin.sym} 4740 10000 0 0 {name=l8122 lab=BLB24}
N 4760 9960 4740 9960 {}
C {lab_pin.sym} 4740 9960 0 0 {name=l8123 lab=WL50}
N 4840 10040 4860 10040 {}
C {lab_pin.sym} 4860 10040 0 0 {name=l8124 lab=VDD}
N 4840 9960 4860 9960 {}
C {lab_pin.sym} 4860 9960 0 0 {name=l8125 lab=VSS}
C {bitcell_6t.sym} 5000 10000 0 0 {name=Xr50c25}
N 4960 10040 4940 10040 {}
C {lab_pin.sym} 4940 10040 0 0 {name=l8126 lab=BL25}
N 4960 10000 4940 10000 {}
C {lab_pin.sym} 4940 10000 0 0 {name=l8127 lab=BLB25}
N 4960 9960 4940 9960 {}
C {lab_pin.sym} 4940 9960 0 0 {name=l8128 lab=WL50}
N 5040 10040 5060 10040 {}
C {lab_pin.sym} 5060 10040 0 0 {name=l8129 lab=VDD}
N 5040 9960 5060 9960 {}
C {lab_pin.sym} 5060 9960 0 0 {name=l8130 lab=VSS}
C {bitcell_6t.sym} 5200 10000 0 0 {name=Xr50c26}
N 5160 10040 5140 10040 {}
C {lab_pin.sym} 5140 10040 0 0 {name=l8131 lab=BL26}
N 5160 10000 5140 10000 {}
C {lab_pin.sym} 5140 10000 0 0 {name=l8132 lab=BLB26}
N 5160 9960 5140 9960 {}
C {lab_pin.sym} 5140 9960 0 0 {name=l8133 lab=WL50}
N 5240 10040 5260 10040 {}
C {lab_pin.sym} 5260 10040 0 0 {name=l8134 lab=VDD}
N 5240 9960 5260 9960 {}
C {lab_pin.sym} 5260 9960 0 0 {name=l8135 lab=VSS}
C {bitcell_6t.sym} 5400 10000 0 0 {name=Xr50c27}
N 5360 10040 5340 10040 {}
C {lab_pin.sym} 5340 10040 0 0 {name=l8136 lab=BL27}
N 5360 10000 5340 10000 {}
C {lab_pin.sym} 5340 10000 0 0 {name=l8137 lab=BLB27}
N 5360 9960 5340 9960 {}
C {lab_pin.sym} 5340 9960 0 0 {name=l8138 lab=WL50}
N 5440 10040 5460 10040 {}
C {lab_pin.sym} 5460 10040 0 0 {name=l8139 lab=VDD}
N 5440 9960 5460 9960 {}
C {lab_pin.sym} 5460 9960 0 0 {name=l8140 lab=VSS}
C {bitcell_6t.sym} 5600 10000 0 0 {name=Xr50c28}
N 5560 10040 5540 10040 {}
C {lab_pin.sym} 5540 10040 0 0 {name=l8141 lab=BL28}
N 5560 10000 5540 10000 {}
C {lab_pin.sym} 5540 10000 0 0 {name=l8142 lab=BLB28}
N 5560 9960 5540 9960 {}
C {lab_pin.sym} 5540 9960 0 0 {name=l8143 lab=WL50}
N 5640 10040 5660 10040 {}
C {lab_pin.sym} 5660 10040 0 0 {name=l8144 lab=VDD}
N 5640 9960 5660 9960 {}
C {lab_pin.sym} 5660 9960 0 0 {name=l8145 lab=VSS}
C {bitcell_6t.sym} 5800 10000 0 0 {name=Xr50c29}
N 5760 10040 5740 10040 {}
C {lab_pin.sym} 5740 10040 0 0 {name=l8146 lab=BL29}
N 5760 10000 5740 10000 {}
C {lab_pin.sym} 5740 10000 0 0 {name=l8147 lab=BLB29}
N 5760 9960 5740 9960 {}
C {lab_pin.sym} 5740 9960 0 0 {name=l8148 lab=WL50}
N 5840 10040 5860 10040 {}
C {lab_pin.sym} 5860 10040 0 0 {name=l8149 lab=VDD}
N 5840 9960 5860 9960 {}
C {lab_pin.sym} 5860 9960 0 0 {name=l8150 lab=VSS}
C {bitcell_6t.sym} 6000 10000 0 0 {name=Xr50c30}
N 5960 10040 5940 10040 {}
C {lab_pin.sym} 5940 10040 0 0 {name=l8151 lab=BL30}
N 5960 10000 5940 10000 {}
C {lab_pin.sym} 5940 10000 0 0 {name=l8152 lab=BLB30}
N 5960 9960 5940 9960 {}
C {lab_pin.sym} 5940 9960 0 0 {name=l8153 lab=WL50}
N 6040 10040 6060 10040 {}
C {lab_pin.sym} 6060 10040 0 0 {name=l8154 lab=VDD}
N 6040 9960 6060 9960 {}
C {lab_pin.sym} 6060 9960 0 0 {name=l8155 lab=VSS}
C {bitcell_6t.sym} 6200 10000 0 0 {name=Xr50c31}
N 6160 10040 6140 10040 {}
C {lab_pin.sym} 6140 10040 0 0 {name=l8156 lab=BL31}
N 6160 10000 6140 10000 {}
C {lab_pin.sym} 6140 10000 0 0 {name=l8157 lab=BLB31}
N 6160 9960 6140 9960 {}
C {lab_pin.sym} 6140 9960 0 0 {name=l8158 lab=WL50}
N 6240 10040 6260 10040 {}
C {lab_pin.sym} 6260 10040 0 0 {name=l8159 lab=VDD}
N 6240 9960 6260 9960 {}
C {lab_pin.sym} 6260 9960 0 0 {name=l8160 lab=VSS}
C {bitcell_6t.sym} 0 10200 0 0 {name=Xr51c0}
N -40 10240 -60 10240 {}
C {lab_pin.sym} -60 10240 0 0 {name=l8161 lab=BL0}
N -40 10200 -60 10200 {}
C {lab_pin.sym} -60 10200 0 0 {name=l8162 lab=BLB0}
N -40 10160 -60 10160 {}
C {lab_pin.sym} -60 10160 0 0 {name=l8163 lab=WL51}
N 40 10240 60 10240 {}
C {lab_pin.sym} 60 10240 0 0 {name=l8164 lab=VDD}
N 40 10160 60 10160 {}
C {lab_pin.sym} 60 10160 0 0 {name=l8165 lab=VSS}
C {bitcell_6t.sym} 200 10200 0 0 {name=Xr51c1}
N 160 10240 140 10240 {}
C {lab_pin.sym} 140 10240 0 0 {name=l8166 lab=BL1}
N 160 10200 140 10200 {}
C {lab_pin.sym} 140 10200 0 0 {name=l8167 lab=BLB1}
N 160 10160 140 10160 {}
C {lab_pin.sym} 140 10160 0 0 {name=l8168 lab=WL51}
N 240 10240 260 10240 {}
C {lab_pin.sym} 260 10240 0 0 {name=l8169 lab=VDD}
N 240 10160 260 10160 {}
C {lab_pin.sym} 260 10160 0 0 {name=l8170 lab=VSS}
C {bitcell_6t.sym} 400 10200 0 0 {name=Xr51c2}
N 360 10240 340 10240 {}
C {lab_pin.sym} 340 10240 0 0 {name=l8171 lab=BL2}
N 360 10200 340 10200 {}
C {lab_pin.sym} 340 10200 0 0 {name=l8172 lab=BLB2}
N 360 10160 340 10160 {}
C {lab_pin.sym} 340 10160 0 0 {name=l8173 lab=WL51}
N 440 10240 460 10240 {}
C {lab_pin.sym} 460 10240 0 0 {name=l8174 lab=VDD}
N 440 10160 460 10160 {}
C {lab_pin.sym} 460 10160 0 0 {name=l8175 lab=VSS}
C {bitcell_6t.sym} 600 10200 0 0 {name=Xr51c3}
N 560 10240 540 10240 {}
C {lab_pin.sym} 540 10240 0 0 {name=l8176 lab=BL3}
N 560 10200 540 10200 {}
C {lab_pin.sym} 540 10200 0 0 {name=l8177 lab=BLB3}
N 560 10160 540 10160 {}
C {lab_pin.sym} 540 10160 0 0 {name=l8178 lab=WL51}
N 640 10240 660 10240 {}
C {lab_pin.sym} 660 10240 0 0 {name=l8179 lab=VDD}
N 640 10160 660 10160 {}
C {lab_pin.sym} 660 10160 0 0 {name=l8180 lab=VSS}
C {bitcell_6t.sym} 800 10200 0 0 {name=Xr51c4}
N 760 10240 740 10240 {}
C {lab_pin.sym} 740 10240 0 0 {name=l8181 lab=BL4}
N 760 10200 740 10200 {}
C {lab_pin.sym} 740 10200 0 0 {name=l8182 lab=BLB4}
N 760 10160 740 10160 {}
C {lab_pin.sym} 740 10160 0 0 {name=l8183 lab=WL51}
N 840 10240 860 10240 {}
C {lab_pin.sym} 860 10240 0 0 {name=l8184 lab=VDD}
N 840 10160 860 10160 {}
C {lab_pin.sym} 860 10160 0 0 {name=l8185 lab=VSS}
C {bitcell_6t.sym} 1000 10200 0 0 {name=Xr51c5}
N 960 10240 940 10240 {}
C {lab_pin.sym} 940 10240 0 0 {name=l8186 lab=BL5}
N 960 10200 940 10200 {}
C {lab_pin.sym} 940 10200 0 0 {name=l8187 lab=BLB5}
N 960 10160 940 10160 {}
C {lab_pin.sym} 940 10160 0 0 {name=l8188 lab=WL51}
N 1040 10240 1060 10240 {}
C {lab_pin.sym} 1060 10240 0 0 {name=l8189 lab=VDD}
N 1040 10160 1060 10160 {}
C {lab_pin.sym} 1060 10160 0 0 {name=l8190 lab=VSS}
C {bitcell_6t.sym} 1200 10200 0 0 {name=Xr51c6}
N 1160 10240 1140 10240 {}
C {lab_pin.sym} 1140 10240 0 0 {name=l8191 lab=BL6}
N 1160 10200 1140 10200 {}
C {lab_pin.sym} 1140 10200 0 0 {name=l8192 lab=BLB6}
N 1160 10160 1140 10160 {}
C {lab_pin.sym} 1140 10160 0 0 {name=l8193 lab=WL51}
N 1240 10240 1260 10240 {}
C {lab_pin.sym} 1260 10240 0 0 {name=l8194 lab=VDD}
N 1240 10160 1260 10160 {}
C {lab_pin.sym} 1260 10160 0 0 {name=l8195 lab=VSS}
C {bitcell_6t.sym} 1400 10200 0 0 {name=Xr51c7}
N 1360 10240 1340 10240 {}
C {lab_pin.sym} 1340 10240 0 0 {name=l8196 lab=BL7}
N 1360 10200 1340 10200 {}
C {lab_pin.sym} 1340 10200 0 0 {name=l8197 lab=BLB7}
N 1360 10160 1340 10160 {}
C {lab_pin.sym} 1340 10160 0 0 {name=l8198 lab=WL51}
N 1440 10240 1460 10240 {}
C {lab_pin.sym} 1460 10240 0 0 {name=l8199 lab=VDD}
N 1440 10160 1460 10160 {}
C {lab_pin.sym} 1460 10160 0 0 {name=l8200 lab=VSS}
C {bitcell_6t.sym} 1600 10200 0 0 {name=Xr51c8}
N 1560 10240 1540 10240 {}
C {lab_pin.sym} 1540 10240 0 0 {name=l8201 lab=BL8}
N 1560 10200 1540 10200 {}
C {lab_pin.sym} 1540 10200 0 0 {name=l8202 lab=BLB8}
N 1560 10160 1540 10160 {}
C {lab_pin.sym} 1540 10160 0 0 {name=l8203 lab=WL51}
N 1640 10240 1660 10240 {}
C {lab_pin.sym} 1660 10240 0 0 {name=l8204 lab=VDD}
N 1640 10160 1660 10160 {}
C {lab_pin.sym} 1660 10160 0 0 {name=l8205 lab=VSS}
C {bitcell_6t.sym} 1800 10200 0 0 {name=Xr51c9}
N 1760 10240 1740 10240 {}
C {lab_pin.sym} 1740 10240 0 0 {name=l8206 lab=BL9}
N 1760 10200 1740 10200 {}
C {lab_pin.sym} 1740 10200 0 0 {name=l8207 lab=BLB9}
N 1760 10160 1740 10160 {}
C {lab_pin.sym} 1740 10160 0 0 {name=l8208 lab=WL51}
N 1840 10240 1860 10240 {}
C {lab_pin.sym} 1860 10240 0 0 {name=l8209 lab=VDD}
N 1840 10160 1860 10160 {}
C {lab_pin.sym} 1860 10160 0 0 {name=l8210 lab=VSS}
C {bitcell_6t.sym} 2000 10200 0 0 {name=Xr51c10}
N 1960 10240 1940 10240 {}
C {lab_pin.sym} 1940 10240 0 0 {name=l8211 lab=BL10}
N 1960 10200 1940 10200 {}
C {lab_pin.sym} 1940 10200 0 0 {name=l8212 lab=BLB10}
N 1960 10160 1940 10160 {}
C {lab_pin.sym} 1940 10160 0 0 {name=l8213 lab=WL51}
N 2040 10240 2060 10240 {}
C {lab_pin.sym} 2060 10240 0 0 {name=l8214 lab=VDD}
N 2040 10160 2060 10160 {}
C {lab_pin.sym} 2060 10160 0 0 {name=l8215 lab=VSS}
C {bitcell_6t.sym} 2200 10200 0 0 {name=Xr51c11}
N 2160 10240 2140 10240 {}
C {lab_pin.sym} 2140 10240 0 0 {name=l8216 lab=BL11}
N 2160 10200 2140 10200 {}
C {lab_pin.sym} 2140 10200 0 0 {name=l8217 lab=BLB11}
N 2160 10160 2140 10160 {}
C {lab_pin.sym} 2140 10160 0 0 {name=l8218 lab=WL51}
N 2240 10240 2260 10240 {}
C {lab_pin.sym} 2260 10240 0 0 {name=l8219 lab=VDD}
N 2240 10160 2260 10160 {}
C {lab_pin.sym} 2260 10160 0 0 {name=l8220 lab=VSS}
C {bitcell_6t.sym} 2400 10200 0 0 {name=Xr51c12}
N 2360 10240 2340 10240 {}
C {lab_pin.sym} 2340 10240 0 0 {name=l8221 lab=BL12}
N 2360 10200 2340 10200 {}
C {lab_pin.sym} 2340 10200 0 0 {name=l8222 lab=BLB12}
N 2360 10160 2340 10160 {}
C {lab_pin.sym} 2340 10160 0 0 {name=l8223 lab=WL51}
N 2440 10240 2460 10240 {}
C {lab_pin.sym} 2460 10240 0 0 {name=l8224 lab=VDD}
N 2440 10160 2460 10160 {}
C {lab_pin.sym} 2460 10160 0 0 {name=l8225 lab=VSS}
C {bitcell_6t.sym} 2600 10200 0 0 {name=Xr51c13}
N 2560 10240 2540 10240 {}
C {lab_pin.sym} 2540 10240 0 0 {name=l8226 lab=BL13}
N 2560 10200 2540 10200 {}
C {lab_pin.sym} 2540 10200 0 0 {name=l8227 lab=BLB13}
N 2560 10160 2540 10160 {}
C {lab_pin.sym} 2540 10160 0 0 {name=l8228 lab=WL51}
N 2640 10240 2660 10240 {}
C {lab_pin.sym} 2660 10240 0 0 {name=l8229 lab=VDD}
N 2640 10160 2660 10160 {}
C {lab_pin.sym} 2660 10160 0 0 {name=l8230 lab=VSS}
C {bitcell_6t.sym} 2800 10200 0 0 {name=Xr51c14}
N 2760 10240 2740 10240 {}
C {lab_pin.sym} 2740 10240 0 0 {name=l8231 lab=BL14}
N 2760 10200 2740 10200 {}
C {lab_pin.sym} 2740 10200 0 0 {name=l8232 lab=BLB14}
N 2760 10160 2740 10160 {}
C {lab_pin.sym} 2740 10160 0 0 {name=l8233 lab=WL51}
N 2840 10240 2860 10240 {}
C {lab_pin.sym} 2860 10240 0 0 {name=l8234 lab=VDD}
N 2840 10160 2860 10160 {}
C {lab_pin.sym} 2860 10160 0 0 {name=l8235 lab=VSS}
C {bitcell_6t.sym} 3000 10200 0 0 {name=Xr51c15}
N 2960 10240 2940 10240 {}
C {lab_pin.sym} 2940 10240 0 0 {name=l8236 lab=BL15}
N 2960 10200 2940 10200 {}
C {lab_pin.sym} 2940 10200 0 0 {name=l8237 lab=BLB15}
N 2960 10160 2940 10160 {}
C {lab_pin.sym} 2940 10160 0 0 {name=l8238 lab=WL51}
N 3040 10240 3060 10240 {}
C {lab_pin.sym} 3060 10240 0 0 {name=l8239 lab=VDD}
N 3040 10160 3060 10160 {}
C {lab_pin.sym} 3060 10160 0 0 {name=l8240 lab=VSS}
C {bitcell_6t.sym} 3200 10200 0 0 {name=Xr51c16}
N 3160 10240 3140 10240 {}
C {lab_pin.sym} 3140 10240 0 0 {name=l8241 lab=BL16}
N 3160 10200 3140 10200 {}
C {lab_pin.sym} 3140 10200 0 0 {name=l8242 lab=BLB16}
N 3160 10160 3140 10160 {}
C {lab_pin.sym} 3140 10160 0 0 {name=l8243 lab=WL51}
N 3240 10240 3260 10240 {}
C {lab_pin.sym} 3260 10240 0 0 {name=l8244 lab=VDD}
N 3240 10160 3260 10160 {}
C {lab_pin.sym} 3260 10160 0 0 {name=l8245 lab=VSS}
C {bitcell_6t.sym} 3400 10200 0 0 {name=Xr51c17}
N 3360 10240 3340 10240 {}
C {lab_pin.sym} 3340 10240 0 0 {name=l8246 lab=BL17}
N 3360 10200 3340 10200 {}
C {lab_pin.sym} 3340 10200 0 0 {name=l8247 lab=BLB17}
N 3360 10160 3340 10160 {}
C {lab_pin.sym} 3340 10160 0 0 {name=l8248 lab=WL51}
N 3440 10240 3460 10240 {}
C {lab_pin.sym} 3460 10240 0 0 {name=l8249 lab=VDD}
N 3440 10160 3460 10160 {}
C {lab_pin.sym} 3460 10160 0 0 {name=l8250 lab=VSS}
C {bitcell_6t.sym} 3600 10200 0 0 {name=Xr51c18}
N 3560 10240 3540 10240 {}
C {lab_pin.sym} 3540 10240 0 0 {name=l8251 lab=BL18}
N 3560 10200 3540 10200 {}
C {lab_pin.sym} 3540 10200 0 0 {name=l8252 lab=BLB18}
N 3560 10160 3540 10160 {}
C {lab_pin.sym} 3540 10160 0 0 {name=l8253 lab=WL51}
N 3640 10240 3660 10240 {}
C {lab_pin.sym} 3660 10240 0 0 {name=l8254 lab=VDD}
N 3640 10160 3660 10160 {}
C {lab_pin.sym} 3660 10160 0 0 {name=l8255 lab=VSS}
C {bitcell_6t.sym} 3800 10200 0 0 {name=Xr51c19}
N 3760 10240 3740 10240 {}
C {lab_pin.sym} 3740 10240 0 0 {name=l8256 lab=BL19}
N 3760 10200 3740 10200 {}
C {lab_pin.sym} 3740 10200 0 0 {name=l8257 lab=BLB19}
N 3760 10160 3740 10160 {}
C {lab_pin.sym} 3740 10160 0 0 {name=l8258 lab=WL51}
N 3840 10240 3860 10240 {}
C {lab_pin.sym} 3860 10240 0 0 {name=l8259 lab=VDD}
N 3840 10160 3860 10160 {}
C {lab_pin.sym} 3860 10160 0 0 {name=l8260 lab=VSS}
C {bitcell_6t.sym} 4000 10200 0 0 {name=Xr51c20}
N 3960 10240 3940 10240 {}
C {lab_pin.sym} 3940 10240 0 0 {name=l8261 lab=BL20}
N 3960 10200 3940 10200 {}
C {lab_pin.sym} 3940 10200 0 0 {name=l8262 lab=BLB20}
N 3960 10160 3940 10160 {}
C {lab_pin.sym} 3940 10160 0 0 {name=l8263 lab=WL51}
N 4040 10240 4060 10240 {}
C {lab_pin.sym} 4060 10240 0 0 {name=l8264 lab=VDD}
N 4040 10160 4060 10160 {}
C {lab_pin.sym} 4060 10160 0 0 {name=l8265 lab=VSS}
C {bitcell_6t.sym} 4200 10200 0 0 {name=Xr51c21}
N 4160 10240 4140 10240 {}
C {lab_pin.sym} 4140 10240 0 0 {name=l8266 lab=BL21}
N 4160 10200 4140 10200 {}
C {lab_pin.sym} 4140 10200 0 0 {name=l8267 lab=BLB21}
N 4160 10160 4140 10160 {}
C {lab_pin.sym} 4140 10160 0 0 {name=l8268 lab=WL51}
N 4240 10240 4260 10240 {}
C {lab_pin.sym} 4260 10240 0 0 {name=l8269 lab=VDD}
N 4240 10160 4260 10160 {}
C {lab_pin.sym} 4260 10160 0 0 {name=l8270 lab=VSS}
C {bitcell_6t.sym} 4400 10200 0 0 {name=Xr51c22}
N 4360 10240 4340 10240 {}
C {lab_pin.sym} 4340 10240 0 0 {name=l8271 lab=BL22}
N 4360 10200 4340 10200 {}
C {lab_pin.sym} 4340 10200 0 0 {name=l8272 lab=BLB22}
N 4360 10160 4340 10160 {}
C {lab_pin.sym} 4340 10160 0 0 {name=l8273 lab=WL51}
N 4440 10240 4460 10240 {}
C {lab_pin.sym} 4460 10240 0 0 {name=l8274 lab=VDD}
N 4440 10160 4460 10160 {}
C {lab_pin.sym} 4460 10160 0 0 {name=l8275 lab=VSS}
C {bitcell_6t.sym} 4600 10200 0 0 {name=Xr51c23}
N 4560 10240 4540 10240 {}
C {lab_pin.sym} 4540 10240 0 0 {name=l8276 lab=BL23}
N 4560 10200 4540 10200 {}
C {lab_pin.sym} 4540 10200 0 0 {name=l8277 lab=BLB23}
N 4560 10160 4540 10160 {}
C {lab_pin.sym} 4540 10160 0 0 {name=l8278 lab=WL51}
N 4640 10240 4660 10240 {}
C {lab_pin.sym} 4660 10240 0 0 {name=l8279 lab=VDD}
N 4640 10160 4660 10160 {}
C {lab_pin.sym} 4660 10160 0 0 {name=l8280 lab=VSS}
C {bitcell_6t.sym} 4800 10200 0 0 {name=Xr51c24}
N 4760 10240 4740 10240 {}
C {lab_pin.sym} 4740 10240 0 0 {name=l8281 lab=BL24}
N 4760 10200 4740 10200 {}
C {lab_pin.sym} 4740 10200 0 0 {name=l8282 lab=BLB24}
N 4760 10160 4740 10160 {}
C {lab_pin.sym} 4740 10160 0 0 {name=l8283 lab=WL51}
N 4840 10240 4860 10240 {}
C {lab_pin.sym} 4860 10240 0 0 {name=l8284 lab=VDD}
N 4840 10160 4860 10160 {}
C {lab_pin.sym} 4860 10160 0 0 {name=l8285 lab=VSS}
C {bitcell_6t.sym} 5000 10200 0 0 {name=Xr51c25}
N 4960 10240 4940 10240 {}
C {lab_pin.sym} 4940 10240 0 0 {name=l8286 lab=BL25}
N 4960 10200 4940 10200 {}
C {lab_pin.sym} 4940 10200 0 0 {name=l8287 lab=BLB25}
N 4960 10160 4940 10160 {}
C {lab_pin.sym} 4940 10160 0 0 {name=l8288 lab=WL51}
N 5040 10240 5060 10240 {}
C {lab_pin.sym} 5060 10240 0 0 {name=l8289 lab=VDD}
N 5040 10160 5060 10160 {}
C {lab_pin.sym} 5060 10160 0 0 {name=l8290 lab=VSS}
C {bitcell_6t.sym} 5200 10200 0 0 {name=Xr51c26}
N 5160 10240 5140 10240 {}
C {lab_pin.sym} 5140 10240 0 0 {name=l8291 lab=BL26}
N 5160 10200 5140 10200 {}
C {lab_pin.sym} 5140 10200 0 0 {name=l8292 lab=BLB26}
N 5160 10160 5140 10160 {}
C {lab_pin.sym} 5140 10160 0 0 {name=l8293 lab=WL51}
N 5240 10240 5260 10240 {}
C {lab_pin.sym} 5260 10240 0 0 {name=l8294 lab=VDD}
N 5240 10160 5260 10160 {}
C {lab_pin.sym} 5260 10160 0 0 {name=l8295 lab=VSS}
C {bitcell_6t.sym} 5400 10200 0 0 {name=Xr51c27}
N 5360 10240 5340 10240 {}
C {lab_pin.sym} 5340 10240 0 0 {name=l8296 lab=BL27}
N 5360 10200 5340 10200 {}
C {lab_pin.sym} 5340 10200 0 0 {name=l8297 lab=BLB27}
N 5360 10160 5340 10160 {}
C {lab_pin.sym} 5340 10160 0 0 {name=l8298 lab=WL51}
N 5440 10240 5460 10240 {}
C {lab_pin.sym} 5460 10240 0 0 {name=l8299 lab=VDD}
N 5440 10160 5460 10160 {}
C {lab_pin.sym} 5460 10160 0 0 {name=l8300 lab=VSS}
C {bitcell_6t.sym} 5600 10200 0 0 {name=Xr51c28}
N 5560 10240 5540 10240 {}
C {lab_pin.sym} 5540 10240 0 0 {name=l8301 lab=BL28}
N 5560 10200 5540 10200 {}
C {lab_pin.sym} 5540 10200 0 0 {name=l8302 lab=BLB28}
N 5560 10160 5540 10160 {}
C {lab_pin.sym} 5540 10160 0 0 {name=l8303 lab=WL51}
N 5640 10240 5660 10240 {}
C {lab_pin.sym} 5660 10240 0 0 {name=l8304 lab=VDD}
N 5640 10160 5660 10160 {}
C {lab_pin.sym} 5660 10160 0 0 {name=l8305 lab=VSS}
C {bitcell_6t.sym} 5800 10200 0 0 {name=Xr51c29}
N 5760 10240 5740 10240 {}
C {lab_pin.sym} 5740 10240 0 0 {name=l8306 lab=BL29}
N 5760 10200 5740 10200 {}
C {lab_pin.sym} 5740 10200 0 0 {name=l8307 lab=BLB29}
N 5760 10160 5740 10160 {}
C {lab_pin.sym} 5740 10160 0 0 {name=l8308 lab=WL51}
N 5840 10240 5860 10240 {}
C {lab_pin.sym} 5860 10240 0 0 {name=l8309 lab=VDD}
N 5840 10160 5860 10160 {}
C {lab_pin.sym} 5860 10160 0 0 {name=l8310 lab=VSS}
C {bitcell_6t.sym} 6000 10200 0 0 {name=Xr51c30}
N 5960 10240 5940 10240 {}
C {lab_pin.sym} 5940 10240 0 0 {name=l8311 lab=BL30}
N 5960 10200 5940 10200 {}
C {lab_pin.sym} 5940 10200 0 0 {name=l8312 lab=BLB30}
N 5960 10160 5940 10160 {}
C {lab_pin.sym} 5940 10160 0 0 {name=l8313 lab=WL51}
N 6040 10240 6060 10240 {}
C {lab_pin.sym} 6060 10240 0 0 {name=l8314 lab=VDD}
N 6040 10160 6060 10160 {}
C {lab_pin.sym} 6060 10160 0 0 {name=l8315 lab=VSS}
C {bitcell_6t.sym} 6200 10200 0 0 {name=Xr51c31}
N 6160 10240 6140 10240 {}
C {lab_pin.sym} 6140 10240 0 0 {name=l8316 lab=BL31}
N 6160 10200 6140 10200 {}
C {lab_pin.sym} 6140 10200 0 0 {name=l8317 lab=BLB31}
N 6160 10160 6140 10160 {}
C {lab_pin.sym} 6140 10160 0 0 {name=l8318 lab=WL51}
N 6240 10240 6260 10240 {}
C {lab_pin.sym} 6260 10240 0 0 {name=l8319 lab=VDD}
N 6240 10160 6260 10160 {}
C {lab_pin.sym} 6260 10160 0 0 {name=l8320 lab=VSS}
C {bitcell_6t.sym} 0 10400 0 0 {name=Xr52c0}
N -40 10440 -60 10440 {}
C {lab_pin.sym} -60 10440 0 0 {name=l8321 lab=BL0}
N -40 10400 -60 10400 {}
C {lab_pin.sym} -60 10400 0 0 {name=l8322 lab=BLB0}
N -40 10360 -60 10360 {}
C {lab_pin.sym} -60 10360 0 0 {name=l8323 lab=WL52}
N 40 10440 60 10440 {}
C {lab_pin.sym} 60 10440 0 0 {name=l8324 lab=VDD}
N 40 10360 60 10360 {}
C {lab_pin.sym} 60 10360 0 0 {name=l8325 lab=VSS}
C {bitcell_6t.sym} 200 10400 0 0 {name=Xr52c1}
N 160 10440 140 10440 {}
C {lab_pin.sym} 140 10440 0 0 {name=l8326 lab=BL1}
N 160 10400 140 10400 {}
C {lab_pin.sym} 140 10400 0 0 {name=l8327 lab=BLB1}
N 160 10360 140 10360 {}
C {lab_pin.sym} 140 10360 0 0 {name=l8328 lab=WL52}
N 240 10440 260 10440 {}
C {lab_pin.sym} 260 10440 0 0 {name=l8329 lab=VDD}
N 240 10360 260 10360 {}
C {lab_pin.sym} 260 10360 0 0 {name=l8330 lab=VSS}
C {bitcell_6t.sym} 400 10400 0 0 {name=Xr52c2}
N 360 10440 340 10440 {}
C {lab_pin.sym} 340 10440 0 0 {name=l8331 lab=BL2}
N 360 10400 340 10400 {}
C {lab_pin.sym} 340 10400 0 0 {name=l8332 lab=BLB2}
N 360 10360 340 10360 {}
C {lab_pin.sym} 340 10360 0 0 {name=l8333 lab=WL52}
N 440 10440 460 10440 {}
C {lab_pin.sym} 460 10440 0 0 {name=l8334 lab=VDD}
N 440 10360 460 10360 {}
C {lab_pin.sym} 460 10360 0 0 {name=l8335 lab=VSS}
C {bitcell_6t.sym} 600 10400 0 0 {name=Xr52c3}
N 560 10440 540 10440 {}
C {lab_pin.sym} 540 10440 0 0 {name=l8336 lab=BL3}
N 560 10400 540 10400 {}
C {lab_pin.sym} 540 10400 0 0 {name=l8337 lab=BLB3}
N 560 10360 540 10360 {}
C {lab_pin.sym} 540 10360 0 0 {name=l8338 lab=WL52}
N 640 10440 660 10440 {}
C {lab_pin.sym} 660 10440 0 0 {name=l8339 lab=VDD}
N 640 10360 660 10360 {}
C {lab_pin.sym} 660 10360 0 0 {name=l8340 lab=VSS}
C {bitcell_6t.sym} 800 10400 0 0 {name=Xr52c4}
N 760 10440 740 10440 {}
C {lab_pin.sym} 740 10440 0 0 {name=l8341 lab=BL4}
N 760 10400 740 10400 {}
C {lab_pin.sym} 740 10400 0 0 {name=l8342 lab=BLB4}
N 760 10360 740 10360 {}
C {lab_pin.sym} 740 10360 0 0 {name=l8343 lab=WL52}
N 840 10440 860 10440 {}
C {lab_pin.sym} 860 10440 0 0 {name=l8344 lab=VDD}
N 840 10360 860 10360 {}
C {lab_pin.sym} 860 10360 0 0 {name=l8345 lab=VSS}
C {bitcell_6t.sym} 1000 10400 0 0 {name=Xr52c5}
N 960 10440 940 10440 {}
C {lab_pin.sym} 940 10440 0 0 {name=l8346 lab=BL5}
N 960 10400 940 10400 {}
C {lab_pin.sym} 940 10400 0 0 {name=l8347 lab=BLB5}
N 960 10360 940 10360 {}
C {lab_pin.sym} 940 10360 0 0 {name=l8348 lab=WL52}
N 1040 10440 1060 10440 {}
C {lab_pin.sym} 1060 10440 0 0 {name=l8349 lab=VDD}
N 1040 10360 1060 10360 {}
C {lab_pin.sym} 1060 10360 0 0 {name=l8350 lab=VSS}
C {bitcell_6t.sym} 1200 10400 0 0 {name=Xr52c6}
N 1160 10440 1140 10440 {}
C {lab_pin.sym} 1140 10440 0 0 {name=l8351 lab=BL6}
N 1160 10400 1140 10400 {}
C {lab_pin.sym} 1140 10400 0 0 {name=l8352 lab=BLB6}
N 1160 10360 1140 10360 {}
C {lab_pin.sym} 1140 10360 0 0 {name=l8353 lab=WL52}
N 1240 10440 1260 10440 {}
C {lab_pin.sym} 1260 10440 0 0 {name=l8354 lab=VDD}
N 1240 10360 1260 10360 {}
C {lab_pin.sym} 1260 10360 0 0 {name=l8355 lab=VSS}
C {bitcell_6t.sym} 1400 10400 0 0 {name=Xr52c7}
N 1360 10440 1340 10440 {}
C {lab_pin.sym} 1340 10440 0 0 {name=l8356 lab=BL7}
N 1360 10400 1340 10400 {}
C {lab_pin.sym} 1340 10400 0 0 {name=l8357 lab=BLB7}
N 1360 10360 1340 10360 {}
C {lab_pin.sym} 1340 10360 0 0 {name=l8358 lab=WL52}
N 1440 10440 1460 10440 {}
C {lab_pin.sym} 1460 10440 0 0 {name=l8359 lab=VDD}
N 1440 10360 1460 10360 {}
C {lab_pin.sym} 1460 10360 0 0 {name=l8360 lab=VSS}
C {bitcell_6t.sym} 1600 10400 0 0 {name=Xr52c8}
N 1560 10440 1540 10440 {}
C {lab_pin.sym} 1540 10440 0 0 {name=l8361 lab=BL8}
N 1560 10400 1540 10400 {}
C {lab_pin.sym} 1540 10400 0 0 {name=l8362 lab=BLB8}
N 1560 10360 1540 10360 {}
C {lab_pin.sym} 1540 10360 0 0 {name=l8363 lab=WL52}
N 1640 10440 1660 10440 {}
C {lab_pin.sym} 1660 10440 0 0 {name=l8364 lab=VDD}
N 1640 10360 1660 10360 {}
C {lab_pin.sym} 1660 10360 0 0 {name=l8365 lab=VSS}
C {bitcell_6t.sym} 1800 10400 0 0 {name=Xr52c9}
N 1760 10440 1740 10440 {}
C {lab_pin.sym} 1740 10440 0 0 {name=l8366 lab=BL9}
N 1760 10400 1740 10400 {}
C {lab_pin.sym} 1740 10400 0 0 {name=l8367 lab=BLB9}
N 1760 10360 1740 10360 {}
C {lab_pin.sym} 1740 10360 0 0 {name=l8368 lab=WL52}
N 1840 10440 1860 10440 {}
C {lab_pin.sym} 1860 10440 0 0 {name=l8369 lab=VDD}
N 1840 10360 1860 10360 {}
C {lab_pin.sym} 1860 10360 0 0 {name=l8370 lab=VSS}
C {bitcell_6t.sym} 2000 10400 0 0 {name=Xr52c10}
N 1960 10440 1940 10440 {}
C {lab_pin.sym} 1940 10440 0 0 {name=l8371 lab=BL10}
N 1960 10400 1940 10400 {}
C {lab_pin.sym} 1940 10400 0 0 {name=l8372 lab=BLB10}
N 1960 10360 1940 10360 {}
C {lab_pin.sym} 1940 10360 0 0 {name=l8373 lab=WL52}
N 2040 10440 2060 10440 {}
C {lab_pin.sym} 2060 10440 0 0 {name=l8374 lab=VDD}
N 2040 10360 2060 10360 {}
C {lab_pin.sym} 2060 10360 0 0 {name=l8375 lab=VSS}
C {bitcell_6t.sym} 2200 10400 0 0 {name=Xr52c11}
N 2160 10440 2140 10440 {}
C {lab_pin.sym} 2140 10440 0 0 {name=l8376 lab=BL11}
N 2160 10400 2140 10400 {}
C {lab_pin.sym} 2140 10400 0 0 {name=l8377 lab=BLB11}
N 2160 10360 2140 10360 {}
C {lab_pin.sym} 2140 10360 0 0 {name=l8378 lab=WL52}
N 2240 10440 2260 10440 {}
C {lab_pin.sym} 2260 10440 0 0 {name=l8379 lab=VDD}
N 2240 10360 2260 10360 {}
C {lab_pin.sym} 2260 10360 0 0 {name=l8380 lab=VSS}
C {bitcell_6t.sym} 2400 10400 0 0 {name=Xr52c12}
N 2360 10440 2340 10440 {}
C {lab_pin.sym} 2340 10440 0 0 {name=l8381 lab=BL12}
N 2360 10400 2340 10400 {}
C {lab_pin.sym} 2340 10400 0 0 {name=l8382 lab=BLB12}
N 2360 10360 2340 10360 {}
C {lab_pin.sym} 2340 10360 0 0 {name=l8383 lab=WL52}
N 2440 10440 2460 10440 {}
C {lab_pin.sym} 2460 10440 0 0 {name=l8384 lab=VDD}
N 2440 10360 2460 10360 {}
C {lab_pin.sym} 2460 10360 0 0 {name=l8385 lab=VSS}
C {bitcell_6t.sym} 2600 10400 0 0 {name=Xr52c13}
N 2560 10440 2540 10440 {}
C {lab_pin.sym} 2540 10440 0 0 {name=l8386 lab=BL13}
N 2560 10400 2540 10400 {}
C {lab_pin.sym} 2540 10400 0 0 {name=l8387 lab=BLB13}
N 2560 10360 2540 10360 {}
C {lab_pin.sym} 2540 10360 0 0 {name=l8388 lab=WL52}
N 2640 10440 2660 10440 {}
C {lab_pin.sym} 2660 10440 0 0 {name=l8389 lab=VDD}
N 2640 10360 2660 10360 {}
C {lab_pin.sym} 2660 10360 0 0 {name=l8390 lab=VSS}
C {bitcell_6t.sym} 2800 10400 0 0 {name=Xr52c14}
N 2760 10440 2740 10440 {}
C {lab_pin.sym} 2740 10440 0 0 {name=l8391 lab=BL14}
N 2760 10400 2740 10400 {}
C {lab_pin.sym} 2740 10400 0 0 {name=l8392 lab=BLB14}
N 2760 10360 2740 10360 {}
C {lab_pin.sym} 2740 10360 0 0 {name=l8393 lab=WL52}
N 2840 10440 2860 10440 {}
C {lab_pin.sym} 2860 10440 0 0 {name=l8394 lab=VDD}
N 2840 10360 2860 10360 {}
C {lab_pin.sym} 2860 10360 0 0 {name=l8395 lab=VSS}
C {bitcell_6t.sym} 3000 10400 0 0 {name=Xr52c15}
N 2960 10440 2940 10440 {}
C {lab_pin.sym} 2940 10440 0 0 {name=l8396 lab=BL15}
N 2960 10400 2940 10400 {}
C {lab_pin.sym} 2940 10400 0 0 {name=l8397 lab=BLB15}
N 2960 10360 2940 10360 {}
C {lab_pin.sym} 2940 10360 0 0 {name=l8398 lab=WL52}
N 3040 10440 3060 10440 {}
C {lab_pin.sym} 3060 10440 0 0 {name=l8399 lab=VDD}
N 3040 10360 3060 10360 {}
C {lab_pin.sym} 3060 10360 0 0 {name=l8400 lab=VSS}
C {bitcell_6t.sym} 3200 10400 0 0 {name=Xr52c16}
N 3160 10440 3140 10440 {}
C {lab_pin.sym} 3140 10440 0 0 {name=l8401 lab=BL16}
N 3160 10400 3140 10400 {}
C {lab_pin.sym} 3140 10400 0 0 {name=l8402 lab=BLB16}
N 3160 10360 3140 10360 {}
C {lab_pin.sym} 3140 10360 0 0 {name=l8403 lab=WL52}
N 3240 10440 3260 10440 {}
C {lab_pin.sym} 3260 10440 0 0 {name=l8404 lab=VDD}
N 3240 10360 3260 10360 {}
C {lab_pin.sym} 3260 10360 0 0 {name=l8405 lab=VSS}
C {bitcell_6t.sym} 3400 10400 0 0 {name=Xr52c17}
N 3360 10440 3340 10440 {}
C {lab_pin.sym} 3340 10440 0 0 {name=l8406 lab=BL17}
N 3360 10400 3340 10400 {}
C {lab_pin.sym} 3340 10400 0 0 {name=l8407 lab=BLB17}
N 3360 10360 3340 10360 {}
C {lab_pin.sym} 3340 10360 0 0 {name=l8408 lab=WL52}
N 3440 10440 3460 10440 {}
C {lab_pin.sym} 3460 10440 0 0 {name=l8409 lab=VDD}
N 3440 10360 3460 10360 {}
C {lab_pin.sym} 3460 10360 0 0 {name=l8410 lab=VSS}
C {bitcell_6t.sym} 3600 10400 0 0 {name=Xr52c18}
N 3560 10440 3540 10440 {}
C {lab_pin.sym} 3540 10440 0 0 {name=l8411 lab=BL18}
N 3560 10400 3540 10400 {}
C {lab_pin.sym} 3540 10400 0 0 {name=l8412 lab=BLB18}
N 3560 10360 3540 10360 {}
C {lab_pin.sym} 3540 10360 0 0 {name=l8413 lab=WL52}
N 3640 10440 3660 10440 {}
C {lab_pin.sym} 3660 10440 0 0 {name=l8414 lab=VDD}
N 3640 10360 3660 10360 {}
C {lab_pin.sym} 3660 10360 0 0 {name=l8415 lab=VSS}
C {bitcell_6t.sym} 3800 10400 0 0 {name=Xr52c19}
N 3760 10440 3740 10440 {}
C {lab_pin.sym} 3740 10440 0 0 {name=l8416 lab=BL19}
N 3760 10400 3740 10400 {}
C {lab_pin.sym} 3740 10400 0 0 {name=l8417 lab=BLB19}
N 3760 10360 3740 10360 {}
C {lab_pin.sym} 3740 10360 0 0 {name=l8418 lab=WL52}
N 3840 10440 3860 10440 {}
C {lab_pin.sym} 3860 10440 0 0 {name=l8419 lab=VDD}
N 3840 10360 3860 10360 {}
C {lab_pin.sym} 3860 10360 0 0 {name=l8420 lab=VSS}
C {bitcell_6t.sym} 4000 10400 0 0 {name=Xr52c20}
N 3960 10440 3940 10440 {}
C {lab_pin.sym} 3940 10440 0 0 {name=l8421 lab=BL20}
N 3960 10400 3940 10400 {}
C {lab_pin.sym} 3940 10400 0 0 {name=l8422 lab=BLB20}
N 3960 10360 3940 10360 {}
C {lab_pin.sym} 3940 10360 0 0 {name=l8423 lab=WL52}
N 4040 10440 4060 10440 {}
C {lab_pin.sym} 4060 10440 0 0 {name=l8424 lab=VDD}
N 4040 10360 4060 10360 {}
C {lab_pin.sym} 4060 10360 0 0 {name=l8425 lab=VSS}
C {bitcell_6t.sym} 4200 10400 0 0 {name=Xr52c21}
N 4160 10440 4140 10440 {}
C {lab_pin.sym} 4140 10440 0 0 {name=l8426 lab=BL21}
N 4160 10400 4140 10400 {}
C {lab_pin.sym} 4140 10400 0 0 {name=l8427 lab=BLB21}
N 4160 10360 4140 10360 {}
C {lab_pin.sym} 4140 10360 0 0 {name=l8428 lab=WL52}
N 4240 10440 4260 10440 {}
C {lab_pin.sym} 4260 10440 0 0 {name=l8429 lab=VDD}
N 4240 10360 4260 10360 {}
C {lab_pin.sym} 4260 10360 0 0 {name=l8430 lab=VSS}
C {bitcell_6t.sym} 4400 10400 0 0 {name=Xr52c22}
N 4360 10440 4340 10440 {}
C {lab_pin.sym} 4340 10440 0 0 {name=l8431 lab=BL22}
N 4360 10400 4340 10400 {}
C {lab_pin.sym} 4340 10400 0 0 {name=l8432 lab=BLB22}
N 4360 10360 4340 10360 {}
C {lab_pin.sym} 4340 10360 0 0 {name=l8433 lab=WL52}
N 4440 10440 4460 10440 {}
C {lab_pin.sym} 4460 10440 0 0 {name=l8434 lab=VDD}
N 4440 10360 4460 10360 {}
C {lab_pin.sym} 4460 10360 0 0 {name=l8435 lab=VSS}
C {bitcell_6t.sym} 4600 10400 0 0 {name=Xr52c23}
N 4560 10440 4540 10440 {}
C {lab_pin.sym} 4540 10440 0 0 {name=l8436 lab=BL23}
N 4560 10400 4540 10400 {}
C {lab_pin.sym} 4540 10400 0 0 {name=l8437 lab=BLB23}
N 4560 10360 4540 10360 {}
C {lab_pin.sym} 4540 10360 0 0 {name=l8438 lab=WL52}
N 4640 10440 4660 10440 {}
C {lab_pin.sym} 4660 10440 0 0 {name=l8439 lab=VDD}
N 4640 10360 4660 10360 {}
C {lab_pin.sym} 4660 10360 0 0 {name=l8440 lab=VSS}
C {bitcell_6t.sym} 4800 10400 0 0 {name=Xr52c24}
N 4760 10440 4740 10440 {}
C {lab_pin.sym} 4740 10440 0 0 {name=l8441 lab=BL24}
N 4760 10400 4740 10400 {}
C {lab_pin.sym} 4740 10400 0 0 {name=l8442 lab=BLB24}
N 4760 10360 4740 10360 {}
C {lab_pin.sym} 4740 10360 0 0 {name=l8443 lab=WL52}
N 4840 10440 4860 10440 {}
C {lab_pin.sym} 4860 10440 0 0 {name=l8444 lab=VDD}
N 4840 10360 4860 10360 {}
C {lab_pin.sym} 4860 10360 0 0 {name=l8445 lab=VSS}
C {bitcell_6t.sym} 5000 10400 0 0 {name=Xr52c25}
N 4960 10440 4940 10440 {}
C {lab_pin.sym} 4940 10440 0 0 {name=l8446 lab=BL25}
N 4960 10400 4940 10400 {}
C {lab_pin.sym} 4940 10400 0 0 {name=l8447 lab=BLB25}
N 4960 10360 4940 10360 {}
C {lab_pin.sym} 4940 10360 0 0 {name=l8448 lab=WL52}
N 5040 10440 5060 10440 {}
C {lab_pin.sym} 5060 10440 0 0 {name=l8449 lab=VDD}
N 5040 10360 5060 10360 {}
C {lab_pin.sym} 5060 10360 0 0 {name=l8450 lab=VSS}
C {bitcell_6t.sym} 5200 10400 0 0 {name=Xr52c26}
N 5160 10440 5140 10440 {}
C {lab_pin.sym} 5140 10440 0 0 {name=l8451 lab=BL26}
N 5160 10400 5140 10400 {}
C {lab_pin.sym} 5140 10400 0 0 {name=l8452 lab=BLB26}
N 5160 10360 5140 10360 {}
C {lab_pin.sym} 5140 10360 0 0 {name=l8453 lab=WL52}
N 5240 10440 5260 10440 {}
C {lab_pin.sym} 5260 10440 0 0 {name=l8454 lab=VDD}
N 5240 10360 5260 10360 {}
C {lab_pin.sym} 5260 10360 0 0 {name=l8455 lab=VSS}
C {bitcell_6t.sym} 5400 10400 0 0 {name=Xr52c27}
N 5360 10440 5340 10440 {}
C {lab_pin.sym} 5340 10440 0 0 {name=l8456 lab=BL27}
N 5360 10400 5340 10400 {}
C {lab_pin.sym} 5340 10400 0 0 {name=l8457 lab=BLB27}
N 5360 10360 5340 10360 {}
C {lab_pin.sym} 5340 10360 0 0 {name=l8458 lab=WL52}
N 5440 10440 5460 10440 {}
C {lab_pin.sym} 5460 10440 0 0 {name=l8459 lab=VDD}
N 5440 10360 5460 10360 {}
C {lab_pin.sym} 5460 10360 0 0 {name=l8460 lab=VSS}
C {bitcell_6t.sym} 5600 10400 0 0 {name=Xr52c28}
N 5560 10440 5540 10440 {}
C {lab_pin.sym} 5540 10440 0 0 {name=l8461 lab=BL28}
N 5560 10400 5540 10400 {}
C {lab_pin.sym} 5540 10400 0 0 {name=l8462 lab=BLB28}
N 5560 10360 5540 10360 {}
C {lab_pin.sym} 5540 10360 0 0 {name=l8463 lab=WL52}
N 5640 10440 5660 10440 {}
C {lab_pin.sym} 5660 10440 0 0 {name=l8464 lab=VDD}
N 5640 10360 5660 10360 {}
C {lab_pin.sym} 5660 10360 0 0 {name=l8465 lab=VSS}
C {bitcell_6t.sym} 5800 10400 0 0 {name=Xr52c29}
N 5760 10440 5740 10440 {}
C {lab_pin.sym} 5740 10440 0 0 {name=l8466 lab=BL29}
N 5760 10400 5740 10400 {}
C {lab_pin.sym} 5740 10400 0 0 {name=l8467 lab=BLB29}
N 5760 10360 5740 10360 {}
C {lab_pin.sym} 5740 10360 0 0 {name=l8468 lab=WL52}
N 5840 10440 5860 10440 {}
C {lab_pin.sym} 5860 10440 0 0 {name=l8469 lab=VDD}
N 5840 10360 5860 10360 {}
C {lab_pin.sym} 5860 10360 0 0 {name=l8470 lab=VSS}
C {bitcell_6t.sym} 6000 10400 0 0 {name=Xr52c30}
N 5960 10440 5940 10440 {}
C {lab_pin.sym} 5940 10440 0 0 {name=l8471 lab=BL30}
N 5960 10400 5940 10400 {}
C {lab_pin.sym} 5940 10400 0 0 {name=l8472 lab=BLB30}
N 5960 10360 5940 10360 {}
C {lab_pin.sym} 5940 10360 0 0 {name=l8473 lab=WL52}
N 6040 10440 6060 10440 {}
C {lab_pin.sym} 6060 10440 0 0 {name=l8474 lab=VDD}
N 6040 10360 6060 10360 {}
C {lab_pin.sym} 6060 10360 0 0 {name=l8475 lab=VSS}
C {bitcell_6t.sym} 6200 10400 0 0 {name=Xr52c31}
N 6160 10440 6140 10440 {}
C {lab_pin.sym} 6140 10440 0 0 {name=l8476 lab=BL31}
N 6160 10400 6140 10400 {}
C {lab_pin.sym} 6140 10400 0 0 {name=l8477 lab=BLB31}
N 6160 10360 6140 10360 {}
C {lab_pin.sym} 6140 10360 0 0 {name=l8478 lab=WL52}
N 6240 10440 6260 10440 {}
C {lab_pin.sym} 6260 10440 0 0 {name=l8479 lab=VDD}
N 6240 10360 6260 10360 {}
C {lab_pin.sym} 6260 10360 0 0 {name=l8480 lab=VSS}
C {bitcell_6t.sym} 0 10600 0 0 {name=Xr53c0}
N -40 10640 -60 10640 {}
C {lab_pin.sym} -60 10640 0 0 {name=l8481 lab=BL0}
N -40 10600 -60 10600 {}
C {lab_pin.sym} -60 10600 0 0 {name=l8482 lab=BLB0}
N -40 10560 -60 10560 {}
C {lab_pin.sym} -60 10560 0 0 {name=l8483 lab=WL53}
N 40 10640 60 10640 {}
C {lab_pin.sym} 60 10640 0 0 {name=l8484 lab=VDD}
N 40 10560 60 10560 {}
C {lab_pin.sym} 60 10560 0 0 {name=l8485 lab=VSS}
C {bitcell_6t.sym} 200 10600 0 0 {name=Xr53c1}
N 160 10640 140 10640 {}
C {lab_pin.sym} 140 10640 0 0 {name=l8486 lab=BL1}
N 160 10600 140 10600 {}
C {lab_pin.sym} 140 10600 0 0 {name=l8487 lab=BLB1}
N 160 10560 140 10560 {}
C {lab_pin.sym} 140 10560 0 0 {name=l8488 lab=WL53}
N 240 10640 260 10640 {}
C {lab_pin.sym} 260 10640 0 0 {name=l8489 lab=VDD}
N 240 10560 260 10560 {}
C {lab_pin.sym} 260 10560 0 0 {name=l8490 lab=VSS}
C {bitcell_6t.sym} 400 10600 0 0 {name=Xr53c2}
N 360 10640 340 10640 {}
C {lab_pin.sym} 340 10640 0 0 {name=l8491 lab=BL2}
N 360 10600 340 10600 {}
C {lab_pin.sym} 340 10600 0 0 {name=l8492 lab=BLB2}
N 360 10560 340 10560 {}
C {lab_pin.sym} 340 10560 0 0 {name=l8493 lab=WL53}
N 440 10640 460 10640 {}
C {lab_pin.sym} 460 10640 0 0 {name=l8494 lab=VDD}
N 440 10560 460 10560 {}
C {lab_pin.sym} 460 10560 0 0 {name=l8495 lab=VSS}
C {bitcell_6t.sym} 600 10600 0 0 {name=Xr53c3}
N 560 10640 540 10640 {}
C {lab_pin.sym} 540 10640 0 0 {name=l8496 lab=BL3}
N 560 10600 540 10600 {}
C {lab_pin.sym} 540 10600 0 0 {name=l8497 lab=BLB3}
N 560 10560 540 10560 {}
C {lab_pin.sym} 540 10560 0 0 {name=l8498 lab=WL53}
N 640 10640 660 10640 {}
C {lab_pin.sym} 660 10640 0 0 {name=l8499 lab=VDD}
N 640 10560 660 10560 {}
C {lab_pin.sym} 660 10560 0 0 {name=l8500 lab=VSS}
C {bitcell_6t.sym} 800 10600 0 0 {name=Xr53c4}
N 760 10640 740 10640 {}
C {lab_pin.sym} 740 10640 0 0 {name=l8501 lab=BL4}
N 760 10600 740 10600 {}
C {lab_pin.sym} 740 10600 0 0 {name=l8502 lab=BLB4}
N 760 10560 740 10560 {}
C {lab_pin.sym} 740 10560 0 0 {name=l8503 lab=WL53}
N 840 10640 860 10640 {}
C {lab_pin.sym} 860 10640 0 0 {name=l8504 lab=VDD}
N 840 10560 860 10560 {}
C {lab_pin.sym} 860 10560 0 0 {name=l8505 lab=VSS}
C {bitcell_6t.sym} 1000 10600 0 0 {name=Xr53c5}
N 960 10640 940 10640 {}
C {lab_pin.sym} 940 10640 0 0 {name=l8506 lab=BL5}
N 960 10600 940 10600 {}
C {lab_pin.sym} 940 10600 0 0 {name=l8507 lab=BLB5}
N 960 10560 940 10560 {}
C {lab_pin.sym} 940 10560 0 0 {name=l8508 lab=WL53}
N 1040 10640 1060 10640 {}
C {lab_pin.sym} 1060 10640 0 0 {name=l8509 lab=VDD}
N 1040 10560 1060 10560 {}
C {lab_pin.sym} 1060 10560 0 0 {name=l8510 lab=VSS}
C {bitcell_6t.sym} 1200 10600 0 0 {name=Xr53c6}
N 1160 10640 1140 10640 {}
C {lab_pin.sym} 1140 10640 0 0 {name=l8511 lab=BL6}
N 1160 10600 1140 10600 {}
C {lab_pin.sym} 1140 10600 0 0 {name=l8512 lab=BLB6}
N 1160 10560 1140 10560 {}
C {lab_pin.sym} 1140 10560 0 0 {name=l8513 lab=WL53}
N 1240 10640 1260 10640 {}
C {lab_pin.sym} 1260 10640 0 0 {name=l8514 lab=VDD}
N 1240 10560 1260 10560 {}
C {lab_pin.sym} 1260 10560 0 0 {name=l8515 lab=VSS}
C {bitcell_6t.sym} 1400 10600 0 0 {name=Xr53c7}
N 1360 10640 1340 10640 {}
C {lab_pin.sym} 1340 10640 0 0 {name=l8516 lab=BL7}
N 1360 10600 1340 10600 {}
C {lab_pin.sym} 1340 10600 0 0 {name=l8517 lab=BLB7}
N 1360 10560 1340 10560 {}
C {lab_pin.sym} 1340 10560 0 0 {name=l8518 lab=WL53}
N 1440 10640 1460 10640 {}
C {lab_pin.sym} 1460 10640 0 0 {name=l8519 lab=VDD}
N 1440 10560 1460 10560 {}
C {lab_pin.sym} 1460 10560 0 0 {name=l8520 lab=VSS}
C {bitcell_6t.sym} 1600 10600 0 0 {name=Xr53c8}
N 1560 10640 1540 10640 {}
C {lab_pin.sym} 1540 10640 0 0 {name=l8521 lab=BL8}
N 1560 10600 1540 10600 {}
C {lab_pin.sym} 1540 10600 0 0 {name=l8522 lab=BLB8}
N 1560 10560 1540 10560 {}
C {lab_pin.sym} 1540 10560 0 0 {name=l8523 lab=WL53}
N 1640 10640 1660 10640 {}
C {lab_pin.sym} 1660 10640 0 0 {name=l8524 lab=VDD}
N 1640 10560 1660 10560 {}
C {lab_pin.sym} 1660 10560 0 0 {name=l8525 lab=VSS}
C {bitcell_6t.sym} 1800 10600 0 0 {name=Xr53c9}
N 1760 10640 1740 10640 {}
C {lab_pin.sym} 1740 10640 0 0 {name=l8526 lab=BL9}
N 1760 10600 1740 10600 {}
C {lab_pin.sym} 1740 10600 0 0 {name=l8527 lab=BLB9}
N 1760 10560 1740 10560 {}
C {lab_pin.sym} 1740 10560 0 0 {name=l8528 lab=WL53}
N 1840 10640 1860 10640 {}
C {lab_pin.sym} 1860 10640 0 0 {name=l8529 lab=VDD}
N 1840 10560 1860 10560 {}
C {lab_pin.sym} 1860 10560 0 0 {name=l8530 lab=VSS}
C {bitcell_6t.sym} 2000 10600 0 0 {name=Xr53c10}
N 1960 10640 1940 10640 {}
C {lab_pin.sym} 1940 10640 0 0 {name=l8531 lab=BL10}
N 1960 10600 1940 10600 {}
C {lab_pin.sym} 1940 10600 0 0 {name=l8532 lab=BLB10}
N 1960 10560 1940 10560 {}
C {lab_pin.sym} 1940 10560 0 0 {name=l8533 lab=WL53}
N 2040 10640 2060 10640 {}
C {lab_pin.sym} 2060 10640 0 0 {name=l8534 lab=VDD}
N 2040 10560 2060 10560 {}
C {lab_pin.sym} 2060 10560 0 0 {name=l8535 lab=VSS}
C {bitcell_6t.sym} 2200 10600 0 0 {name=Xr53c11}
N 2160 10640 2140 10640 {}
C {lab_pin.sym} 2140 10640 0 0 {name=l8536 lab=BL11}
N 2160 10600 2140 10600 {}
C {lab_pin.sym} 2140 10600 0 0 {name=l8537 lab=BLB11}
N 2160 10560 2140 10560 {}
C {lab_pin.sym} 2140 10560 0 0 {name=l8538 lab=WL53}
N 2240 10640 2260 10640 {}
C {lab_pin.sym} 2260 10640 0 0 {name=l8539 lab=VDD}
N 2240 10560 2260 10560 {}
C {lab_pin.sym} 2260 10560 0 0 {name=l8540 lab=VSS}
C {bitcell_6t.sym} 2400 10600 0 0 {name=Xr53c12}
N 2360 10640 2340 10640 {}
C {lab_pin.sym} 2340 10640 0 0 {name=l8541 lab=BL12}
N 2360 10600 2340 10600 {}
C {lab_pin.sym} 2340 10600 0 0 {name=l8542 lab=BLB12}
N 2360 10560 2340 10560 {}
C {lab_pin.sym} 2340 10560 0 0 {name=l8543 lab=WL53}
N 2440 10640 2460 10640 {}
C {lab_pin.sym} 2460 10640 0 0 {name=l8544 lab=VDD}
N 2440 10560 2460 10560 {}
C {lab_pin.sym} 2460 10560 0 0 {name=l8545 lab=VSS}
C {bitcell_6t.sym} 2600 10600 0 0 {name=Xr53c13}
N 2560 10640 2540 10640 {}
C {lab_pin.sym} 2540 10640 0 0 {name=l8546 lab=BL13}
N 2560 10600 2540 10600 {}
C {lab_pin.sym} 2540 10600 0 0 {name=l8547 lab=BLB13}
N 2560 10560 2540 10560 {}
C {lab_pin.sym} 2540 10560 0 0 {name=l8548 lab=WL53}
N 2640 10640 2660 10640 {}
C {lab_pin.sym} 2660 10640 0 0 {name=l8549 lab=VDD}
N 2640 10560 2660 10560 {}
C {lab_pin.sym} 2660 10560 0 0 {name=l8550 lab=VSS}
C {bitcell_6t.sym} 2800 10600 0 0 {name=Xr53c14}
N 2760 10640 2740 10640 {}
C {lab_pin.sym} 2740 10640 0 0 {name=l8551 lab=BL14}
N 2760 10600 2740 10600 {}
C {lab_pin.sym} 2740 10600 0 0 {name=l8552 lab=BLB14}
N 2760 10560 2740 10560 {}
C {lab_pin.sym} 2740 10560 0 0 {name=l8553 lab=WL53}
N 2840 10640 2860 10640 {}
C {lab_pin.sym} 2860 10640 0 0 {name=l8554 lab=VDD}
N 2840 10560 2860 10560 {}
C {lab_pin.sym} 2860 10560 0 0 {name=l8555 lab=VSS}
C {bitcell_6t.sym} 3000 10600 0 0 {name=Xr53c15}
N 2960 10640 2940 10640 {}
C {lab_pin.sym} 2940 10640 0 0 {name=l8556 lab=BL15}
N 2960 10600 2940 10600 {}
C {lab_pin.sym} 2940 10600 0 0 {name=l8557 lab=BLB15}
N 2960 10560 2940 10560 {}
C {lab_pin.sym} 2940 10560 0 0 {name=l8558 lab=WL53}
N 3040 10640 3060 10640 {}
C {lab_pin.sym} 3060 10640 0 0 {name=l8559 lab=VDD}
N 3040 10560 3060 10560 {}
C {lab_pin.sym} 3060 10560 0 0 {name=l8560 lab=VSS}
C {bitcell_6t.sym} 3200 10600 0 0 {name=Xr53c16}
N 3160 10640 3140 10640 {}
C {lab_pin.sym} 3140 10640 0 0 {name=l8561 lab=BL16}
N 3160 10600 3140 10600 {}
C {lab_pin.sym} 3140 10600 0 0 {name=l8562 lab=BLB16}
N 3160 10560 3140 10560 {}
C {lab_pin.sym} 3140 10560 0 0 {name=l8563 lab=WL53}
N 3240 10640 3260 10640 {}
C {lab_pin.sym} 3260 10640 0 0 {name=l8564 lab=VDD}
N 3240 10560 3260 10560 {}
C {lab_pin.sym} 3260 10560 0 0 {name=l8565 lab=VSS}
C {bitcell_6t.sym} 3400 10600 0 0 {name=Xr53c17}
N 3360 10640 3340 10640 {}
C {lab_pin.sym} 3340 10640 0 0 {name=l8566 lab=BL17}
N 3360 10600 3340 10600 {}
C {lab_pin.sym} 3340 10600 0 0 {name=l8567 lab=BLB17}
N 3360 10560 3340 10560 {}
C {lab_pin.sym} 3340 10560 0 0 {name=l8568 lab=WL53}
N 3440 10640 3460 10640 {}
C {lab_pin.sym} 3460 10640 0 0 {name=l8569 lab=VDD}
N 3440 10560 3460 10560 {}
C {lab_pin.sym} 3460 10560 0 0 {name=l8570 lab=VSS}
C {bitcell_6t.sym} 3600 10600 0 0 {name=Xr53c18}
N 3560 10640 3540 10640 {}
C {lab_pin.sym} 3540 10640 0 0 {name=l8571 lab=BL18}
N 3560 10600 3540 10600 {}
C {lab_pin.sym} 3540 10600 0 0 {name=l8572 lab=BLB18}
N 3560 10560 3540 10560 {}
C {lab_pin.sym} 3540 10560 0 0 {name=l8573 lab=WL53}
N 3640 10640 3660 10640 {}
C {lab_pin.sym} 3660 10640 0 0 {name=l8574 lab=VDD}
N 3640 10560 3660 10560 {}
C {lab_pin.sym} 3660 10560 0 0 {name=l8575 lab=VSS}
C {bitcell_6t.sym} 3800 10600 0 0 {name=Xr53c19}
N 3760 10640 3740 10640 {}
C {lab_pin.sym} 3740 10640 0 0 {name=l8576 lab=BL19}
N 3760 10600 3740 10600 {}
C {lab_pin.sym} 3740 10600 0 0 {name=l8577 lab=BLB19}
N 3760 10560 3740 10560 {}
C {lab_pin.sym} 3740 10560 0 0 {name=l8578 lab=WL53}
N 3840 10640 3860 10640 {}
C {lab_pin.sym} 3860 10640 0 0 {name=l8579 lab=VDD}
N 3840 10560 3860 10560 {}
C {lab_pin.sym} 3860 10560 0 0 {name=l8580 lab=VSS}
C {bitcell_6t.sym} 4000 10600 0 0 {name=Xr53c20}
N 3960 10640 3940 10640 {}
C {lab_pin.sym} 3940 10640 0 0 {name=l8581 lab=BL20}
N 3960 10600 3940 10600 {}
C {lab_pin.sym} 3940 10600 0 0 {name=l8582 lab=BLB20}
N 3960 10560 3940 10560 {}
C {lab_pin.sym} 3940 10560 0 0 {name=l8583 lab=WL53}
N 4040 10640 4060 10640 {}
C {lab_pin.sym} 4060 10640 0 0 {name=l8584 lab=VDD}
N 4040 10560 4060 10560 {}
C {lab_pin.sym} 4060 10560 0 0 {name=l8585 lab=VSS}
C {bitcell_6t.sym} 4200 10600 0 0 {name=Xr53c21}
N 4160 10640 4140 10640 {}
C {lab_pin.sym} 4140 10640 0 0 {name=l8586 lab=BL21}
N 4160 10600 4140 10600 {}
C {lab_pin.sym} 4140 10600 0 0 {name=l8587 lab=BLB21}
N 4160 10560 4140 10560 {}
C {lab_pin.sym} 4140 10560 0 0 {name=l8588 lab=WL53}
N 4240 10640 4260 10640 {}
C {lab_pin.sym} 4260 10640 0 0 {name=l8589 lab=VDD}
N 4240 10560 4260 10560 {}
C {lab_pin.sym} 4260 10560 0 0 {name=l8590 lab=VSS}
C {bitcell_6t.sym} 4400 10600 0 0 {name=Xr53c22}
N 4360 10640 4340 10640 {}
C {lab_pin.sym} 4340 10640 0 0 {name=l8591 lab=BL22}
N 4360 10600 4340 10600 {}
C {lab_pin.sym} 4340 10600 0 0 {name=l8592 lab=BLB22}
N 4360 10560 4340 10560 {}
C {lab_pin.sym} 4340 10560 0 0 {name=l8593 lab=WL53}
N 4440 10640 4460 10640 {}
C {lab_pin.sym} 4460 10640 0 0 {name=l8594 lab=VDD}
N 4440 10560 4460 10560 {}
C {lab_pin.sym} 4460 10560 0 0 {name=l8595 lab=VSS}
C {bitcell_6t.sym} 4600 10600 0 0 {name=Xr53c23}
N 4560 10640 4540 10640 {}
C {lab_pin.sym} 4540 10640 0 0 {name=l8596 lab=BL23}
N 4560 10600 4540 10600 {}
C {lab_pin.sym} 4540 10600 0 0 {name=l8597 lab=BLB23}
N 4560 10560 4540 10560 {}
C {lab_pin.sym} 4540 10560 0 0 {name=l8598 lab=WL53}
N 4640 10640 4660 10640 {}
C {lab_pin.sym} 4660 10640 0 0 {name=l8599 lab=VDD}
N 4640 10560 4660 10560 {}
C {lab_pin.sym} 4660 10560 0 0 {name=l8600 lab=VSS}
C {bitcell_6t.sym} 4800 10600 0 0 {name=Xr53c24}
N 4760 10640 4740 10640 {}
C {lab_pin.sym} 4740 10640 0 0 {name=l8601 lab=BL24}
N 4760 10600 4740 10600 {}
C {lab_pin.sym} 4740 10600 0 0 {name=l8602 lab=BLB24}
N 4760 10560 4740 10560 {}
C {lab_pin.sym} 4740 10560 0 0 {name=l8603 lab=WL53}
N 4840 10640 4860 10640 {}
C {lab_pin.sym} 4860 10640 0 0 {name=l8604 lab=VDD}
N 4840 10560 4860 10560 {}
C {lab_pin.sym} 4860 10560 0 0 {name=l8605 lab=VSS}
C {bitcell_6t.sym} 5000 10600 0 0 {name=Xr53c25}
N 4960 10640 4940 10640 {}
C {lab_pin.sym} 4940 10640 0 0 {name=l8606 lab=BL25}
N 4960 10600 4940 10600 {}
C {lab_pin.sym} 4940 10600 0 0 {name=l8607 lab=BLB25}
N 4960 10560 4940 10560 {}
C {lab_pin.sym} 4940 10560 0 0 {name=l8608 lab=WL53}
N 5040 10640 5060 10640 {}
C {lab_pin.sym} 5060 10640 0 0 {name=l8609 lab=VDD}
N 5040 10560 5060 10560 {}
C {lab_pin.sym} 5060 10560 0 0 {name=l8610 lab=VSS}
C {bitcell_6t.sym} 5200 10600 0 0 {name=Xr53c26}
N 5160 10640 5140 10640 {}
C {lab_pin.sym} 5140 10640 0 0 {name=l8611 lab=BL26}
N 5160 10600 5140 10600 {}
C {lab_pin.sym} 5140 10600 0 0 {name=l8612 lab=BLB26}
N 5160 10560 5140 10560 {}
C {lab_pin.sym} 5140 10560 0 0 {name=l8613 lab=WL53}
N 5240 10640 5260 10640 {}
C {lab_pin.sym} 5260 10640 0 0 {name=l8614 lab=VDD}
N 5240 10560 5260 10560 {}
C {lab_pin.sym} 5260 10560 0 0 {name=l8615 lab=VSS}
C {bitcell_6t.sym} 5400 10600 0 0 {name=Xr53c27}
N 5360 10640 5340 10640 {}
C {lab_pin.sym} 5340 10640 0 0 {name=l8616 lab=BL27}
N 5360 10600 5340 10600 {}
C {lab_pin.sym} 5340 10600 0 0 {name=l8617 lab=BLB27}
N 5360 10560 5340 10560 {}
C {lab_pin.sym} 5340 10560 0 0 {name=l8618 lab=WL53}
N 5440 10640 5460 10640 {}
C {lab_pin.sym} 5460 10640 0 0 {name=l8619 lab=VDD}
N 5440 10560 5460 10560 {}
C {lab_pin.sym} 5460 10560 0 0 {name=l8620 lab=VSS}
C {bitcell_6t.sym} 5600 10600 0 0 {name=Xr53c28}
N 5560 10640 5540 10640 {}
C {lab_pin.sym} 5540 10640 0 0 {name=l8621 lab=BL28}
N 5560 10600 5540 10600 {}
C {lab_pin.sym} 5540 10600 0 0 {name=l8622 lab=BLB28}
N 5560 10560 5540 10560 {}
C {lab_pin.sym} 5540 10560 0 0 {name=l8623 lab=WL53}
N 5640 10640 5660 10640 {}
C {lab_pin.sym} 5660 10640 0 0 {name=l8624 lab=VDD}
N 5640 10560 5660 10560 {}
C {lab_pin.sym} 5660 10560 0 0 {name=l8625 lab=VSS}
C {bitcell_6t.sym} 5800 10600 0 0 {name=Xr53c29}
N 5760 10640 5740 10640 {}
C {lab_pin.sym} 5740 10640 0 0 {name=l8626 lab=BL29}
N 5760 10600 5740 10600 {}
C {lab_pin.sym} 5740 10600 0 0 {name=l8627 lab=BLB29}
N 5760 10560 5740 10560 {}
C {lab_pin.sym} 5740 10560 0 0 {name=l8628 lab=WL53}
N 5840 10640 5860 10640 {}
C {lab_pin.sym} 5860 10640 0 0 {name=l8629 lab=VDD}
N 5840 10560 5860 10560 {}
C {lab_pin.sym} 5860 10560 0 0 {name=l8630 lab=VSS}
C {bitcell_6t.sym} 6000 10600 0 0 {name=Xr53c30}
N 5960 10640 5940 10640 {}
C {lab_pin.sym} 5940 10640 0 0 {name=l8631 lab=BL30}
N 5960 10600 5940 10600 {}
C {lab_pin.sym} 5940 10600 0 0 {name=l8632 lab=BLB30}
N 5960 10560 5940 10560 {}
C {lab_pin.sym} 5940 10560 0 0 {name=l8633 lab=WL53}
N 6040 10640 6060 10640 {}
C {lab_pin.sym} 6060 10640 0 0 {name=l8634 lab=VDD}
N 6040 10560 6060 10560 {}
C {lab_pin.sym} 6060 10560 0 0 {name=l8635 lab=VSS}
C {bitcell_6t.sym} 6200 10600 0 0 {name=Xr53c31}
N 6160 10640 6140 10640 {}
C {lab_pin.sym} 6140 10640 0 0 {name=l8636 lab=BL31}
N 6160 10600 6140 10600 {}
C {lab_pin.sym} 6140 10600 0 0 {name=l8637 lab=BLB31}
N 6160 10560 6140 10560 {}
C {lab_pin.sym} 6140 10560 0 0 {name=l8638 lab=WL53}
N 6240 10640 6260 10640 {}
C {lab_pin.sym} 6260 10640 0 0 {name=l8639 lab=VDD}
N 6240 10560 6260 10560 {}
C {lab_pin.sym} 6260 10560 0 0 {name=l8640 lab=VSS}
C {bitcell_6t.sym} 0 10800 0 0 {name=Xr54c0}
N -40 10840 -60 10840 {}
C {lab_pin.sym} -60 10840 0 0 {name=l8641 lab=BL0}
N -40 10800 -60 10800 {}
C {lab_pin.sym} -60 10800 0 0 {name=l8642 lab=BLB0}
N -40 10760 -60 10760 {}
C {lab_pin.sym} -60 10760 0 0 {name=l8643 lab=WL54}
N 40 10840 60 10840 {}
C {lab_pin.sym} 60 10840 0 0 {name=l8644 lab=VDD}
N 40 10760 60 10760 {}
C {lab_pin.sym} 60 10760 0 0 {name=l8645 lab=VSS}
C {bitcell_6t.sym} 200 10800 0 0 {name=Xr54c1}
N 160 10840 140 10840 {}
C {lab_pin.sym} 140 10840 0 0 {name=l8646 lab=BL1}
N 160 10800 140 10800 {}
C {lab_pin.sym} 140 10800 0 0 {name=l8647 lab=BLB1}
N 160 10760 140 10760 {}
C {lab_pin.sym} 140 10760 0 0 {name=l8648 lab=WL54}
N 240 10840 260 10840 {}
C {lab_pin.sym} 260 10840 0 0 {name=l8649 lab=VDD}
N 240 10760 260 10760 {}
C {lab_pin.sym} 260 10760 0 0 {name=l8650 lab=VSS}
C {bitcell_6t.sym} 400 10800 0 0 {name=Xr54c2}
N 360 10840 340 10840 {}
C {lab_pin.sym} 340 10840 0 0 {name=l8651 lab=BL2}
N 360 10800 340 10800 {}
C {lab_pin.sym} 340 10800 0 0 {name=l8652 lab=BLB2}
N 360 10760 340 10760 {}
C {lab_pin.sym} 340 10760 0 0 {name=l8653 lab=WL54}
N 440 10840 460 10840 {}
C {lab_pin.sym} 460 10840 0 0 {name=l8654 lab=VDD}
N 440 10760 460 10760 {}
C {lab_pin.sym} 460 10760 0 0 {name=l8655 lab=VSS}
C {bitcell_6t.sym} 600 10800 0 0 {name=Xr54c3}
N 560 10840 540 10840 {}
C {lab_pin.sym} 540 10840 0 0 {name=l8656 lab=BL3}
N 560 10800 540 10800 {}
C {lab_pin.sym} 540 10800 0 0 {name=l8657 lab=BLB3}
N 560 10760 540 10760 {}
C {lab_pin.sym} 540 10760 0 0 {name=l8658 lab=WL54}
N 640 10840 660 10840 {}
C {lab_pin.sym} 660 10840 0 0 {name=l8659 lab=VDD}
N 640 10760 660 10760 {}
C {lab_pin.sym} 660 10760 0 0 {name=l8660 lab=VSS}
C {bitcell_6t.sym} 800 10800 0 0 {name=Xr54c4}
N 760 10840 740 10840 {}
C {lab_pin.sym} 740 10840 0 0 {name=l8661 lab=BL4}
N 760 10800 740 10800 {}
C {lab_pin.sym} 740 10800 0 0 {name=l8662 lab=BLB4}
N 760 10760 740 10760 {}
C {lab_pin.sym} 740 10760 0 0 {name=l8663 lab=WL54}
N 840 10840 860 10840 {}
C {lab_pin.sym} 860 10840 0 0 {name=l8664 lab=VDD}
N 840 10760 860 10760 {}
C {lab_pin.sym} 860 10760 0 0 {name=l8665 lab=VSS}
C {bitcell_6t.sym} 1000 10800 0 0 {name=Xr54c5}
N 960 10840 940 10840 {}
C {lab_pin.sym} 940 10840 0 0 {name=l8666 lab=BL5}
N 960 10800 940 10800 {}
C {lab_pin.sym} 940 10800 0 0 {name=l8667 lab=BLB5}
N 960 10760 940 10760 {}
C {lab_pin.sym} 940 10760 0 0 {name=l8668 lab=WL54}
N 1040 10840 1060 10840 {}
C {lab_pin.sym} 1060 10840 0 0 {name=l8669 lab=VDD}
N 1040 10760 1060 10760 {}
C {lab_pin.sym} 1060 10760 0 0 {name=l8670 lab=VSS}
C {bitcell_6t.sym} 1200 10800 0 0 {name=Xr54c6}
N 1160 10840 1140 10840 {}
C {lab_pin.sym} 1140 10840 0 0 {name=l8671 lab=BL6}
N 1160 10800 1140 10800 {}
C {lab_pin.sym} 1140 10800 0 0 {name=l8672 lab=BLB6}
N 1160 10760 1140 10760 {}
C {lab_pin.sym} 1140 10760 0 0 {name=l8673 lab=WL54}
N 1240 10840 1260 10840 {}
C {lab_pin.sym} 1260 10840 0 0 {name=l8674 lab=VDD}
N 1240 10760 1260 10760 {}
C {lab_pin.sym} 1260 10760 0 0 {name=l8675 lab=VSS}
C {bitcell_6t.sym} 1400 10800 0 0 {name=Xr54c7}
N 1360 10840 1340 10840 {}
C {lab_pin.sym} 1340 10840 0 0 {name=l8676 lab=BL7}
N 1360 10800 1340 10800 {}
C {lab_pin.sym} 1340 10800 0 0 {name=l8677 lab=BLB7}
N 1360 10760 1340 10760 {}
C {lab_pin.sym} 1340 10760 0 0 {name=l8678 lab=WL54}
N 1440 10840 1460 10840 {}
C {lab_pin.sym} 1460 10840 0 0 {name=l8679 lab=VDD}
N 1440 10760 1460 10760 {}
C {lab_pin.sym} 1460 10760 0 0 {name=l8680 lab=VSS}
C {bitcell_6t.sym} 1600 10800 0 0 {name=Xr54c8}
N 1560 10840 1540 10840 {}
C {lab_pin.sym} 1540 10840 0 0 {name=l8681 lab=BL8}
N 1560 10800 1540 10800 {}
C {lab_pin.sym} 1540 10800 0 0 {name=l8682 lab=BLB8}
N 1560 10760 1540 10760 {}
C {lab_pin.sym} 1540 10760 0 0 {name=l8683 lab=WL54}
N 1640 10840 1660 10840 {}
C {lab_pin.sym} 1660 10840 0 0 {name=l8684 lab=VDD}
N 1640 10760 1660 10760 {}
C {lab_pin.sym} 1660 10760 0 0 {name=l8685 lab=VSS}
C {bitcell_6t.sym} 1800 10800 0 0 {name=Xr54c9}
N 1760 10840 1740 10840 {}
C {lab_pin.sym} 1740 10840 0 0 {name=l8686 lab=BL9}
N 1760 10800 1740 10800 {}
C {lab_pin.sym} 1740 10800 0 0 {name=l8687 lab=BLB9}
N 1760 10760 1740 10760 {}
C {lab_pin.sym} 1740 10760 0 0 {name=l8688 lab=WL54}
N 1840 10840 1860 10840 {}
C {lab_pin.sym} 1860 10840 0 0 {name=l8689 lab=VDD}
N 1840 10760 1860 10760 {}
C {lab_pin.sym} 1860 10760 0 0 {name=l8690 lab=VSS}
C {bitcell_6t.sym} 2000 10800 0 0 {name=Xr54c10}
N 1960 10840 1940 10840 {}
C {lab_pin.sym} 1940 10840 0 0 {name=l8691 lab=BL10}
N 1960 10800 1940 10800 {}
C {lab_pin.sym} 1940 10800 0 0 {name=l8692 lab=BLB10}
N 1960 10760 1940 10760 {}
C {lab_pin.sym} 1940 10760 0 0 {name=l8693 lab=WL54}
N 2040 10840 2060 10840 {}
C {lab_pin.sym} 2060 10840 0 0 {name=l8694 lab=VDD}
N 2040 10760 2060 10760 {}
C {lab_pin.sym} 2060 10760 0 0 {name=l8695 lab=VSS}
C {bitcell_6t.sym} 2200 10800 0 0 {name=Xr54c11}
N 2160 10840 2140 10840 {}
C {lab_pin.sym} 2140 10840 0 0 {name=l8696 lab=BL11}
N 2160 10800 2140 10800 {}
C {lab_pin.sym} 2140 10800 0 0 {name=l8697 lab=BLB11}
N 2160 10760 2140 10760 {}
C {lab_pin.sym} 2140 10760 0 0 {name=l8698 lab=WL54}
N 2240 10840 2260 10840 {}
C {lab_pin.sym} 2260 10840 0 0 {name=l8699 lab=VDD}
N 2240 10760 2260 10760 {}
C {lab_pin.sym} 2260 10760 0 0 {name=l8700 lab=VSS}
C {bitcell_6t.sym} 2400 10800 0 0 {name=Xr54c12}
N 2360 10840 2340 10840 {}
C {lab_pin.sym} 2340 10840 0 0 {name=l8701 lab=BL12}
N 2360 10800 2340 10800 {}
C {lab_pin.sym} 2340 10800 0 0 {name=l8702 lab=BLB12}
N 2360 10760 2340 10760 {}
C {lab_pin.sym} 2340 10760 0 0 {name=l8703 lab=WL54}
N 2440 10840 2460 10840 {}
C {lab_pin.sym} 2460 10840 0 0 {name=l8704 lab=VDD}
N 2440 10760 2460 10760 {}
C {lab_pin.sym} 2460 10760 0 0 {name=l8705 lab=VSS}
C {bitcell_6t.sym} 2600 10800 0 0 {name=Xr54c13}
N 2560 10840 2540 10840 {}
C {lab_pin.sym} 2540 10840 0 0 {name=l8706 lab=BL13}
N 2560 10800 2540 10800 {}
C {lab_pin.sym} 2540 10800 0 0 {name=l8707 lab=BLB13}
N 2560 10760 2540 10760 {}
C {lab_pin.sym} 2540 10760 0 0 {name=l8708 lab=WL54}
N 2640 10840 2660 10840 {}
C {lab_pin.sym} 2660 10840 0 0 {name=l8709 lab=VDD}
N 2640 10760 2660 10760 {}
C {lab_pin.sym} 2660 10760 0 0 {name=l8710 lab=VSS}
C {bitcell_6t.sym} 2800 10800 0 0 {name=Xr54c14}
N 2760 10840 2740 10840 {}
C {lab_pin.sym} 2740 10840 0 0 {name=l8711 lab=BL14}
N 2760 10800 2740 10800 {}
C {lab_pin.sym} 2740 10800 0 0 {name=l8712 lab=BLB14}
N 2760 10760 2740 10760 {}
C {lab_pin.sym} 2740 10760 0 0 {name=l8713 lab=WL54}
N 2840 10840 2860 10840 {}
C {lab_pin.sym} 2860 10840 0 0 {name=l8714 lab=VDD}
N 2840 10760 2860 10760 {}
C {lab_pin.sym} 2860 10760 0 0 {name=l8715 lab=VSS}
C {bitcell_6t.sym} 3000 10800 0 0 {name=Xr54c15}
N 2960 10840 2940 10840 {}
C {lab_pin.sym} 2940 10840 0 0 {name=l8716 lab=BL15}
N 2960 10800 2940 10800 {}
C {lab_pin.sym} 2940 10800 0 0 {name=l8717 lab=BLB15}
N 2960 10760 2940 10760 {}
C {lab_pin.sym} 2940 10760 0 0 {name=l8718 lab=WL54}
N 3040 10840 3060 10840 {}
C {lab_pin.sym} 3060 10840 0 0 {name=l8719 lab=VDD}
N 3040 10760 3060 10760 {}
C {lab_pin.sym} 3060 10760 0 0 {name=l8720 lab=VSS}
C {bitcell_6t.sym} 3200 10800 0 0 {name=Xr54c16}
N 3160 10840 3140 10840 {}
C {lab_pin.sym} 3140 10840 0 0 {name=l8721 lab=BL16}
N 3160 10800 3140 10800 {}
C {lab_pin.sym} 3140 10800 0 0 {name=l8722 lab=BLB16}
N 3160 10760 3140 10760 {}
C {lab_pin.sym} 3140 10760 0 0 {name=l8723 lab=WL54}
N 3240 10840 3260 10840 {}
C {lab_pin.sym} 3260 10840 0 0 {name=l8724 lab=VDD}
N 3240 10760 3260 10760 {}
C {lab_pin.sym} 3260 10760 0 0 {name=l8725 lab=VSS}
C {bitcell_6t.sym} 3400 10800 0 0 {name=Xr54c17}
N 3360 10840 3340 10840 {}
C {lab_pin.sym} 3340 10840 0 0 {name=l8726 lab=BL17}
N 3360 10800 3340 10800 {}
C {lab_pin.sym} 3340 10800 0 0 {name=l8727 lab=BLB17}
N 3360 10760 3340 10760 {}
C {lab_pin.sym} 3340 10760 0 0 {name=l8728 lab=WL54}
N 3440 10840 3460 10840 {}
C {lab_pin.sym} 3460 10840 0 0 {name=l8729 lab=VDD}
N 3440 10760 3460 10760 {}
C {lab_pin.sym} 3460 10760 0 0 {name=l8730 lab=VSS}
C {bitcell_6t.sym} 3600 10800 0 0 {name=Xr54c18}
N 3560 10840 3540 10840 {}
C {lab_pin.sym} 3540 10840 0 0 {name=l8731 lab=BL18}
N 3560 10800 3540 10800 {}
C {lab_pin.sym} 3540 10800 0 0 {name=l8732 lab=BLB18}
N 3560 10760 3540 10760 {}
C {lab_pin.sym} 3540 10760 0 0 {name=l8733 lab=WL54}
N 3640 10840 3660 10840 {}
C {lab_pin.sym} 3660 10840 0 0 {name=l8734 lab=VDD}
N 3640 10760 3660 10760 {}
C {lab_pin.sym} 3660 10760 0 0 {name=l8735 lab=VSS}
C {bitcell_6t.sym} 3800 10800 0 0 {name=Xr54c19}
N 3760 10840 3740 10840 {}
C {lab_pin.sym} 3740 10840 0 0 {name=l8736 lab=BL19}
N 3760 10800 3740 10800 {}
C {lab_pin.sym} 3740 10800 0 0 {name=l8737 lab=BLB19}
N 3760 10760 3740 10760 {}
C {lab_pin.sym} 3740 10760 0 0 {name=l8738 lab=WL54}
N 3840 10840 3860 10840 {}
C {lab_pin.sym} 3860 10840 0 0 {name=l8739 lab=VDD}
N 3840 10760 3860 10760 {}
C {lab_pin.sym} 3860 10760 0 0 {name=l8740 lab=VSS}
C {bitcell_6t.sym} 4000 10800 0 0 {name=Xr54c20}
N 3960 10840 3940 10840 {}
C {lab_pin.sym} 3940 10840 0 0 {name=l8741 lab=BL20}
N 3960 10800 3940 10800 {}
C {lab_pin.sym} 3940 10800 0 0 {name=l8742 lab=BLB20}
N 3960 10760 3940 10760 {}
C {lab_pin.sym} 3940 10760 0 0 {name=l8743 lab=WL54}
N 4040 10840 4060 10840 {}
C {lab_pin.sym} 4060 10840 0 0 {name=l8744 lab=VDD}
N 4040 10760 4060 10760 {}
C {lab_pin.sym} 4060 10760 0 0 {name=l8745 lab=VSS}
C {bitcell_6t.sym} 4200 10800 0 0 {name=Xr54c21}
N 4160 10840 4140 10840 {}
C {lab_pin.sym} 4140 10840 0 0 {name=l8746 lab=BL21}
N 4160 10800 4140 10800 {}
C {lab_pin.sym} 4140 10800 0 0 {name=l8747 lab=BLB21}
N 4160 10760 4140 10760 {}
C {lab_pin.sym} 4140 10760 0 0 {name=l8748 lab=WL54}
N 4240 10840 4260 10840 {}
C {lab_pin.sym} 4260 10840 0 0 {name=l8749 lab=VDD}
N 4240 10760 4260 10760 {}
C {lab_pin.sym} 4260 10760 0 0 {name=l8750 lab=VSS}
C {bitcell_6t.sym} 4400 10800 0 0 {name=Xr54c22}
N 4360 10840 4340 10840 {}
C {lab_pin.sym} 4340 10840 0 0 {name=l8751 lab=BL22}
N 4360 10800 4340 10800 {}
C {lab_pin.sym} 4340 10800 0 0 {name=l8752 lab=BLB22}
N 4360 10760 4340 10760 {}
C {lab_pin.sym} 4340 10760 0 0 {name=l8753 lab=WL54}
N 4440 10840 4460 10840 {}
C {lab_pin.sym} 4460 10840 0 0 {name=l8754 lab=VDD}
N 4440 10760 4460 10760 {}
C {lab_pin.sym} 4460 10760 0 0 {name=l8755 lab=VSS}
C {bitcell_6t.sym} 4600 10800 0 0 {name=Xr54c23}
N 4560 10840 4540 10840 {}
C {lab_pin.sym} 4540 10840 0 0 {name=l8756 lab=BL23}
N 4560 10800 4540 10800 {}
C {lab_pin.sym} 4540 10800 0 0 {name=l8757 lab=BLB23}
N 4560 10760 4540 10760 {}
C {lab_pin.sym} 4540 10760 0 0 {name=l8758 lab=WL54}
N 4640 10840 4660 10840 {}
C {lab_pin.sym} 4660 10840 0 0 {name=l8759 lab=VDD}
N 4640 10760 4660 10760 {}
C {lab_pin.sym} 4660 10760 0 0 {name=l8760 lab=VSS}
C {bitcell_6t.sym} 4800 10800 0 0 {name=Xr54c24}
N 4760 10840 4740 10840 {}
C {lab_pin.sym} 4740 10840 0 0 {name=l8761 lab=BL24}
N 4760 10800 4740 10800 {}
C {lab_pin.sym} 4740 10800 0 0 {name=l8762 lab=BLB24}
N 4760 10760 4740 10760 {}
C {lab_pin.sym} 4740 10760 0 0 {name=l8763 lab=WL54}
N 4840 10840 4860 10840 {}
C {lab_pin.sym} 4860 10840 0 0 {name=l8764 lab=VDD}
N 4840 10760 4860 10760 {}
C {lab_pin.sym} 4860 10760 0 0 {name=l8765 lab=VSS}
C {bitcell_6t.sym} 5000 10800 0 0 {name=Xr54c25}
N 4960 10840 4940 10840 {}
C {lab_pin.sym} 4940 10840 0 0 {name=l8766 lab=BL25}
N 4960 10800 4940 10800 {}
C {lab_pin.sym} 4940 10800 0 0 {name=l8767 lab=BLB25}
N 4960 10760 4940 10760 {}
C {lab_pin.sym} 4940 10760 0 0 {name=l8768 lab=WL54}
N 5040 10840 5060 10840 {}
C {lab_pin.sym} 5060 10840 0 0 {name=l8769 lab=VDD}
N 5040 10760 5060 10760 {}
C {lab_pin.sym} 5060 10760 0 0 {name=l8770 lab=VSS}
C {bitcell_6t.sym} 5200 10800 0 0 {name=Xr54c26}
N 5160 10840 5140 10840 {}
C {lab_pin.sym} 5140 10840 0 0 {name=l8771 lab=BL26}
N 5160 10800 5140 10800 {}
C {lab_pin.sym} 5140 10800 0 0 {name=l8772 lab=BLB26}
N 5160 10760 5140 10760 {}
C {lab_pin.sym} 5140 10760 0 0 {name=l8773 lab=WL54}
N 5240 10840 5260 10840 {}
C {lab_pin.sym} 5260 10840 0 0 {name=l8774 lab=VDD}
N 5240 10760 5260 10760 {}
C {lab_pin.sym} 5260 10760 0 0 {name=l8775 lab=VSS}
C {bitcell_6t.sym} 5400 10800 0 0 {name=Xr54c27}
N 5360 10840 5340 10840 {}
C {lab_pin.sym} 5340 10840 0 0 {name=l8776 lab=BL27}
N 5360 10800 5340 10800 {}
C {lab_pin.sym} 5340 10800 0 0 {name=l8777 lab=BLB27}
N 5360 10760 5340 10760 {}
C {lab_pin.sym} 5340 10760 0 0 {name=l8778 lab=WL54}
N 5440 10840 5460 10840 {}
C {lab_pin.sym} 5460 10840 0 0 {name=l8779 lab=VDD}
N 5440 10760 5460 10760 {}
C {lab_pin.sym} 5460 10760 0 0 {name=l8780 lab=VSS}
C {bitcell_6t.sym} 5600 10800 0 0 {name=Xr54c28}
N 5560 10840 5540 10840 {}
C {lab_pin.sym} 5540 10840 0 0 {name=l8781 lab=BL28}
N 5560 10800 5540 10800 {}
C {lab_pin.sym} 5540 10800 0 0 {name=l8782 lab=BLB28}
N 5560 10760 5540 10760 {}
C {lab_pin.sym} 5540 10760 0 0 {name=l8783 lab=WL54}
N 5640 10840 5660 10840 {}
C {lab_pin.sym} 5660 10840 0 0 {name=l8784 lab=VDD}
N 5640 10760 5660 10760 {}
C {lab_pin.sym} 5660 10760 0 0 {name=l8785 lab=VSS}
C {bitcell_6t.sym} 5800 10800 0 0 {name=Xr54c29}
N 5760 10840 5740 10840 {}
C {lab_pin.sym} 5740 10840 0 0 {name=l8786 lab=BL29}
N 5760 10800 5740 10800 {}
C {lab_pin.sym} 5740 10800 0 0 {name=l8787 lab=BLB29}
N 5760 10760 5740 10760 {}
C {lab_pin.sym} 5740 10760 0 0 {name=l8788 lab=WL54}
N 5840 10840 5860 10840 {}
C {lab_pin.sym} 5860 10840 0 0 {name=l8789 lab=VDD}
N 5840 10760 5860 10760 {}
C {lab_pin.sym} 5860 10760 0 0 {name=l8790 lab=VSS}
C {bitcell_6t.sym} 6000 10800 0 0 {name=Xr54c30}
N 5960 10840 5940 10840 {}
C {lab_pin.sym} 5940 10840 0 0 {name=l8791 lab=BL30}
N 5960 10800 5940 10800 {}
C {lab_pin.sym} 5940 10800 0 0 {name=l8792 lab=BLB30}
N 5960 10760 5940 10760 {}
C {lab_pin.sym} 5940 10760 0 0 {name=l8793 lab=WL54}
N 6040 10840 6060 10840 {}
C {lab_pin.sym} 6060 10840 0 0 {name=l8794 lab=VDD}
N 6040 10760 6060 10760 {}
C {lab_pin.sym} 6060 10760 0 0 {name=l8795 lab=VSS}
C {bitcell_6t.sym} 6200 10800 0 0 {name=Xr54c31}
N 6160 10840 6140 10840 {}
C {lab_pin.sym} 6140 10840 0 0 {name=l8796 lab=BL31}
N 6160 10800 6140 10800 {}
C {lab_pin.sym} 6140 10800 0 0 {name=l8797 lab=BLB31}
N 6160 10760 6140 10760 {}
C {lab_pin.sym} 6140 10760 0 0 {name=l8798 lab=WL54}
N 6240 10840 6260 10840 {}
C {lab_pin.sym} 6260 10840 0 0 {name=l8799 lab=VDD}
N 6240 10760 6260 10760 {}
C {lab_pin.sym} 6260 10760 0 0 {name=l8800 lab=VSS}
C {bitcell_6t.sym} 0 11000 0 0 {name=Xr55c0}
N -40 11040 -60 11040 {}
C {lab_pin.sym} -60 11040 0 0 {name=l8801 lab=BL0}
N -40 11000 -60 11000 {}
C {lab_pin.sym} -60 11000 0 0 {name=l8802 lab=BLB0}
N -40 10960 -60 10960 {}
C {lab_pin.sym} -60 10960 0 0 {name=l8803 lab=WL55}
N 40 11040 60 11040 {}
C {lab_pin.sym} 60 11040 0 0 {name=l8804 lab=VDD}
N 40 10960 60 10960 {}
C {lab_pin.sym} 60 10960 0 0 {name=l8805 lab=VSS}
C {bitcell_6t.sym} 200 11000 0 0 {name=Xr55c1}
N 160 11040 140 11040 {}
C {lab_pin.sym} 140 11040 0 0 {name=l8806 lab=BL1}
N 160 11000 140 11000 {}
C {lab_pin.sym} 140 11000 0 0 {name=l8807 lab=BLB1}
N 160 10960 140 10960 {}
C {lab_pin.sym} 140 10960 0 0 {name=l8808 lab=WL55}
N 240 11040 260 11040 {}
C {lab_pin.sym} 260 11040 0 0 {name=l8809 lab=VDD}
N 240 10960 260 10960 {}
C {lab_pin.sym} 260 10960 0 0 {name=l8810 lab=VSS}
C {bitcell_6t.sym} 400 11000 0 0 {name=Xr55c2}
N 360 11040 340 11040 {}
C {lab_pin.sym} 340 11040 0 0 {name=l8811 lab=BL2}
N 360 11000 340 11000 {}
C {lab_pin.sym} 340 11000 0 0 {name=l8812 lab=BLB2}
N 360 10960 340 10960 {}
C {lab_pin.sym} 340 10960 0 0 {name=l8813 lab=WL55}
N 440 11040 460 11040 {}
C {lab_pin.sym} 460 11040 0 0 {name=l8814 lab=VDD}
N 440 10960 460 10960 {}
C {lab_pin.sym} 460 10960 0 0 {name=l8815 lab=VSS}
C {bitcell_6t.sym} 600 11000 0 0 {name=Xr55c3}
N 560 11040 540 11040 {}
C {lab_pin.sym} 540 11040 0 0 {name=l8816 lab=BL3}
N 560 11000 540 11000 {}
C {lab_pin.sym} 540 11000 0 0 {name=l8817 lab=BLB3}
N 560 10960 540 10960 {}
C {lab_pin.sym} 540 10960 0 0 {name=l8818 lab=WL55}
N 640 11040 660 11040 {}
C {lab_pin.sym} 660 11040 0 0 {name=l8819 lab=VDD}
N 640 10960 660 10960 {}
C {lab_pin.sym} 660 10960 0 0 {name=l8820 lab=VSS}
C {bitcell_6t.sym} 800 11000 0 0 {name=Xr55c4}
N 760 11040 740 11040 {}
C {lab_pin.sym} 740 11040 0 0 {name=l8821 lab=BL4}
N 760 11000 740 11000 {}
C {lab_pin.sym} 740 11000 0 0 {name=l8822 lab=BLB4}
N 760 10960 740 10960 {}
C {lab_pin.sym} 740 10960 0 0 {name=l8823 lab=WL55}
N 840 11040 860 11040 {}
C {lab_pin.sym} 860 11040 0 0 {name=l8824 lab=VDD}
N 840 10960 860 10960 {}
C {lab_pin.sym} 860 10960 0 0 {name=l8825 lab=VSS}
C {bitcell_6t.sym} 1000 11000 0 0 {name=Xr55c5}
N 960 11040 940 11040 {}
C {lab_pin.sym} 940 11040 0 0 {name=l8826 lab=BL5}
N 960 11000 940 11000 {}
C {lab_pin.sym} 940 11000 0 0 {name=l8827 lab=BLB5}
N 960 10960 940 10960 {}
C {lab_pin.sym} 940 10960 0 0 {name=l8828 lab=WL55}
N 1040 11040 1060 11040 {}
C {lab_pin.sym} 1060 11040 0 0 {name=l8829 lab=VDD}
N 1040 10960 1060 10960 {}
C {lab_pin.sym} 1060 10960 0 0 {name=l8830 lab=VSS}
C {bitcell_6t.sym} 1200 11000 0 0 {name=Xr55c6}
N 1160 11040 1140 11040 {}
C {lab_pin.sym} 1140 11040 0 0 {name=l8831 lab=BL6}
N 1160 11000 1140 11000 {}
C {lab_pin.sym} 1140 11000 0 0 {name=l8832 lab=BLB6}
N 1160 10960 1140 10960 {}
C {lab_pin.sym} 1140 10960 0 0 {name=l8833 lab=WL55}
N 1240 11040 1260 11040 {}
C {lab_pin.sym} 1260 11040 0 0 {name=l8834 lab=VDD}
N 1240 10960 1260 10960 {}
C {lab_pin.sym} 1260 10960 0 0 {name=l8835 lab=VSS}
C {bitcell_6t.sym} 1400 11000 0 0 {name=Xr55c7}
N 1360 11040 1340 11040 {}
C {lab_pin.sym} 1340 11040 0 0 {name=l8836 lab=BL7}
N 1360 11000 1340 11000 {}
C {lab_pin.sym} 1340 11000 0 0 {name=l8837 lab=BLB7}
N 1360 10960 1340 10960 {}
C {lab_pin.sym} 1340 10960 0 0 {name=l8838 lab=WL55}
N 1440 11040 1460 11040 {}
C {lab_pin.sym} 1460 11040 0 0 {name=l8839 lab=VDD}
N 1440 10960 1460 10960 {}
C {lab_pin.sym} 1460 10960 0 0 {name=l8840 lab=VSS}
C {bitcell_6t.sym} 1600 11000 0 0 {name=Xr55c8}
N 1560 11040 1540 11040 {}
C {lab_pin.sym} 1540 11040 0 0 {name=l8841 lab=BL8}
N 1560 11000 1540 11000 {}
C {lab_pin.sym} 1540 11000 0 0 {name=l8842 lab=BLB8}
N 1560 10960 1540 10960 {}
C {lab_pin.sym} 1540 10960 0 0 {name=l8843 lab=WL55}
N 1640 11040 1660 11040 {}
C {lab_pin.sym} 1660 11040 0 0 {name=l8844 lab=VDD}
N 1640 10960 1660 10960 {}
C {lab_pin.sym} 1660 10960 0 0 {name=l8845 lab=VSS}
C {bitcell_6t.sym} 1800 11000 0 0 {name=Xr55c9}
N 1760 11040 1740 11040 {}
C {lab_pin.sym} 1740 11040 0 0 {name=l8846 lab=BL9}
N 1760 11000 1740 11000 {}
C {lab_pin.sym} 1740 11000 0 0 {name=l8847 lab=BLB9}
N 1760 10960 1740 10960 {}
C {lab_pin.sym} 1740 10960 0 0 {name=l8848 lab=WL55}
N 1840 11040 1860 11040 {}
C {lab_pin.sym} 1860 11040 0 0 {name=l8849 lab=VDD}
N 1840 10960 1860 10960 {}
C {lab_pin.sym} 1860 10960 0 0 {name=l8850 lab=VSS}
C {bitcell_6t.sym} 2000 11000 0 0 {name=Xr55c10}
N 1960 11040 1940 11040 {}
C {lab_pin.sym} 1940 11040 0 0 {name=l8851 lab=BL10}
N 1960 11000 1940 11000 {}
C {lab_pin.sym} 1940 11000 0 0 {name=l8852 lab=BLB10}
N 1960 10960 1940 10960 {}
C {lab_pin.sym} 1940 10960 0 0 {name=l8853 lab=WL55}
N 2040 11040 2060 11040 {}
C {lab_pin.sym} 2060 11040 0 0 {name=l8854 lab=VDD}
N 2040 10960 2060 10960 {}
C {lab_pin.sym} 2060 10960 0 0 {name=l8855 lab=VSS}
C {bitcell_6t.sym} 2200 11000 0 0 {name=Xr55c11}
N 2160 11040 2140 11040 {}
C {lab_pin.sym} 2140 11040 0 0 {name=l8856 lab=BL11}
N 2160 11000 2140 11000 {}
C {lab_pin.sym} 2140 11000 0 0 {name=l8857 lab=BLB11}
N 2160 10960 2140 10960 {}
C {lab_pin.sym} 2140 10960 0 0 {name=l8858 lab=WL55}
N 2240 11040 2260 11040 {}
C {lab_pin.sym} 2260 11040 0 0 {name=l8859 lab=VDD}
N 2240 10960 2260 10960 {}
C {lab_pin.sym} 2260 10960 0 0 {name=l8860 lab=VSS}
C {bitcell_6t.sym} 2400 11000 0 0 {name=Xr55c12}
N 2360 11040 2340 11040 {}
C {lab_pin.sym} 2340 11040 0 0 {name=l8861 lab=BL12}
N 2360 11000 2340 11000 {}
C {lab_pin.sym} 2340 11000 0 0 {name=l8862 lab=BLB12}
N 2360 10960 2340 10960 {}
C {lab_pin.sym} 2340 10960 0 0 {name=l8863 lab=WL55}
N 2440 11040 2460 11040 {}
C {lab_pin.sym} 2460 11040 0 0 {name=l8864 lab=VDD}
N 2440 10960 2460 10960 {}
C {lab_pin.sym} 2460 10960 0 0 {name=l8865 lab=VSS}
C {bitcell_6t.sym} 2600 11000 0 0 {name=Xr55c13}
N 2560 11040 2540 11040 {}
C {lab_pin.sym} 2540 11040 0 0 {name=l8866 lab=BL13}
N 2560 11000 2540 11000 {}
C {lab_pin.sym} 2540 11000 0 0 {name=l8867 lab=BLB13}
N 2560 10960 2540 10960 {}
C {lab_pin.sym} 2540 10960 0 0 {name=l8868 lab=WL55}
N 2640 11040 2660 11040 {}
C {lab_pin.sym} 2660 11040 0 0 {name=l8869 lab=VDD}
N 2640 10960 2660 10960 {}
C {lab_pin.sym} 2660 10960 0 0 {name=l8870 lab=VSS}
C {bitcell_6t.sym} 2800 11000 0 0 {name=Xr55c14}
N 2760 11040 2740 11040 {}
C {lab_pin.sym} 2740 11040 0 0 {name=l8871 lab=BL14}
N 2760 11000 2740 11000 {}
C {lab_pin.sym} 2740 11000 0 0 {name=l8872 lab=BLB14}
N 2760 10960 2740 10960 {}
C {lab_pin.sym} 2740 10960 0 0 {name=l8873 lab=WL55}
N 2840 11040 2860 11040 {}
C {lab_pin.sym} 2860 11040 0 0 {name=l8874 lab=VDD}
N 2840 10960 2860 10960 {}
C {lab_pin.sym} 2860 10960 0 0 {name=l8875 lab=VSS}
C {bitcell_6t.sym} 3000 11000 0 0 {name=Xr55c15}
N 2960 11040 2940 11040 {}
C {lab_pin.sym} 2940 11040 0 0 {name=l8876 lab=BL15}
N 2960 11000 2940 11000 {}
C {lab_pin.sym} 2940 11000 0 0 {name=l8877 lab=BLB15}
N 2960 10960 2940 10960 {}
C {lab_pin.sym} 2940 10960 0 0 {name=l8878 lab=WL55}
N 3040 11040 3060 11040 {}
C {lab_pin.sym} 3060 11040 0 0 {name=l8879 lab=VDD}
N 3040 10960 3060 10960 {}
C {lab_pin.sym} 3060 10960 0 0 {name=l8880 lab=VSS}
C {bitcell_6t.sym} 3200 11000 0 0 {name=Xr55c16}
N 3160 11040 3140 11040 {}
C {lab_pin.sym} 3140 11040 0 0 {name=l8881 lab=BL16}
N 3160 11000 3140 11000 {}
C {lab_pin.sym} 3140 11000 0 0 {name=l8882 lab=BLB16}
N 3160 10960 3140 10960 {}
C {lab_pin.sym} 3140 10960 0 0 {name=l8883 lab=WL55}
N 3240 11040 3260 11040 {}
C {lab_pin.sym} 3260 11040 0 0 {name=l8884 lab=VDD}
N 3240 10960 3260 10960 {}
C {lab_pin.sym} 3260 10960 0 0 {name=l8885 lab=VSS}
C {bitcell_6t.sym} 3400 11000 0 0 {name=Xr55c17}
N 3360 11040 3340 11040 {}
C {lab_pin.sym} 3340 11040 0 0 {name=l8886 lab=BL17}
N 3360 11000 3340 11000 {}
C {lab_pin.sym} 3340 11000 0 0 {name=l8887 lab=BLB17}
N 3360 10960 3340 10960 {}
C {lab_pin.sym} 3340 10960 0 0 {name=l8888 lab=WL55}
N 3440 11040 3460 11040 {}
C {lab_pin.sym} 3460 11040 0 0 {name=l8889 lab=VDD}
N 3440 10960 3460 10960 {}
C {lab_pin.sym} 3460 10960 0 0 {name=l8890 lab=VSS}
C {bitcell_6t.sym} 3600 11000 0 0 {name=Xr55c18}
N 3560 11040 3540 11040 {}
C {lab_pin.sym} 3540 11040 0 0 {name=l8891 lab=BL18}
N 3560 11000 3540 11000 {}
C {lab_pin.sym} 3540 11000 0 0 {name=l8892 lab=BLB18}
N 3560 10960 3540 10960 {}
C {lab_pin.sym} 3540 10960 0 0 {name=l8893 lab=WL55}
N 3640 11040 3660 11040 {}
C {lab_pin.sym} 3660 11040 0 0 {name=l8894 lab=VDD}
N 3640 10960 3660 10960 {}
C {lab_pin.sym} 3660 10960 0 0 {name=l8895 lab=VSS}
C {bitcell_6t.sym} 3800 11000 0 0 {name=Xr55c19}
N 3760 11040 3740 11040 {}
C {lab_pin.sym} 3740 11040 0 0 {name=l8896 lab=BL19}
N 3760 11000 3740 11000 {}
C {lab_pin.sym} 3740 11000 0 0 {name=l8897 lab=BLB19}
N 3760 10960 3740 10960 {}
C {lab_pin.sym} 3740 10960 0 0 {name=l8898 lab=WL55}
N 3840 11040 3860 11040 {}
C {lab_pin.sym} 3860 11040 0 0 {name=l8899 lab=VDD}
N 3840 10960 3860 10960 {}
C {lab_pin.sym} 3860 10960 0 0 {name=l8900 lab=VSS}
C {bitcell_6t.sym} 4000 11000 0 0 {name=Xr55c20}
N 3960 11040 3940 11040 {}
C {lab_pin.sym} 3940 11040 0 0 {name=l8901 lab=BL20}
N 3960 11000 3940 11000 {}
C {lab_pin.sym} 3940 11000 0 0 {name=l8902 lab=BLB20}
N 3960 10960 3940 10960 {}
C {lab_pin.sym} 3940 10960 0 0 {name=l8903 lab=WL55}
N 4040 11040 4060 11040 {}
C {lab_pin.sym} 4060 11040 0 0 {name=l8904 lab=VDD}
N 4040 10960 4060 10960 {}
C {lab_pin.sym} 4060 10960 0 0 {name=l8905 lab=VSS}
C {bitcell_6t.sym} 4200 11000 0 0 {name=Xr55c21}
N 4160 11040 4140 11040 {}
C {lab_pin.sym} 4140 11040 0 0 {name=l8906 lab=BL21}
N 4160 11000 4140 11000 {}
C {lab_pin.sym} 4140 11000 0 0 {name=l8907 lab=BLB21}
N 4160 10960 4140 10960 {}
C {lab_pin.sym} 4140 10960 0 0 {name=l8908 lab=WL55}
N 4240 11040 4260 11040 {}
C {lab_pin.sym} 4260 11040 0 0 {name=l8909 lab=VDD}
N 4240 10960 4260 10960 {}
C {lab_pin.sym} 4260 10960 0 0 {name=l8910 lab=VSS}
C {bitcell_6t.sym} 4400 11000 0 0 {name=Xr55c22}
N 4360 11040 4340 11040 {}
C {lab_pin.sym} 4340 11040 0 0 {name=l8911 lab=BL22}
N 4360 11000 4340 11000 {}
C {lab_pin.sym} 4340 11000 0 0 {name=l8912 lab=BLB22}
N 4360 10960 4340 10960 {}
C {lab_pin.sym} 4340 10960 0 0 {name=l8913 lab=WL55}
N 4440 11040 4460 11040 {}
C {lab_pin.sym} 4460 11040 0 0 {name=l8914 lab=VDD}
N 4440 10960 4460 10960 {}
C {lab_pin.sym} 4460 10960 0 0 {name=l8915 lab=VSS}
C {bitcell_6t.sym} 4600 11000 0 0 {name=Xr55c23}
N 4560 11040 4540 11040 {}
C {lab_pin.sym} 4540 11040 0 0 {name=l8916 lab=BL23}
N 4560 11000 4540 11000 {}
C {lab_pin.sym} 4540 11000 0 0 {name=l8917 lab=BLB23}
N 4560 10960 4540 10960 {}
C {lab_pin.sym} 4540 10960 0 0 {name=l8918 lab=WL55}
N 4640 11040 4660 11040 {}
C {lab_pin.sym} 4660 11040 0 0 {name=l8919 lab=VDD}
N 4640 10960 4660 10960 {}
C {lab_pin.sym} 4660 10960 0 0 {name=l8920 lab=VSS}
C {bitcell_6t.sym} 4800 11000 0 0 {name=Xr55c24}
N 4760 11040 4740 11040 {}
C {lab_pin.sym} 4740 11040 0 0 {name=l8921 lab=BL24}
N 4760 11000 4740 11000 {}
C {lab_pin.sym} 4740 11000 0 0 {name=l8922 lab=BLB24}
N 4760 10960 4740 10960 {}
C {lab_pin.sym} 4740 10960 0 0 {name=l8923 lab=WL55}
N 4840 11040 4860 11040 {}
C {lab_pin.sym} 4860 11040 0 0 {name=l8924 lab=VDD}
N 4840 10960 4860 10960 {}
C {lab_pin.sym} 4860 10960 0 0 {name=l8925 lab=VSS}
C {bitcell_6t.sym} 5000 11000 0 0 {name=Xr55c25}
N 4960 11040 4940 11040 {}
C {lab_pin.sym} 4940 11040 0 0 {name=l8926 lab=BL25}
N 4960 11000 4940 11000 {}
C {lab_pin.sym} 4940 11000 0 0 {name=l8927 lab=BLB25}
N 4960 10960 4940 10960 {}
C {lab_pin.sym} 4940 10960 0 0 {name=l8928 lab=WL55}
N 5040 11040 5060 11040 {}
C {lab_pin.sym} 5060 11040 0 0 {name=l8929 lab=VDD}
N 5040 10960 5060 10960 {}
C {lab_pin.sym} 5060 10960 0 0 {name=l8930 lab=VSS}
C {bitcell_6t.sym} 5200 11000 0 0 {name=Xr55c26}
N 5160 11040 5140 11040 {}
C {lab_pin.sym} 5140 11040 0 0 {name=l8931 lab=BL26}
N 5160 11000 5140 11000 {}
C {lab_pin.sym} 5140 11000 0 0 {name=l8932 lab=BLB26}
N 5160 10960 5140 10960 {}
C {lab_pin.sym} 5140 10960 0 0 {name=l8933 lab=WL55}
N 5240 11040 5260 11040 {}
C {lab_pin.sym} 5260 11040 0 0 {name=l8934 lab=VDD}
N 5240 10960 5260 10960 {}
C {lab_pin.sym} 5260 10960 0 0 {name=l8935 lab=VSS}
C {bitcell_6t.sym} 5400 11000 0 0 {name=Xr55c27}
N 5360 11040 5340 11040 {}
C {lab_pin.sym} 5340 11040 0 0 {name=l8936 lab=BL27}
N 5360 11000 5340 11000 {}
C {lab_pin.sym} 5340 11000 0 0 {name=l8937 lab=BLB27}
N 5360 10960 5340 10960 {}
C {lab_pin.sym} 5340 10960 0 0 {name=l8938 lab=WL55}
N 5440 11040 5460 11040 {}
C {lab_pin.sym} 5460 11040 0 0 {name=l8939 lab=VDD}
N 5440 10960 5460 10960 {}
C {lab_pin.sym} 5460 10960 0 0 {name=l8940 lab=VSS}
C {bitcell_6t.sym} 5600 11000 0 0 {name=Xr55c28}
N 5560 11040 5540 11040 {}
C {lab_pin.sym} 5540 11040 0 0 {name=l8941 lab=BL28}
N 5560 11000 5540 11000 {}
C {lab_pin.sym} 5540 11000 0 0 {name=l8942 lab=BLB28}
N 5560 10960 5540 10960 {}
C {lab_pin.sym} 5540 10960 0 0 {name=l8943 lab=WL55}
N 5640 11040 5660 11040 {}
C {lab_pin.sym} 5660 11040 0 0 {name=l8944 lab=VDD}
N 5640 10960 5660 10960 {}
C {lab_pin.sym} 5660 10960 0 0 {name=l8945 lab=VSS}
C {bitcell_6t.sym} 5800 11000 0 0 {name=Xr55c29}
N 5760 11040 5740 11040 {}
C {lab_pin.sym} 5740 11040 0 0 {name=l8946 lab=BL29}
N 5760 11000 5740 11000 {}
C {lab_pin.sym} 5740 11000 0 0 {name=l8947 lab=BLB29}
N 5760 10960 5740 10960 {}
C {lab_pin.sym} 5740 10960 0 0 {name=l8948 lab=WL55}
N 5840 11040 5860 11040 {}
C {lab_pin.sym} 5860 11040 0 0 {name=l8949 lab=VDD}
N 5840 10960 5860 10960 {}
C {lab_pin.sym} 5860 10960 0 0 {name=l8950 lab=VSS}
C {bitcell_6t.sym} 6000 11000 0 0 {name=Xr55c30}
N 5960 11040 5940 11040 {}
C {lab_pin.sym} 5940 11040 0 0 {name=l8951 lab=BL30}
N 5960 11000 5940 11000 {}
C {lab_pin.sym} 5940 11000 0 0 {name=l8952 lab=BLB30}
N 5960 10960 5940 10960 {}
C {lab_pin.sym} 5940 10960 0 0 {name=l8953 lab=WL55}
N 6040 11040 6060 11040 {}
C {lab_pin.sym} 6060 11040 0 0 {name=l8954 lab=VDD}
N 6040 10960 6060 10960 {}
C {lab_pin.sym} 6060 10960 0 0 {name=l8955 lab=VSS}
C {bitcell_6t.sym} 6200 11000 0 0 {name=Xr55c31}
N 6160 11040 6140 11040 {}
C {lab_pin.sym} 6140 11040 0 0 {name=l8956 lab=BL31}
N 6160 11000 6140 11000 {}
C {lab_pin.sym} 6140 11000 0 0 {name=l8957 lab=BLB31}
N 6160 10960 6140 10960 {}
C {lab_pin.sym} 6140 10960 0 0 {name=l8958 lab=WL55}
N 6240 11040 6260 11040 {}
C {lab_pin.sym} 6260 11040 0 0 {name=l8959 lab=VDD}
N 6240 10960 6260 10960 {}
C {lab_pin.sym} 6260 10960 0 0 {name=l8960 lab=VSS}
C {bitcell_6t.sym} 0 11200 0 0 {name=Xr56c0}
N -40 11240 -60 11240 {}
C {lab_pin.sym} -60 11240 0 0 {name=l8961 lab=BL0}
N -40 11200 -60 11200 {}
C {lab_pin.sym} -60 11200 0 0 {name=l8962 lab=BLB0}
N -40 11160 -60 11160 {}
C {lab_pin.sym} -60 11160 0 0 {name=l8963 lab=WL56}
N 40 11240 60 11240 {}
C {lab_pin.sym} 60 11240 0 0 {name=l8964 lab=VDD}
N 40 11160 60 11160 {}
C {lab_pin.sym} 60 11160 0 0 {name=l8965 lab=VSS}
C {bitcell_6t.sym} 200 11200 0 0 {name=Xr56c1}
N 160 11240 140 11240 {}
C {lab_pin.sym} 140 11240 0 0 {name=l8966 lab=BL1}
N 160 11200 140 11200 {}
C {lab_pin.sym} 140 11200 0 0 {name=l8967 lab=BLB1}
N 160 11160 140 11160 {}
C {lab_pin.sym} 140 11160 0 0 {name=l8968 lab=WL56}
N 240 11240 260 11240 {}
C {lab_pin.sym} 260 11240 0 0 {name=l8969 lab=VDD}
N 240 11160 260 11160 {}
C {lab_pin.sym} 260 11160 0 0 {name=l8970 lab=VSS}
C {bitcell_6t.sym} 400 11200 0 0 {name=Xr56c2}
N 360 11240 340 11240 {}
C {lab_pin.sym} 340 11240 0 0 {name=l8971 lab=BL2}
N 360 11200 340 11200 {}
C {lab_pin.sym} 340 11200 0 0 {name=l8972 lab=BLB2}
N 360 11160 340 11160 {}
C {lab_pin.sym} 340 11160 0 0 {name=l8973 lab=WL56}
N 440 11240 460 11240 {}
C {lab_pin.sym} 460 11240 0 0 {name=l8974 lab=VDD}
N 440 11160 460 11160 {}
C {lab_pin.sym} 460 11160 0 0 {name=l8975 lab=VSS}
C {bitcell_6t.sym} 600 11200 0 0 {name=Xr56c3}
N 560 11240 540 11240 {}
C {lab_pin.sym} 540 11240 0 0 {name=l8976 lab=BL3}
N 560 11200 540 11200 {}
C {lab_pin.sym} 540 11200 0 0 {name=l8977 lab=BLB3}
N 560 11160 540 11160 {}
C {lab_pin.sym} 540 11160 0 0 {name=l8978 lab=WL56}
N 640 11240 660 11240 {}
C {lab_pin.sym} 660 11240 0 0 {name=l8979 lab=VDD}
N 640 11160 660 11160 {}
C {lab_pin.sym} 660 11160 0 0 {name=l8980 lab=VSS}
C {bitcell_6t.sym} 800 11200 0 0 {name=Xr56c4}
N 760 11240 740 11240 {}
C {lab_pin.sym} 740 11240 0 0 {name=l8981 lab=BL4}
N 760 11200 740 11200 {}
C {lab_pin.sym} 740 11200 0 0 {name=l8982 lab=BLB4}
N 760 11160 740 11160 {}
C {lab_pin.sym} 740 11160 0 0 {name=l8983 lab=WL56}
N 840 11240 860 11240 {}
C {lab_pin.sym} 860 11240 0 0 {name=l8984 lab=VDD}
N 840 11160 860 11160 {}
C {lab_pin.sym} 860 11160 0 0 {name=l8985 lab=VSS}
C {bitcell_6t.sym} 1000 11200 0 0 {name=Xr56c5}
N 960 11240 940 11240 {}
C {lab_pin.sym} 940 11240 0 0 {name=l8986 lab=BL5}
N 960 11200 940 11200 {}
C {lab_pin.sym} 940 11200 0 0 {name=l8987 lab=BLB5}
N 960 11160 940 11160 {}
C {lab_pin.sym} 940 11160 0 0 {name=l8988 lab=WL56}
N 1040 11240 1060 11240 {}
C {lab_pin.sym} 1060 11240 0 0 {name=l8989 lab=VDD}
N 1040 11160 1060 11160 {}
C {lab_pin.sym} 1060 11160 0 0 {name=l8990 lab=VSS}
C {bitcell_6t.sym} 1200 11200 0 0 {name=Xr56c6}
N 1160 11240 1140 11240 {}
C {lab_pin.sym} 1140 11240 0 0 {name=l8991 lab=BL6}
N 1160 11200 1140 11200 {}
C {lab_pin.sym} 1140 11200 0 0 {name=l8992 lab=BLB6}
N 1160 11160 1140 11160 {}
C {lab_pin.sym} 1140 11160 0 0 {name=l8993 lab=WL56}
N 1240 11240 1260 11240 {}
C {lab_pin.sym} 1260 11240 0 0 {name=l8994 lab=VDD}
N 1240 11160 1260 11160 {}
C {lab_pin.sym} 1260 11160 0 0 {name=l8995 lab=VSS}
C {bitcell_6t.sym} 1400 11200 0 0 {name=Xr56c7}
N 1360 11240 1340 11240 {}
C {lab_pin.sym} 1340 11240 0 0 {name=l8996 lab=BL7}
N 1360 11200 1340 11200 {}
C {lab_pin.sym} 1340 11200 0 0 {name=l8997 lab=BLB7}
N 1360 11160 1340 11160 {}
C {lab_pin.sym} 1340 11160 0 0 {name=l8998 lab=WL56}
N 1440 11240 1460 11240 {}
C {lab_pin.sym} 1460 11240 0 0 {name=l8999 lab=VDD}
N 1440 11160 1460 11160 {}
C {lab_pin.sym} 1460 11160 0 0 {name=l9000 lab=VSS}
C {bitcell_6t.sym} 1600 11200 0 0 {name=Xr56c8}
N 1560 11240 1540 11240 {}
C {lab_pin.sym} 1540 11240 0 0 {name=l9001 lab=BL8}
N 1560 11200 1540 11200 {}
C {lab_pin.sym} 1540 11200 0 0 {name=l9002 lab=BLB8}
N 1560 11160 1540 11160 {}
C {lab_pin.sym} 1540 11160 0 0 {name=l9003 lab=WL56}
N 1640 11240 1660 11240 {}
C {lab_pin.sym} 1660 11240 0 0 {name=l9004 lab=VDD}
N 1640 11160 1660 11160 {}
C {lab_pin.sym} 1660 11160 0 0 {name=l9005 lab=VSS}
C {bitcell_6t.sym} 1800 11200 0 0 {name=Xr56c9}
N 1760 11240 1740 11240 {}
C {lab_pin.sym} 1740 11240 0 0 {name=l9006 lab=BL9}
N 1760 11200 1740 11200 {}
C {lab_pin.sym} 1740 11200 0 0 {name=l9007 lab=BLB9}
N 1760 11160 1740 11160 {}
C {lab_pin.sym} 1740 11160 0 0 {name=l9008 lab=WL56}
N 1840 11240 1860 11240 {}
C {lab_pin.sym} 1860 11240 0 0 {name=l9009 lab=VDD}
N 1840 11160 1860 11160 {}
C {lab_pin.sym} 1860 11160 0 0 {name=l9010 lab=VSS}
C {bitcell_6t.sym} 2000 11200 0 0 {name=Xr56c10}
N 1960 11240 1940 11240 {}
C {lab_pin.sym} 1940 11240 0 0 {name=l9011 lab=BL10}
N 1960 11200 1940 11200 {}
C {lab_pin.sym} 1940 11200 0 0 {name=l9012 lab=BLB10}
N 1960 11160 1940 11160 {}
C {lab_pin.sym} 1940 11160 0 0 {name=l9013 lab=WL56}
N 2040 11240 2060 11240 {}
C {lab_pin.sym} 2060 11240 0 0 {name=l9014 lab=VDD}
N 2040 11160 2060 11160 {}
C {lab_pin.sym} 2060 11160 0 0 {name=l9015 lab=VSS}
C {bitcell_6t.sym} 2200 11200 0 0 {name=Xr56c11}
N 2160 11240 2140 11240 {}
C {lab_pin.sym} 2140 11240 0 0 {name=l9016 lab=BL11}
N 2160 11200 2140 11200 {}
C {lab_pin.sym} 2140 11200 0 0 {name=l9017 lab=BLB11}
N 2160 11160 2140 11160 {}
C {lab_pin.sym} 2140 11160 0 0 {name=l9018 lab=WL56}
N 2240 11240 2260 11240 {}
C {lab_pin.sym} 2260 11240 0 0 {name=l9019 lab=VDD}
N 2240 11160 2260 11160 {}
C {lab_pin.sym} 2260 11160 0 0 {name=l9020 lab=VSS}
C {bitcell_6t.sym} 2400 11200 0 0 {name=Xr56c12}
N 2360 11240 2340 11240 {}
C {lab_pin.sym} 2340 11240 0 0 {name=l9021 lab=BL12}
N 2360 11200 2340 11200 {}
C {lab_pin.sym} 2340 11200 0 0 {name=l9022 lab=BLB12}
N 2360 11160 2340 11160 {}
C {lab_pin.sym} 2340 11160 0 0 {name=l9023 lab=WL56}
N 2440 11240 2460 11240 {}
C {lab_pin.sym} 2460 11240 0 0 {name=l9024 lab=VDD}
N 2440 11160 2460 11160 {}
C {lab_pin.sym} 2460 11160 0 0 {name=l9025 lab=VSS}
C {bitcell_6t.sym} 2600 11200 0 0 {name=Xr56c13}
N 2560 11240 2540 11240 {}
C {lab_pin.sym} 2540 11240 0 0 {name=l9026 lab=BL13}
N 2560 11200 2540 11200 {}
C {lab_pin.sym} 2540 11200 0 0 {name=l9027 lab=BLB13}
N 2560 11160 2540 11160 {}
C {lab_pin.sym} 2540 11160 0 0 {name=l9028 lab=WL56}
N 2640 11240 2660 11240 {}
C {lab_pin.sym} 2660 11240 0 0 {name=l9029 lab=VDD}
N 2640 11160 2660 11160 {}
C {lab_pin.sym} 2660 11160 0 0 {name=l9030 lab=VSS}
C {bitcell_6t.sym} 2800 11200 0 0 {name=Xr56c14}
N 2760 11240 2740 11240 {}
C {lab_pin.sym} 2740 11240 0 0 {name=l9031 lab=BL14}
N 2760 11200 2740 11200 {}
C {lab_pin.sym} 2740 11200 0 0 {name=l9032 lab=BLB14}
N 2760 11160 2740 11160 {}
C {lab_pin.sym} 2740 11160 0 0 {name=l9033 lab=WL56}
N 2840 11240 2860 11240 {}
C {lab_pin.sym} 2860 11240 0 0 {name=l9034 lab=VDD}
N 2840 11160 2860 11160 {}
C {lab_pin.sym} 2860 11160 0 0 {name=l9035 lab=VSS}
C {bitcell_6t.sym} 3000 11200 0 0 {name=Xr56c15}
N 2960 11240 2940 11240 {}
C {lab_pin.sym} 2940 11240 0 0 {name=l9036 lab=BL15}
N 2960 11200 2940 11200 {}
C {lab_pin.sym} 2940 11200 0 0 {name=l9037 lab=BLB15}
N 2960 11160 2940 11160 {}
C {lab_pin.sym} 2940 11160 0 0 {name=l9038 lab=WL56}
N 3040 11240 3060 11240 {}
C {lab_pin.sym} 3060 11240 0 0 {name=l9039 lab=VDD}
N 3040 11160 3060 11160 {}
C {lab_pin.sym} 3060 11160 0 0 {name=l9040 lab=VSS}
C {bitcell_6t.sym} 3200 11200 0 0 {name=Xr56c16}
N 3160 11240 3140 11240 {}
C {lab_pin.sym} 3140 11240 0 0 {name=l9041 lab=BL16}
N 3160 11200 3140 11200 {}
C {lab_pin.sym} 3140 11200 0 0 {name=l9042 lab=BLB16}
N 3160 11160 3140 11160 {}
C {lab_pin.sym} 3140 11160 0 0 {name=l9043 lab=WL56}
N 3240 11240 3260 11240 {}
C {lab_pin.sym} 3260 11240 0 0 {name=l9044 lab=VDD}
N 3240 11160 3260 11160 {}
C {lab_pin.sym} 3260 11160 0 0 {name=l9045 lab=VSS}
C {bitcell_6t.sym} 3400 11200 0 0 {name=Xr56c17}
N 3360 11240 3340 11240 {}
C {lab_pin.sym} 3340 11240 0 0 {name=l9046 lab=BL17}
N 3360 11200 3340 11200 {}
C {lab_pin.sym} 3340 11200 0 0 {name=l9047 lab=BLB17}
N 3360 11160 3340 11160 {}
C {lab_pin.sym} 3340 11160 0 0 {name=l9048 lab=WL56}
N 3440 11240 3460 11240 {}
C {lab_pin.sym} 3460 11240 0 0 {name=l9049 lab=VDD}
N 3440 11160 3460 11160 {}
C {lab_pin.sym} 3460 11160 0 0 {name=l9050 lab=VSS}
C {bitcell_6t.sym} 3600 11200 0 0 {name=Xr56c18}
N 3560 11240 3540 11240 {}
C {lab_pin.sym} 3540 11240 0 0 {name=l9051 lab=BL18}
N 3560 11200 3540 11200 {}
C {lab_pin.sym} 3540 11200 0 0 {name=l9052 lab=BLB18}
N 3560 11160 3540 11160 {}
C {lab_pin.sym} 3540 11160 0 0 {name=l9053 lab=WL56}
N 3640 11240 3660 11240 {}
C {lab_pin.sym} 3660 11240 0 0 {name=l9054 lab=VDD}
N 3640 11160 3660 11160 {}
C {lab_pin.sym} 3660 11160 0 0 {name=l9055 lab=VSS}
C {bitcell_6t.sym} 3800 11200 0 0 {name=Xr56c19}
N 3760 11240 3740 11240 {}
C {lab_pin.sym} 3740 11240 0 0 {name=l9056 lab=BL19}
N 3760 11200 3740 11200 {}
C {lab_pin.sym} 3740 11200 0 0 {name=l9057 lab=BLB19}
N 3760 11160 3740 11160 {}
C {lab_pin.sym} 3740 11160 0 0 {name=l9058 lab=WL56}
N 3840 11240 3860 11240 {}
C {lab_pin.sym} 3860 11240 0 0 {name=l9059 lab=VDD}
N 3840 11160 3860 11160 {}
C {lab_pin.sym} 3860 11160 0 0 {name=l9060 lab=VSS}
C {bitcell_6t.sym} 4000 11200 0 0 {name=Xr56c20}
N 3960 11240 3940 11240 {}
C {lab_pin.sym} 3940 11240 0 0 {name=l9061 lab=BL20}
N 3960 11200 3940 11200 {}
C {lab_pin.sym} 3940 11200 0 0 {name=l9062 lab=BLB20}
N 3960 11160 3940 11160 {}
C {lab_pin.sym} 3940 11160 0 0 {name=l9063 lab=WL56}
N 4040 11240 4060 11240 {}
C {lab_pin.sym} 4060 11240 0 0 {name=l9064 lab=VDD}
N 4040 11160 4060 11160 {}
C {lab_pin.sym} 4060 11160 0 0 {name=l9065 lab=VSS}
C {bitcell_6t.sym} 4200 11200 0 0 {name=Xr56c21}
N 4160 11240 4140 11240 {}
C {lab_pin.sym} 4140 11240 0 0 {name=l9066 lab=BL21}
N 4160 11200 4140 11200 {}
C {lab_pin.sym} 4140 11200 0 0 {name=l9067 lab=BLB21}
N 4160 11160 4140 11160 {}
C {lab_pin.sym} 4140 11160 0 0 {name=l9068 lab=WL56}
N 4240 11240 4260 11240 {}
C {lab_pin.sym} 4260 11240 0 0 {name=l9069 lab=VDD}
N 4240 11160 4260 11160 {}
C {lab_pin.sym} 4260 11160 0 0 {name=l9070 lab=VSS}
C {bitcell_6t.sym} 4400 11200 0 0 {name=Xr56c22}
N 4360 11240 4340 11240 {}
C {lab_pin.sym} 4340 11240 0 0 {name=l9071 lab=BL22}
N 4360 11200 4340 11200 {}
C {lab_pin.sym} 4340 11200 0 0 {name=l9072 lab=BLB22}
N 4360 11160 4340 11160 {}
C {lab_pin.sym} 4340 11160 0 0 {name=l9073 lab=WL56}
N 4440 11240 4460 11240 {}
C {lab_pin.sym} 4460 11240 0 0 {name=l9074 lab=VDD}
N 4440 11160 4460 11160 {}
C {lab_pin.sym} 4460 11160 0 0 {name=l9075 lab=VSS}
C {bitcell_6t.sym} 4600 11200 0 0 {name=Xr56c23}
N 4560 11240 4540 11240 {}
C {lab_pin.sym} 4540 11240 0 0 {name=l9076 lab=BL23}
N 4560 11200 4540 11200 {}
C {lab_pin.sym} 4540 11200 0 0 {name=l9077 lab=BLB23}
N 4560 11160 4540 11160 {}
C {lab_pin.sym} 4540 11160 0 0 {name=l9078 lab=WL56}
N 4640 11240 4660 11240 {}
C {lab_pin.sym} 4660 11240 0 0 {name=l9079 lab=VDD}
N 4640 11160 4660 11160 {}
C {lab_pin.sym} 4660 11160 0 0 {name=l9080 lab=VSS}
C {bitcell_6t.sym} 4800 11200 0 0 {name=Xr56c24}
N 4760 11240 4740 11240 {}
C {lab_pin.sym} 4740 11240 0 0 {name=l9081 lab=BL24}
N 4760 11200 4740 11200 {}
C {lab_pin.sym} 4740 11200 0 0 {name=l9082 lab=BLB24}
N 4760 11160 4740 11160 {}
C {lab_pin.sym} 4740 11160 0 0 {name=l9083 lab=WL56}
N 4840 11240 4860 11240 {}
C {lab_pin.sym} 4860 11240 0 0 {name=l9084 lab=VDD}
N 4840 11160 4860 11160 {}
C {lab_pin.sym} 4860 11160 0 0 {name=l9085 lab=VSS}
C {bitcell_6t.sym} 5000 11200 0 0 {name=Xr56c25}
N 4960 11240 4940 11240 {}
C {lab_pin.sym} 4940 11240 0 0 {name=l9086 lab=BL25}
N 4960 11200 4940 11200 {}
C {lab_pin.sym} 4940 11200 0 0 {name=l9087 lab=BLB25}
N 4960 11160 4940 11160 {}
C {lab_pin.sym} 4940 11160 0 0 {name=l9088 lab=WL56}
N 5040 11240 5060 11240 {}
C {lab_pin.sym} 5060 11240 0 0 {name=l9089 lab=VDD}
N 5040 11160 5060 11160 {}
C {lab_pin.sym} 5060 11160 0 0 {name=l9090 lab=VSS}
C {bitcell_6t.sym} 5200 11200 0 0 {name=Xr56c26}
N 5160 11240 5140 11240 {}
C {lab_pin.sym} 5140 11240 0 0 {name=l9091 lab=BL26}
N 5160 11200 5140 11200 {}
C {lab_pin.sym} 5140 11200 0 0 {name=l9092 lab=BLB26}
N 5160 11160 5140 11160 {}
C {lab_pin.sym} 5140 11160 0 0 {name=l9093 lab=WL56}
N 5240 11240 5260 11240 {}
C {lab_pin.sym} 5260 11240 0 0 {name=l9094 lab=VDD}
N 5240 11160 5260 11160 {}
C {lab_pin.sym} 5260 11160 0 0 {name=l9095 lab=VSS}
C {bitcell_6t.sym} 5400 11200 0 0 {name=Xr56c27}
N 5360 11240 5340 11240 {}
C {lab_pin.sym} 5340 11240 0 0 {name=l9096 lab=BL27}
N 5360 11200 5340 11200 {}
C {lab_pin.sym} 5340 11200 0 0 {name=l9097 lab=BLB27}
N 5360 11160 5340 11160 {}
C {lab_pin.sym} 5340 11160 0 0 {name=l9098 lab=WL56}
N 5440 11240 5460 11240 {}
C {lab_pin.sym} 5460 11240 0 0 {name=l9099 lab=VDD}
N 5440 11160 5460 11160 {}
C {lab_pin.sym} 5460 11160 0 0 {name=l9100 lab=VSS}
C {bitcell_6t.sym} 5600 11200 0 0 {name=Xr56c28}
N 5560 11240 5540 11240 {}
C {lab_pin.sym} 5540 11240 0 0 {name=l9101 lab=BL28}
N 5560 11200 5540 11200 {}
C {lab_pin.sym} 5540 11200 0 0 {name=l9102 lab=BLB28}
N 5560 11160 5540 11160 {}
C {lab_pin.sym} 5540 11160 0 0 {name=l9103 lab=WL56}
N 5640 11240 5660 11240 {}
C {lab_pin.sym} 5660 11240 0 0 {name=l9104 lab=VDD}
N 5640 11160 5660 11160 {}
C {lab_pin.sym} 5660 11160 0 0 {name=l9105 lab=VSS}
C {bitcell_6t.sym} 5800 11200 0 0 {name=Xr56c29}
N 5760 11240 5740 11240 {}
C {lab_pin.sym} 5740 11240 0 0 {name=l9106 lab=BL29}
N 5760 11200 5740 11200 {}
C {lab_pin.sym} 5740 11200 0 0 {name=l9107 lab=BLB29}
N 5760 11160 5740 11160 {}
C {lab_pin.sym} 5740 11160 0 0 {name=l9108 lab=WL56}
N 5840 11240 5860 11240 {}
C {lab_pin.sym} 5860 11240 0 0 {name=l9109 lab=VDD}
N 5840 11160 5860 11160 {}
C {lab_pin.sym} 5860 11160 0 0 {name=l9110 lab=VSS}
C {bitcell_6t.sym} 6000 11200 0 0 {name=Xr56c30}
N 5960 11240 5940 11240 {}
C {lab_pin.sym} 5940 11240 0 0 {name=l9111 lab=BL30}
N 5960 11200 5940 11200 {}
C {lab_pin.sym} 5940 11200 0 0 {name=l9112 lab=BLB30}
N 5960 11160 5940 11160 {}
C {lab_pin.sym} 5940 11160 0 0 {name=l9113 lab=WL56}
N 6040 11240 6060 11240 {}
C {lab_pin.sym} 6060 11240 0 0 {name=l9114 lab=VDD}
N 6040 11160 6060 11160 {}
C {lab_pin.sym} 6060 11160 0 0 {name=l9115 lab=VSS}
C {bitcell_6t.sym} 6200 11200 0 0 {name=Xr56c31}
N 6160 11240 6140 11240 {}
C {lab_pin.sym} 6140 11240 0 0 {name=l9116 lab=BL31}
N 6160 11200 6140 11200 {}
C {lab_pin.sym} 6140 11200 0 0 {name=l9117 lab=BLB31}
N 6160 11160 6140 11160 {}
C {lab_pin.sym} 6140 11160 0 0 {name=l9118 lab=WL56}
N 6240 11240 6260 11240 {}
C {lab_pin.sym} 6260 11240 0 0 {name=l9119 lab=VDD}
N 6240 11160 6260 11160 {}
C {lab_pin.sym} 6260 11160 0 0 {name=l9120 lab=VSS}
C {bitcell_6t.sym} 0 11400 0 0 {name=Xr57c0}
N -40 11440 -60 11440 {}
C {lab_pin.sym} -60 11440 0 0 {name=l9121 lab=BL0}
N -40 11400 -60 11400 {}
C {lab_pin.sym} -60 11400 0 0 {name=l9122 lab=BLB0}
N -40 11360 -60 11360 {}
C {lab_pin.sym} -60 11360 0 0 {name=l9123 lab=WL57}
N 40 11440 60 11440 {}
C {lab_pin.sym} 60 11440 0 0 {name=l9124 lab=VDD}
N 40 11360 60 11360 {}
C {lab_pin.sym} 60 11360 0 0 {name=l9125 lab=VSS}
C {bitcell_6t.sym} 200 11400 0 0 {name=Xr57c1}
N 160 11440 140 11440 {}
C {lab_pin.sym} 140 11440 0 0 {name=l9126 lab=BL1}
N 160 11400 140 11400 {}
C {lab_pin.sym} 140 11400 0 0 {name=l9127 lab=BLB1}
N 160 11360 140 11360 {}
C {lab_pin.sym} 140 11360 0 0 {name=l9128 lab=WL57}
N 240 11440 260 11440 {}
C {lab_pin.sym} 260 11440 0 0 {name=l9129 lab=VDD}
N 240 11360 260 11360 {}
C {lab_pin.sym} 260 11360 0 0 {name=l9130 lab=VSS}
C {bitcell_6t.sym} 400 11400 0 0 {name=Xr57c2}
N 360 11440 340 11440 {}
C {lab_pin.sym} 340 11440 0 0 {name=l9131 lab=BL2}
N 360 11400 340 11400 {}
C {lab_pin.sym} 340 11400 0 0 {name=l9132 lab=BLB2}
N 360 11360 340 11360 {}
C {lab_pin.sym} 340 11360 0 0 {name=l9133 lab=WL57}
N 440 11440 460 11440 {}
C {lab_pin.sym} 460 11440 0 0 {name=l9134 lab=VDD}
N 440 11360 460 11360 {}
C {lab_pin.sym} 460 11360 0 0 {name=l9135 lab=VSS}
C {bitcell_6t.sym} 600 11400 0 0 {name=Xr57c3}
N 560 11440 540 11440 {}
C {lab_pin.sym} 540 11440 0 0 {name=l9136 lab=BL3}
N 560 11400 540 11400 {}
C {lab_pin.sym} 540 11400 0 0 {name=l9137 lab=BLB3}
N 560 11360 540 11360 {}
C {lab_pin.sym} 540 11360 0 0 {name=l9138 lab=WL57}
N 640 11440 660 11440 {}
C {lab_pin.sym} 660 11440 0 0 {name=l9139 lab=VDD}
N 640 11360 660 11360 {}
C {lab_pin.sym} 660 11360 0 0 {name=l9140 lab=VSS}
C {bitcell_6t.sym} 800 11400 0 0 {name=Xr57c4}
N 760 11440 740 11440 {}
C {lab_pin.sym} 740 11440 0 0 {name=l9141 lab=BL4}
N 760 11400 740 11400 {}
C {lab_pin.sym} 740 11400 0 0 {name=l9142 lab=BLB4}
N 760 11360 740 11360 {}
C {lab_pin.sym} 740 11360 0 0 {name=l9143 lab=WL57}
N 840 11440 860 11440 {}
C {lab_pin.sym} 860 11440 0 0 {name=l9144 lab=VDD}
N 840 11360 860 11360 {}
C {lab_pin.sym} 860 11360 0 0 {name=l9145 lab=VSS}
C {bitcell_6t.sym} 1000 11400 0 0 {name=Xr57c5}
N 960 11440 940 11440 {}
C {lab_pin.sym} 940 11440 0 0 {name=l9146 lab=BL5}
N 960 11400 940 11400 {}
C {lab_pin.sym} 940 11400 0 0 {name=l9147 lab=BLB5}
N 960 11360 940 11360 {}
C {lab_pin.sym} 940 11360 0 0 {name=l9148 lab=WL57}
N 1040 11440 1060 11440 {}
C {lab_pin.sym} 1060 11440 0 0 {name=l9149 lab=VDD}
N 1040 11360 1060 11360 {}
C {lab_pin.sym} 1060 11360 0 0 {name=l9150 lab=VSS}
C {bitcell_6t.sym} 1200 11400 0 0 {name=Xr57c6}
N 1160 11440 1140 11440 {}
C {lab_pin.sym} 1140 11440 0 0 {name=l9151 lab=BL6}
N 1160 11400 1140 11400 {}
C {lab_pin.sym} 1140 11400 0 0 {name=l9152 lab=BLB6}
N 1160 11360 1140 11360 {}
C {lab_pin.sym} 1140 11360 0 0 {name=l9153 lab=WL57}
N 1240 11440 1260 11440 {}
C {lab_pin.sym} 1260 11440 0 0 {name=l9154 lab=VDD}
N 1240 11360 1260 11360 {}
C {lab_pin.sym} 1260 11360 0 0 {name=l9155 lab=VSS}
C {bitcell_6t.sym} 1400 11400 0 0 {name=Xr57c7}
N 1360 11440 1340 11440 {}
C {lab_pin.sym} 1340 11440 0 0 {name=l9156 lab=BL7}
N 1360 11400 1340 11400 {}
C {lab_pin.sym} 1340 11400 0 0 {name=l9157 lab=BLB7}
N 1360 11360 1340 11360 {}
C {lab_pin.sym} 1340 11360 0 0 {name=l9158 lab=WL57}
N 1440 11440 1460 11440 {}
C {lab_pin.sym} 1460 11440 0 0 {name=l9159 lab=VDD}
N 1440 11360 1460 11360 {}
C {lab_pin.sym} 1460 11360 0 0 {name=l9160 lab=VSS}
C {bitcell_6t.sym} 1600 11400 0 0 {name=Xr57c8}
N 1560 11440 1540 11440 {}
C {lab_pin.sym} 1540 11440 0 0 {name=l9161 lab=BL8}
N 1560 11400 1540 11400 {}
C {lab_pin.sym} 1540 11400 0 0 {name=l9162 lab=BLB8}
N 1560 11360 1540 11360 {}
C {lab_pin.sym} 1540 11360 0 0 {name=l9163 lab=WL57}
N 1640 11440 1660 11440 {}
C {lab_pin.sym} 1660 11440 0 0 {name=l9164 lab=VDD}
N 1640 11360 1660 11360 {}
C {lab_pin.sym} 1660 11360 0 0 {name=l9165 lab=VSS}
C {bitcell_6t.sym} 1800 11400 0 0 {name=Xr57c9}
N 1760 11440 1740 11440 {}
C {lab_pin.sym} 1740 11440 0 0 {name=l9166 lab=BL9}
N 1760 11400 1740 11400 {}
C {lab_pin.sym} 1740 11400 0 0 {name=l9167 lab=BLB9}
N 1760 11360 1740 11360 {}
C {lab_pin.sym} 1740 11360 0 0 {name=l9168 lab=WL57}
N 1840 11440 1860 11440 {}
C {lab_pin.sym} 1860 11440 0 0 {name=l9169 lab=VDD}
N 1840 11360 1860 11360 {}
C {lab_pin.sym} 1860 11360 0 0 {name=l9170 lab=VSS}
C {bitcell_6t.sym} 2000 11400 0 0 {name=Xr57c10}
N 1960 11440 1940 11440 {}
C {lab_pin.sym} 1940 11440 0 0 {name=l9171 lab=BL10}
N 1960 11400 1940 11400 {}
C {lab_pin.sym} 1940 11400 0 0 {name=l9172 lab=BLB10}
N 1960 11360 1940 11360 {}
C {lab_pin.sym} 1940 11360 0 0 {name=l9173 lab=WL57}
N 2040 11440 2060 11440 {}
C {lab_pin.sym} 2060 11440 0 0 {name=l9174 lab=VDD}
N 2040 11360 2060 11360 {}
C {lab_pin.sym} 2060 11360 0 0 {name=l9175 lab=VSS}
C {bitcell_6t.sym} 2200 11400 0 0 {name=Xr57c11}
N 2160 11440 2140 11440 {}
C {lab_pin.sym} 2140 11440 0 0 {name=l9176 lab=BL11}
N 2160 11400 2140 11400 {}
C {lab_pin.sym} 2140 11400 0 0 {name=l9177 lab=BLB11}
N 2160 11360 2140 11360 {}
C {lab_pin.sym} 2140 11360 0 0 {name=l9178 lab=WL57}
N 2240 11440 2260 11440 {}
C {lab_pin.sym} 2260 11440 0 0 {name=l9179 lab=VDD}
N 2240 11360 2260 11360 {}
C {lab_pin.sym} 2260 11360 0 0 {name=l9180 lab=VSS}
C {bitcell_6t.sym} 2400 11400 0 0 {name=Xr57c12}
N 2360 11440 2340 11440 {}
C {lab_pin.sym} 2340 11440 0 0 {name=l9181 lab=BL12}
N 2360 11400 2340 11400 {}
C {lab_pin.sym} 2340 11400 0 0 {name=l9182 lab=BLB12}
N 2360 11360 2340 11360 {}
C {lab_pin.sym} 2340 11360 0 0 {name=l9183 lab=WL57}
N 2440 11440 2460 11440 {}
C {lab_pin.sym} 2460 11440 0 0 {name=l9184 lab=VDD}
N 2440 11360 2460 11360 {}
C {lab_pin.sym} 2460 11360 0 0 {name=l9185 lab=VSS}
C {bitcell_6t.sym} 2600 11400 0 0 {name=Xr57c13}
N 2560 11440 2540 11440 {}
C {lab_pin.sym} 2540 11440 0 0 {name=l9186 lab=BL13}
N 2560 11400 2540 11400 {}
C {lab_pin.sym} 2540 11400 0 0 {name=l9187 lab=BLB13}
N 2560 11360 2540 11360 {}
C {lab_pin.sym} 2540 11360 0 0 {name=l9188 lab=WL57}
N 2640 11440 2660 11440 {}
C {lab_pin.sym} 2660 11440 0 0 {name=l9189 lab=VDD}
N 2640 11360 2660 11360 {}
C {lab_pin.sym} 2660 11360 0 0 {name=l9190 lab=VSS}
C {bitcell_6t.sym} 2800 11400 0 0 {name=Xr57c14}
N 2760 11440 2740 11440 {}
C {lab_pin.sym} 2740 11440 0 0 {name=l9191 lab=BL14}
N 2760 11400 2740 11400 {}
C {lab_pin.sym} 2740 11400 0 0 {name=l9192 lab=BLB14}
N 2760 11360 2740 11360 {}
C {lab_pin.sym} 2740 11360 0 0 {name=l9193 lab=WL57}
N 2840 11440 2860 11440 {}
C {lab_pin.sym} 2860 11440 0 0 {name=l9194 lab=VDD}
N 2840 11360 2860 11360 {}
C {lab_pin.sym} 2860 11360 0 0 {name=l9195 lab=VSS}
C {bitcell_6t.sym} 3000 11400 0 0 {name=Xr57c15}
N 2960 11440 2940 11440 {}
C {lab_pin.sym} 2940 11440 0 0 {name=l9196 lab=BL15}
N 2960 11400 2940 11400 {}
C {lab_pin.sym} 2940 11400 0 0 {name=l9197 lab=BLB15}
N 2960 11360 2940 11360 {}
C {lab_pin.sym} 2940 11360 0 0 {name=l9198 lab=WL57}
N 3040 11440 3060 11440 {}
C {lab_pin.sym} 3060 11440 0 0 {name=l9199 lab=VDD}
N 3040 11360 3060 11360 {}
C {lab_pin.sym} 3060 11360 0 0 {name=l9200 lab=VSS}
C {bitcell_6t.sym} 3200 11400 0 0 {name=Xr57c16}
N 3160 11440 3140 11440 {}
C {lab_pin.sym} 3140 11440 0 0 {name=l9201 lab=BL16}
N 3160 11400 3140 11400 {}
C {lab_pin.sym} 3140 11400 0 0 {name=l9202 lab=BLB16}
N 3160 11360 3140 11360 {}
C {lab_pin.sym} 3140 11360 0 0 {name=l9203 lab=WL57}
N 3240 11440 3260 11440 {}
C {lab_pin.sym} 3260 11440 0 0 {name=l9204 lab=VDD}
N 3240 11360 3260 11360 {}
C {lab_pin.sym} 3260 11360 0 0 {name=l9205 lab=VSS}
C {bitcell_6t.sym} 3400 11400 0 0 {name=Xr57c17}
N 3360 11440 3340 11440 {}
C {lab_pin.sym} 3340 11440 0 0 {name=l9206 lab=BL17}
N 3360 11400 3340 11400 {}
C {lab_pin.sym} 3340 11400 0 0 {name=l9207 lab=BLB17}
N 3360 11360 3340 11360 {}
C {lab_pin.sym} 3340 11360 0 0 {name=l9208 lab=WL57}
N 3440 11440 3460 11440 {}
C {lab_pin.sym} 3460 11440 0 0 {name=l9209 lab=VDD}
N 3440 11360 3460 11360 {}
C {lab_pin.sym} 3460 11360 0 0 {name=l9210 lab=VSS}
C {bitcell_6t.sym} 3600 11400 0 0 {name=Xr57c18}
N 3560 11440 3540 11440 {}
C {lab_pin.sym} 3540 11440 0 0 {name=l9211 lab=BL18}
N 3560 11400 3540 11400 {}
C {lab_pin.sym} 3540 11400 0 0 {name=l9212 lab=BLB18}
N 3560 11360 3540 11360 {}
C {lab_pin.sym} 3540 11360 0 0 {name=l9213 lab=WL57}
N 3640 11440 3660 11440 {}
C {lab_pin.sym} 3660 11440 0 0 {name=l9214 lab=VDD}
N 3640 11360 3660 11360 {}
C {lab_pin.sym} 3660 11360 0 0 {name=l9215 lab=VSS}
C {bitcell_6t.sym} 3800 11400 0 0 {name=Xr57c19}
N 3760 11440 3740 11440 {}
C {lab_pin.sym} 3740 11440 0 0 {name=l9216 lab=BL19}
N 3760 11400 3740 11400 {}
C {lab_pin.sym} 3740 11400 0 0 {name=l9217 lab=BLB19}
N 3760 11360 3740 11360 {}
C {lab_pin.sym} 3740 11360 0 0 {name=l9218 lab=WL57}
N 3840 11440 3860 11440 {}
C {lab_pin.sym} 3860 11440 0 0 {name=l9219 lab=VDD}
N 3840 11360 3860 11360 {}
C {lab_pin.sym} 3860 11360 0 0 {name=l9220 lab=VSS}
C {bitcell_6t.sym} 4000 11400 0 0 {name=Xr57c20}
N 3960 11440 3940 11440 {}
C {lab_pin.sym} 3940 11440 0 0 {name=l9221 lab=BL20}
N 3960 11400 3940 11400 {}
C {lab_pin.sym} 3940 11400 0 0 {name=l9222 lab=BLB20}
N 3960 11360 3940 11360 {}
C {lab_pin.sym} 3940 11360 0 0 {name=l9223 lab=WL57}
N 4040 11440 4060 11440 {}
C {lab_pin.sym} 4060 11440 0 0 {name=l9224 lab=VDD}
N 4040 11360 4060 11360 {}
C {lab_pin.sym} 4060 11360 0 0 {name=l9225 lab=VSS}
C {bitcell_6t.sym} 4200 11400 0 0 {name=Xr57c21}
N 4160 11440 4140 11440 {}
C {lab_pin.sym} 4140 11440 0 0 {name=l9226 lab=BL21}
N 4160 11400 4140 11400 {}
C {lab_pin.sym} 4140 11400 0 0 {name=l9227 lab=BLB21}
N 4160 11360 4140 11360 {}
C {lab_pin.sym} 4140 11360 0 0 {name=l9228 lab=WL57}
N 4240 11440 4260 11440 {}
C {lab_pin.sym} 4260 11440 0 0 {name=l9229 lab=VDD}
N 4240 11360 4260 11360 {}
C {lab_pin.sym} 4260 11360 0 0 {name=l9230 lab=VSS}
C {bitcell_6t.sym} 4400 11400 0 0 {name=Xr57c22}
N 4360 11440 4340 11440 {}
C {lab_pin.sym} 4340 11440 0 0 {name=l9231 lab=BL22}
N 4360 11400 4340 11400 {}
C {lab_pin.sym} 4340 11400 0 0 {name=l9232 lab=BLB22}
N 4360 11360 4340 11360 {}
C {lab_pin.sym} 4340 11360 0 0 {name=l9233 lab=WL57}
N 4440 11440 4460 11440 {}
C {lab_pin.sym} 4460 11440 0 0 {name=l9234 lab=VDD}
N 4440 11360 4460 11360 {}
C {lab_pin.sym} 4460 11360 0 0 {name=l9235 lab=VSS}
C {bitcell_6t.sym} 4600 11400 0 0 {name=Xr57c23}
N 4560 11440 4540 11440 {}
C {lab_pin.sym} 4540 11440 0 0 {name=l9236 lab=BL23}
N 4560 11400 4540 11400 {}
C {lab_pin.sym} 4540 11400 0 0 {name=l9237 lab=BLB23}
N 4560 11360 4540 11360 {}
C {lab_pin.sym} 4540 11360 0 0 {name=l9238 lab=WL57}
N 4640 11440 4660 11440 {}
C {lab_pin.sym} 4660 11440 0 0 {name=l9239 lab=VDD}
N 4640 11360 4660 11360 {}
C {lab_pin.sym} 4660 11360 0 0 {name=l9240 lab=VSS}
C {bitcell_6t.sym} 4800 11400 0 0 {name=Xr57c24}
N 4760 11440 4740 11440 {}
C {lab_pin.sym} 4740 11440 0 0 {name=l9241 lab=BL24}
N 4760 11400 4740 11400 {}
C {lab_pin.sym} 4740 11400 0 0 {name=l9242 lab=BLB24}
N 4760 11360 4740 11360 {}
C {lab_pin.sym} 4740 11360 0 0 {name=l9243 lab=WL57}
N 4840 11440 4860 11440 {}
C {lab_pin.sym} 4860 11440 0 0 {name=l9244 lab=VDD}
N 4840 11360 4860 11360 {}
C {lab_pin.sym} 4860 11360 0 0 {name=l9245 lab=VSS}
C {bitcell_6t.sym} 5000 11400 0 0 {name=Xr57c25}
N 4960 11440 4940 11440 {}
C {lab_pin.sym} 4940 11440 0 0 {name=l9246 lab=BL25}
N 4960 11400 4940 11400 {}
C {lab_pin.sym} 4940 11400 0 0 {name=l9247 lab=BLB25}
N 4960 11360 4940 11360 {}
C {lab_pin.sym} 4940 11360 0 0 {name=l9248 lab=WL57}
N 5040 11440 5060 11440 {}
C {lab_pin.sym} 5060 11440 0 0 {name=l9249 lab=VDD}
N 5040 11360 5060 11360 {}
C {lab_pin.sym} 5060 11360 0 0 {name=l9250 lab=VSS}
C {bitcell_6t.sym} 5200 11400 0 0 {name=Xr57c26}
N 5160 11440 5140 11440 {}
C {lab_pin.sym} 5140 11440 0 0 {name=l9251 lab=BL26}
N 5160 11400 5140 11400 {}
C {lab_pin.sym} 5140 11400 0 0 {name=l9252 lab=BLB26}
N 5160 11360 5140 11360 {}
C {lab_pin.sym} 5140 11360 0 0 {name=l9253 lab=WL57}
N 5240 11440 5260 11440 {}
C {lab_pin.sym} 5260 11440 0 0 {name=l9254 lab=VDD}
N 5240 11360 5260 11360 {}
C {lab_pin.sym} 5260 11360 0 0 {name=l9255 lab=VSS}
C {bitcell_6t.sym} 5400 11400 0 0 {name=Xr57c27}
N 5360 11440 5340 11440 {}
C {lab_pin.sym} 5340 11440 0 0 {name=l9256 lab=BL27}
N 5360 11400 5340 11400 {}
C {lab_pin.sym} 5340 11400 0 0 {name=l9257 lab=BLB27}
N 5360 11360 5340 11360 {}
C {lab_pin.sym} 5340 11360 0 0 {name=l9258 lab=WL57}
N 5440 11440 5460 11440 {}
C {lab_pin.sym} 5460 11440 0 0 {name=l9259 lab=VDD}
N 5440 11360 5460 11360 {}
C {lab_pin.sym} 5460 11360 0 0 {name=l9260 lab=VSS}
C {bitcell_6t.sym} 5600 11400 0 0 {name=Xr57c28}
N 5560 11440 5540 11440 {}
C {lab_pin.sym} 5540 11440 0 0 {name=l9261 lab=BL28}
N 5560 11400 5540 11400 {}
C {lab_pin.sym} 5540 11400 0 0 {name=l9262 lab=BLB28}
N 5560 11360 5540 11360 {}
C {lab_pin.sym} 5540 11360 0 0 {name=l9263 lab=WL57}
N 5640 11440 5660 11440 {}
C {lab_pin.sym} 5660 11440 0 0 {name=l9264 lab=VDD}
N 5640 11360 5660 11360 {}
C {lab_pin.sym} 5660 11360 0 0 {name=l9265 lab=VSS}
C {bitcell_6t.sym} 5800 11400 0 0 {name=Xr57c29}
N 5760 11440 5740 11440 {}
C {lab_pin.sym} 5740 11440 0 0 {name=l9266 lab=BL29}
N 5760 11400 5740 11400 {}
C {lab_pin.sym} 5740 11400 0 0 {name=l9267 lab=BLB29}
N 5760 11360 5740 11360 {}
C {lab_pin.sym} 5740 11360 0 0 {name=l9268 lab=WL57}
N 5840 11440 5860 11440 {}
C {lab_pin.sym} 5860 11440 0 0 {name=l9269 lab=VDD}
N 5840 11360 5860 11360 {}
C {lab_pin.sym} 5860 11360 0 0 {name=l9270 lab=VSS}
C {bitcell_6t.sym} 6000 11400 0 0 {name=Xr57c30}
N 5960 11440 5940 11440 {}
C {lab_pin.sym} 5940 11440 0 0 {name=l9271 lab=BL30}
N 5960 11400 5940 11400 {}
C {lab_pin.sym} 5940 11400 0 0 {name=l9272 lab=BLB30}
N 5960 11360 5940 11360 {}
C {lab_pin.sym} 5940 11360 0 0 {name=l9273 lab=WL57}
N 6040 11440 6060 11440 {}
C {lab_pin.sym} 6060 11440 0 0 {name=l9274 lab=VDD}
N 6040 11360 6060 11360 {}
C {lab_pin.sym} 6060 11360 0 0 {name=l9275 lab=VSS}
C {bitcell_6t.sym} 6200 11400 0 0 {name=Xr57c31}
N 6160 11440 6140 11440 {}
C {lab_pin.sym} 6140 11440 0 0 {name=l9276 lab=BL31}
N 6160 11400 6140 11400 {}
C {lab_pin.sym} 6140 11400 0 0 {name=l9277 lab=BLB31}
N 6160 11360 6140 11360 {}
C {lab_pin.sym} 6140 11360 0 0 {name=l9278 lab=WL57}
N 6240 11440 6260 11440 {}
C {lab_pin.sym} 6260 11440 0 0 {name=l9279 lab=VDD}
N 6240 11360 6260 11360 {}
C {lab_pin.sym} 6260 11360 0 0 {name=l9280 lab=VSS}
C {bitcell_6t.sym} 0 11600 0 0 {name=Xr58c0}
N -40 11640 -60 11640 {}
C {lab_pin.sym} -60 11640 0 0 {name=l9281 lab=BL0}
N -40 11600 -60 11600 {}
C {lab_pin.sym} -60 11600 0 0 {name=l9282 lab=BLB0}
N -40 11560 -60 11560 {}
C {lab_pin.sym} -60 11560 0 0 {name=l9283 lab=WL58}
N 40 11640 60 11640 {}
C {lab_pin.sym} 60 11640 0 0 {name=l9284 lab=VDD}
N 40 11560 60 11560 {}
C {lab_pin.sym} 60 11560 0 0 {name=l9285 lab=VSS}
C {bitcell_6t.sym} 200 11600 0 0 {name=Xr58c1}
N 160 11640 140 11640 {}
C {lab_pin.sym} 140 11640 0 0 {name=l9286 lab=BL1}
N 160 11600 140 11600 {}
C {lab_pin.sym} 140 11600 0 0 {name=l9287 lab=BLB1}
N 160 11560 140 11560 {}
C {lab_pin.sym} 140 11560 0 0 {name=l9288 lab=WL58}
N 240 11640 260 11640 {}
C {lab_pin.sym} 260 11640 0 0 {name=l9289 lab=VDD}
N 240 11560 260 11560 {}
C {lab_pin.sym} 260 11560 0 0 {name=l9290 lab=VSS}
C {bitcell_6t.sym} 400 11600 0 0 {name=Xr58c2}
N 360 11640 340 11640 {}
C {lab_pin.sym} 340 11640 0 0 {name=l9291 lab=BL2}
N 360 11600 340 11600 {}
C {lab_pin.sym} 340 11600 0 0 {name=l9292 lab=BLB2}
N 360 11560 340 11560 {}
C {lab_pin.sym} 340 11560 0 0 {name=l9293 lab=WL58}
N 440 11640 460 11640 {}
C {lab_pin.sym} 460 11640 0 0 {name=l9294 lab=VDD}
N 440 11560 460 11560 {}
C {lab_pin.sym} 460 11560 0 0 {name=l9295 lab=VSS}
C {bitcell_6t.sym} 600 11600 0 0 {name=Xr58c3}
N 560 11640 540 11640 {}
C {lab_pin.sym} 540 11640 0 0 {name=l9296 lab=BL3}
N 560 11600 540 11600 {}
C {lab_pin.sym} 540 11600 0 0 {name=l9297 lab=BLB3}
N 560 11560 540 11560 {}
C {lab_pin.sym} 540 11560 0 0 {name=l9298 lab=WL58}
N 640 11640 660 11640 {}
C {lab_pin.sym} 660 11640 0 0 {name=l9299 lab=VDD}
N 640 11560 660 11560 {}
C {lab_pin.sym} 660 11560 0 0 {name=l9300 lab=VSS}
C {bitcell_6t.sym} 800 11600 0 0 {name=Xr58c4}
N 760 11640 740 11640 {}
C {lab_pin.sym} 740 11640 0 0 {name=l9301 lab=BL4}
N 760 11600 740 11600 {}
C {lab_pin.sym} 740 11600 0 0 {name=l9302 lab=BLB4}
N 760 11560 740 11560 {}
C {lab_pin.sym} 740 11560 0 0 {name=l9303 lab=WL58}
N 840 11640 860 11640 {}
C {lab_pin.sym} 860 11640 0 0 {name=l9304 lab=VDD}
N 840 11560 860 11560 {}
C {lab_pin.sym} 860 11560 0 0 {name=l9305 lab=VSS}
C {bitcell_6t.sym} 1000 11600 0 0 {name=Xr58c5}
N 960 11640 940 11640 {}
C {lab_pin.sym} 940 11640 0 0 {name=l9306 lab=BL5}
N 960 11600 940 11600 {}
C {lab_pin.sym} 940 11600 0 0 {name=l9307 lab=BLB5}
N 960 11560 940 11560 {}
C {lab_pin.sym} 940 11560 0 0 {name=l9308 lab=WL58}
N 1040 11640 1060 11640 {}
C {lab_pin.sym} 1060 11640 0 0 {name=l9309 lab=VDD}
N 1040 11560 1060 11560 {}
C {lab_pin.sym} 1060 11560 0 0 {name=l9310 lab=VSS}
C {bitcell_6t.sym} 1200 11600 0 0 {name=Xr58c6}
N 1160 11640 1140 11640 {}
C {lab_pin.sym} 1140 11640 0 0 {name=l9311 lab=BL6}
N 1160 11600 1140 11600 {}
C {lab_pin.sym} 1140 11600 0 0 {name=l9312 lab=BLB6}
N 1160 11560 1140 11560 {}
C {lab_pin.sym} 1140 11560 0 0 {name=l9313 lab=WL58}
N 1240 11640 1260 11640 {}
C {lab_pin.sym} 1260 11640 0 0 {name=l9314 lab=VDD}
N 1240 11560 1260 11560 {}
C {lab_pin.sym} 1260 11560 0 0 {name=l9315 lab=VSS}
C {bitcell_6t.sym} 1400 11600 0 0 {name=Xr58c7}
N 1360 11640 1340 11640 {}
C {lab_pin.sym} 1340 11640 0 0 {name=l9316 lab=BL7}
N 1360 11600 1340 11600 {}
C {lab_pin.sym} 1340 11600 0 0 {name=l9317 lab=BLB7}
N 1360 11560 1340 11560 {}
C {lab_pin.sym} 1340 11560 0 0 {name=l9318 lab=WL58}
N 1440 11640 1460 11640 {}
C {lab_pin.sym} 1460 11640 0 0 {name=l9319 lab=VDD}
N 1440 11560 1460 11560 {}
C {lab_pin.sym} 1460 11560 0 0 {name=l9320 lab=VSS}
C {bitcell_6t.sym} 1600 11600 0 0 {name=Xr58c8}
N 1560 11640 1540 11640 {}
C {lab_pin.sym} 1540 11640 0 0 {name=l9321 lab=BL8}
N 1560 11600 1540 11600 {}
C {lab_pin.sym} 1540 11600 0 0 {name=l9322 lab=BLB8}
N 1560 11560 1540 11560 {}
C {lab_pin.sym} 1540 11560 0 0 {name=l9323 lab=WL58}
N 1640 11640 1660 11640 {}
C {lab_pin.sym} 1660 11640 0 0 {name=l9324 lab=VDD}
N 1640 11560 1660 11560 {}
C {lab_pin.sym} 1660 11560 0 0 {name=l9325 lab=VSS}
C {bitcell_6t.sym} 1800 11600 0 0 {name=Xr58c9}
N 1760 11640 1740 11640 {}
C {lab_pin.sym} 1740 11640 0 0 {name=l9326 lab=BL9}
N 1760 11600 1740 11600 {}
C {lab_pin.sym} 1740 11600 0 0 {name=l9327 lab=BLB9}
N 1760 11560 1740 11560 {}
C {lab_pin.sym} 1740 11560 0 0 {name=l9328 lab=WL58}
N 1840 11640 1860 11640 {}
C {lab_pin.sym} 1860 11640 0 0 {name=l9329 lab=VDD}
N 1840 11560 1860 11560 {}
C {lab_pin.sym} 1860 11560 0 0 {name=l9330 lab=VSS}
C {bitcell_6t.sym} 2000 11600 0 0 {name=Xr58c10}
N 1960 11640 1940 11640 {}
C {lab_pin.sym} 1940 11640 0 0 {name=l9331 lab=BL10}
N 1960 11600 1940 11600 {}
C {lab_pin.sym} 1940 11600 0 0 {name=l9332 lab=BLB10}
N 1960 11560 1940 11560 {}
C {lab_pin.sym} 1940 11560 0 0 {name=l9333 lab=WL58}
N 2040 11640 2060 11640 {}
C {lab_pin.sym} 2060 11640 0 0 {name=l9334 lab=VDD}
N 2040 11560 2060 11560 {}
C {lab_pin.sym} 2060 11560 0 0 {name=l9335 lab=VSS}
C {bitcell_6t.sym} 2200 11600 0 0 {name=Xr58c11}
N 2160 11640 2140 11640 {}
C {lab_pin.sym} 2140 11640 0 0 {name=l9336 lab=BL11}
N 2160 11600 2140 11600 {}
C {lab_pin.sym} 2140 11600 0 0 {name=l9337 lab=BLB11}
N 2160 11560 2140 11560 {}
C {lab_pin.sym} 2140 11560 0 0 {name=l9338 lab=WL58}
