C {lab_pin.sym} 3540 50360 0 0 {name=l40413 lab=WL252}
N 3640 50440 3660 50440 {}
C {lab_pin.sym} 3660 50440 0 0 {name=l40414 lab=VDD}
N 3640 50360 3660 50360 {}
C {lab_pin.sym} 3660 50360 0 0 {name=l40415 lab=VSS}
C {bitcell_6t.sym} 3800 50400 0 0 {name=Xr252c19}
N 3760 50440 3740 50440 {}
C {lab_pin.sym} 3740 50440 0 0 {name=l40416 lab=BL19}
N 3760 50400 3740 50400 {}
C {lab_pin.sym} 3740 50400 0 0 {name=l40417 lab=BLB19}
N 3760 50360 3740 50360 {}
C {lab_pin.sym} 3740 50360 0 0 {name=l40418 lab=WL252}
N 3840 50440 3860 50440 {}
C {lab_pin.sym} 3860 50440 0 0 {name=l40419 lab=VDD}
N 3840 50360 3860 50360 {}
C {lab_pin.sym} 3860 50360 0 0 {name=l40420 lab=VSS}
C {bitcell_6t.sym} 4000 50400 0 0 {name=Xr252c20}
N 3960 50440 3940 50440 {}
C {lab_pin.sym} 3940 50440 0 0 {name=l40421 lab=BL20}
N 3960 50400 3940 50400 {}
C {lab_pin.sym} 3940 50400 0 0 {name=l40422 lab=BLB20}
N 3960 50360 3940 50360 {}
C {lab_pin.sym} 3940 50360 0 0 {name=l40423 lab=WL252}
N 4040 50440 4060 50440 {}
C {lab_pin.sym} 4060 50440 0 0 {name=l40424 lab=VDD}
N 4040 50360 4060 50360 {}
C {lab_pin.sym} 4060 50360 0 0 {name=l40425 lab=VSS}
C {bitcell_6t.sym} 4200 50400 0 0 {name=Xr252c21}
N 4160 50440 4140 50440 {}
C {lab_pin.sym} 4140 50440 0 0 {name=l40426 lab=BL21}
N 4160 50400 4140 50400 {}
C {lab_pin.sym} 4140 50400 0 0 {name=l40427 lab=BLB21}
N 4160 50360 4140 50360 {}
C {lab_pin.sym} 4140 50360 0 0 {name=l40428 lab=WL252}
N 4240 50440 4260 50440 {}
C {lab_pin.sym} 4260 50440 0 0 {name=l40429 lab=VDD}
N 4240 50360 4260 50360 {}
C {lab_pin.sym} 4260 50360 0 0 {name=l40430 lab=VSS}
C {bitcell_6t.sym} 4400 50400 0 0 {name=Xr252c22}
N 4360 50440 4340 50440 {}
C {lab_pin.sym} 4340 50440 0 0 {name=l40431 lab=BL22}
N 4360 50400 4340 50400 {}
C {lab_pin.sym} 4340 50400 0 0 {name=l40432 lab=BLB22}
N 4360 50360 4340 50360 {}
C {lab_pin.sym} 4340 50360 0 0 {name=l40433 lab=WL252}
N 4440 50440 4460 50440 {}
C {lab_pin.sym} 4460 50440 0 0 {name=l40434 lab=VDD}
N 4440 50360 4460 50360 {}
C {lab_pin.sym} 4460 50360 0 0 {name=l40435 lab=VSS}
C {bitcell_6t.sym} 4600 50400 0 0 {name=Xr252c23}
N 4560 50440 4540 50440 {}
C {lab_pin.sym} 4540 50440 0 0 {name=l40436 lab=BL23}
N 4560 50400 4540 50400 {}
C {lab_pin.sym} 4540 50400 0 0 {name=l40437 lab=BLB23}
N 4560 50360 4540 50360 {}
C {lab_pin.sym} 4540 50360 0 0 {name=l40438 lab=WL252}
N 4640 50440 4660 50440 {}
C {lab_pin.sym} 4660 50440 0 0 {name=l40439 lab=VDD}
N 4640 50360 4660 50360 {}
C {lab_pin.sym} 4660 50360 0 0 {name=l40440 lab=VSS}
C {bitcell_6t.sym} 4800 50400 0 0 {name=Xr252c24}
N 4760 50440 4740 50440 {}
C {lab_pin.sym} 4740 50440 0 0 {name=l40441 lab=BL24}
N 4760 50400 4740 50400 {}
C {lab_pin.sym} 4740 50400 0 0 {name=l40442 lab=BLB24}
N 4760 50360 4740 50360 {}
C {lab_pin.sym} 4740 50360 0 0 {name=l40443 lab=WL252}
N 4840 50440 4860 50440 {}
C {lab_pin.sym} 4860 50440 0 0 {name=l40444 lab=VDD}
N 4840 50360 4860 50360 {}
C {lab_pin.sym} 4860 50360 0 0 {name=l40445 lab=VSS}
C {bitcell_6t.sym} 5000 50400 0 0 {name=Xr252c25}
N 4960 50440 4940 50440 {}
C {lab_pin.sym} 4940 50440 0 0 {name=l40446 lab=BL25}
N 4960 50400 4940 50400 {}
C {lab_pin.sym} 4940 50400 0 0 {name=l40447 lab=BLB25}
N 4960 50360 4940 50360 {}
C {lab_pin.sym} 4940 50360 0 0 {name=l40448 lab=WL252}
N 5040 50440 5060 50440 {}
C {lab_pin.sym} 5060 50440 0 0 {name=l40449 lab=VDD}
N 5040 50360 5060 50360 {}
C {lab_pin.sym} 5060 50360 0 0 {name=l40450 lab=VSS}
C {bitcell_6t.sym} 5200 50400 0 0 {name=Xr252c26}
N 5160 50440 5140 50440 {}
C {lab_pin.sym} 5140 50440 0 0 {name=l40451 lab=BL26}
N 5160 50400 5140 50400 {}
C {lab_pin.sym} 5140 50400 0 0 {name=l40452 lab=BLB26}
N 5160 50360 5140 50360 {}
C {lab_pin.sym} 5140 50360 0 0 {name=l40453 lab=WL252}
N 5240 50440 5260 50440 {}
C {lab_pin.sym} 5260 50440 0 0 {name=l40454 lab=VDD}
N 5240 50360 5260 50360 {}
C {lab_pin.sym} 5260 50360 0 0 {name=l40455 lab=VSS}
C {bitcell_6t.sym} 5400 50400 0 0 {name=Xr252c27}
N 5360 50440 5340 50440 {}
C {lab_pin.sym} 5340 50440 0 0 {name=l40456 lab=BL27}
N 5360 50400 5340 50400 {}
C {lab_pin.sym} 5340 50400 0 0 {name=l40457 lab=BLB27}
N 5360 50360 5340 50360 {}
C {lab_pin.sym} 5340 50360 0 0 {name=l40458 lab=WL252}
N 5440 50440 5460 50440 {}
C {lab_pin.sym} 5460 50440 0 0 {name=l40459 lab=VDD}
N 5440 50360 5460 50360 {}
C {lab_pin.sym} 5460 50360 0 0 {name=l40460 lab=VSS}
C {bitcell_6t.sym} 5600 50400 0 0 {name=Xr252c28}
N 5560 50440 5540 50440 {}
C {lab_pin.sym} 5540 50440 0 0 {name=l40461 lab=BL28}
N 5560 50400 5540 50400 {}
C {lab_pin.sym} 5540 50400 0 0 {name=l40462 lab=BLB28}
N 5560 50360 5540 50360 {}
C {lab_pin.sym} 5540 50360 0 0 {name=l40463 lab=WL252}
N 5640 50440 5660 50440 {}
C {lab_pin.sym} 5660 50440 0 0 {name=l40464 lab=VDD}
N 5640 50360 5660 50360 {}
C {lab_pin.sym} 5660 50360 0 0 {name=l40465 lab=VSS}
C {bitcell_6t.sym} 5800 50400 0 0 {name=Xr252c29}
N 5760 50440 5740 50440 {}
C {lab_pin.sym} 5740 50440 0 0 {name=l40466 lab=BL29}
N 5760 50400 5740 50400 {}
C {lab_pin.sym} 5740 50400 0 0 {name=l40467 lab=BLB29}
N 5760 50360 5740 50360 {}
C {lab_pin.sym} 5740 50360 0 0 {name=l40468 lab=WL252}
N 5840 50440 5860 50440 {}
C {lab_pin.sym} 5860 50440 0 0 {name=l40469 lab=VDD}
N 5840 50360 5860 50360 {}
C {lab_pin.sym} 5860 50360 0 0 {name=l40470 lab=VSS}
C {bitcell_6t.sym} 6000 50400 0 0 {name=Xr252c30}
N 5960 50440 5940 50440 {}
C {lab_pin.sym} 5940 50440 0 0 {name=l40471 lab=BL30}
N 5960 50400 5940 50400 {}
C {lab_pin.sym} 5940 50400 0 0 {name=l40472 lab=BLB30}
N 5960 50360 5940 50360 {}
C {lab_pin.sym} 5940 50360 0 0 {name=l40473 lab=WL252}
N 6040 50440 6060 50440 {}
C {lab_pin.sym} 6060 50440 0 0 {name=l40474 lab=VDD}
N 6040 50360 6060 50360 {}
C {lab_pin.sym} 6060 50360 0 0 {name=l40475 lab=VSS}
C {bitcell_6t.sym} 6200 50400 0 0 {name=Xr252c31}
N 6160 50440 6140 50440 {}
C {lab_pin.sym} 6140 50440 0 0 {name=l40476 lab=BL31}
N 6160 50400 6140 50400 {}
C {lab_pin.sym} 6140 50400 0 0 {name=l40477 lab=BLB31}
N 6160 50360 6140 50360 {}
C {lab_pin.sym} 6140 50360 0 0 {name=l40478 lab=WL252}
N 6240 50440 6260 50440 {}
C {lab_pin.sym} 6260 50440 0 0 {name=l40479 lab=VDD}
N 6240 50360 6260 50360 {}
C {lab_pin.sym} 6260 50360 0 0 {name=l40480 lab=VSS}
C {bitcell_6t.sym} 0 50600 0 0 {name=Xr253c0}
N -40 50640 -60 50640 {}
C {lab_pin.sym} -60 50640 0 0 {name=l40481 lab=BL0}
N -40 50600 -60 50600 {}
C {lab_pin.sym} -60 50600 0 0 {name=l40482 lab=BLB0}
N -40 50560 -60 50560 {}
C {lab_pin.sym} -60 50560 0 0 {name=l40483 lab=WL253}
N 40 50640 60 50640 {}
C {lab_pin.sym} 60 50640 0 0 {name=l40484 lab=VDD}
N 40 50560 60 50560 {}
C {lab_pin.sym} 60 50560 0 0 {name=l40485 lab=VSS}
C {bitcell_6t.sym} 200 50600 0 0 {name=Xr253c1}
N 160 50640 140 50640 {}
C {lab_pin.sym} 140 50640 0 0 {name=l40486 lab=BL1}
N 160 50600 140 50600 {}
C {lab_pin.sym} 140 50600 0 0 {name=l40487 lab=BLB1}
N 160 50560 140 50560 {}
C {lab_pin.sym} 140 50560 0 0 {name=l40488 lab=WL253}
N 240 50640 260 50640 {}
C {lab_pin.sym} 260 50640 0 0 {name=l40489 lab=VDD}
N 240 50560 260 50560 {}
C {lab_pin.sym} 260 50560 0 0 {name=l40490 lab=VSS}
C {bitcell_6t.sym} 400 50600 0 0 {name=Xr253c2}
N 360 50640 340 50640 {}
C {lab_pin.sym} 340 50640 0 0 {name=l40491 lab=BL2}
N 360 50600 340 50600 {}
C {lab_pin.sym} 340 50600 0 0 {name=l40492 lab=BLB2}
N 360 50560 340 50560 {}
C {lab_pin.sym} 340 50560 0 0 {name=l40493 lab=WL253}
N 440 50640 460 50640 {}
C {lab_pin.sym} 460 50640 0 0 {name=l40494 lab=VDD}
N 440 50560 460 50560 {}
C {lab_pin.sym} 460 50560 0 0 {name=l40495 lab=VSS}
C {bitcell_6t.sym} 600 50600 0 0 {name=Xr253c3}
N 560 50640 540 50640 {}
C {lab_pin.sym} 540 50640 0 0 {name=l40496 lab=BL3}
N 560 50600 540 50600 {}
C {lab_pin.sym} 540 50600 0 0 {name=l40497 lab=BLB3}
N 560 50560 540 50560 {}
C {lab_pin.sym} 540 50560 0 0 {name=l40498 lab=WL253}
N 640 50640 660 50640 {}
C {lab_pin.sym} 660 50640 0 0 {name=l40499 lab=VDD}
N 640 50560 660 50560 {}
C {lab_pin.sym} 660 50560 0 0 {name=l40500 lab=VSS}
C {bitcell_6t.sym} 800 50600 0 0 {name=Xr253c4}
N 760 50640 740 50640 {}
C {lab_pin.sym} 740 50640 0 0 {name=l40501 lab=BL4}
N 760 50600 740 50600 {}
C {lab_pin.sym} 740 50600 0 0 {name=l40502 lab=BLB4}
N 760 50560 740 50560 {}
C {lab_pin.sym} 740 50560 0 0 {name=l40503 lab=WL253}
N 840 50640 860 50640 {}
C {lab_pin.sym} 860 50640 0 0 {name=l40504 lab=VDD}
N 840 50560 860 50560 {}
C {lab_pin.sym} 860 50560 0 0 {name=l40505 lab=VSS}
C {bitcell_6t.sym} 1000 50600 0 0 {name=Xr253c5}
N 960 50640 940 50640 {}
C {lab_pin.sym} 940 50640 0 0 {name=l40506 lab=BL5}
N 960 50600 940 50600 {}
C {lab_pin.sym} 940 50600 0 0 {name=l40507 lab=BLB5}
N 960 50560 940 50560 {}
C {lab_pin.sym} 940 50560 0 0 {name=l40508 lab=WL253}
N 1040 50640 1060 50640 {}
C {lab_pin.sym} 1060 50640 0 0 {name=l40509 lab=VDD}
N 1040 50560 1060 50560 {}
C {lab_pin.sym} 1060 50560 0 0 {name=l40510 lab=VSS}
C {bitcell_6t.sym} 1200 50600 0 0 {name=Xr253c6}
N 1160 50640 1140 50640 {}
C {lab_pin.sym} 1140 50640 0 0 {name=l40511 lab=BL6}
N 1160 50600 1140 50600 {}
C {lab_pin.sym} 1140 50600 0 0 {name=l40512 lab=BLB6}
N 1160 50560 1140 50560 {}
C {lab_pin.sym} 1140 50560 0 0 {name=l40513 lab=WL253}
N 1240 50640 1260 50640 {}
C {lab_pin.sym} 1260 50640 0 0 {name=l40514 lab=VDD}
N 1240 50560 1260 50560 {}
C {lab_pin.sym} 1260 50560 0 0 {name=l40515 lab=VSS}
C {bitcell_6t.sym} 1400 50600 0 0 {name=Xr253c7}
N 1360 50640 1340 50640 {}
C {lab_pin.sym} 1340 50640 0 0 {name=l40516 lab=BL7}
N 1360 50600 1340 50600 {}
C {lab_pin.sym} 1340 50600 0 0 {name=l40517 lab=BLB7}
N 1360 50560 1340 50560 {}
C {lab_pin.sym} 1340 50560 0 0 {name=l40518 lab=WL253}
N 1440 50640 1460 50640 {}
C {lab_pin.sym} 1460 50640 0 0 {name=l40519 lab=VDD}
N 1440 50560 1460 50560 {}
C {lab_pin.sym} 1460 50560 0 0 {name=l40520 lab=VSS}
C {bitcell_6t.sym} 1600 50600 0 0 {name=Xr253c8}
N 1560 50640 1540 50640 {}
C {lab_pin.sym} 1540 50640 0 0 {name=l40521 lab=BL8}
N 1560 50600 1540 50600 {}
C {lab_pin.sym} 1540 50600 0 0 {name=l40522 lab=BLB8}
N 1560 50560 1540 50560 {}
C {lab_pin.sym} 1540 50560 0 0 {name=l40523 lab=WL253}
N 1640 50640 1660 50640 {}
C {lab_pin.sym} 1660 50640 0 0 {name=l40524 lab=VDD}
N 1640 50560 1660 50560 {}
C {lab_pin.sym} 1660 50560 0 0 {name=l40525 lab=VSS}
C {bitcell_6t.sym} 1800 50600 0 0 {name=Xr253c9}
N 1760 50640 1740 50640 {}
C {lab_pin.sym} 1740 50640 0 0 {name=l40526 lab=BL9}
N 1760 50600 1740 50600 {}
C {lab_pin.sym} 1740 50600 0 0 {name=l40527 lab=BLB9}
N 1760 50560 1740 50560 {}
C {lab_pin.sym} 1740 50560 0 0 {name=l40528 lab=WL253}
N 1840 50640 1860 50640 {}
C {lab_pin.sym} 1860 50640 0 0 {name=l40529 lab=VDD}
N 1840 50560 1860 50560 {}
C {lab_pin.sym} 1860 50560 0 0 {name=l40530 lab=VSS}
C {bitcell_6t.sym} 2000 50600 0 0 {name=Xr253c10}
N 1960 50640 1940 50640 {}
C {lab_pin.sym} 1940 50640 0 0 {name=l40531 lab=BL10}
N 1960 50600 1940 50600 {}
C {lab_pin.sym} 1940 50600 0 0 {name=l40532 lab=BLB10}
N 1960 50560 1940 50560 {}
C {lab_pin.sym} 1940 50560 0 0 {name=l40533 lab=WL253}
N 2040 50640 2060 50640 {}
C {lab_pin.sym} 2060 50640 0 0 {name=l40534 lab=VDD}
N 2040 50560 2060 50560 {}
C {lab_pin.sym} 2060 50560 0 0 {name=l40535 lab=VSS}
C {bitcell_6t.sym} 2200 50600 0 0 {name=Xr253c11}
N 2160 50640 2140 50640 {}
C {lab_pin.sym} 2140 50640 0 0 {name=l40536 lab=BL11}
N 2160 50600 2140 50600 {}
C {lab_pin.sym} 2140 50600 0 0 {name=l40537 lab=BLB11}
N 2160 50560 2140 50560 {}
C {lab_pin.sym} 2140 50560 0 0 {name=l40538 lab=WL253}
N 2240 50640 2260 50640 {}
C {lab_pin.sym} 2260 50640 0 0 {name=l40539 lab=VDD}
N 2240 50560 2260 50560 {}
C {lab_pin.sym} 2260 50560 0 0 {name=l40540 lab=VSS}
C {bitcell_6t.sym} 2400 50600 0 0 {name=Xr253c12}
N 2360 50640 2340 50640 {}
C {lab_pin.sym} 2340 50640 0 0 {name=l40541 lab=BL12}
N 2360 50600 2340 50600 {}
C {lab_pin.sym} 2340 50600 0 0 {name=l40542 lab=BLB12}
N 2360 50560 2340 50560 {}
C {lab_pin.sym} 2340 50560 0 0 {name=l40543 lab=WL253}
N 2440 50640 2460 50640 {}
C {lab_pin.sym} 2460 50640 0 0 {name=l40544 lab=VDD}
N 2440 50560 2460 50560 {}
C {lab_pin.sym} 2460 50560 0 0 {name=l40545 lab=VSS}
C {bitcell_6t.sym} 2600 50600 0 0 {name=Xr253c13}
N 2560 50640 2540 50640 {}
C {lab_pin.sym} 2540 50640 0 0 {name=l40546 lab=BL13}
N 2560 50600 2540 50600 {}
C {lab_pin.sym} 2540 50600 0 0 {name=l40547 lab=BLB13}
N 2560 50560 2540 50560 {}
C {lab_pin.sym} 2540 50560 0 0 {name=l40548 lab=WL253}
N 2640 50640 2660 50640 {}
C {lab_pin.sym} 2660 50640 0 0 {name=l40549 lab=VDD}
N 2640 50560 2660 50560 {}
C {lab_pin.sym} 2660 50560 0 0 {name=l40550 lab=VSS}
C {bitcell_6t.sym} 2800 50600 0 0 {name=Xr253c14}
N 2760 50640 2740 50640 {}
C {lab_pin.sym} 2740 50640 0 0 {name=l40551 lab=BL14}
N 2760 50600 2740 50600 {}
C {lab_pin.sym} 2740 50600 0 0 {name=l40552 lab=BLB14}
N 2760 50560 2740 50560 {}
C {lab_pin.sym} 2740 50560 0 0 {name=l40553 lab=WL253}
N 2840 50640 2860 50640 {}
C {lab_pin.sym} 2860 50640 0 0 {name=l40554 lab=VDD}
N 2840 50560 2860 50560 {}
C {lab_pin.sym} 2860 50560 0 0 {name=l40555 lab=VSS}
C {bitcell_6t.sym} 3000 50600 0 0 {name=Xr253c15}
N 2960 50640 2940 50640 {}
C {lab_pin.sym} 2940 50640 0 0 {name=l40556 lab=BL15}
N 2960 50600 2940 50600 {}
C {lab_pin.sym} 2940 50600 0 0 {name=l40557 lab=BLB15}
N 2960 50560 2940 50560 {}
C {lab_pin.sym} 2940 50560 0 0 {name=l40558 lab=WL253}
N 3040 50640 3060 50640 {}
C {lab_pin.sym} 3060 50640 0 0 {name=l40559 lab=VDD}
N 3040 50560 3060 50560 {}
C {lab_pin.sym} 3060 50560 0 0 {name=l40560 lab=VSS}
C {bitcell_6t.sym} 3200 50600 0 0 {name=Xr253c16}
N 3160 50640 3140 50640 {}
C {lab_pin.sym} 3140 50640 0 0 {name=l40561 lab=BL16}
N 3160 50600 3140 50600 {}
C {lab_pin.sym} 3140 50600 0 0 {name=l40562 lab=BLB16}
N 3160 50560 3140 50560 {}
C {lab_pin.sym} 3140 50560 0 0 {name=l40563 lab=WL253}
N 3240 50640 3260 50640 {}
C {lab_pin.sym} 3260 50640 0 0 {name=l40564 lab=VDD}
N 3240 50560 3260 50560 {}
C {lab_pin.sym} 3260 50560 0 0 {name=l40565 lab=VSS}
C {bitcell_6t.sym} 3400 50600 0 0 {name=Xr253c17}
N 3360 50640 3340 50640 {}
C {lab_pin.sym} 3340 50640 0 0 {name=l40566 lab=BL17}
N 3360 50600 3340 50600 {}
C {lab_pin.sym} 3340 50600 0 0 {name=l40567 lab=BLB17}
N 3360 50560 3340 50560 {}
C {lab_pin.sym} 3340 50560 0 0 {name=l40568 lab=WL253}
N 3440 50640 3460 50640 {}
C {lab_pin.sym} 3460 50640 0 0 {name=l40569 lab=VDD}
N 3440 50560 3460 50560 {}
C {lab_pin.sym} 3460 50560 0 0 {name=l40570 lab=VSS}
C {bitcell_6t.sym} 3600 50600 0 0 {name=Xr253c18}
N 3560 50640 3540 50640 {}
C {lab_pin.sym} 3540 50640 0 0 {name=l40571 lab=BL18}
N 3560 50600 3540 50600 {}
C {lab_pin.sym} 3540 50600 0 0 {name=l40572 lab=BLB18}
N 3560 50560 3540 50560 {}
C {lab_pin.sym} 3540 50560 0 0 {name=l40573 lab=WL253}
N 3640 50640 3660 50640 {}
C {lab_pin.sym} 3660 50640 0 0 {name=l40574 lab=VDD}
N 3640 50560 3660 50560 {}
C {lab_pin.sym} 3660 50560 0 0 {name=l40575 lab=VSS}
C {bitcell_6t.sym} 3800 50600 0 0 {name=Xr253c19}
N 3760 50640 3740 50640 {}
C {lab_pin.sym} 3740 50640 0 0 {name=l40576 lab=BL19}
N 3760 50600 3740 50600 {}
C {lab_pin.sym} 3740 50600 0 0 {name=l40577 lab=BLB19}
N 3760 50560 3740 50560 {}
C {lab_pin.sym} 3740 50560 0 0 {name=l40578 lab=WL253}
N 3840 50640 3860 50640 {}
C {lab_pin.sym} 3860 50640 0 0 {name=l40579 lab=VDD}
N 3840 50560 3860 50560 {}
C {lab_pin.sym} 3860 50560 0 0 {name=l40580 lab=VSS}
C {bitcell_6t.sym} 4000 50600 0 0 {name=Xr253c20}
N 3960 50640 3940 50640 {}
C {lab_pin.sym} 3940 50640 0 0 {name=l40581 lab=BL20}
N 3960 50600 3940 50600 {}
C {lab_pin.sym} 3940 50600 0 0 {name=l40582 lab=BLB20}
N 3960 50560 3940 50560 {}
C {lab_pin.sym} 3940 50560 0 0 {name=l40583 lab=WL253}
N 4040 50640 4060 50640 {}
C {lab_pin.sym} 4060 50640 0 0 {name=l40584 lab=VDD}
N 4040 50560 4060 50560 {}
C {lab_pin.sym} 4060 50560 0 0 {name=l40585 lab=VSS}
C {bitcell_6t.sym} 4200 50600 0 0 {name=Xr253c21}
N 4160 50640 4140 50640 {}
C {lab_pin.sym} 4140 50640 0 0 {name=l40586 lab=BL21}
N 4160 50600 4140 50600 {}
C {lab_pin.sym} 4140 50600 0 0 {name=l40587 lab=BLB21}
N 4160 50560 4140 50560 {}
C {lab_pin.sym} 4140 50560 0 0 {name=l40588 lab=WL253}
N 4240 50640 4260 50640 {}
C {lab_pin.sym} 4260 50640 0 0 {name=l40589 lab=VDD}
N 4240 50560 4260 50560 {}
C {lab_pin.sym} 4260 50560 0 0 {name=l40590 lab=VSS}
C {bitcell_6t.sym} 4400 50600 0 0 {name=Xr253c22}
N 4360 50640 4340 50640 {}
C {lab_pin.sym} 4340 50640 0 0 {name=l40591 lab=BL22}
N 4360 50600 4340 50600 {}
C {lab_pin.sym} 4340 50600 0 0 {name=l40592 lab=BLB22}
N 4360 50560 4340 50560 {}
C {lab_pin.sym} 4340 50560 0 0 {name=l40593 lab=WL253}
N 4440 50640 4460 50640 {}
C {lab_pin.sym} 4460 50640 0 0 {name=l40594 lab=VDD}
N 4440 50560 4460 50560 {}
C {lab_pin.sym} 4460 50560 0 0 {name=l40595 lab=VSS}
C {bitcell_6t.sym} 4600 50600 0 0 {name=Xr253c23}
N 4560 50640 4540 50640 {}
C {lab_pin.sym} 4540 50640 0 0 {name=l40596 lab=BL23}
N 4560 50600 4540 50600 {}
C {lab_pin.sym} 4540 50600 0 0 {name=l40597 lab=BLB23}
N 4560 50560 4540 50560 {}
C {lab_pin.sym} 4540 50560 0 0 {name=l40598 lab=WL253}
N 4640 50640 4660 50640 {}
C {lab_pin.sym} 4660 50640 0 0 {name=l40599 lab=VDD}
N 4640 50560 4660 50560 {}
C {lab_pin.sym} 4660 50560 0 0 {name=l40600 lab=VSS}
C {bitcell_6t.sym} 4800 50600 0 0 {name=Xr253c24}
N 4760 50640 4740 50640 {}
C {lab_pin.sym} 4740 50640 0 0 {name=l40601 lab=BL24}
N 4760 50600 4740 50600 {}
C {lab_pin.sym} 4740 50600 0 0 {name=l40602 lab=BLB24}
N 4760 50560 4740 50560 {}
C {lab_pin.sym} 4740 50560 0 0 {name=l40603 lab=WL253}
N 4840 50640 4860 50640 {}
C {lab_pin.sym} 4860 50640 0 0 {name=l40604 lab=VDD}
N 4840 50560 4860 50560 {}
C {lab_pin.sym} 4860 50560 0 0 {name=l40605 lab=VSS}
C {bitcell_6t.sym} 5000 50600 0 0 {name=Xr253c25}
N 4960 50640 4940 50640 {}
C {lab_pin.sym} 4940 50640 0 0 {name=l40606 lab=BL25}
N 4960 50600 4940 50600 {}
C {lab_pin.sym} 4940 50600 0 0 {name=l40607 lab=BLB25}
N 4960 50560 4940 50560 {}
C {lab_pin.sym} 4940 50560 0 0 {name=l40608 lab=WL253}
N 5040 50640 5060 50640 {}
C {lab_pin.sym} 5060 50640 0 0 {name=l40609 lab=VDD}
N 5040 50560 5060 50560 {}
C {lab_pin.sym} 5060 50560 0 0 {name=l40610 lab=VSS}
C {bitcell_6t.sym} 5200 50600 0 0 {name=Xr253c26}
N 5160 50640 5140 50640 {}
C {lab_pin.sym} 5140 50640 0 0 {name=l40611 lab=BL26}
N 5160 50600 5140 50600 {}
C {lab_pin.sym} 5140 50600 0 0 {name=l40612 lab=BLB26}
N 5160 50560 5140 50560 {}
C {lab_pin.sym} 5140 50560 0 0 {name=l40613 lab=WL253}
N 5240 50640 5260 50640 {}
C {lab_pin.sym} 5260 50640 0 0 {name=l40614 lab=VDD}
N 5240 50560 5260 50560 {}
C {lab_pin.sym} 5260 50560 0 0 {name=l40615 lab=VSS}
C {bitcell_6t.sym} 5400 50600 0 0 {name=Xr253c27}
N 5360 50640 5340 50640 {}
C {lab_pin.sym} 5340 50640 0 0 {name=l40616 lab=BL27}
N 5360 50600 5340 50600 {}
C {lab_pin.sym} 5340 50600 0 0 {name=l40617 lab=BLB27}
N 5360 50560 5340 50560 {}
C {lab_pin.sym} 5340 50560 0 0 {name=l40618 lab=WL253}
N 5440 50640 5460 50640 {}
C {lab_pin.sym} 5460 50640 0 0 {name=l40619 lab=VDD}
N 5440 50560 5460 50560 {}
C {lab_pin.sym} 5460 50560 0 0 {name=l40620 lab=VSS}
C {bitcell_6t.sym} 5600 50600 0 0 {name=Xr253c28}
N 5560 50640 5540 50640 {}
C {lab_pin.sym} 5540 50640 0 0 {name=l40621 lab=BL28}
N 5560 50600 5540 50600 {}
C {lab_pin.sym} 5540 50600 0 0 {name=l40622 lab=BLB28}
N 5560 50560 5540 50560 {}
C {lab_pin.sym} 5540 50560 0 0 {name=l40623 lab=WL253}
N 5640 50640 5660 50640 {}
C {lab_pin.sym} 5660 50640 0 0 {name=l40624 lab=VDD}
N 5640 50560 5660 50560 {}
C {lab_pin.sym} 5660 50560 0 0 {name=l40625 lab=VSS}
C {bitcell_6t.sym} 5800 50600 0 0 {name=Xr253c29}
N 5760 50640 5740 50640 {}
C {lab_pin.sym} 5740 50640 0 0 {name=l40626 lab=BL29}
N 5760 50600 5740 50600 {}
C {lab_pin.sym} 5740 50600 0 0 {name=l40627 lab=BLB29}
N 5760 50560 5740 50560 {}
C {lab_pin.sym} 5740 50560 0 0 {name=l40628 lab=WL253}
N 5840 50640 5860 50640 {}
C {lab_pin.sym} 5860 50640 0 0 {name=l40629 lab=VDD}
N 5840 50560 5860 50560 {}
C {lab_pin.sym} 5860 50560 0 0 {name=l40630 lab=VSS}
C {bitcell_6t.sym} 6000 50600 0 0 {name=Xr253c30}
N 5960 50640 5940 50640 {}
C {lab_pin.sym} 5940 50640 0 0 {name=l40631 lab=BL30}
N 5960 50600 5940 50600 {}
C {lab_pin.sym} 5940 50600 0 0 {name=l40632 lab=BLB30}
N 5960 50560 5940 50560 {}
C {lab_pin.sym} 5940 50560 0 0 {name=l40633 lab=WL253}
N 6040 50640 6060 50640 {}
C {lab_pin.sym} 6060 50640 0 0 {name=l40634 lab=VDD}
N 6040 50560 6060 50560 {}
C {lab_pin.sym} 6060 50560 0 0 {name=l40635 lab=VSS}
C {bitcell_6t.sym} 6200 50600 0 0 {name=Xr253c31}
N 6160 50640 6140 50640 {}
C {lab_pin.sym} 6140 50640 0 0 {name=l40636 lab=BL31}
N 6160 50600 6140 50600 {}
C {lab_pin.sym} 6140 50600 0 0 {name=l40637 lab=BLB31}
N 6160 50560 6140 50560 {}
C {lab_pin.sym} 6140 50560 0 0 {name=l40638 lab=WL253}
N 6240 50640 6260 50640 {}
C {lab_pin.sym} 6260 50640 0 0 {name=l40639 lab=VDD}
N 6240 50560 6260 50560 {}
C {lab_pin.sym} 6260 50560 0 0 {name=l40640 lab=VSS}
C {bitcell_6t.sym} 0 50800 0 0 {name=Xr254c0}
N -40 50840 -60 50840 {}
C {lab_pin.sym} -60 50840 0 0 {name=l40641 lab=BL0}
N -40 50800 -60 50800 {}
C {lab_pin.sym} -60 50800 0 0 {name=l40642 lab=BLB0}
N -40 50760 -60 50760 {}
C {lab_pin.sym} -60 50760 0 0 {name=l40643 lab=WL254}
N 40 50840 60 50840 {}
C {lab_pin.sym} 60 50840 0 0 {name=l40644 lab=VDD}
N 40 50760 60 50760 {}
C {lab_pin.sym} 60 50760 0 0 {name=l40645 lab=VSS}
C {bitcell_6t.sym} 200 50800 0 0 {name=Xr254c1}
N 160 50840 140 50840 {}
C {lab_pin.sym} 140 50840 0 0 {name=l40646 lab=BL1}
N 160 50800 140 50800 {}
C {lab_pin.sym} 140 50800 0 0 {name=l40647 lab=BLB1}
N 160 50760 140 50760 {}
C {lab_pin.sym} 140 50760 0 0 {name=l40648 lab=WL254}
N 240 50840 260 50840 {}
C {lab_pin.sym} 260 50840 0 0 {name=l40649 lab=VDD}
N 240 50760 260 50760 {}
C {lab_pin.sym} 260 50760 0 0 {name=l40650 lab=VSS}
C {bitcell_6t.sym} 400 50800 0 0 {name=Xr254c2}
N 360 50840 340 50840 {}
C {lab_pin.sym} 340 50840 0 0 {name=l40651 lab=BL2}
N 360 50800 340 50800 {}
C {lab_pin.sym} 340 50800 0 0 {name=l40652 lab=BLB2}
N 360 50760 340 50760 {}
C {lab_pin.sym} 340 50760 0 0 {name=l40653 lab=WL254}
N 440 50840 460 50840 {}
C {lab_pin.sym} 460 50840 0 0 {name=l40654 lab=VDD}
N 440 50760 460 50760 {}
C {lab_pin.sym} 460 50760 0 0 {name=l40655 lab=VSS}
C {bitcell_6t.sym} 600 50800 0 0 {name=Xr254c3}
N 560 50840 540 50840 {}
C {lab_pin.sym} 540 50840 0 0 {name=l40656 lab=BL3}
N 560 50800 540 50800 {}
C {lab_pin.sym} 540 50800 0 0 {name=l40657 lab=BLB3}
N 560 50760 540 50760 {}
C {lab_pin.sym} 540 50760 0 0 {name=l40658 lab=WL254}
N 640 50840 660 50840 {}
C {lab_pin.sym} 660 50840 0 0 {name=l40659 lab=VDD}
N 640 50760 660 50760 {}
C {lab_pin.sym} 660 50760 0 0 {name=l40660 lab=VSS}
C {bitcell_6t.sym} 800 50800 0 0 {name=Xr254c4}
N 760 50840 740 50840 {}
C {lab_pin.sym} 740 50840 0 0 {name=l40661 lab=BL4}
N 760 50800 740 50800 {}
C {lab_pin.sym} 740 50800 0 0 {name=l40662 lab=BLB4}
N 760 50760 740 50760 {}
C {lab_pin.sym} 740 50760 0 0 {name=l40663 lab=WL254}
N 840 50840 860 50840 {}
C {lab_pin.sym} 860 50840 0 0 {name=l40664 lab=VDD}
N 840 50760 860 50760 {}
C {lab_pin.sym} 860 50760 0 0 {name=l40665 lab=VSS}
C {bitcell_6t.sym} 1000 50800 0 0 {name=Xr254c5}
N 960 50840 940 50840 {}
C {lab_pin.sym} 940 50840 0 0 {name=l40666 lab=BL5}
N 960 50800 940 50800 {}
C {lab_pin.sym} 940 50800 0 0 {name=l40667 lab=BLB5}
N 960 50760 940 50760 {}
C {lab_pin.sym} 940 50760 0 0 {name=l40668 lab=WL254}
N 1040 50840 1060 50840 {}
C {lab_pin.sym} 1060 50840 0 0 {name=l40669 lab=VDD}
N 1040 50760 1060 50760 {}
C {lab_pin.sym} 1060 50760 0 0 {name=l40670 lab=VSS}
C {bitcell_6t.sym} 1200 50800 0 0 {name=Xr254c6}
N 1160 50840 1140 50840 {}
C {lab_pin.sym} 1140 50840 0 0 {name=l40671 lab=BL6}
N 1160 50800 1140 50800 {}
C {lab_pin.sym} 1140 50800 0 0 {name=l40672 lab=BLB6}
N 1160 50760 1140 50760 {}
C {lab_pin.sym} 1140 50760 0 0 {name=l40673 lab=WL254}
N 1240 50840 1260 50840 {}
C {lab_pin.sym} 1260 50840 0 0 {name=l40674 lab=VDD}
N 1240 50760 1260 50760 {}
C {lab_pin.sym} 1260 50760 0 0 {name=l40675 lab=VSS}
C {bitcell_6t.sym} 1400 50800 0 0 {name=Xr254c7}
N 1360 50840 1340 50840 {}
C {lab_pin.sym} 1340 50840 0 0 {name=l40676 lab=BL7}
N 1360 50800 1340 50800 {}
C {lab_pin.sym} 1340 50800 0 0 {name=l40677 lab=BLB7}
N 1360 50760 1340 50760 {}
C {lab_pin.sym} 1340 50760 0 0 {name=l40678 lab=WL254}
N 1440 50840 1460 50840 {}
C {lab_pin.sym} 1460 50840 0 0 {name=l40679 lab=VDD}
N 1440 50760 1460 50760 {}
C {lab_pin.sym} 1460 50760 0 0 {name=l40680 lab=VSS}
C {bitcell_6t.sym} 1600 50800 0 0 {name=Xr254c8}
N 1560 50840 1540 50840 {}
C {lab_pin.sym} 1540 50840 0 0 {name=l40681 lab=BL8}
N 1560 50800 1540 50800 {}
C {lab_pin.sym} 1540 50800 0 0 {name=l40682 lab=BLB8}
N 1560 50760 1540 50760 {}
C {lab_pin.sym} 1540 50760 0 0 {name=l40683 lab=WL254}
N 1640 50840 1660 50840 {}
C {lab_pin.sym} 1660 50840 0 0 {name=l40684 lab=VDD}
N 1640 50760 1660 50760 {}
C {lab_pin.sym} 1660 50760 0 0 {name=l40685 lab=VSS}
C {bitcell_6t.sym} 1800 50800 0 0 {name=Xr254c9}
N 1760 50840 1740 50840 {}
C {lab_pin.sym} 1740 50840 0 0 {name=l40686 lab=BL9}
N 1760 50800 1740 50800 {}
C {lab_pin.sym} 1740 50800 0 0 {name=l40687 lab=BLB9}
N 1760 50760 1740 50760 {}
C {lab_pin.sym} 1740 50760 0 0 {name=l40688 lab=WL254}
N 1840 50840 1860 50840 {}
C {lab_pin.sym} 1860 50840 0 0 {name=l40689 lab=VDD}
N 1840 50760 1860 50760 {}
C {lab_pin.sym} 1860 50760 0 0 {name=l40690 lab=VSS}
C {bitcell_6t.sym} 2000 50800 0 0 {name=Xr254c10}
N 1960 50840 1940 50840 {}
C {lab_pin.sym} 1940 50840 0 0 {name=l40691 lab=BL10}
N 1960 50800 1940 50800 {}
C {lab_pin.sym} 1940 50800 0 0 {name=l40692 lab=BLB10}
N 1960 50760 1940 50760 {}
C {lab_pin.sym} 1940 50760 0 0 {name=l40693 lab=WL254}
N 2040 50840 2060 50840 {}
C {lab_pin.sym} 2060 50840 0 0 {name=l40694 lab=VDD}
N 2040 50760 2060 50760 {}
C {lab_pin.sym} 2060 50760 0 0 {name=l40695 lab=VSS}
C {bitcell_6t.sym} 2200 50800 0 0 {name=Xr254c11}
N 2160 50840 2140 50840 {}
C {lab_pin.sym} 2140 50840 0 0 {name=l40696 lab=BL11}
N 2160 50800 2140 50800 {}
C {lab_pin.sym} 2140 50800 0 0 {name=l40697 lab=BLB11}
N 2160 50760 2140 50760 {}
C {lab_pin.sym} 2140 50760 0 0 {name=l40698 lab=WL254}
N 2240 50840 2260 50840 {}
C {lab_pin.sym} 2260 50840 0 0 {name=l40699 lab=VDD}
N 2240 50760 2260 50760 {}
C {lab_pin.sym} 2260 50760 0 0 {name=l40700 lab=VSS}
C {bitcell_6t.sym} 2400 50800 0 0 {name=Xr254c12}
N 2360 50840 2340 50840 {}
C {lab_pin.sym} 2340 50840 0 0 {name=l40701 lab=BL12}
N 2360 50800 2340 50800 {}
C {lab_pin.sym} 2340 50800 0 0 {name=l40702 lab=BLB12}
N 2360 50760 2340 50760 {}
C {lab_pin.sym} 2340 50760 0 0 {name=l40703 lab=WL254}
N 2440 50840 2460 50840 {}
C {lab_pin.sym} 2460 50840 0 0 {name=l40704 lab=VDD}
N 2440 50760 2460 50760 {}
C {lab_pin.sym} 2460 50760 0 0 {name=l40705 lab=VSS}
C {bitcell_6t.sym} 2600 50800 0 0 {name=Xr254c13}
N 2560 50840 2540 50840 {}
C {lab_pin.sym} 2540 50840 0 0 {name=l40706 lab=BL13}
N 2560 50800 2540 50800 {}
C {lab_pin.sym} 2540 50800 0 0 {name=l40707 lab=BLB13}
N 2560 50760 2540 50760 {}
C {lab_pin.sym} 2540 50760 0 0 {name=l40708 lab=WL254}
N 2640 50840 2660 50840 {}
C {lab_pin.sym} 2660 50840 0 0 {name=l40709 lab=VDD}
N 2640 50760 2660 50760 {}
C {lab_pin.sym} 2660 50760 0 0 {name=l40710 lab=VSS}
C {bitcell_6t.sym} 2800 50800 0 0 {name=Xr254c14}
N 2760 50840 2740 50840 {}
C {lab_pin.sym} 2740 50840 0 0 {name=l40711 lab=BL14}
N 2760 50800 2740 50800 {}
C {lab_pin.sym} 2740 50800 0 0 {name=l40712 lab=BLB14}
N 2760 50760 2740 50760 {}
C {lab_pin.sym} 2740 50760 0 0 {name=l40713 lab=WL254}
N 2840 50840 2860 50840 {}
C {lab_pin.sym} 2860 50840 0 0 {name=l40714 lab=VDD}
N 2840 50760 2860 50760 {}
C {lab_pin.sym} 2860 50760 0 0 {name=l40715 lab=VSS}
C {bitcell_6t.sym} 3000 50800 0 0 {name=Xr254c15}
N 2960 50840 2940 50840 {}
C {lab_pin.sym} 2940 50840 0 0 {name=l40716 lab=BL15}
N 2960 50800 2940 50800 {}
C {lab_pin.sym} 2940 50800 0 0 {name=l40717 lab=BLB15}
N 2960 50760 2940 50760 {}
C {lab_pin.sym} 2940 50760 0 0 {name=l40718 lab=WL254}
N 3040 50840 3060 50840 {}
C {lab_pin.sym} 3060 50840 0 0 {name=l40719 lab=VDD}
N 3040 50760 3060 50760 {}
C {lab_pin.sym} 3060 50760 0 0 {name=l40720 lab=VSS}
C {bitcell_6t.sym} 3200 50800 0 0 {name=Xr254c16}
N 3160 50840 3140 50840 {}
C {lab_pin.sym} 3140 50840 0 0 {name=l40721 lab=BL16}
N 3160 50800 3140 50800 {}
C {lab_pin.sym} 3140 50800 0 0 {name=l40722 lab=BLB16}
N 3160 50760 3140 50760 {}
C {lab_pin.sym} 3140 50760 0 0 {name=l40723 lab=WL254}
N 3240 50840 3260 50840 {}
C {lab_pin.sym} 3260 50840 0 0 {name=l40724 lab=VDD}
N 3240 50760 3260 50760 {}
C {lab_pin.sym} 3260 50760 0 0 {name=l40725 lab=VSS}
C {bitcell_6t.sym} 3400 50800 0 0 {name=Xr254c17}
N 3360 50840 3340 50840 {}
C {lab_pin.sym} 3340 50840 0 0 {name=l40726 lab=BL17}
N 3360 50800 3340 50800 {}
C {lab_pin.sym} 3340 50800 0 0 {name=l40727 lab=BLB17}
N 3360 50760 3340 50760 {}
C {lab_pin.sym} 3340 50760 0 0 {name=l40728 lab=WL254}
N 3440 50840 3460 50840 {}
C {lab_pin.sym} 3460 50840 0 0 {name=l40729 lab=VDD}
N 3440 50760 3460 50760 {}
C {lab_pin.sym} 3460 50760 0 0 {name=l40730 lab=VSS}
C {bitcell_6t.sym} 3600 50800 0 0 {name=Xr254c18}
N 3560 50840 3540 50840 {}
C {lab_pin.sym} 3540 50840 0 0 {name=l40731 lab=BL18}
N 3560 50800 3540 50800 {}
C {lab_pin.sym} 3540 50800 0 0 {name=l40732 lab=BLB18}
N 3560 50760 3540 50760 {}
C {lab_pin.sym} 3540 50760 0 0 {name=l40733 lab=WL254}
N 3640 50840 3660 50840 {}
C {lab_pin.sym} 3660 50840 0 0 {name=l40734 lab=VDD}
N 3640 50760 3660 50760 {}
C {lab_pin.sym} 3660 50760 0 0 {name=l40735 lab=VSS}
C {bitcell_6t.sym} 3800 50800 0 0 {name=Xr254c19}
N 3760 50840 3740 50840 {}
C {lab_pin.sym} 3740 50840 0 0 {name=l40736 lab=BL19}
N 3760 50800 3740 50800 {}
C {lab_pin.sym} 3740 50800 0 0 {name=l40737 lab=BLB19}
N 3760 50760 3740 50760 {}
C {lab_pin.sym} 3740 50760 0 0 {name=l40738 lab=WL254}
N 3840 50840 3860 50840 {}
C {lab_pin.sym} 3860 50840 0 0 {name=l40739 lab=VDD}
N 3840 50760 3860 50760 {}
C {lab_pin.sym} 3860 50760 0 0 {name=l40740 lab=VSS}
C {bitcell_6t.sym} 4000 50800 0 0 {name=Xr254c20}
N 3960 50840 3940 50840 {}
C {lab_pin.sym} 3940 50840 0 0 {name=l40741 lab=BL20}
N 3960 50800 3940 50800 {}
C {lab_pin.sym} 3940 50800 0 0 {name=l40742 lab=BLB20}
N 3960 50760 3940 50760 {}
C {lab_pin.sym} 3940 50760 0 0 {name=l40743 lab=WL254}
N 4040 50840 4060 50840 {}
C {lab_pin.sym} 4060 50840 0 0 {name=l40744 lab=VDD}
N 4040 50760 4060 50760 {}
C {lab_pin.sym} 4060 50760 0 0 {name=l40745 lab=VSS}
C {bitcell_6t.sym} 4200 50800 0 0 {name=Xr254c21}
N 4160 50840 4140 50840 {}
C {lab_pin.sym} 4140 50840 0 0 {name=l40746 lab=BL21}
N 4160 50800 4140 50800 {}
C {lab_pin.sym} 4140 50800 0 0 {name=l40747 lab=BLB21}
N 4160 50760 4140 50760 {}
C {lab_pin.sym} 4140 50760 0 0 {name=l40748 lab=WL254}
N 4240 50840 4260 50840 {}
C {lab_pin.sym} 4260 50840 0 0 {name=l40749 lab=VDD}
N 4240 50760 4260 50760 {}
C {lab_pin.sym} 4260 50760 0 0 {name=l40750 lab=VSS}
C {bitcell_6t.sym} 4400 50800 0 0 {name=Xr254c22}
N 4360 50840 4340 50840 {}
C {lab_pin.sym} 4340 50840 0 0 {name=l40751 lab=BL22}
N 4360 50800 4340 50800 {}
C {lab_pin.sym} 4340 50800 0 0 {name=l40752 lab=BLB22}
N 4360 50760 4340 50760 {}
C {lab_pin.sym} 4340 50760 0 0 {name=l40753 lab=WL254}
N 4440 50840 4460 50840 {}
C {lab_pin.sym} 4460 50840 0 0 {name=l40754 lab=VDD}
N 4440 50760 4460 50760 {}
C {lab_pin.sym} 4460 50760 0 0 {name=l40755 lab=VSS}
C {bitcell_6t.sym} 4600 50800 0 0 {name=Xr254c23}
N 4560 50840 4540 50840 {}
C {lab_pin.sym} 4540 50840 0 0 {name=l40756 lab=BL23}
N 4560 50800 4540 50800 {}
C {lab_pin.sym} 4540 50800 0 0 {name=l40757 lab=BLB23}
N 4560 50760 4540 50760 {}
C {lab_pin.sym} 4540 50760 0 0 {name=l40758 lab=WL254}
N 4640 50840 4660 50840 {}
C {lab_pin.sym} 4660 50840 0 0 {name=l40759 lab=VDD}
N 4640 50760 4660 50760 {}
C {lab_pin.sym} 4660 50760 0 0 {name=l40760 lab=VSS}
C {bitcell_6t.sym} 4800 50800 0 0 {name=Xr254c24}
N 4760 50840 4740 50840 {}
C {lab_pin.sym} 4740 50840 0 0 {name=l40761 lab=BL24}
N 4760 50800 4740 50800 {}
C {lab_pin.sym} 4740 50800 0 0 {name=l40762 lab=BLB24}
N 4760 50760 4740 50760 {}
C {lab_pin.sym} 4740 50760 0 0 {name=l40763 lab=WL254}
N 4840 50840 4860 50840 {}
C {lab_pin.sym} 4860 50840 0 0 {name=l40764 lab=VDD}
N 4840 50760 4860 50760 {}
C {lab_pin.sym} 4860 50760 0 0 {name=l40765 lab=VSS}
C {bitcell_6t.sym} 5000 50800 0 0 {name=Xr254c25}
N 4960 50840 4940 50840 {}
C {lab_pin.sym} 4940 50840 0 0 {name=l40766 lab=BL25}
N 4960 50800 4940 50800 {}
C {lab_pin.sym} 4940 50800 0 0 {name=l40767 lab=BLB25}
N 4960 50760 4940 50760 {}
C {lab_pin.sym} 4940 50760 0 0 {name=l40768 lab=WL254}
N 5040 50840 5060 50840 {}
C {lab_pin.sym} 5060 50840 0 0 {name=l40769 lab=VDD}
N 5040 50760 5060 50760 {}
C {lab_pin.sym} 5060 50760 0 0 {name=l40770 lab=VSS}
C {bitcell_6t.sym} 5200 50800 0 0 {name=Xr254c26}
N 5160 50840 5140 50840 {}
C {lab_pin.sym} 5140 50840 0 0 {name=l40771 lab=BL26}
N 5160 50800 5140 50800 {}
C {lab_pin.sym} 5140 50800 0 0 {name=l40772 lab=BLB26}
N 5160 50760 5140 50760 {}
C {lab_pin.sym} 5140 50760 0 0 {name=l40773 lab=WL254}
N 5240 50840 5260 50840 {}
C {lab_pin.sym} 5260 50840 0 0 {name=l40774 lab=VDD}
N 5240 50760 5260 50760 {}
C {lab_pin.sym} 5260 50760 0 0 {name=l40775 lab=VSS}
C {bitcell_6t.sym} 5400 50800 0 0 {name=Xr254c27}
N 5360 50840 5340 50840 {}
C {lab_pin.sym} 5340 50840 0 0 {name=l40776 lab=BL27}
N 5360 50800 5340 50800 {}
C {lab_pin.sym} 5340 50800 0 0 {name=l40777 lab=BLB27}
N 5360 50760 5340 50760 {}
C {lab_pin.sym} 5340 50760 0 0 {name=l40778 lab=WL254}
N 5440 50840 5460 50840 {}
C {lab_pin.sym} 5460 50840 0 0 {name=l40779 lab=VDD}
N 5440 50760 5460 50760 {}
C {lab_pin.sym} 5460 50760 0 0 {name=l40780 lab=VSS}
C {bitcell_6t.sym} 5600 50800 0 0 {name=Xr254c28}
N 5560 50840 5540 50840 {}
C {lab_pin.sym} 5540 50840 0 0 {name=l40781 lab=BL28}
N 5560 50800 5540 50800 {}
C {lab_pin.sym} 5540 50800 0 0 {name=l40782 lab=BLB28}
N 5560 50760 5540 50760 {}
C {lab_pin.sym} 5540 50760 0 0 {name=l40783 lab=WL254}
N 5640 50840 5660 50840 {}
C {lab_pin.sym} 5660 50840 0 0 {name=l40784 lab=VDD}
N 5640 50760 5660 50760 {}
C {lab_pin.sym} 5660 50760 0 0 {name=l40785 lab=VSS}
C {bitcell_6t.sym} 5800 50800 0 0 {name=Xr254c29}
N 5760 50840 5740 50840 {}
C {lab_pin.sym} 5740 50840 0 0 {name=l40786 lab=BL29}
N 5760 50800 5740 50800 {}
C {lab_pin.sym} 5740 50800 0 0 {name=l40787 lab=BLB29}
N 5760 50760 5740 50760 {}
C {lab_pin.sym} 5740 50760 0 0 {name=l40788 lab=WL254}
N 5840 50840 5860 50840 {}
C {lab_pin.sym} 5860 50840 0 0 {name=l40789 lab=VDD}
N 5840 50760 5860 50760 {}
C {lab_pin.sym} 5860 50760 0 0 {name=l40790 lab=VSS}
C {bitcell_6t.sym} 6000 50800 0 0 {name=Xr254c30}
N 5960 50840 5940 50840 {}
C {lab_pin.sym} 5940 50840 0 0 {name=l40791 lab=BL30}
N 5960 50800 5940 50800 {}
C {lab_pin.sym} 5940 50800 0 0 {name=l40792 lab=BLB30}
N 5960 50760 5940 50760 {}
C {lab_pin.sym} 5940 50760 0 0 {name=l40793 lab=WL254}
N 6040 50840 6060 50840 {}
C {lab_pin.sym} 6060 50840 0 0 {name=l40794 lab=VDD}
N 6040 50760 6060 50760 {}
C {lab_pin.sym} 6060 50760 0 0 {name=l40795 lab=VSS}
C {bitcell_6t.sym} 6200 50800 0 0 {name=Xr254c31}
N 6160 50840 6140 50840 {}
C {lab_pin.sym} 6140 50840 0 0 {name=l40796 lab=BL31}
N 6160 50800 6140 50800 {}
C {lab_pin.sym} 6140 50800 0 0 {name=l40797 lab=BLB31}
N 6160 50760 6140 50760 {}
C {lab_pin.sym} 6140 50760 0 0 {name=l40798 lab=WL254}
N 6240 50840 6260 50840 {}
C {lab_pin.sym} 6260 50840 0 0 {name=l40799 lab=VDD}
N 6240 50760 6260 50760 {}
C {lab_pin.sym} 6260 50760 0 0 {name=l40800 lab=VSS}
C {bitcell_6t.sym} 0 51000 0 0 {name=Xr255c0}
N -40 51040 -60 51040 {}
C {lab_pin.sym} -60 51040 0 0 {name=l40801 lab=BL0}
N -40 51000 -60 51000 {}
C {lab_pin.sym} -60 51000 0 0 {name=l40802 lab=BLB0}
N -40 50960 -60 50960 {}
C {lab_pin.sym} -60 50960 0 0 {name=l40803 lab=WL255}
N 40 51040 60 51040 {}
C {lab_pin.sym} 60 51040 0 0 {name=l40804 lab=VDD}
N 40 50960 60 50960 {}
C {lab_pin.sym} 60 50960 0 0 {name=l40805 lab=VSS}
C {bitcell_6t.sym} 200 51000 0 0 {name=Xr255c1}
N 160 51040 140 51040 {}
C {lab_pin.sym} 140 51040 0 0 {name=l40806 lab=BL1}
N 160 51000 140 51000 {}
C {lab_pin.sym} 140 51000 0 0 {name=l40807 lab=BLB1}
N 160 50960 140 50960 {}
C {lab_pin.sym} 140 50960 0 0 {name=l40808 lab=WL255}
N 240 51040 260 51040 {}
C {lab_pin.sym} 260 51040 0 0 {name=l40809 lab=VDD}
N 240 50960 260 50960 {}
C {lab_pin.sym} 260 50960 0 0 {name=l40810 lab=VSS}
C {bitcell_6t.sym} 400 51000 0 0 {name=Xr255c2}
N 360 51040 340 51040 {}
C {lab_pin.sym} 340 51040 0 0 {name=l40811 lab=BL2}
N 360 51000 340 51000 {}
C {lab_pin.sym} 340 51000 0 0 {name=l40812 lab=BLB2}
N 360 50960 340 50960 {}
C {lab_pin.sym} 340 50960 0 0 {name=l40813 lab=WL255}
N 440 51040 460 51040 {}
C {lab_pin.sym} 460 51040 0 0 {name=l40814 lab=VDD}
N 440 50960 460 50960 {}
C {lab_pin.sym} 460 50960 0 0 {name=l40815 lab=VSS}
C {bitcell_6t.sym} 600 51000 0 0 {name=Xr255c3}
N 560 51040 540 51040 {}
C {lab_pin.sym} 540 51040 0 0 {name=l40816 lab=BL3}
N 560 51000 540 51000 {}
C {lab_pin.sym} 540 51000 0 0 {name=l40817 lab=BLB3}
N 560 50960 540 50960 {}
C {lab_pin.sym} 540 50960 0 0 {name=l40818 lab=WL255}
N 640 51040 660 51040 {}
C {lab_pin.sym} 660 51040 0 0 {name=l40819 lab=VDD}
N 640 50960 660 50960 {}
C {lab_pin.sym} 660 50960 0 0 {name=l40820 lab=VSS}
C {bitcell_6t.sym} 800 51000 0 0 {name=Xr255c4}
N 760 51040 740 51040 {}
C {lab_pin.sym} 740 51040 0 0 {name=l40821 lab=BL4}
N 760 51000 740 51000 {}
C {lab_pin.sym} 740 51000 0 0 {name=l40822 lab=BLB4}
N 760 50960 740 50960 {}
C {lab_pin.sym} 740 50960 0 0 {name=l40823 lab=WL255}
N 840 51040 860 51040 {}
C {lab_pin.sym} 860 51040 0 0 {name=l40824 lab=VDD}
N 840 50960 860 50960 {}
C {lab_pin.sym} 860 50960 0 0 {name=l40825 lab=VSS}
C {bitcell_6t.sym} 1000 51000 0 0 {name=Xr255c5}
N 960 51040 940 51040 {}
C {lab_pin.sym} 940 51040 0 0 {name=l40826 lab=BL5}
N 960 51000 940 51000 {}
C {lab_pin.sym} 940 51000 0 0 {name=l40827 lab=BLB5}
N 960 50960 940 50960 {}
C {lab_pin.sym} 940 50960 0 0 {name=l40828 lab=WL255}
N 1040 51040 1060 51040 {}
C {lab_pin.sym} 1060 51040 0 0 {name=l40829 lab=VDD}
N 1040 50960 1060 50960 {}
C {lab_pin.sym} 1060 50960 0 0 {name=l40830 lab=VSS}
C {bitcell_6t.sym} 1200 51000 0 0 {name=Xr255c6}
N 1160 51040 1140 51040 {}
C {lab_pin.sym} 1140 51040 0 0 {name=l40831 lab=BL6}
N 1160 51000 1140 51000 {}
C {lab_pin.sym} 1140 51000 0 0 {name=l40832 lab=BLB6}
N 1160 50960 1140 50960 {}
C {lab_pin.sym} 1140 50960 0 0 {name=l40833 lab=WL255}
N 1240 51040 1260 51040 {}
C {lab_pin.sym} 1260 51040 0 0 {name=l40834 lab=VDD}
N 1240 50960 1260 50960 {}
C {lab_pin.sym} 1260 50960 0 0 {name=l40835 lab=VSS}
C {bitcell_6t.sym} 1400 51000 0 0 {name=Xr255c7}
N 1360 51040 1340 51040 {}
C {lab_pin.sym} 1340 51040 0 0 {name=l40836 lab=BL7}
N 1360 51000 1340 51000 {}
C {lab_pin.sym} 1340 51000 0 0 {name=l40837 lab=BLB7}
N 1360 50960 1340 50960 {}
C {lab_pin.sym} 1340 50960 0 0 {name=l40838 lab=WL255}
N 1440 51040 1460 51040 {}
C {lab_pin.sym} 1460 51040 0 0 {name=l40839 lab=VDD}
N 1440 50960 1460 50960 {}
C {lab_pin.sym} 1460 50960 0 0 {name=l40840 lab=VSS}
C {bitcell_6t.sym} 1600 51000 0 0 {name=Xr255c8}
N 1560 51040 1540 51040 {}
C {lab_pin.sym} 1540 51040 0 0 {name=l40841 lab=BL8}
N 1560 51000 1540 51000 {}
C {lab_pin.sym} 1540 51000 0 0 {name=l40842 lab=BLB8}
N 1560 50960 1540 50960 {}
C {lab_pin.sym} 1540 50960 0 0 {name=l40843 lab=WL255}
N 1640 51040 1660 51040 {}
C {lab_pin.sym} 1660 51040 0 0 {name=l40844 lab=VDD}
N 1640 50960 1660 50960 {}
C {lab_pin.sym} 1660 50960 0 0 {name=l40845 lab=VSS}
C {bitcell_6t.sym} 1800 51000 0 0 {name=Xr255c9}
N 1760 51040 1740 51040 {}
C {lab_pin.sym} 1740 51040 0 0 {name=l40846 lab=BL9}
N 1760 51000 1740 51000 {}
C {lab_pin.sym} 1740 51000 0 0 {name=l40847 lab=BLB9}
N 1760 50960 1740 50960 {}
C {lab_pin.sym} 1740 50960 0 0 {name=l40848 lab=WL255}
N 1840 51040 1860 51040 {}
C {lab_pin.sym} 1860 51040 0 0 {name=l40849 lab=VDD}
N 1840 50960 1860 50960 {}
C {lab_pin.sym} 1860 50960 0 0 {name=l40850 lab=VSS}
C {bitcell_6t.sym} 2000 51000 0 0 {name=Xr255c10}
N 1960 51040 1940 51040 {}
C {lab_pin.sym} 1940 51040 0 0 {name=l40851 lab=BL10}
N 1960 51000 1940 51000 {}
C {lab_pin.sym} 1940 51000 0 0 {name=l40852 lab=BLB10}
N 1960 50960 1940 50960 {}
C {lab_pin.sym} 1940 50960 0 0 {name=l40853 lab=WL255}
N 2040 51040 2060 51040 {}
C {lab_pin.sym} 2060 51040 0 0 {name=l40854 lab=VDD}
N 2040 50960 2060 50960 {}
C {lab_pin.sym} 2060 50960 0 0 {name=l40855 lab=VSS}
C {bitcell_6t.sym} 2200 51000 0 0 {name=Xr255c11}
N 2160 51040 2140 51040 {}
C {lab_pin.sym} 2140 51040 0 0 {name=l40856 lab=BL11}
N 2160 51000 2140 51000 {}
C {lab_pin.sym} 2140 51000 0 0 {name=l40857 lab=BLB11}
N 2160 50960 2140 50960 {}
C {lab_pin.sym} 2140 50960 0 0 {name=l40858 lab=WL255}
N 2240 51040 2260 51040 {}
C {lab_pin.sym} 2260 51040 0 0 {name=l40859 lab=VDD}
N 2240 50960 2260 50960 {}
C {lab_pin.sym} 2260 50960 0 0 {name=l40860 lab=VSS}
C {bitcell_6t.sym} 2400 51000 0 0 {name=Xr255c12}
N 2360 51040 2340 51040 {}
C {lab_pin.sym} 2340 51040 0 0 {name=l40861 lab=BL12}
N 2360 51000 2340 51000 {}
C {lab_pin.sym} 2340 51000 0 0 {name=l40862 lab=BLB12}
N 2360 50960 2340 50960 {}
C {lab_pin.sym} 2340 50960 0 0 {name=l40863 lab=WL255}
N 2440 51040 2460 51040 {}
C {lab_pin.sym} 2460 51040 0 0 {name=l40864 lab=VDD}
N 2440 50960 2460 50960 {}
C {lab_pin.sym} 2460 50960 0 0 {name=l40865 lab=VSS}
C {bitcell_6t.sym} 2600 51000 0 0 {name=Xr255c13}
N 2560 51040 2540 51040 {}
C {lab_pin.sym} 2540 51040 0 0 {name=l40866 lab=BL13}
N 2560 51000 2540 51000 {}
C {lab_pin.sym} 2540 51000 0 0 {name=l40867 lab=BLB13}
N 2560 50960 2540 50960 {}
C {lab_pin.sym} 2540 50960 0 0 {name=l40868 lab=WL255}
N 2640 51040 2660 51040 {}
C {lab_pin.sym} 2660 51040 0 0 {name=l40869 lab=VDD}
N 2640 50960 2660 50960 {}
C {lab_pin.sym} 2660 50960 0 0 {name=l40870 lab=VSS}
C {bitcell_6t.sym} 2800 51000 0 0 {name=Xr255c14}
N 2760 51040 2740 51040 {}
C {lab_pin.sym} 2740 51040 0 0 {name=l40871 lab=BL14}
N 2760 51000 2740 51000 {}
C {lab_pin.sym} 2740 51000 0 0 {name=l40872 lab=BLB14}
N 2760 50960 2740 50960 {}
C {lab_pin.sym} 2740 50960 0 0 {name=l40873 lab=WL255}
N 2840 51040 2860 51040 {}
C {lab_pin.sym} 2860 51040 0 0 {name=l40874 lab=VDD}
N 2840 50960 2860 50960 {}
C {lab_pin.sym} 2860 50960 0 0 {name=l40875 lab=VSS}
C {bitcell_6t.sym} 3000 51000 0 0 {name=Xr255c15}
N 2960 51040 2940 51040 {}
C {lab_pin.sym} 2940 51040 0 0 {name=l40876 lab=BL15}
N 2960 51000 2940 51000 {}
C {lab_pin.sym} 2940 51000 0 0 {name=l40877 lab=BLB15}
N 2960 50960 2940 50960 {}
C {lab_pin.sym} 2940 50960 0 0 {name=l40878 lab=WL255}
N 3040 51040 3060 51040 {}
C {lab_pin.sym} 3060 51040 0 0 {name=l40879 lab=VDD}
N 3040 50960 3060 50960 {}
C {lab_pin.sym} 3060 50960 0 0 {name=l40880 lab=VSS}
C {bitcell_6t.sym} 3200 51000 0 0 {name=Xr255c16}
N 3160 51040 3140 51040 {}
C {lab_pin.sym} 3140 51040 0 0 {name=l40881 lab=BL16}
N 3160 51000 3140 51000 {}
C {lab_pin.sym} 3140 51000 0 0 {name=l40882 lab=BLB16}
N 3160 50960 3140 50960 {}
C {lab_pin.sym} 3140 50960 0 0 {name=l40883 lab=WL255}
N 3240 51040 3260 51040 {}
C {lab_pin.sym} 3260 51040 0 0 {name=l40884 lab=VDD}
N 3240 50960 3260 50960 {}
C {lab_pin.sym} 3260 50960 0 0 {name=l40885 lab=VSS}
C {bitcell_6t.sym} 3400 51000 0 0 {name=Xr255c17}
N 3360 51040 3340 51040 {}
C {lab_pin.sym} 3340 51040 0 0 {name=l40886 lab=BL17}
N 3360 51000 3340 51000 {}
C {lab_pin.sym} 3340 51000 0 0 {name=l40887 lab=BLB17}
N 3360 50960 3340 50960 {}
C {lab_pin.sym} 3340 50960 0 0 {name=l40888 lab=WL255}
N 3440 51040 3460 51040 {}
C {lab_pin.sym} 3460 51040 0 0 {name=l40889 lab=VDD}
N 3440 50960 3460 50960 {}
C {lab_pin.sym} 3460 50960 0 0 {name=l40890 lab=VSS}
C {bitcell_6t.sym} 3600 51000 0 0 {name=Xr255c18}
N 3560 51040 3540 51040 {}
C {lab_pin.sym} 3540 51040 0 0 {name=l40891 lab=BL18}
N 3560 51000 3540 51000 {}
C {lab_pin.sym} 3540 51000 0 0 {name=l40892 lab=BLB18}
N 3560 50960 3540 50960 {}
C {lab_pin.sym} 3540 50960 0 0 {name=l40893 lab=WL255}
N 3640 51040 3660 51040 {}
C {lab_pin.sym} 3660 51040 0 0 {name=l40894 lab=VDD}
N 3640 50960 3660 50960 {}
C {lab_pin.sym} 3660 50960 0 0 {name=l40895 lab=VSS}
C {bitcell_6t.sym} 3800 51000 0 0 {name=Xr255c19}
N 3760 51040 3740 51040 {}
C {lab_pin.sym} 3740 51040 0 0 {name=l40896 lab=BL19}
N 3760 51000 3740 51000 {}
C {lab_pin.sym} 3740 51000 0 0 {name=l40897 lab=BLB19}
N 3760 50960 3740 50960 {}
C {lab_pin.sym} 3740 50960 0 0 {name=l40898 lab=WL255}
N 3840 51040 3860 51040 {}
C {lab_pin.sym} 3860 51040 0 0 {name=l40899 lab=VDD}
N 3840 50960 3860 50960 {}
C {lab_pin.sym} 3860 50960 0 0 {name=l40900 lab=VSS}
C {bitcell_6t.sym} 4000 51000 0 0 {name=Xr255c20}
N 3960 51040 3940 51040 {}
C {lab_pin.sym} 3940 51040 0 0 {name=l40901 lab=BL20}
N 3960 51000 3940 51000 {}
C {lab_pin.sym} 3940 51000 0 0 {name=l40902 lab=BLB20}
N 3960 50960 3940 50960 {}
C {lab_pin.sym} 3940 50960 0 0 {name=l40903 lab=WL255}
N 4040 51040 4060 51040 {}
C {lab_pin.sym} 4060 51040 0 0 {name=l40904 lab=VDD}
N 4040 50960 4060 50960 {}
C {lab_pin.sym} 4060 50960 0 0 {name=l40905 lab=VSS}
C {bitcell_6t.sym} 4200 51000 0 0 {name=Xr255c21}
N 4160 51040 4140 51040 {}
C {lab_pin.sym} 4140 51040 0 0 {name=l40906 lab=BL21}
N 4160 51000 4140 51000 {}
C {lab_pin.sym} 4140 51000 0 0 {name=l40907 lab=BLB21}
N 4160 50960 4140 50960 {}
C {lab_pin.sym} 4140 50960 0 0 {name=l40908 lab=WL255}
N 4240 51040 4260 51040 {}
C {lab_pin.sym} 4260 51040 0 0 {name=l40909 lab=VDD}
N 4240 50960 4260 50960 {}
C {lab_pin.sym} 4260 50960 0 0 {name=l40910 lab=VSS}
C {bitcell_6t.sym} 4400 51000 0 0 {name=Xr255c22}
N 4360 51040 4340 51040 {}
C {lab_pin.sym} 4340 51040 0 0 {name=l40911 lab=BL22}
N 4360 51000 4340 51000 {}
C {lab_pin.sym} 4340 51000 0 0 {name=l40912 lab=BLB22}
N 4360 50960 4340 50960 {}
C {lab_pin.sym} 4340 50960 0 0 {name=l40913 lab=WL255}
N 4440 51040 4460 51040 {}
C {lab_pin.sym} 4460 51040 0 0 {name=l40914 lab=VDD}
N 4440 50960 4460 50960 {}
C {lab_pin.sym} 4460 50960 0 0 {name=l40915 lab=VSS}
C {bitcell_6t.sym} 4600 51000 0 0 {name=Xr255c23}
N 4560 51040 4540 51040 {}
C {lab_pin.sym} 4540 51040 0 0 {name=l40916 lab=BL23}
N 4560 51000 4540 51000 {}
C {lab_pin.sym} 4540 51000 0 0 {name=l40917 lab=BLB23}
N 4560 50960 4540 50960 {}
C {lab_pin.sym} 4540 50960 0 0 {name=l40918 lab=WL255}
N 4640 51040 4660 51040 {}
C {lab_pin.sym} 4660 51040 0 0 {name=l40919 lab=VDD}
N 4640 50960 4660 50960 {}
C {lab_pin.sym} 4660 50960 0 0 {name=l40920 lab=VSS}
C {bitcell_6t.sym} 4800 51000 0 0 {name=Xr255c24}
N 4760 51040 4740 51040 {}
C {lab_pin.sym} 4740 51040 0 0 {name=l40921 lab=BL24}
N 4760 51000 4740 51000 {}
C {lab_pin.sym} 4740 51000 0 0 {name=l40922 lab=BLB24}
N 4760 50960 4740 50960 {}
C {lab_pin.sym} 4740 50960 0 0 {name=l40923 lab=WL255}
N 4840 51040 4860 51040 {}
C {lab_pin.sym} 4860 51040 0 0 {name=l40924 lab=VDD}
N 4840 50960 4860 50960 {}
C {lab_pin.sym} 4860 50960 0 0 {name=l40925 lab=VSS}
C {bitcell_6t.sym} 5000 51000 0 0 {name=Xr255c25}
N 4960 51040 4940 51040 {}
C {lab_pin.sym} 4940 51040 0 0 {name=l40926 lab=BL25}
N 4960 51000 4940 51000 {}
C {lab_pin.sym} 4940 51000 0 0 {name=l40927 lab=BLB25}
N 4960 50960 4940 50960 {}
C {lab_pin.sym} 4940 50960 0 0 {name=l40928 lab=WL255}
N 5040 51040 5060 51040 {}
C {lab_pin.sym} 5060 51040 0 0 {name=l40929 lab=VDD}
N 5040 50960 5060 50960 {}
C {lab_pin.sym} 5060 50960 0 0 {name=l40930 lab=VSS}
C {bitcell_6t.sym} 5200 51000 0 0 {name=Xr255c26}
N 5160 51040 5140 51040 {}
C {lab_pin.sym} 5140 51040 0 0 {name=l40931 lab=BL26}
N 5160 51000 5140 51000 {}
C {lab_pin.sym} 5140 51000 0 0 {name=l40932 lab=BLB26}
N 5160 50960 5140 50960 {}
C {lab_pin.sym} 5140 50960 0 0 {name=l40933 lab=WL255}
N 5240 51040 5260 51040 {}
C {lab_pin.sym} 5260 51040 0 0 {name=l40934 lab=VDD}
N 5240 50960 5260 50960 {}
C {lab_pin.sym} 5260 50960 0 0 {name=l40935 lab=VSS}
C {bitcell_6t.sym} 5400 51000 0 0 {name=Xr255c27}
N 5360 51040 5340 51040 {}
C {lab_pin.sym} 5340 51040 0 0 {name=l40936 lab=BL27}
N 5360 51000 5340 51000 {}
C {lab_pin.sym} 5340 51000 0 0 {name=l40937 lab=BLB27}
N 5360 50960 5340 50960 {}
C {lab_pin.sym} 5340 50960 0 0 {name=l40938 lab=WL255}
N 5440 51040 5460 51040 {}
C {lab_pin.sym} 5460 51040 0 0 {name=l40939 lab=VDD}
N 5440 50960 5460 50960 {}
C {lab_pin.sym} 5460 50960 0 0 {name=l40940 lab=VSS}
C {bitcell_6t.sym} 5600 51000 0 0 {name=Xr255c28}
N 5560 51040 5540 51040 {}
C {lab_pin.sym} 5540 51040 0 0 {name=l40941 lab=BL28}
N 5560 51000 5540 51000 {}
C {lab_pin.sym} 5540 51000 0 0 {name=l40942 lab=BLB28}
N 5560 50960 5540 50960 {}
C {lab_pin.sym} 5540 50960 0 0 {name=l40943 lab=WL255}
N 5640 51040 5660 51040 {}
C {lab_pin.sym} 5660 51040 0 0 {name=l40944 lab=VDD}
N 5640 50960 5660 50960 {}
C {lab_pin.sym} 5660 50960 0 0 {name=l40945 lab=VSS}
C {bitcell_6t.sym} 5800 51000 0 0 {name=Xr255c29}
N 5760 51040 5740 51040 {}
C {lab_pin.sym} 5740 51040 0 0 {name=l40946 lab=BL29}
N 5760 51000 5740 51000 {}
C {lab_pin.sym} 5740 51000 0 0 {name=l40947 lab=BLB29}
N 5760 50960 5740 50960 {}
C {lab_pin.sym} 5740 50960 0 0 {name=l40948 lab=WL255}
N 5840 51040 5860 51040 {}
C {lab_pin.sym} 5860 51040 0 0 {name=l40949 lab=VDD}
N 5840 50960 5860 50960 {}
C {lab_pin.sym} 5860 50960 0 0 {name=l40950 lab=VSS}
C {bitcell_6t.sym} 6000 51000 0 0 {name=Xr255c30}
N 5960 51040 5940 51040 {}
C {lab_pin.sym} 5940 51040 0 0 {name=l40951 lab=BL30}
N 5960 51000 5940 51000 {}
C {lab_pin.sym} 5940 51000 0 0 {name=l40952 lab=BLB30}
N 5960 50960 5940 50960 {}
C {lab_pin.sym} 5940 50960 0 0 {name=l40953 lab=WL255}
N 6040 51040 6060 51040 {}
C {lab_pin.sym} 6060 51040 0 0 {name=l40954 lab=VDD}
N 6040 50960 6060 50960 {}
C {lab_pin.sym} 6060 50960 0 0 {name=l40955 lab=VSS}
C {bitcell_6t.sym} 6200 51000 0 0 {name=Xr255c31}
N 6160 51040 6140 51040 {}
C {lab_pin.sym} 6140 51040 0 0 {name=l40956 lab=BL31}
N 6160 51000 6140 51000 {}
C {lab_pin.sym} 6140 51000 0 0 {name=l40957 lab=BLB31}
N 6160 50960 6140 50960 {}
C {lab_pin.sym} 6140 50960 0 0 {name=l40958 lab=WL255}
N 6240 51040 6260 51040 {}
C {lab_pin.sym} 6260 51040 0 0 {name=l40959 lab=VDD}
N 6240 50960 6260 50960 {}
C {lab_pin.sym} 6260 50960 0 0 {name=l40960 lab=VSS}
* --- top-level ports ---
C {ipin.sym} -300 0 0 0 {name=pwl1 lab=WL0}
C {ipin.sym} -300 200 0 0 {name=pwl2 lab=WL1}
C {ipin.sym} -300 400 0 0 {name=pwl3 lab=WL2}
C {ipin.sym} -300 600 0 0 {name=pwl4 lab=WL3}
C {ipin.sym} -300 800 0 0 {name=pwl5 lab=WL4}
C {ipin.sym} -300 1000 0 0 {name=pwl6 lab=WL5}
C {ipin.sym} -300 1200 0 0 {name=pwl7 lab=WL6}
C {ipin.sym} -300 1400 0 0 {name=pwl8 lab=WL7}
C {ipin.sym} -300 1600 0 0 {name=pwl9 lab=WL8}
C {ipin.sym} -300 1800 0 0 {name=pwl10 lab=WL9}
C {ipin.sym} -300 2000 0 0 {name=pwl11 lab=WL10}
C {ipin.sym} -300 2200 0 0 {name=pwl12 lab=WL11}
C {ipin.sym} -300 2400 0 0 {name=pwl13 lab=WL12}
C {ipin.sym} -300 2600 0 0 {name=pwl14 lab=WL13}
C {ipin.sym} -300 2800 0 0 {name=pwl15 lab=WL14}
C {ipin.sym} -300 3000 0 0 {name=pwl16 lab=WL15}
C {ipin.sym} -300 3200 0 0 {name=pwl17 lab=WL16}
C {ipin.sym} -300 3400 0 0 {name=pwl18 lab=WL17}
C {ipin.sym} -300 3600 0 0 {name=pwl19 lab=WL18}
C {ipin.sym} -300 3800 0 0 {name=pwl20 lab=WL19}
C {ipin.sym} -300 4000 0 0 {name=pwl21 lab=WL20}
C {ipin.sym} -300 4200 0 0 {name=pwl22 lab=WL21}
C {ipin.sym} -300 4400 0 0 {name=pwl23 lab=WL22}
C {ipin.sym} -300 4600 0 0 {name=pwl24 lab=WL23}
C {ipin.sym} -300 4800 0 0 {name=pwl25 lab=WL24}
C {ipin.sym} -300 5000 0 0 {name=pwl26 lab=WL25}
C {ipin.sym} -300 5200 0 0 {name=pwl27 lab=WL26}
C {ipin.sym} -300 5400 0 0 {name=pwl28 lab=WL27}
C {ipin.sym} -300 5600 0 0 {name=pwl29 lab=WL28}
C {ipin.sym} -300 5800 0 0 {name=pwl30 lab=WL29}
C {ipin.sym} -300 6000 0 0 {name=pwl31 lab=WL30}
C {ipin.sym} -300 6200 0 0 {name=pwl32 lab=WL31}
C {ipin.sym} -300 6400 0 0 {name=pwl33 lab=WL32}
C {ipin.sym} -300 6600 0 0 {name=pwl34 lab=WL33}
C {ipin.sym} -300 6800 0 0 {name=pwl35 lab=WL34}
C {ipin.sym} -300 7000 0 0 {name=pwl36 lab=WL35}
C {ipin.sym} -300 7200 0 0 {name=pwl37 lab=WL36}
C {ipin.sym} -300 7400 0 0 {name=pwl38 lab=WL37}
C {ipin.sym} -300 7600 0 0 {name=pwl39 lab=WL38}
C {ipin.sym} -300 7800 0 0 {name=pwl40 lab=WL39}
C {ipin.sym} -300 8000 0 0 {name=pwl41 lab=WL40}
C {ipin.sym} -300 8200 0 0 {name=pwl42 lab=WL41}
C {ipin.sym} -300 8400 0 0 {name=pwl43 lab=WL42}
C {ipin.sym} -300 8600 0 0 {name=pwl44 lab=WL43}
C {ipin.sym} -300 8800 0 0 {name=pwl45 lab=WL44}
C {ipin.sym} -300 9000 0 0 {name=pwl46 lab=WL45}
C {ipin.sym} -300 9200 0 0 {name=pwl47 lab=WL46}
C {ipin.sym} -300 9400 0 0 {name=pwl48 lab=WL47}
C {ipin.sym} -300 9600 0 0 {name=pwl49 lab=WL48}
C {ipin.sym} -300 9800 0 0 {name=pwl50 lab=WL49}
C {ipin.sym} -300 10000 0 0 {name=pwl51 lab=WL50}
C {ipin.sym} -300 10200 0 0 {name=pwl52 lab=WL51}
C {ipin.sym} -300 10400 0 0 {name=pwl53 lab=WL52}
C {ipin.sym} -300 10600 0 0 {name=pwl54 lab=WL53}
C {ipin.sym} -300 10800 0 0 {name=pwl55 lab=WL54}
C {ipin.sym} -300 11000 0 0 {name=pwl56 lab=WL55}
C {ipin.sym} -300 11200 0 0 {name=pwl57 lab=WL56}
C {ipin.sym} -300 11400 0 0 {name=pwl58 lab=WL57}
C {ipin.sym} -300 11600 0 0 {name=pwl59 lab=WL58}
C {ipin.sym} -300 11800 0 0 {name=pwl60 lab=WL59}
C {ipin.sym} -300 12000 0 0 {name=pwl61 lab=WL60}
C {ipin.sym} -300 12200 0 0 {name=pwl62 lab=WL61}
C {ipin.sym} -300 12400 0 0 {name=pwl63 lab=WL62}
C {ipin.sym} -300 12600 0 0 {name=pwl64 lab=WL63}
C {ipin.sym} -300 12800 0 0 {name=pwl65 lab=WL64}
C {ipin.sym} -300 13000 0 0 {name=pwl66 lab=WL65}
C {ipin.sym} -300 13200 0 0 {name=pwl67 lab=WL66}
C {ipin.sym} -300 13400 0 0 {name=pwl68 lab=WL67}
C {ipin.sym} -300 13600 0 0 {name=pwl69 lab=WL68}
C {ipin.sym} -300 13800 0 0 {name=pwl70 lab=WL69}
C {ipin.sym} -300 14000 0 0 {name=pwl71 lab=WL70}
C {ipin.sym} -300 14200 0 0 {name=pwl72 lab=WL71}
C {ipin.sym} -300 14400 0 0 {name=pwl73 lab=WL72}
C {ipin.sym} -300 14600 0 0 {name=pwl74 lab=WL73}
C {ipin.sym} -300 14800 0 0 {name=pwl75 lab=WL74}
C {ipin.sym} -300 15000 0 0 {name=pwl76 lab=WL75}
C {ipin.sym} -300 15200 0 0 {name=pwl77 lab=WL76}
C {ipin.sym} -300 15400 0 0 {name=pwl78 lab=WL77}
C {ipin.sym} -300 15600 0 0 {name=pwl79 lab=WL78}
C {ipin.sym} -300 15800 0 0 {name=pwl80 lab=WL79}
C {ipin.sym} -300 16000 0 0 {name=pwl81 lab=WL80}
C {ipin.sym} -300 16200 0 0 {name=pwl82 lab=WL81}
C {ipin.sym} -300 16400 0 0 {name=pwl83 lab=WL82}
C {ipin.sym} -300 16600 0 0 {name=pwl84 lab=WL83}
C {ipin.sym} -300 16800 0 0 {name=pwl85 lab=WL84}
C {ipin.sym} -300 17000 0 0 {name=pwl86 lab=WL85}
C {ipin.sym} -300 17200 0 0 {name=pwl87 lab=WL86}
C {ipin.sym} -300 17400 0 0 {name=pwl88 lab=WL87}
C {ipin.sym} -300 17600 0 0 {name=pwl89 lab=WL88}
C {ipin.sym} -300 17800 0 0 {name=pwl90 lab=WL89}
C {ipin.sym} -300 18000 0 0 {name=pwl91 lab=WL90}
C {ipin.sym} -300 18200 0 0 {name=pwl92 lab=WL91}
C {ipin.sym} -300 18400 0 0 {name=pwl93 lab=WL92}
C {ipin.sym} -300 18600 0 0 {name=pwl94 lab=WL93}
C {ipin.sym} -300 18800 0 0 {name=pwl95 lab=WL94}
C {ipin.sym} -300 19000 0 0 {name=pwl96 lab=WL95}
C {ipin.sym} -300 19200 0 0 {name=pwl97 lab=WL96}
C {ipin.sym} -300 19400 0 0 {name=pwl98 lab=WL97}
C {ipin.sym} -300 19600 0 0 {name=pwl99 lab=WL98}
C {ipin.sym} -300 19800 0 0 {name=pwl100 lab=WL99}
C {ipin.sym} -300 20000 0 0 {name=pwl101 lab=WL100}
C {ipin.sym} -300 20200 0 0 {name=pwl102 lab=WL101}
C {ipin.sym} -300 20400 0 0 {name=pwl103 lab=WL102}
C {ipin.sym} -300 20600 0 0 {name=pwl104 lab=WL103}
C {ipin.sym} -300 20800 0 0 {name=pwl105 lab=WL104}
C {ipin.sym} -300 21000 0 0 {name=pwl106 lab=WL105}
C {ipin.sym} -300 21200 0 0 {name=pwl107 lab=WL106}
C {ipin.sym} -300 21400 0 0 {name=pwl108 lab=WL107}
C {ipin.sym} -300 21600 0 0 {name=pwl109 lab=WL108}
C {ipin.sym} -300 21800 0 0 {name=pwl110 lab=WL109}
C {ipin.sym} -300 22000 0 0 {name=pwl111 lab=WL110}
C {ipin.sym} -300 22200 0 0 {name=pwl112 lab=WL111}
C {ipin.sym} -300 22400 0 0 {name=pwl113 lab=WL112}
C {ipin.sym} -300 22600 0 0 {name=pwl114 lab=WL113}
C {ipin.sym} -300 22800 0 0 {name=pwl115 lab=WL114}
C {ipin.sym} -300 23000 0 0 {name=pwl116 lab=WL115}
C {ipin.sym} -300 23200 0 0 {name=pwl117 lab=WL116}
C {ipin.sym} -300 23400 0 0 {name=pwl118 lab=WL117}
C {ipin.sym} -300 23600 0 0 {name=pwl119 lab=WL118}
C {ipin.sym} -300 23800 0 0 {name=pwl120 lab=WL119}
C {ipin.sym} -300 24000 0 0 {name=pwl121 lab=WL120}
C {ipin.sym} -300 24200 0 0 {name=pwl122 lab=WL121}
C {ipin.sym} -300 24400 0 0 {name=pwl123 lab=WL122}
C {ipin.sym} -300 24600 0 0 {name=pwl124 lab=WL123}
C {ipin.sym} -300 24800 0 0 {name=pwl125 lab=WL124}
C {ipin.sym} -300 25000 0 0 {name=pwl126 lab=WL125}
C {ipin.sym} -300 25200 0 0 {name=pwl127 lab=WL126}
C {ipin.sym} -300 25400 0 0 {name=pwl128 lab=WL127}
C {ipin.sym} -300 25600 0 0 {name=pwl129 lab=WL128}
C {ipin.sym} -300 25800 0 0 {name=pwl130 lab=WL129}
C {ipin.sym} -300 26000 0 0 {name=pwl131 lab=WL130}
C {ipin.sym} -300 26200 0 0 {name=pwl132 lab=WL131}
C {ipin.sym} -300 26400 0 0 {name=pwl133 lab=WL132}
C {ipin.sym} -300 26600 0 0 {name=pwl134 lab=WL133}
C {ipin.sym} -300 26800 0 0 {name=pwl135 lab=WL134}
C {ipin.sym} -300 27000 0 0 {name=pwl136 lab=WL135}
C {ipin.sym} -300 27200 0 0 {name=pwl137 lab=WL136}
C {ipin.sym} -300 27400 0 0 {name=pwl138 lab=WL137}
C {ipin.sym} -300 27600 0 0 {name=pwl139 lab=WL138}
C {ipin.sym} -300 27800 0 0 {name=pwl140 lab=WL139}
C {ipin.sym} -300 28000 0 0 {name=pwl141 lab=WL140}
C {ipin.sym} -300 28200 0 0 {name=pwl142 lab=WL141}
C {ipin.sym} -300 28400 0 0 {name=pwl143 lab=WL142}
C {ipin.sym} -300 28600 0 0 {name=pwl144 lab=WL143}
C {ipin.sym} -300 28800 0 0 {name=pwl145 lab=WL144}
C {ipin.sym} -300 29000 0 0 {name=pwl146 lab=WL145}
C {ipin.sym} -300 29200 0 0 {name=pwl147 lab=WL146}
C {ipin.sym} -300 29400 0 0 {name=pwl148 lab=WL147}
C {ipin.sym} -300 29600 0 0 {name=pwl149 lab=WL148}
C {ipin.sym} -300 29800 0 0 {name=pwl150 lab=WL149}
C {ipin.sym} -300 30000 0 0 {name=pwl151 lab=WL150}
C {ipin.sym} -300 30200 0 0 {name=pwl152 lab=WL151}
C {ipin.sym} -300 30400 0 0 {name=pwl153 lab=WL152}
C {ipin.sym} -300 30600 0 0 {name=pwl154 lab=WL153}
C {ipin.sym} -300 30800 0 0 {name=pwl155 lab=WL154}
C {ipin.sym} -300 31000 0 0 {name=pwl156 lab=WL155}
C {ipin.sym} -300 31200 0 0 {name=pwl157 lab=WL156}
C {ipin.sym} -300 31400 0 0 {name=pwl158 lab=WL157}
C {ipin.sym} -300 31600 0 0 {name=pwl159 lab=WL158}
C {ipin.sym} -300 31800 0 0 {name=pwl160 lab=WL159}
C {ipin.sym} -300 32000 0 0 {name=pwl161 lab=WL160}
C {ipin.sym} -300 32200 0 0 {name=pwl162 lab=WL161}
C {ipin.sym} -300 32400 0 0 {name=pwl163 lab=WL162}
C {ipin.sym} -300 32600 0 0 {name=pwl164 lab=WL163}
C {ipin.sym} -300 32800 0 0 {name=pwl165 lab=WL164}
C {ipin.sym} -300 33000 0 0 {name=pwl166 lab=WL165}
C {ipin.sym} -300 33200 0 0 {name=pwl167 lab=WL166}
C {ipin.sym} -300 33400 0 0 {name=pwl168 lab=WL167}
C {ipin.sym} -300 33600 0 0 {name=pwl169 lab=WL168}
C {ipin.sym} -300 33800 0 0 {name=pwl170 lab=WL169}
C {ipin.sym} -300 34000 0 0 {name=pwl171 lab=WL170}
C {ipin.sym} -300 34200 0 0 {name=pwl172 lab=WL171}
C {ipin.sym} -300 34400 0 0 {name=pwl173 lab=WL172}
C {ipin.sym} -300 34600 0 0 {name=pwl174 lab=WL173}
C {ipin.sym} -300 34800 0 0 {name=pwl175 lab=WL174}
C {ipin.sym} -300 35000 0 0 {name=pwl176 lab=WL175}
C {ipin.sym} -300 35200 0 0 {name=pwl177 lab=WL176}
C {ipin.sym} -300 35400 0 0 {name=pwl178 lab=WL177}
C {ipin.sym} -300 35600 0 0 {name=pwl179 lab=WL178}
C {ipin.sym} -300 35800 0 0 {name=pwl180 lab=WL179}
C {ipin.sym} -300 36000 0 0 {name=pwl181 lab=WL180}
C {ipin.sym} -300 36200 0 0 {name=pwl182 lab=WL181}
C {ipin.sym} -300 36400 0 0 {name=pwl183 lab=WL182}
C {ipin.sym} -300 36600 0 0 {name=pwl184 lab=WL183}
C {ipin.sym} -300 36800 0 0 {name=pwl185 lab=WL184}
C {ipin.sym} -300 37000 0 0 {name=pwl186 lab=WL185}
C {ipin.sym} -300 37200 0 0 {name=pwl187 lab=WL186}
C {ipin.sym} -300 37400 0 0 {name=pwl188 lab=WL187}
C {ipin.sym} -300 37600 0 0 {name=pwl189 lab=WL188}
C {ipin.sym} -300 37800 0 0 {name=pwl190 lab=WL189}
C {ipin.sym} -300 38000 0 0 {name=pwl191 lab=WL190}
C {ipin.sym} -300 38200 0 0 {name=pwl192 lab=WL191}
C {ipin.sym} -300 38400 0 0 {name=pwl193 lab=WL192}
C {ipin.sym} -300 38600 0 0 {name=pwl194 lab=WL193}
C {ipin.sym} -300 38800 0 0 {name=pwl195 lab=WL194}
C {ipin.sym} -300 39000 0 0 {name=pwl196 lab=WL195}
C {ipin.sym} -300 39200 0 0 {name=pwl197 lab=WL196}
C {ipin.sym} -300 39400 0 0 {name=pwl198 lab=WL197}
C {ipin.sym} -300 39600 0 0 {name=pwl199 lab=WL198}
C {ipin.sym} -300 39800 0 0 {name=pwl200 lab=WL199}
C {ipin.sym} -300 40000 0 0 {name=pwl201 lab=WL200}
C {ipin.sym} -300 40200 0 0 {name=pwl202 lab=WL201}
C {ipin.sym} -300 40400 0 0 {name=pwl203 lab=WL202}
C {ipin.sym} -300 40600 0 0 {name=pwl204 lab=WL203}
C {ipin.sym} -300 40800 0 0 {name=pwl205 lab=WL204}
C {ipin.sym} -300 41000 0 0 {name=pwl206 lab=WL205}
C {ipin.sym} -300 41200 0 0 {name=pwl207 lab=WL206}
C {ipin.sym} -300 41400 0 0 {name=pwl208 lab=WL207}
C {ipin.sym} -300 41600 0 0 {name=pwl209 lab=WL208}
C {ipin.sym} -300 41800 0 0 {name=pwl210 lab=WL209}
C {ipin.sym} -300 42000 0 0 {name=pwl211 lab=WL210}
C {ipin.sym} -300 42200 0 0 {name=pwl212 lab=WL211}
C {ipin.sym} -300 42400 0 0 {name=pwl213 lab=WL212}
C {ipin.sym} -300 42600 0 0 {name=pwl214 lab=WL213}
C {ipin.sym} -300 42800 0 0 {name=pwl215 lab=WL214}
C {ipin.sym} -300 43000 0 0 {name=pwl216 lab=WL215}
C {ipin.sym} -300 43200 0 0 {name=pwl217 lab=WL216}
C {ipin.sym} -300 43400 0 0 {name=pwl218 lab=WL217}
C {ipin.sym} -300 43600 0 0 {name=pwl219 lab=WL218}
C {ipin.sym} -300 43800 0 0 {name=pwl220 lab=WL219}
C {ipin.sym} -300 44000 0 0 {name=pwl221 lab=WL220}
C {ipin.sym} -300 44200 0 0 {name=pwl222 lab=WL221}
C {ipin.sym} -300 44400 0 0 {name=pwl223 lab=WL222}
C {ipin.sym} -300 44600 0 0 {name=pwl224 lab=WL223}
C {ipin.sym} -300 44800 0 0 {name=pwl225 lab=WL224}
C {ipin.sym} -300 45000 0 0 {name=pwl226 lab=WL225}
C {ipin.sym} -300 45200 0 0 {name=pwl227 lab=WL226}
C {ipin.sym} -300 45400 0 0 {name=pwl228 lab=WL227}
C {ipin.sym} -300 45600 0 0 {name=pwl229 lab=WL228}
C {ipin.sym} -300 45800 0 0 {name=pwl230 lab=WL229}
C {ipin.sym} -300 46000 0 0 {name=pwl231 lab=WL230}
C {ipin.sym} -300 46200 0 0 {name=pwl232 lab=WL231}
C {ipin.sym} -300 46400 0 0 {name=pwl233 lab=WL232}
C {ipin.sym} -300 46600 0 0 {name=pwl234 lab=WL233}
C {ipin.sym} -300 46800 0 0 {name=pwl235 lab=WL234}
C {ipin.sym} -300 47000 0 0 {name=pwl236 lab=WL235}
C {ipin.sym} -300 47200 0 0 {name=pwl237 lab=WL236}
C {ipin.sym} -300 47400 0 0 {name=pwl238 lab=WL237}
C {ipin.sym} -300 47600 0 0 {name=pwl239 lab=WL238}
C {ipin.sym} -300 47800 0 0 {name=pwl240 lab=WL239}
C {ipin.sym} -300 48000 0 0 {name=pwl241 lab=WL240}
C {ipin.sym} -300 48200 0 0 {name=pwl242 lab=WL241}
C {ipin.sym} -300 48400 0 0 {name=pwl243 lab=WL242}
C {ipin.sym} -300 48600 0 0 {name=pwl244 lab=WL243}
C {ipin.sym} -300 48800 0 0 {name=pwl245 lab=WL244}
C {ipin.sym} -300 49000 0 0 {name=pwl246 lab=WL245}
C {ipin.sym} -300 49200 0 0 {name=pwl247 lab=WL246}
C {ipin.sym} -300 49400 0 0 {name=pwl248 lab=WL247}
C {ipin.sym} -300 49600 0 0 {name=pwl249 lab=WL248}
C {ipin.sym} -300 49800 0 0 {name=pwl250 lab=WL249}
C {ipin.sym} -300 50000 0 0 {name=pwl251 lab=WL250}
C {ipin.sym} -300 50200 0 0 {name=pwl252 lab=WL251}
C {ipin.sym} -300 50400 0 0 {name=pwl253 lab=WL252}
C {ipin.sym} -300 50600 0 0 {name=pwl254 lab=WL253}
C {ipin.sym} -300 50800 0 0 {name=pwl255 lab=WL254}
C {ipin.sym} -300 51000 0 0 {name=pwl256 lab=WL255}
C {iopin.sym} 0 51300 0 0 {name=pbl257 lab=BL0}
C {iopin.sym} 0 51400 0 0 {name=pblb258 lab=BLB0}
C {iopin.sym} 200 51300 0 0 {name=pbl259 lab=BL1}
C {iopin.sym} 200 51400 0 0 {name=pblb260 lab=BLB1}
C {iopin.sym} 400 51300 0 0 {name=pbl261 lab=BL2}
C {iopin.sym} 400 51400 0 0 {name=pblb262 lab=BLB2}
C {iopin.sym} 600 51300 0 0 {name=pbl263 lab=BL3}
C {iopin.sym} 600 51400 0 0 {name=pblb264 lab=BLB3}
C {iopin.sym} 800 51300 0 0 {name=pbl265 lab=BL4}
C {iopin.sym} 800 51400 0 0 {name=pblb266 lab=BLB4}
C {iopin.sym} 1000 51300 0 0 {name=pbl267 lab=BL5}
C {iopin.sym} 1000 51400 0 0 {name=pblb268 lab=BLB5}
C {iopin.sym} 1200 51300 0 0 {name=pbl269 lab=BL6}
C {iopin.sym} 1200 51400 0 0 {name=pblb270 lab=BLB6}
C {iopin.sym} 1400 51300 0 0 {name=pbl271 lab=BL7}
C {iopin.sym} 1400 51400 0 0 {name=pblb272 lab=BLB7}
C {iopin.sym} 1600 51300 0 0 {name=pbl273 lab=BL8}
C {iopin.sym} 1600 51400 0 0 {name=pblb274 lab=BLB8}
C {iopin.sym} 1800 51300 0 0 {name=pbl275 lab=BL9}
C {iopin.sym} 1800 51400 0 0 {name=pblb276 lab=BLB9}
C {iopin.sym} 2000 51300 0 0 {name=pbl277 lab=BL10}
C {iopin.sym} 2000 51400 0 0 {name=pblb278 lab=BLB10}
C {iopin.sym} 2200 51300 0 0 {name=pbl279 lab=BL11}
C {iopin.sym} 2200 51400 0 0 {name=pblb280 lab=BLB11}
C {iopin.sym} 2400 51300 0 0 {name=pbl281 lab=BL12}
C {iopin.sym} 2400 51400 0 0 {name=pblb282 lab=BLB12}
C {iopin.sym} 2600 51300 0 0 {name=pbl283 lab=BL13}
C {iopin.sym} 2600 51400 0 0 {name=pblb284 lab=BLB13}
C {iopin.sym} 2800 51300 0 0 {name=pbl285 lab=BL14}
C {iopin.sym} 2800 51400 0 0 {name=pblb286 lab=BLB14}
C {iopin.sym} 3000 51300 0 0 {name=pbl287 lab=BL15}
C {iopin.sym} 3000 51400 0 0 {name=pblb288 lab=BLB15}
C {iopin.sym} 3200 51300 0 0 {name=pbl289 lab=BL16}
C {iopin.sym} 3200 51400 0 0 {name=pblb290 lab=BLB16}
C {iopin.sym} 3400 51300 0 0 {name=pbl291 lab=BL17}
C {iopin.sym} 3400 51400 0 0 {name=pblb292 lab=BLB17}
C {iopin.sym} 3600 51300 0 0 {name=pbl293 lab=BL18}
C {iopin.sym} 3600 51400 0 0 {name=pblb294 lab=BLB18}
C {iopin.sym} 3800 51300 0 0 {name=pbl295 lab=BL19}
C {iopin.sym} 3800 51400 0 0 {name=pblb296 lab=BLB19}
C {iopin.sym} 4000 51300 0 0 {name=pbl297 lab=BL20}
C {iopin.sym} 4000 51400 0 0 {name=pblb298 lab=BLB20}
C {iopin.sym} 4200 51300 0 0 {name=pbl299 lab=BL21}
C {iopin.sym} 4200 51400 0 0 {name=pblb300 lab=BLB21}
C {iopin.sym} 4400 51300 0 0 {name=pbl301 lab=BL22}
C {iopin.sym} 4400 51400 0 0 {name=pblb302 lab=BLB22}
C {iopin.sym} 4600 51300 0 0 {name=pbl303 lab=BL23}
C {iopin.sym} 4600 51400 0 0 {name=pblb304 lab=BLB23}
C {iopin.sym} 4800 51300 0 0 {name=pbl305 lab=BL24}
C {iopin.sym} 4800 51400 0 0 {name=pblb306 lab=BLB24}
C {iopin.sym} 5000 51300 0 0 {name=pbl307 lab=BL25}
C {iopin.sym} 5000 51400 0 0 {name=pblb308 lab=BLB25}
C {iopin.sym} 5200 51300 0 0 {name=pbl309 lab=BL26}
C {iopin.sym} 5200 51400 0 0 {name=pblb310 lab=BLB26}
C {iopin.sym} 5400 51300 0 0 {name=pbl311 lab=BL27}
C {iopin.sym} 5400 51400 0 0 {name=pblb312 lab=BLB27}
C {iopin.sym} 5600 51300 0 0 {name=pbl313 lab=BL28}
C {iopin.sym} 5600 51400 0 0 {name=pblb314 lab=BLB28}
C {iopin.sym} 5800 51300 0 0 {name=pbl315 lab=BL29}
C {iopin.sym} 5800 51400 0 0 {name=pblb316 lab=BLB29}
C {iopin.sym} 6000 51300 0 0 {name=pbl317 lab=BL30}
C {iopin.sym} 6000 51400 0 0 {name=pblb318 lab=BLB30}
C {iopin.sym} 6200 51300 0 0 {name=pbl319 lab=BL31}
C {iopin.sym} 6200 51400 0 0 {name=pblb320 lab=BLB31}
C {iopin.sym} -300 51500 0 0 {name=pvdd321 lab=VDD}
C {iopin.sym} -300 51600 0 0 {name=pvss322 lab=VSS}
