v {xschem version=3.4.7 file_version=1.2
* sram_256x32_array -- 256 x 32 6T bitcell array core (issue #21, T1
* item 1), MACHINE-GENERATED by design/generate_array.py -- do not
* hand-edit; re-run the generator instead (see design/README.md). Output is
* a pure function of --rows/--cols (no wall-clock/environment-dependent
* content), so re-running the generator reproduces this file byte-for-byte;
* provenance (who/when) belongs to git history, not the file body.
*
* Tiles design/bitcell_6t.sym 256 x 32 = 8192 times. Net
* connectivity is established purely by matching "lab=" text (xschem's
* label-net convention -- see this script's module docstring), not by
* routed wires between cells:
*   WL0..WL255   -- one wordline per row, shared by all 32 cells in
*                    that row
*   BL0..BL31, BLB0..BLB31 -- one differential bitline pair per
*                    column, shared by all 256 cells in that column
*   VDD, VSS  -- global rails, shared by all 8192 cells
*
* This is the bitcell-array *core* only (spec/sram.md's ratified 256 x 32,
* single fixed instance) -- address decode, column mux, sense amp and
* write driver (the periphery needed to expose spec/sram.md's full 1RW
* macro pin list: A, CEN, CLK, D, Q, GWEN, WEN) are out of this issue's
* scope; the top-level ports below are the raw per-row/per-column array
* pins, matching layout/README.md's equivalent scoping note for the
* parallel GDS tiling (issue #22 / PR #36).
}
G {}
K {}
V {}
S {}
E {}
C {bitcell_6t.sym} 0 0 0 0 {name=Xr0c0}
N -40 40 -60 40 {}
C {lab_pin.sym} -60 40 0 0 {name=l1 lab=BL0}
N -40 0 -60 0 {}
C {lab_pin.sym} -60 0 0 0 {name=l2 lab=BLB0}
N -40 -40 -60 -40 {}
C {lab_pin.sym} -60 -40 0 0 {name=l3 lab=WL0}
N 40 40 60 40 {}
C {lab_pin.sym} 60 40 0 0 {name=l4 lab=VDD}
N 40 -40 60 -40 {}
C {lab_pin.sym} 60 -40 0 0 {name=l5 lab=VSS}
C {bitcell_6t.sym} 200 0 0 0 {name=Xr0c1}
N 160 40 140 40 {}
C {lab_pin.sym} 140 40 0 0 {name=l6 lab=BL1}
N 160 0 140 0 {}
C {lab_pin.sym} 140 0 0 0 {name=l7 lab=BLB1}
N 160 -40 140 -40 {}
C {lab_pin.sym} 140 -40 0 0 {name=l8 lab=WL0}
N 240 40 260 40 {}
C {lab_pin.sym} 260 40 0 0 {name=l9 lab=VDD}
N 240 -40 260 -40 {}
C {lab_pin.sym} 260 -40 0 0 {name=l10 lab=VSS}
C {bitcell_6t.sym} 400 0 0 0 {name=Xr0c2}
N 360 40 340 40 {}
C {lab_pin.sym} 340 40 0 0 {name=l11 lab=BL2}
N 360 0 340 0 {}
C {lab_pin.sym} 340 0 0 0 {name=l12 lab=BLB2}
N 360 -40 340 -40 {}
C {lab_pin.sym} 340 -40 0 0 {name=l13 lab=WL0}
N 440 40 460 40 {}
C {lab_pin.sym} 460 40 0 0 {name=l14 lab=VDD}
N 440 -40 460 -40 {}
C {lab_pin.sym} 460 -40 0 0 {name=l15 lab=VSS}
C {bitcell_6t.sym} 600 0 0 0 {name=Xr0c3}
N 560 40 540 40 {}
C {lab_pin.sym} 540 40 0 0 {name=l16 lab=BL3}
N 560 0 540 0 {}
C {lab_pin.sym} 540 0 0 0 {name=l17 lab=BLB3}
N 560 -40 540 -40 {}
C {lab_pin.sym} 540 -40 0 0 {name=l18 lab=WL0}
N 640 40 660 40 {}
C {lab_pin.sym} 660 40 0 0 {name=l19 lab=VDD}
N 640 -40 660 -40 {}
C {lab_pin.sym} 660 -40 0 0 {name=l20 lab=VSS}
C {bitcell_6t.sym} 800 0 0 0 {name=Xr0c4}
N 760 40 740 40 {}
C {lab_pin.sym} 740 40 0 0 {name=l21 lab=BL4}
N 760 0 740 0 {}
C {lab_pin.sym} 740 0 0 0 {name=l22 lab=BLB4}
N 760 -40 740 -40 {}
C {lab_pin.sym} 740 -40 0 0 {name=l23 lab=WL0}
N 840 40 860 40 {}
C {lab_pin.sym} 860 40 0 0 {name=l24 lab=VDD}
N 840 -40 860 -40 {}
C {lab_pin.sym} 860 -40 0 0 {name=l25 lab=VSS}
C {bitcell_6t.sym} 1000 0 0 0 {name=Xr0c5}
N 960 40 940 40 {}
C {lab_pin.sym} 940 40 0 0 {name=l26 lab=BL5}
N 960 0 940 0 {}
C {lab_pin.sym} 940 0 0 0 {name=l27 lab=BLB5}
N 960 -40 940 -40 {}
C {lab_pin.sym} 940 -40 0 0 {name=l28 lab=WL0}
N 1040 40 1060 40 {}
C {lab_pin.sym} 1060 40 0 0 {name=l29 lab=VDD}
N 1040 -40 1060 -40 {}
C {lab_pin.sym} 1060 -40 0 0 {name=l30 lab=VSS}
C {bitcell_6t.sym} 1200 0 0 0 {name=Xr0c6}
N 1160 40 1140 40 {}
C {lab_pin.sym} 1140 40 0 0 {name=l31 lab=BL6}
N 1160 0 1140 0 {}
C {lab_pin.sym} 1140 0 0 0 {name=l32 lab=BLB6}
N 1160 -40 1140 -40 {}
C {lab_pin.sym} 1140 -40 0 0 {name=l33 lab=WL0}
N 1240 40 1260 40 {}
C {lab_pin.sym} 1260 40 0 0 {name=l34 lab=VDD}
N 1240 -40 1260 -40 {}
C {lab_pin.sym} 1260 -40 0 0 {name=l35 lab=VSS}
C {bitcell_6t.sym} 1400 0 0 0 {name=Xr0c7}
N 1360 40 1340 40 {}
C {lab_pin.sym} 1340 40 0 0 {name=l36 lab=BL7}
N 1360 0 1340 0 {}
C {lab_pin.sym} 1340 0 0 0 {name=l37 lab=BLB7}
N 1360 -40 1340 -40 {}
C {lab_pin.sym} 1340 -40 0 0 {name=l38 lab=WL0}
N 1440 40 1460 40 {}
C {lab_pin.sym} 1460 40 0 0 {name=l39 lab=VDD}
N 1440 -40 1460 -40 {}
C {lab_pin.sym} 1460 -40 0 0 {name=l40 lab=VSS}
C {bitcell_6t.sym} 1600 0 0 0 {name=Xr0c8}
N 1560 40 1540 40 {}
C {lab_pin.sym} 1540 40 0 0 {name=l41 lab=BL8}
N 1560 0 1540 0 {}
C {lab_pin.sym} 1540 0 0 0 {name=l42 lab=BLB8}
N 1560 -40 1540 -40 {}
C {lab_pin.sym} 1540 -40 0 0 {name=l43 lab=WL0}
N 1640 40 1660 40 {}
C {lab_pin.sym} 1660 40 0 0 {name=l44 lab=VDD}
N 1640 -40 1660 -40 {}
C {lab_pin.sym} 1660 -40 0 0 {name=l45 lab=VSS}
C {bitcell_6t.sym} 1800 0 0 0 {name=Xr0c9}
N 1760 40 1740 40 {}
C {lab_pin.sym} 1740 40 0 0 {name=l46 lab=BL9}
N 1760 0 1740 0 {}
C {lab_pin.sym} 1740 0 0 0 {name=l47 lab=BLB9}
N 1760 -40 1740 -40 {}
C {lab_pin.sym} 1740 -40 0 0 {name=l48 lab=WL0}
N 1840 40 1860 40 {}
C {lab_pin.sym} 1860 40 0 0 {name=l49 lab=VDD}
N 1840 -40 1860 -40 {}
C {lab_pin.sym} 1860 -40 0 0 {name=l50 lab=VSS}
C {bitcell_6t.sym} 2000 0 0 0 {name=Xr0c10}
N 1960 40 1940 40 {}
C {lab_pin.sym} 1940 40 0 0 {name=l51 lab=BL10}
N 1960 0 1940 0 {}
C {lab_pin.sym} 1940 0 0 0 {name=l52 lab=BLB10}
N 1960 -40 1940 -40 {}
C {lab_pin.sym} 1940 -40 0 0 {name=l53 lab=WL0}
N 2040 40 2060 40 {}
C {lab_pin.sym} 2060 40 0 0 {name=l54 lab=VDD}
N 2040 -40 2060 -40 {}
C {lab_pin.sym} 2060 -40 0 0 {name=l55 lab=VSS}
C {bitcell_6t.sym} 2200 0 0 0 {name=Xr0c11}
N 2160 40 2140 40 {}
C {lab_pin.sym} 2140 40 0 0 {name=l56 lab=BL11}
N 2160 0 2140 0 {}
C {lab_pin.sym} 2140 0 0 0 {name=l57 lab=BLB11}
N 2160 -40 2140 -40 {}
C {lab_pin.sym} 2140 -40 0 0 {name=l58 lab=WL0}
N 2240 40 2260 40 {}
C {lab_pin.sym} 2260 40 0 0 {name=l59 lab=VDD}
N 2240 -40 2260 -40 {}
C {lab_pin.sym} 2260 -40 0 0 {name=l60 lab=VSS}
C {bitcell_6t.sym} 2400 0 0 0 {name=Xr0c12}
N 2360 40 2340 40 {}
C {lab_pin.sym} 2340 40 0 0 {name=l61 lab=BL12}
N 2360 0 2340 0 {}
C {lab_pin.sym} 2340 0 0 0 {name=l62 lab=BLB12}
N 2360 -40 2340 -40 {}
C {lab_pin.sym} 2340 -40 0 0 {name=l63 lab=WL0}
N 2440 40 2460 40 {}
C {lab_pin.sym} 2460 40 0 0 {name=l64 lab=VDD}
N 2440 -40 2460 -40 {}
C {lab_pin.sym} 2460 -40 0 0 {name=l65 lab=VSS}
C {bitcell_6t.sym} 2600 0 0 0 {name=Xr0c13}
N 2560 40 2540 40 {}
C {lab_pin.sym} 2540 40 0 0 {name=l66 lab=BL13}
N 2560 0 2540 0 {}
C {lab_pin.sym} 2540 0 0 0 {name=l67 lab=BLB13}
N 2560 -40 2540 -40 {}
C {lab_pin.sym} 2540 -40 0 0 {name=l68 lab=WL0}
N 2640 40 2660 40 {}
C {lab_pin.sym} 2660 40 0 0 {name=l69 lab=VDD}
N 2640 -40 2660 -40 {}
C {lab_pin.sym} 2660 -40 0 0 {name=l70 lab=VSS}
C {bitcell_6t.sym} 2800 0 0 0 {name=Xr0c14}
N 2760 40 2740 40 {}
C {lab_pin.sym} 2740 40 0 0 {name=l71 lab=BL14}
N 2760 0 2740 0 {}
C {lab_pin.sym} 2740 0 0 0 {name=l72 lab=BLB14}
N 2760 -40 2740 -40 {}
C {lab_pin.sym} 2740 -40 0 0 {name=l73 lab=WL0}
N 2840 40 2860 40 {}
C {lab_pin.sym} 2860 40 0 0 {name=l74 lab=VDD}
N 2840 -40 2860 -40 {}
C {lab_pin.sym} 2860 -40 0 0 {name=l75 lab=VSS}
C {bitcell_6t.sym} 3000 0 0 0 {name=Xr0c15}
N 2960 40 2940 40 {}
C {lab_pin.sym} 2940 40 0 0 {name=l76 lab=BL15}
N 2960 0 2940 0 {}
C {lab_pin.sym} 2940 0 0 0 {name=l77 lab=BLB15}
N 2960 -40 2940 -40 {}
C {lab_pin.sym} 2940 -40 0 0 {name=l78 lab=WL0}
N 3040 40 3060 40 {}
C {lab_pin.sym} 3060 40 0 0 {name=l79 lab=VDD}
N 3040 -40 3060 -40 {}
C {lab_pin.sym} 3060 -40 0 0 {name=l80 lab=VSS}
C {bitcell_6t.sym} 3200 0 0 0 {name=Xr0c16}
N 3160 40 3140 40 {}
C {lab_pin.sym} 3140 40 0 0 {name=l81 lab=BL16}
N 3160 0 3140 0 {}
C {lab_pin.sym} 3140 0 0 0 {name=l82 lab=BLB16}
N 3160 -40 3140 -40 {}
C {lab_pin.sym} 3140 -40 0 0 {name=l83 lab=WL0}
N 3240 40 3260 40 {}
C {lab_pin.sym} 3260 40 0 0 {name=l84 lab=VDD}
N 3240 -40 3260 -40 {}
C {lab_pin.sym} 3260 -40 0 0 {name=l85 lab=VSS}
C {bitcell_6t.sym} 3400 0 0 0 {name=Xr0c17}
N 3360 40 3340 40 {}
C {lab_pin.sym} 3340 40 0 0 {name=l86 lab=BL17}
N 3360 0 3340 0 {}
C {lab_pin.sym} 3340 0 0 0 {name=l87 lab=BLB17}
N 3360 -40 3340 -40 {}
C {lab_pin.sym} 3340 -40 0 0 {name=l88 lab=WL0}
N 3440 40 3460 40 {}
C {lab_pin.sym} 3460 40 0 0 {name=l89 lab=VDD}
N 3440 -40 3460 -40 {}
C {lab_pin.sym} 3460 -40 0 0 {name=l90 lab=VSS}
C {bitcell_6t.sym} 3600 0 0 0 {name=Xr0c18}
N 3560 40 3540 40 {}
C {lab_pin.sym} 3540 40 0 0 {name=l91 lab=BL18}
N 3560 0 3540 0 {}
C {lab_pin.sym} 3540 0 0 0 {name=l92 lab=BLB18}
N 3560 -40 3540 -40 {}
C {lab_pin.sym} 3540 -40 0 0 {name=l93 lab=WL0}
N 3640 40 3660 40 {}
C {lab_pin.sym} 3660 40 0 0 {name=l94 lab=VDD}
N 3640 -40 3660 -40 {}
C {lab_pin.sym} 3660 -40 0 0 {name=l95 lab=VSS}
C {bitcell_6t.sym} 3800 0 0 0 {name=Xr0c19}
N 3760 40 3740 40 {}
C {lab_pin.sym} 3740 40 0 0 {name=l96 lab=BL19}
N 3760 0 3740 0 {}
C {lab_pin.sym} 3740 0 0 0 {name=l97 lab=BLB19}
N 3760 -40 3740 -40 {}
C {lab_pin.sym} 3740 -40 0 0 {name=l98 lab=WL0}
N 3840 40 3860 40 {}
C {lab_pin.sym} 3860 40 0 0 {name=l99 lab=VDD}
N 3840 -40 3860 -40 {}
C {lab_pin.sym} 3860 -40 0 0 {name=l100 lab=VSS}
C {bitcell_6t.sym} 4000 0 0 0 {name=Xr0c20}
N 3960 40 3940 40 {}
C {lab_pin.sym} 3940 40 0 0 {name=l101 lab=BL20}
N 3960 0 3940 0 {}
C {lab_pin.sym} 3940 0 0 0 {name=l102 lab=BLB20}
N 3960 -40 3940 -40 {}
C {lab_pin.sym} 3940 -40 0 0 {name=l103 lab=WL0}
N 4040 40 4060 40 {}
C {lab_pin.sym} 4060 40 0 0 {name=l104 lab=VDD}
N 4040 -40 4060 -40 {}
C {lab_pin.sym} 4060 -40 0 0 {name=l105 lab=VSS}
C {bitcell_6t.sym} 4200 0 0 0 {name=Xr0c21}
N 4160 40 4140 40 {}
C {lab_pin.sym} 4140 40 0 0 {name=l106 lab=BL21}
N 4160 0 4140 0 {}
C {lab_pin.sym} 4140 0 0 0 {name=l107 lab=BLB21}
N 4160 -40 4140 -40 {}
C {lab_pin.sym} 4140 -40 0 0 {name=l108 lab=WL0}
N 4240 40 4260 40 {}
C {lab_pin.sym} 4260 40 0 0 {name=l109 lab=VDD}
N 4240 -40 4260 -40 {}
C {lab_pin.sym} 4260 -40 0 0 {name=l110 lab=VSS}
C {bitcell_6t.sym} 4400 0 0 0 {name=Xr0c22}
N 4360 40 4340 40 {}
C {lab_pin.sym} 4340 40 0 0 {name=l111 lab=BL22}
N 4360 0 4340 0 {}
C {lab_pin.sym} 4340 0 0 0 {name=l112 lab=BLB22}
N 4360 -40 4340 -40 {}
C {lab_pin.sym} 4340 -40 0 0 {name=l113 lab=WL0}
N 4440 40 4460 40 {}
C {lab_pin.sym} 4460 40 0 0 {name=l114 lab=VDD}
N 4440 -40 4460 -40 {}
C {lab_pin.sym} 4460 -40 0 0 {name=l115 lab=VSS}
C {bitcell_6t.sym} 4600 0 0 0 {name=Xr0c23}
N 4560 40 4540 40 {}
C {lab_pin.sym} 4540 40 0 0 {name=l116 lab=BL23}
N 4560 0 4540 0 {}
C {lab_pin.sym} 4540 0 0 0 {name=l117 lab=BLB23}
N 4560 -40 4540 -40 {}
C {lab_pin.sym} 4540 -40 0 0 {name=l118 lab=WL0}
N 4640 40 4660 40 {}
C {lab_pin.sym} 4660 40 0 0 {name=l119 lab=VDD}
N 4640 -40 4660 -40 {}
C {lab_pin.sym} 4660 -40 0 0 {name=l120 lab=VSS}
C {bitcell_6t.sym} 4800 0 0 0 {name=Xr0c24}
N 4760 40 4740 40 {}
C {lab_pin.sym} 4740 40 0 0 {name=l121 lab=BL24}
N 4760 0 4740 0 {}
C {lab_pin.sym} 4740 0 0 0 {name=l122 lab=BLB24}
N 4760 -40 4740 -40 {}
C {lab_pin.sym} 4740 -40 0 0 {name=l123 lab=WL0}
N 4840 40 4860 40 {}
C {lab_pin.sym} 4860 40 0 0 {name=l124 lab=VDD}
N 4840 -40 4860 -40 {}
C {lab_pin.sym} 4860 -40 0 0 {name=l125 lab=VSS}
C {bitcell_6t.sym} 5000 0 0 0 {name=Xr0c25}
N 4960 40 4940 40 {}
C {lab_pin.sym} 4940 40 0 0 {name=l126 lab=BL25}
N 4960 0 4940 0 {}
C {lab_pin.sym} 4940 0 0 0 {name=l127 lab=BLB25}
N 4960 -40 4940 -40 {}
C {lab_pin.sym} 4940 -40 0 0 {name=l128 lab=WL0}
N 5040 40 5060 40 {}
C {lab_pin.sym} 5060 40 0 0 {name=l129 lab=VDD}
N 5040 -40 5060 -40 {}
C {lab_pin.sym} 5060 -40 0 0 {name=l130 lab=VSS}
C {bitcell_6t.sym} 5200 0 0 0 {name=Xr0c26}
N 5160 40 5140 40 {}
C {lab_pin.sym} 5140 40 0 0 {name=l131 lab=BL26}
N 5160 0 5140 0 {}
C {lab_pin.sym} 5140 0 0 0 {name=l132 lab=BLB26}
N 5160 -40 5140 -40 {}
C {lab_pin.sym} 5140 -40 0 0 {name=l133 lab=WL0}
N 5240 40 5260 40 {}
C {lab_pin.sym} 5260 40 0 0 {name=l134 lab=VDD}
N 5240 -40 5260 -40 {}
C {lab_pin.sym} 5260 -40 0 0 {name=l135 lab=VSS}
C {bitcell_6t.sym} 5400 0 0 0 {name=Xr0c27}
N 5360 40 5340 40 {}
C {lab_pin.sym} 5340 40 0 0 {name=l136 lab=BL27}
N 5360 0 5340 0 {}
C {lab_pin.sym} 5340 0 0 0 {name=l137 lab=BLB27}
N 5360 -40 5340 -40 {}
C {lab_pin.sym} 5340 -40 0 0 {name=l138 lab=WL0}
N 5440 40 5460 40 {}
C {lab_pin.sym} 5460 40 0 0 {name=l139 lab=VDD}
N 5440 -40 5460 -40 {}
C {lab_pin.sym} 5460 -40 0 0 {name=l140 lab=VSS}
C {bitcell_6t.sym} 5600 0 0 0 {name=Xr0c28}
N 5560 40 5540 40 {}
C {lab_pin.sym} 5540 40 0 0 {name=l141 lab=BL28}
N 5560 0 5540 0 {}
C {lab_pin.sym} 5540 0 0 0 {name=l142 lab=BLB28}
N 5560 -40 5540 -40 {}
C {lab_pin.sym} 5540 -40 0 0 {name=l143 lab=WL0}
N 5640 40 5660 40 {}
C {lab_pin.sym} 5660 40 0 0 {name=l144 lab=VDD}
N 5640 -40 5660 -40 {}
C {lab_pin.sym} 5660 -40 0 0 {name=l145 lab=VSS}
C {bitcell_6t.sym} 5800 0 0 0 {name=Xr0c29}
N 5760 40 5740 40 {}
C {lab_pin.sym} 5740 40 0 0 {name=l146 lab=BL29}
N 5760 0 5740 0 {}
C {lab_pin.sym} 5740 0 0 0 {name=l147 lab=BLB29}
N 5760 -40 5740 -40 {}
C {lab_pin.sym} 5740 -40 0 0 {name=l148 lab=WL0}
N 5840 40 5860 40 {}
C {lab_pin.sym} 5860 40 0 0 {name=l149 lab=VDD}
N 5840 -40 5860 -40 {}
C {lab_pin.sym} 5860 -40 0 0 {name=l150 lab=VSS}
C {bitcell_6t.sym} 6000 0 0 0 {name=Xr0c30}
N 5960 40 5940 40 {}
C {lab_pin.sym} 5940 40 0 0 {name=l151 lab=BL30}
N 5960 0 5940 0 {}
C {lab_pin.sym} 5940 0 0 0 {name=l152 lab=BLB30}
N 5960 -40 5940 -40 {}
C {lab_pin.sym} 5940 -40 0 0 {name=l153 lab=WL0}
N 6040 40 6060 40 {}
C {lab_pin.sym} 6060 40 0 0 {name=l154 lab=VDD}
N 6040 -40 6060 -40 {}
C {lab_pin.sym} 6060 -40 0 0 {name=l155 lab=VSS}
C {bitcell_6t.sym} 6200 0 0 0 {name=Xr0c31}
N 6160 40 6140 40 {}
C {lab_pin.sym} 6140 40 0 0 {name=l156 lab=BL31}
N 6160 0 6140 0 {}
C {lab_pin.sym} 6140 0 0 0 {name=l157 lab=BLB31}
N 6160 -40 6140 -40 {}
C {lab_pin.sym} 6140 -40 0 0 {name=l158 lab=WL0}
N 6240 40 6260 40 {}
C {lab_pin.sym} 6260 40 0 0 {name=l159 lab=VDD}
N 6240 -40 6260 -40 {}
C {lab_pin.sym} 6260 -40 0 0 {name=l160 lab=VSS}
C {bitcell_6t.sym} 0 200 0 0 {name=Xr1c0}
N -40 240 -60 240 {}
C {lab_pin.sym} -60 240 0 0 {name=l161 lab=BL0}
N -40 200 -60 200 {}
C {lab_pin.sym} -60 200 0 0 {name=l162 lab=BLB0}
N -40 160 -60 160 {}
C {lab_pin.sym} -60 160 0 0 {name=l163 lab=WL1}
N 40 240 60 240 {}
C {lab_pin.sym} 60 240 0 0 {name=l164 lab=VDD}
N 40 160 60 160 {}
C {lab_pin.sym} 60 160 0 0 {name=l165 lab=VSS}
C {bitcell_6t.sym} 200 200 0 0 {name=Xr1c1}
N 160 240 140 240 {}
C {lab_pin.sym} 140 240 0 0 {name=l166 lab=BL1}
N 160 200 140 200 {}
C {lab_pin.sym} 140 200 0 0 {name=l167 lab=BLB1}
N 160 160 140 160 {}
C {lab_pin.sym} 140 160 0 0 {name=l168 lab=WL1}
N 240 240 260 240 {}
C {lab_pin.sym} 260 240 0 0 {name=l169 lab=VDD}
N 240 160 260 160 {}
C {lab_pin.sym} 260 160 0 0 {name=l170 lab=VSS}
C {bitcell_6t.sym} 400 200 0 0 {name=Xr1c2}
N 360 240 340 240 {}
C {lab_pin.sym} 340 240 0 0 {name=l171 lab=BL2}
N 360 200 340 200 {}
C {lab_pin.sym} 340 200 0 0 {name=l172 lab=BLB2}
N 360 160 340 160 {}
C {lab_pin.sym} 340 160 0 0 {name=l173 lab=WL1}
N 440 240 460 240 {}
C {lab_pin.sym} 460 240 0 0 {name=l174 lab=VDD}
N 440 160 460 160 {}
C {lab_pin.sym} 460 160 0 0 {name=l175 lab=VSS}
C {bitcell_6t.sym} 600 200 0 0 {name=Xr1c3}
N 560 240 540 240 {}
C {lab_pin.sym} 540 240 0 0 {name=l176 lab=BL3}
N 560 200 540 200 {}
C {lab_pin.sym} 540 200 0 0 {name=l177 lab=BLB3}
N 560 160 540 160 {}
C {lab_pin.sym} 540 160 0 0 {name=l178 lab=WL1}
N 640 240 660 240 {}
C {lab_pin.sym} 660 240 0 0 {name=l179 lab=VDD}
N 640 160 660 160 {}
C {lab_pin.sym} 660 160 0 0 {name=l180 lab=VSS}
C {bitcell_6t.sym} 800 200 0 0 {name=Xr1c4}
N 760 240 740 240 {}
C {lab_pin.sym} 740 240 0 0 {name=l181 lab=BL4}
N 760 200 740 200 {}
C {lab_pin.sym} 740 200 0 0 {name=l182 lab=BLB4}
N 760 160 740 160 {}
C {lab_pin.sym} 740 160 0 0 {name=l183 lab=WL1}
N 840 240 860 240 {}
C {lab_pin.sym} 860 240 0 0 {name=l184 lab=VDD}
N 840 160 860 160 {}
C {lab_pin.sym} 860 160 0 0 {name=l185 lab=VSS}
C {bitcell_6t.sym} 1000 200 0 0 {name=Xr1c5}
N 960 240 940 240 {}
C {lab_pin.sym} 940 240 0 0 {name=l186 lab=BL5}
N 960 200 940 200 {}
C {lab_pin.sym} 940 200 0 0 {name=l187 lab=BLB5}
N 960 160 940 160 {}
C {lab_pin.sym} 940 160 0 0 {name=l188 lab=WL1}
N 1040 240 1060 240 {}
C {lab_pin.sym} 1060 240 0 0 {name=l189 lab=VDD}
N 1040 160 1060 160 {}
C {lab_pin.sym} 1060 160 0 0 {name=l190 lab=VSS}
C {bitcell_6t.sym} 1200 200 0 0 {name=Xr1c6}
N 1160 240 1140 240 {}
C {lab_pin.sym} 1140 240 0 0 {name=l191 lab=BL6}
N 1160 200 1140 200 {}
C {lab_pin.sym} 1140 200 0 0 {name=l192 lab=BLB6}
N 1160 160 1140 160 {}
C {lab_pin.sym} 1140 160 0 0 {name=l193 lab=WL1}
N 1240 240 1260 240 {}
C {lab_pin.sym} 1260 240 0 0 {name=l194 lab=VDD}
N 1240 160 1260 160 {}
C {lab_pin.sym} 1260 160 0 0 {name=l195 lab=VSS}
C {bitcell_6t.sym} 1400 200 0 0 {name=Xr1c7}
N 1360 240 1340 240 {}
C {lab_pin.sym} 1340 240 0 0 {name=l196 lab=BL7}
N 1360 200 1340 200 {}
C {lab_pin.sym} 1340 200 0 0 {name=l197 lab=BLB7}
N 1360 160 1340 160 {}
C {lab_pin.sym} 1340 160 0 0 {name=l198 lab=WL1}
N 1440 240 1460 240 {}
C {lab_pin.sym} 1460 240 0 0 {name=l199 lab=VDD}
N 1440 160 1460 160 {}
C {lab_pin.sym} 1460 160 0 0 {name=l200 lab=VSS}
C {bitcell_6t.sym} 1600 200 0 0 {name=Xr1c8}
N 1560 240 1540 240 {}
C {lab_pin.sym} 1540 240 0 0 {name=l201 lab=BL8}
N 1560 200 1540 200 {}
C {lab_pin.sym} 1540 200 0 0 {name=l202 lab=BLB8}
N 1560 160 1540 160 {}
C {lab_pin.sym} 1540 160 0 0 {name=l203 lab=WL1}
N 1640 240 1660 240 {}
C {lab_pin.sym} 1660 240 0 0 {name=l204 lab=VDD}
N 1640 160 1660 160 {}
C {lab_pin.sym} 1660 160 0 0 {name=l205 lab=VSS}
C {bitcell_6t.sym} 1800 200 0 0 {name=Xr1c9}
N 1760 240 1740 240 {}
C {lab_pin.sym} 1740 240 0 0 {name=l206 lab=BL9}
N 1760 200 1740 200 {}
C {lab_pin.sym} 1740 200 0 0 {name=l207 lab=BLB9}
N 1760 160 1740 160 {}
C {lab_pin.sym} 1740 160 0 0 {name=l208 lab=WL1}
N 1840 240 1860 240 {}
C {lab_pin.sym} 1860 240 0 0 {name=l209 lab=VDD}
N 1840 160 1860 160 {}
C {lab_pin.sym} 1860 160 0 0 {name=l210 lab=VSS}
C {bitcell_6t.sym} 2000 200 0 0 {name=Xr1c10}
N 1960 240 1940 240 {}
C {lab_pin.sym} 1940 240 0 0 {name=l211 lab=BL10}
N 1960 200 1940 200 {}
C {lab_pin.sym} 1940 200 0 0 {name=l212 lab=BLB10}
N 1960 160 1940 160 {}
C {lab_pin.sym} 1940 160 0 0 {name=l213 lab=WL1}
N 2040 240 2060 240 {}
C {lab_pin.sym} 2060 240 0 0 {name=l214 lab=VDD}
N 2040 160 2060 160 {}
C {lab_pin.sym} 2060 160 0 0 {name=l215 lab=VSS}
C {bitcell_6t.sym} 2200 200 0 0 {name=Xr1c11}
N 2160 240 2140 240 {}
C {lab_pin.sym} 2140 240 0 0 {name=l216 lab=BL11}
N 2160 200 2140 200 {}
C {lab_pin.sym} 2140 200 0 0 {name=l217 lab=BLB11}
N 2160 160 2140 160 {}
C {lab_pin.sym} 2140 160 0 0 {name=l218 lab=WL1}
N 2240 240 2260 240 {}
C {lab_pin.sym} 2260 240 0 0 {name=l219 lab=VDD}
N 2240 160 2260 160 {}
C {lab_pin.sym} 2260 160 0 0 {name=l220 lab=VSS}
C {bitcell_6t.sym} 2400 200 0 0 {name=Xr1c12}
N 2360 240 2340 240 {}
C {lab_pin.sym} 2340 240 0 0 {name=l221 lab=BL12}
N 2360 200 2340 200 {}
C {lab_pin.sym} 2340 200 0 0 {name=l222 lab=BLB12}
N 2360 160 2340 160 {}
C {lab_pin.sym} 2340 160 0 0 {name=l223 lab=WL1}
N 2440 240 2460 240 {}
C {lab_pin.sym} 2460 240 0 0 {name=l224 lab=VDD}
N 2440 160 2460 160 {}
C {lab_pin.sym} 2460 160 0 0 {name=l225 lab=VSS}
C {bitcell_6t.sym} 2600 200 0 0 {name=Xr1c13}
N 2560 240 2540 240 {}
C {lab_pin.sym} 2540 240 0 0 {name=l226 lab=BL13}
N 2560 200 2540 200 {}
C {lab_pin.sym} 2540 200 0 0 {name=l227 lab=BLB13}
N 2560 160 2540 160 {}
C {lab_pin.sym} 2540 160 0 0 {name=l228 lab=WL1}
N 2640 240 2660 240 {}
C {lab_pin.sym} 2660 240 0 0 {name=l229 lab=VDD}
N 2640 160 2660 160 {}
C {lab_pin.sym} 2660 160 0 0 {name=l230 lab=VSS}
C {bitcell_6t.sym} 2800 200 0 0 {name=Xr1c14}
N 2760 240 2740 240 {}
C {lab_pin.sym} 2740 240 0 0 {name=l231 lab=BL14}
N 2760 200 2740 200 {}
C {lab_pin.sym} 2740 200 0 0 {name=l232 lab=BLB14}
N 2760 160 2740 160 {}
C {lab_pin.sym} 2740 160 0 0 {name=l233 lab=WL1}
N 2840 240 2860 240 {}
C {lab_pin.sym} 2860 240 0 0 {name=l234 lab=VDD}
N 2840 160 2860 160 {}
C {lab_pin.sym} 2860 160 0 0 {name=l235 lab=VSS}
C {bitcell_6t.sym} 3000 200 0 0 {name=Xr1c15}
N 2960 240 2940 240 {}
C {lab_pin.sym} 2940 240 0 0 {name=l236 lab=BL15}
N 2960 200 2940 200 {}
C {lab_pin.sym} 2940 200 0 0 {name=l237 lab=BLB15}
N 2960 160 2940 160 {}
C {lab_pin.sym} 2940 160 0 0 {name=l238 lab=WL1}
N 3040 240 3060 240 {}
C {lab_pin.sym} 3060 240 0 0 {name=l239 lab=VDD}
N 3040 160 3060 160 {}
C {lab_pin.sym} 3060 160 0 0 {name=l240 lab=VSS}
C {bitcell_6t.sym} 3200 200 0 0 {name=Xr1c16}
N 3160 240 3140 240 {}
C {lab_pin.sym} 3140 240 0 0 {name=l241 lab=BL16}
N 3160 200 3140 200 {}
C {lab_pin.sym} 3140 200 0 0 {name=l242 lab=BLB16}
N 3160 160 3140 160 {}
C {lab_pin.sym} 3140 160 0 0 {name=l243 lab=WL1}
N 3240 240 3260 240 {}
C {lab_pin.sym} 3260 240 0 0 {name=l244 lab=VDD}
N 3240 160 3260 160 {}
C {lab_pin.sym} 3260 160 0 0 {name=l245 lab=VSS}
C {bitcell_6t.sym} 3400 200 0 0 {name=Xr1c17}
N 3360 240 3340 240 {}
C {lab_pin.sym} 3340 240 0 0 {name=l246 lab=BL17}
N 3360 200 3340 200 {}
C {lab_pin.sym} 3340 200 0 0 {name=l247 lab=BLB17}
N 3360 160 3340 160 {}
C {lab_pin.sym} 3340 160 0 0 {name=l248 lab=WL1}
N 3440 240 3460 240 {}
C {lab_pin.sym} 3460 240 0 0 {name=l249 lab=VDD}
N 3440 160 3460 160 {}
C {lab_pin.sym} 3460 160 0 0 {name=l250 lab=VSS}
C {bitcell_6t.sym} 3600 200 0 0 {name=Xr1c18}
N 3560 240 3540 240 {}
C {lab_pin.sym} 3540 240 0 0 {name=l251 lab=BL18}
N 3560 200 3540 200 {}
C {lab_pin.sym} 3540 200 0 0 {name=l252 lab=BLB18}
N 3560 160 3540 160 {}
C {lab_pin.sym} 3540 160 0 0 {name=l253 lab=WL1}
N 3640 240 3660 240 {}
C {lab_pin.sym} 3660 240 0 0 {name=l254 lab=VDD}
N 3640 160 3660 160 {}
C {lab_pin.sym} 3660 160 0 0 {name=l255 lab=VSS}
C {bitcell_6t.sym} 3800 200 0 0 {name=Xr1c19}
N 3760 240 3740 240 {}
C {lab_pin.sym} 3740 240 0 0 {name=l256 lab=BL19}
N 3760 200 3740 200 {}
C {lab_pin.sym} 3740 200 0 0 {name=l257 lab=BLB19}
N 3760 160 3740 160 {}
C {lab_pin.sym} 3740 160 0 0 {name=l258 lab=WL1}
N 3840 240 3860 240 {}
C {lab_pin.sym} 3860 240 0 0 {name=l259 lab=VDD}
N 3840 160 3860 160 {}
C {lab_pin.sym} 3860 160 0 0 {name=l260 lab=VSS}
C {bitcell_6t.sym} 4000 200 0 0 {name=Xr1c20}
N 3960 240 3940 240 {}
C {lab_pin.sym} 3940 240 0 0 {name=l261 lab=BL20}
N 3960 200 3940 200 {}
C {lab_pin.sym} 3940 200 0 0 {name=l262 lab=BLB20}
N 3960 160 3940 160 {}
C {lab_pin.sym} 3940 160 0 0 {name=l263 lab=WL1}
N 4040 240 4060 240 {}
C {lab_pin.sym} 4060 240 0 0 {name=l264 lab=VDD}
N 4040 160 4060 160 {}
C {lab_pin.sym} 4060 160 0 0 {name=l265 lab=VSS}
C {bitcell_6t.sym} 4200 200 0 0 {name=Xr1c21}
N 4160 240 4140 240 {}
C {lab_pin.sym} 4140 240 0 0 {name=l266 lab=BL21}
N 4160 200 4140 200 {}
C {lab_pin.sym} 4140 200 0 0 {name=l267 lab=BLB21}
N 4160 160 4140 160 {}
C {lab_pin.sym} 4140 160 0 0 {name=l268 lab=WL1}
N 4240 240 4260 240 {}
C {lab_pin.sym} 4260 240 0 0 {name=l269 lab=VDD}
N 4240 160 4260 160 {}
C {lab_pin.sym} 4260 160 0 0 {name=l270 lab=VSS}
C {bitcell_6t.sym} 4400 200 0 0 {name=Xr1c22}
N 4360 240 4340 240 {}
C {lab_pin.sym} 4340 240 0 0 {name=l271 lab=BL22}
N 4360 200 4340 200 {}
C {lab_pin.sym} 4340 200 0 0 {name=l272 lab=BLB22}
N 4360 160 4340 160 {}
C {lab_pin.sym} 4340 160 0 0 {name=l273 lab=WL1}
N 4440 240 4460 240 {}
C {lab_pin.sym} 4460 240 0 0 {name=l274 lab=VDD}
N 4440 160 4460 160 {}
C {lab_pin.sym} 4460 160 0 0 {name=l275 lab=VSS}
C {bitcell_6t.sym} 4600 200 0 0 {name=Xr1c23}
N 4560 240 4540 240 {}
C {lab_pin.sym} 4540 240 0 0 {name=l276 lab=BL23}
N 4560 200 4540 200 {}
C {lab_pin.sym} 4540 200 0 0 {name=l277 lab=BLB23}
N 4560 160 4540 160 {}
C {lab_pin.sym} 4540 160 0 0 {name=l278 lab=WL1}
N 4640 240 4660 240 {}
C {lab_pin.sym} 4660 240 0 0 {name=l279 lab=VDD}
N 4640 160 4660 160 {}
C {lab_pin.sym} 4660 160 0 0 {name=l280 lab=VSS}
C {bitcell_6t.sym} 4800 200 0 0 {name=Xr1c24}
N 4760 240 4740 240 {}
C {lab_pin.sym} 4740 240 0 0 {name=l281 lab=BL24}
N 4760 200 4740 200 {}
C {lab_pin.sym} 4740 200 0 0 {name=l282 lab=BLB24}
N 4760 160 4740 160 {}
C {lab_pin.sym} 4740 160 0 0 {name=l283 lab=WL1}
N 4840 240 4860 240 {}
C {lab_pin.sym} 4860 240 0 0 {name=l284 lab=VDD}
N 4840 160 4860 160 {}
C {lab_pin.sym} 4860 160 0 0 {name=l285 lab=VSS}
C {bitcell_6t.sym} 5000 200 0 0 {name=Xr1c25}
N 4960 240 4940 240 {}
C {lab_pin.sym} 4940 240 0 0 {name=l286 lab=BL25}
N 4960 200 4940 200 {}
C {lab_pin.sym} 4940 200 0 0 {name=l287 lab=BLB25}
N 4960 160 4940 160 {}
C {lab_pin.sym} 4940 160 0 0 {name=l288 lab=WL1}
N 5040 240 5060 240 {}
C {lab_pin.sym} 5060 240 0 0 {name=l289 lab=VDD}
N 5040 160 5060 160 {}
C {lab_pin.sym} 5060 160 0 0 {name=l290 lab=VSS}
C {bitcell_6t.sym} 5200 200 0 0 {name=Xr1c26}
N 5160 240 5140 240 {}
C {lab_pin.sym} 5140 240 0 0 {name=l291 lab=BL26}
N 5160 200 5140 200 {}
C {lab_pin.sym} 5140 200 0 0 {name=l292 lab=BLB26}
N 5160 160 5140 160 {}
C {lab_pin.sym} 5140 160 0 0 {name=l293 lab=WL1}
N 5240 240 5260 240 {}
C {lab_pin.sym} 5260 240 0 0 {name=l294 lab=VDD}
N 5240 160 5260 160 {}
C {lab_pin.sym} 5260 160 0 0 {name=l295 lab=VSS}
C {bitcell_6t.sym} 5400 200 0 0 {name=Xr1c27}
N 5360 240 5340 240 {}
C {lab_pin.sym} 5340 240 0 0 {name=l296 lab=BL27}
N 5360 200 5340 200 {}
C {lab_pin.sym} 5340 200 0 0 {name=l297 lab=BLB27}
N 5360 160 5340 160 {}
C {lab_pin.sym} 5340 160 0 0 {name=l298 lab=WL1}
N 5440 240 5460 240 {}
C {lab_pin.sym} 5460 240 0 0 {name=l299 lab=VDD}
N 5440 160 5460 160 {}
C {lab_pin.sym} 5460 160 0 0 {name=l300 lab=VSS}
C {bitcell_6t.sym} 5600 200 0 0 {name=Xr1c28}
N 5560 240 5540 240 {}
C {lab_pin.sym} 5540 240 0 0 {name=l301 lab=BL28}
N 5560 200 5540 200 {}
C {lab_pin.sym} 5540 200 0 0 {name=l302 lab=BLB28}
N 5560 160 5540 160 {}
C {lab_pin.sym} 5540 160 0 0 {name=l303 lab=WL1}
N 5640 240 5660 240 {}
C {lab_pin.sym} 5660 240 0 0 {name=l304 lab=VDD}
N 5640 160 5660 160 {}
C {lab_pin.sym} 5660 160 0 0 {name=l305 lab=VSS}
C {bitcell_6t.sym} 5800 200 0 0 {name=Xr1c29}
N 5760 240 5740 240 {}
C {lab_pin.sym} 5740 240 0 0 {name=l306 lab=BL29}
N 5760 200 5740 200 {}
C {lab_pin.sym} 5740 200 0 0 {name=l307 lab=BLB29}
N 5760 160 5740 160 {}
C {lab_pin.sym} 5740 160 0 0 {name=l308 lab=WL1}
N 5840 240 5860 240 {}
C {lab_pin.sym} 5860 240 0 0 {name=l309 lab=VDD}
N 5840 160 5860 160 {}
C {lab_pin.sym} 5860 160 0 0 {name=l310 lab=VSS}
C {bitcell_6t.sym} 6000 200 0 0 {name=Xr1c30}
N 5960 240 5940 240 {}
C {lab_pin.sym} 5940 240 0 0 {name=l311 lab=BL30}
N 5960 200 5940 200 {}
C {lab_pin.sym} 5940 200 0 0 {name=l312 lab=BLB30}
N 5960 160 5940 160 {}
C {lab_pin.sym} 5940 160 0 0 {name=l313 lab=WL1}
N 6040 240 6060 240 {}
C {lab_pin.sym} 6060 240 0 0 {name=l314 lab=VDD}
N 6040 160 6060 160 {}
C {lab_pin.sym} 6060 160 0 0 {name=l315 lab=VSS}
C {bitcell_6t.sym} 6200 200 0 0 {name=Xr1c31}
N 6160 240 6140 240 {}
C {lab_pin.sym} 6140 240 0 0 {name=l316 lab=BL31}
N 6160 200 6140 200 {}
C {lab_pin.sym} 6140 200 0 0 {name=l317 lab=BLB31}
N 6160 160 6140 160 {}
C {lab_pin.sym} 6140 160 0 0 {name=l318 lab=WL1}
N 6240 240 6260 240 {}
C {lab_pin.sym} 6260 240 0 0 {name=l319 lab=VDD}
N 6240 160 6260 160 {}
C {lab_pin.sym} 6260 160 0 0 {name=l320 lab=VSS}
C {bitcell_6t.sym} 0 400 0 0 {name=Xr2c0}
N -40 440 -60 440 {}
C {lab_pin.sym} -60 440 0 0 {name=l321 lab=BL0}
N -40 400 -60 400 {}
C {lab_pin.sym} -60 400 0 0 {name=l322 lab=BLB0}
N -40 360 -60 360 {}
C {lab_pin.sym} -60 360 0 0 {name=l323 lab=WL2}
N 40 440 60 440 {}
C {lab_pin.sym} 60 440 0 0 {name=l324 lab=VDD}
N 40 360 60 360 {}
C {lab_pin.sym} 60 360 0 0 {name=l325 lab=VSS}
C {bitcell_6t.sym} 200 400 0 0 {name=Xr2c1}
N 160 440 140 440 {}
C {lab_pin.sym} 140 440 0 0 {name=l326 lab=BL1}
N 160 400 140 400 {}
C {lab_pin.sym} 140 400 0 0 {name=l327 lab=BLB1}
N 160 360 140 360 {}
C {lab_pin.sym} 140 360 0 0 {name=l328 lab=WL2}
N 240 440 260 440 {}
C {lab_pin.sym} 260 440 0 0 {name=l329 lab=VDD}
N 240 360 260 360 {}
C {lab_pin.sym} 260 360 0 0 {name=l330 lab=VSS}
C {bitcell_6t.sym} 400 400 0 0 {name=Xr2c2}
N 360 440 340 440 {}
C {lab_pin.sym} 340 440 0 0 {name=l331 lab=BL2}
N 360 400 340 400 {}
C {lab_pin.sym} 340 400 0 0 {name=l332 lab=BLB2}
N 360 360 340 360 {}
C {lab_pin.sym} 340 360 0 0 {name=l333 lab=WL2}
N 440 440 460 440 {}
C {lab_pin.sym} 460 440 0 0 {name=l334 lab=VDD}
N 440 360 460 360 {}
C {lab_pin.sym} 460 360 0 0 {name=l335 lab=VSS}
C {bitcell_6t.sym} 600 400 0 0 {name=Xr2c3}
N 560 440 540 440 {}
C {lab_pin.sym} 540 440 0 0 {name=l336 lab=BL3}
N 560 400 540 400 {}
C {lab_pin.sym} 540 400 0 0 {name=l337 lab=BLB3}
N 560 360 540 360 {}
C {lab_pin.sym} 540 360 0 0 {name=l338 lab=WL2}
N 640 440 660 440 {}
C {lab_pin.sym} 660 440 0 0 {name=l339 lab=VDD}
N 640 360 660 360 {}
C {lab_pin.sym} 660 360 0 0 {name=l340 lab=VSS}
C {bitcell_6t.sym} 800 400 0 0 {name=Xr2c4}
N 760 440 740 440 {}
C {lab_pin.sym} 740 440 0 0 {name=l341 lab=BL4}
N 760 400 740 400 {}
C {lab_pin.sym} 740 400 0 0 {name=l342 lab=BLB4}
N 760 360 740 360 {}
C {lab_pin.sym} 740 360 0 0 {name=l343 lab=WL2}
N 840 440 860 440 {}
C {lab_pin.sym} 860 440 0 0 {name=l344 lab=VDD}
N 840 360 860 360 {}
C {lab_pin.sym} 860 360 0 0 {name=l345 lab=VSS}
C {bitcell_6t.sym} 1000 400 0 0 {name=Xr2c5}
N 960 440 940 440 {}
C {lab_pin.sym} 940 440 0 0 {name=l346 lab=BL5}
N 960 400 940 400 {}
C {lab_pin.sym} 940 400 0 0 {name=l347 lab=BLB5}
N 960 360 940 360 {}
C {lab_pin.sym} 940 360 0 0 {name=l348 lab=WL2}
N 1040 440 1060 440 {}
C {lab_pin.sym} 1060 440 0 0 {name=l349 lab=VDD}
N 1040 360 1060 360 {}
C {lab_pin.sym} 1060 360 0 0 {name=l350 lab=VSS}
C {bitcell_6t.sym} 1200 400 0 0 {name=Xr2c6}
N 1160 440 1140 440 {}
C {lab_pin.sym} 1140 440 0 0 {name=l351 lab=BL6}
N 1160 400 1140 400 {}
C {lab_pin.sym} 1140 400 0 0 {name=l352 lab=BLB6}
N 1160 360 1140 360 {}
C {lab_pin.sym} 1140 360 0 0 {name=l353 lab=WL2}
N 1240 440 1260 440 {}
C {lab_pin.sym} 1260 440 0 0 {name=l354 lab=VDD}
N 1240 360 1260 360 {}
C {lab_pin.sym} 1260 360 0 0 {name=l355 lab=VSS}
C {bitcell_6t.sym} 1400 400 0 0 {name=Xr2c7}
N 1360 440 1340 440 {}
C {lab_pin.sym} 1340 440 0 0 {name=l356 lab=BL7}
N 1360 400 1340 400 {}
C {lab_pin.sym} 1340 400 0 0 {name=l357 lab=BLB7}
N 1360 360 1340 360 {}
C {lab_pin.sym} 1340 360 0 0 {name=l358 lab=WL2}
N 1440 440 1460 440 {}
C {lab_pin.sym} 1460 440 0 0 {name=l359 lab=VDD}
N 1440 360 1460 360 {}
C {lab_pin.sym} 1460 360 0 0 {name=l360 lab=VSS}
C {bitcell_6t.sym} 1600 400 0 0 {name=Xr2c8}
N 1560 440 1540 440 {}
C {lab_pin.sym} 1540 440 0 0 {name=l361 lab=BL8}
N 1560 400 1540 400 {}
C {lab_pin.sym} 1540 400 0 0 {name=l362 lab=BLB8}
N 1560 360 1540 360 {}
C {lab_pin.sym} 1540 360 0 0 {name=l363 lab=WL2}
N 1640 440 1660 440 {}
C {lab_pin.sym} 1660 440 0 0 {name=l364 lab=VDD}
N 1640 360 1660 360 {}
C {lab_pin.sym} 1660 360 0 0 {name=l365 lab=VSS}
C {bitcell_6t.sym} 1800 400 0 0 {name=Xr2c9}
N 1760 440 1740 440 {}
C {lab_pin.sym} 1740 440 0 0 {name=l366 lab=BL9}
N 1760 400 1740 400 {}
C {lab_pin.sym} 1740 400 0 0 {name=l367 lab=BLB9}
N 1760 360 1740 360 {}
C {lab_pin.sym} 1740 360 0 0 {name=l368 lab=WL2}
N 1840 440 1860 440 {}
C {lab_pin.sym} 1860 440 0 0 {name=l369 lab=VDD}
N 1840 360 1860 360 {}
C {lab_pin.sym} 1860 360 0 0 {name=l370 lab=VSS}
C {bitcell_6t.sym} 2000 400 0 0 {name=Xr2c10}
N 1960 440 1940 440 {}
C {lab_pin.sym} 1940 440 0 0 {name=l371 lab=BL10}
N 1960 400 1940 400 {}
C {lab_pin.sym} 1940 400 0 0 {name=l372 lab=BLB10}
N 1960 360 1940 360 {}
C {lab_pin.sym} 1940 360 0 0 {name=l373 lab=WL2}
N 2040 440 2060 440 {}
C {lab_pin.sym} 2060 440 0 0 {name=l374 lab=VDD}
N 2040 360 2060 360 {}
C {lab_pin.sym} 2060 360 0 0 {name=l375 lab=VSS}
C {bitcell_6t.sym} 2200 400 0 0 {name=Xr2c11}
N 2160 440 2140 440 {}
C {lab_pin.sym} 2140 440 0 0 {name=l376 lab=BL11}
N 2160 400 2140 400 {}
C {lab_pin.sym} 2140 400 0 0 {name=l377 lab=BLB11}
N 2160 360 2140 360 {}
C {lab_pin.sym} 2140 360 0 0 {name=l378 lab=WL2}
N 2240 440 2260 440 {}
C {lab_pin.sym} 2260 440 0 0 {name=l379 lab=VDD}
N 2240 360 2260 360 {}
C {lab_pin.sym} 2260 360 0 0 {name=l380 lab=VSS}
C {bitcell_6t.sym} 2400 400 0 0 {name=Xr2c12}
N 2360 440 2340 440 {}
C {lab_pin.sym} 2340 440 0 0 {name=l381 lab=BL12}
N 2360 400 2340 400 {}
C {lab_pin.sym} 2340 400 0 0 {name=l382 lab=BLB12}
N 2360 360 2340 360 {}
C {lab_pin.sym} 2340 360 0 0 {name=l383 lab=WL2}
N 2440 440 2460 440 {}
C {lab_pin.sym} 2460 440 0 0 {name=l384 lab=VDD}
N 2440 360 2460 360 {}
C {lab_pin.sym} 2460 360 0 0 {name=l385 lab=VSS}
C {bitcell_6t.sym} 2600 400 0 0 {name=Xr2c13}
N 2560 440 2540 440 {}
C {lab_pin.sym} 2540 440 0 0 {name=l386 lab=BL13}
N 2560 400 2540 400 {}
C {lab_pin.sym} 2540 400 0 0 {name=l387 lab=BLB13}
N 2560 360 2540 360 {}
C {lab_pin.sym} 2540 360 0 0 {name=l388 lab=WL2}
N 2640 440 2660 440 {}
C {lab_pin.sym} 2660 440 0 0 {name=l389 lab=VDD}
N 2640 360 2660 360 {}
C {lab_pin.sym} 2660 360 0 0 {name=l390 lab=VSS}
C {bitcell_6t.sym} 2800 400 0 0 {name=Xr2c14}
N 2760 440 2740 440 {}
C {lab_pin.sym} 2740 440 0 0 {name=l391 lab=BL14}
N 2760 400 2740 400 {}
C {lab_pin.sym} 2740 400 0 0 {name=l392 lab=BLB14}
N 2760 360 2740 360 {}
C {lab_pin.sym} 2740 360 0 0 {name=l393 lab=WL2}
N 2840 440 2860 440 {}
C {lab_pin.sym} 2860 440 0 0 {name=l394 lab=VDD}
N 2840 360 2860 360 {}
C {lab_pin.sym} 2860 360 0 0 {name=l395 lab=VSS}
C {bitcell_6t.sym} 3000 400 0 0 {name=Xr2c15}
N 2960 440 2940 440 {}
C {lab_pin.sym} 2940 440 0 0 {name=l396 lab=BL15}
N 2960 400 2940 400 {}
C {lab_pin.sym} 2940 400 0 0 {name=l397 lab=BLB15}
N 2960 360 2940 360 {}
C {lab_pin.sym} 2940 360 0 0 {name=l398 lab=WL2}
N 3040 440 3060 440 {}
C {lab_pin.sym} 3060 440 0 0 {name=l399 lab=VDD}
N 3040 360 3060 360 {}
C {lab_pin.sym} 3060 360 0 0 {name=l400 lab=VSS}
C {bitcell_6t.sym} 3200 400 0 0 {name=Xr2c16}
N 3160 440 3140 440 {}
C {lab_pin.sym} 3140 440 0 0 {name=l401 lab=BL16}
N 3160 400 3140 400 {}
C {lab_pin.sym} 3140 400 0 0 {name=l402 lab=BLB16}
N 3160 360 3140 360 {}
C {lab_pin.sym} 3140 360 0 0 {name=l403 lab=WL2}
N 3240 440 3260 440 {}
C {lab_pin.sym} 3260 440 0 0 {name=l404 lab=VDD}
N 3240 360 3260 360 {}
C {lab_pin.sym} 3260 360 0 0 {name=l405 lab=VSS}
C {bitcell_6t.sym} 3400 400 0 0 {name=Xr2c17}
N 3360 440 3340 440 {}
C {lab_pin.sym} 3340 440 0 0 {name=l406 lab=BL17}
N 3360 400 3340 400 {}
C {lab_pin.sym} 3340 400 0 0 {name=l407 lab=BLB17}
N 3360 360 3340 360 {}
C {lab_pin.sym} 3340 360 0 0 {name=l408 lab=WL2}
N 3440 440 3460 440 {}
C {lab_pin.sym} 3460 440 0 0 {name=l409 lab=VDD}
N 3440 360 3460 360 {}
C {lab_pin.sym} 3460 360 0 0 {name=l410 lab=VSS}
C {bitcell_6t.sym} 3600 400 0 0 {name=Xr2c18}
N 3560 440 3540 440 {}
C {lab_pin.sym} 3540 440 0 0 {name=l411 lab=BL18}
N 3560 400 3540 400 {}
C {lab_pin.sym} 3540 400 0 0 {name=l412 lab=BLB18}
N 3560 360 3540 360 {}
C {lab_pin.sym} 3540 360 0 0 {name=l413 lab=WL2}
N 3640 440 3660 440 {}
C {lab_pin.sym} 3660 440 0 0 {name=l414 lab=VDD}
N 3640 360 3660 360 {}
C {lab_pin.sym} 3660 360 0 0 {name=l415 lab=VSS}
C {bitcell_6t.sym} 3800 400 0 0 {name=Xr2c19}
N 3760 440 3740 440 {}
C {lab_pin.sym} 3740 440 0 0 {name=l416 lab=BL19}
N 3760 400 3740 400 {}
C {lab_pin.sym} 3740 400 0 0 {name=l417 lab=BLB19}
N 3760 360 3740 360 {}
C {lab_pin.sym} 3740 360 0 0 {name=l418 lab=WL2}
N 3840 440 3860 440 {}
C {lab_pin.sym} 3860 440 0 0 {name=l419 lab=VDD}
N 3840 360 3860 360 {}
C {lab_pin.sym} 3860 360 0 0 {name=l420 lab=VSS}
C {bitcell_6t.sym} 4000 400 0 0 {name=Xr2c20}
N 3960 440 3940 440 {}
C {lab_pin.sym} 3940 440 0 0 {name=l421 lab=BL20}
N 3960 400 3940 400 {}
C {lab_pin.sym} 3940 400 0 0 {name=l422 lab=BLB20}
N 3960 360 3940 360 {}
C {lab_pin.sym} 3940 360 0 0 {name=l423 lab=WL2}
N 4040 440 4060 440 {}
C {lab_pin.sym} 4060 440 0 0 {name=l424 lab=VDD}
N 4040 360 4060 360 {}
C {lab_pin.sym} 4060 360 0 0 {name=l425 lab=VSS}
C {bitcell_6t.sym} 4200 400 0 0 {name=Xr2c21}
N 4160 440 4140 440 {}
C {lab_pin.sym} 4140 440 0 0 {name=l426 lab=BL21}
N 4160 400 4140 400 {}
C {lab_pin.sym} 4140 400 0 0 {name=l427 lab=BLB21}
N 4160 360 4140 360 {}
C {lab_pin.sym} 4140 360 0 0 {name=l428 lab=WL2}
N 4240 440 4260 440 {}
C {lab_pin.sym} 4260 440 0 0 {name=l429 lab=VDD}
N 4240 360 4260 360 {}
C {lab_pin.sym} 4260 360 0 0 {name=l430 lab=VSS}
C {bitcell_6t.sym} 4400 400 0 0 {name=Xr2c22}
N 4360 440 4340 440 {}
C {lab_pin.sym} 4340 440 0 0 {name=l431 lab=BL22}
N 4360 400 4340 400 {}
C {lab_pin.sym} 4340 400 0 0 {name=l432 lab=BLB22}
N 4360 360 4340 360 {}
C {lab_pin.sym} 4340 360 0 0 {name=l433 lab=WL2}
N 4440 440 4460 440 {}
C {lab_pin.sym} 4460 440 0 0 {name=l434 lab=VDD}
N 4440 360 4460 360 {}
C {lab_pin.sym} 4460 360 0 0 {name=l435 lab=VSS}
C {bitcell_6t.sym} 4600 400 0 0 {name=Xr2c23}
N 4560 440 4540 440 {}
C {lab_pin.sym} 4540 440 0 0 {name=l436 lab=BL23}
N 4560 400 4540 400 {}
C {lab_pin.sym} 4540 400 0 0 {name=l437 lab=BLB23}
N 4560 360 4540 360 {}
C {lab_pin.sym} 4540 360 0 0 {name=l438 lab=WL2}
N 4640 440 4660 440 {}
C {lab_pin.sym} 4660 440 0 0 {name=l439 lab=VDD}
N 4640 360 4660 360 {}
C {lab_pin.sym} 4660 360 0 0 {name=l440 lab=VSS}
C {bitcell_6t.sym} 4800 400 0 0 {name=Xr2c24}
N 4760 440 4740 440 {}
C {lab_pin.sym} 4740 440 0 0 {name=l441 lab=BL24}
N 4760 400 4740 400 {}
C {lab_pin.sym} 4740 400 0 0 {name=l442 lab=BLB24}
N 4760 360 4740 360 {}
C {lab_pin.sym} 4740 360 0 0 {name=l443 lab=WL2}
N 4840 440 4860 440 {}
C {lab_pin.sym} 4860 440 0 0 {name=l444 lab=VDD}
N 4840 360 4860 360 {}
C {lab_pin.sym} 4860 360 0 0 {name=l445 lab=VSS}
C {bitcell_6t.sym} 5000 400 0 0 {name=Xr2c25}
N 4960 440 4940 440 {}
C {lab_pin.sym} 4940 440 0 0 {name=l446 lab=BL25}
N 4960 400 4940 400 {}
C {lab_pin.sym} 4940 400 0 0 {name=l447 lab=BLB25}
N 4960 360 4940 360 {}
C {lab_pin.sym} 4940 360 0 0 {name=l448 lab=WL2}
N 5040 440 5060 440 {}
C {lab_pin.sym} 5060 440 0 0 {name=l449 lab=VDD}
N 5040 360 5060 360 {}
C {lab_pin.sym} 5060 360 0 0 {name=l450 lab=VSS}
C {bitcell_6t.sym} 5200 400 0 0 {name=Xr2c26}
N 5160 440 5140 440 {}
C {lab_pin.sym} 5140 440 0 0 {name=l451 lab=BL26}
N 5160 400 5140 400 {}
C {lab_pin.sym} 5140 400 0 0 {name=l452 lab=BLB26}
N 5160 360 5140 360 {}
C {lab_pin.sym} 5140 360 0 0 {name=l453 lab=WL2}
N 5240 440 5260 440 {}
C {lab_pin.sym} 5260 440 0 0 {name=l454 lab=VDD}
N 5240 360 5260 360 {}
C {lab_pin.sym} 5260 360 0 0 {name=l455 lab=VSS}
C {bitcell_6t.sym} 5400 400 0 0 {name=Xr2c27}
N 5360 440 5340 440 {}
C {lab_pin.sym} 5340 440 0 0 {name=l456 lab=BL27}
N 5360 400 5340 400 {}
C {lab_pin.sym} 5340 400 0 0 {name=l457 lab=BLB27}
N 5360 360 5340 360 {}
C {lab_pin.sym} 5340 360 0 0 {name=l458 lab=WL2}
N 5440 440 5460 440 {}
C {lab_pin.sym} 5460 440 0 0 {name=l459 lab=VDD}
N 5440 360 5460 360 {}
C {lab_pin.sym} 5460 360 0 0 {name=l460 lab=VSS}
C {bitcell_6t.sym} 5600 400 0 0 {name=Xr2c28}
N 5560 440 5540 440 {}
C {lab_pin.sym} 5540 440 0 0 {name=l461 lab=BL28}
N 5560 400 5540 400 {}
C {lab_pin.sym} 5540 400 0 0 {name=l462 lab=BLB28}
N 5560 360 5540 360 {}
C {lab_pin.sym} 5540 360 0 0 {name=l463 lab=WL2}
N 5640 440 5660 440 {}
C {lab_pin.sym} 5660 440 0 0 {name=l464 lab=VDD}
N 5640 360 5660 360 {}
C {lab_pin.sym} 5660 360 0 0 {name=l465 lab=VSS}
C {bitcell_6t.sym} 5800 400 0 0 {name=Xr2c29}
N 5760 440 5740 440 {}
C {lab_pin.sym} 5740 440 0 0 {name=l466 lab=BL29}
N 5760 400 5740 400 {}
C {lab_pin.sym} 5740 400 0 0 {name=l467 lab=BLB29}
N 5760 360 5740 360 {}
C {lab_pin.sym} 5740 360 0 0 {name=l468 lab=WL2}
N 5840 440 5860 440 {}
C {lab_pin.sym} 5860 440 0 0 {name=l469 lab=VDD}
N 5840 360 5860 360 {}
C {lab_pin.sym} 5860 360 0 0 {name=l470 lab=VSS}
C {bitcell_6t.sym} 6000 400 0 0 {name=Xr2c30}
N 5960 440 5940 440 {}
C {lab_pin.sym} 5940 440 0 0 {name=l471 lab=BL30}
N 5960 400 5940 400 {}
C {lab_pin.sym} 5940 400 0 0 {name=l472 lab=BLB30}
N 5960 360 5940 360 {}
C {lab_pin.sym} 5940 360 0 0 {name=l473 lab=WL2}
N 6040 440 6060 440 {}
C {lab_pin.sym} 6060 440 0 0 {name=l474 lab=VDD}
N 6040 360 6060 360 {}
C {lab_pin.sym} 6060 360 0 0 {name=l475 lab=VSS}
C {bitcell_6t.sym} 6200 400 0 0 {name=Xr2c31}
N 6160 440 6140 440 {}
C {lab_pin.sym} 6140 440 0 0 {name=l476 lab=BL31}
N 6160 400 6140 400 {}
C {lab_pin.sym} 6140 400 0 0 {name=l477 lab=BLB31}
N 6160 360 6140 360 {}
C {lab_pin.sym} 6140 360 0 0 {name=l478 lab=WL2}
N 6240 440 6260 440 {}
C {lab_pin.sym} 6260 440 0 0 {name=l479 lab=VDD}
N 6240 360 6260 360 {}
C {lab_pin.sym} 6260 360 0 0 {name=l480 lab=VSS}
C {bitcell_6t.sym} 0 600 0 0 {name=Xr3c0}
N -40 640 -60 640 {}
C {lab_pin.sym} -60 640 0 0 {name=l481 lab=BL0}
N -40 600 -60 600 {}
C {lab_pin.sym} -60 600 0 0 {name=l482 lab=BLB0}
N -40 560 -60 560 {}
C {lab_pin.sym} -60 560 0 0 {name=l483 lab=WL3}
N 40 640 60 640 {}
C {lab_pin.sym} 60 640 0 0 {name=l484 lab=VDD}
N 40 560 60 560 {}
C {lab_pin.sym} 60 560 0 0 {name=l485 lab=VSS}
C {bitcell_6t.sym} 200 600 0 0 {name=Xr3c1}
N 160 640 140 640 {}
C {lab_pin.sym} 140 640 0 0 {name=l486 lab=BL1}
N 160 600 140 600 {}
C {lab_pin.sym} 140 600 0 0 {name=l487 lab=BLB1}
N 160 560 140 560 {}
C {lab_pin.sym} 140 560 0 0 {name=l488 lab=WL3}
N 240 640 260 640 {}
C {lab_pin.sym} 260 640 0 0 {name=l489 lab=VDD}
N 240 560 260 560 {}
C {lab_pin.sym} 260 560 0 0 {name=l490 lab=VSS}
C {bitcell_6t.sym} 400 600 0 0 {name=Xr3c2}
N 360 640 340 640 {}
C {lab_pin.sym} 340 640 0 0 {name=l491 lab=BL2}
N 360 600 340 600 {}
C {lab_pin.sym} 340 600 0 0 {name=l492 lab=BLB2}
N 360 560 340 560 {}
C {lab_pin.sym} 340 560 0 0 {name=l493 lab=WL3}
N 440 640 460 640 {}
C {lab_pin.sym} 460 640 0 0 {name=l494 lab=VDD}
N 440 560 460 560 {}
C {lab_pin.sym} 460 560 0 0 {name=l495 lab=VSS}
C {bitcell_6t.sym} 600 600 0 0 {name=Xr3c3}
N 560 640 540 640 {}
C {lab_pin.sym} 540 640 0 0 {name=l496 lab=BL3}
N 560 600 540 600 {}
C {lab_pin.sym} 540 600 0 0 {name=l497 lab=BLB3}
N 560 560 540 560 {}
C {lab_pin.sym} 540 560 0 0 {name=l498 lab=WL3}
N 640 640 660 640 {}
C {lab_pin.sym} 660 640 0 0 {name=l499 lab=VDD}
N 640 560 660 560 {}
C {lab_pin.sym} 660 560 0 0 {name=l500 lab=VSS}
C {bitcell_6t.sym} 800 600 0 0 {name=Xr3c4}
N 760 640 740 640 {}
C {lab_pin.sym} 740 640 0 0 {name=l501 lab=BL4}
N 760 600 740 600 {}
C {lab_pin.sym} 740 600 0 0 {name=l502 lab=BLB4}
N 760 560 740 560 {}
C {lab_pin.sym} 740 560 0 0 {name=l503 lab=WL3}
N 840 640 860 640 {}
C {lab_pin.sym} 860 640 0 0 {name=l504 lab=VDD}
N 840 560 860 560 {}
C {lab_pin.sym} 860 560 0 0 {name=l505 lab=VSS}
C {bitcell_6t.sym} 1000 600 0 0 {name=Xr3c5}
N 960 640 940 640 {}
C {lab_pin.sym} 940 640 0 0 {name=l506 lab=BL5}
N 960 600 940 600 {}
C {lab_pin.sym} 940 600 0 0 {name=l507 lab=BLB5}
N 960 560 940 560 {}
C {lab_pin.sym} 940 560 0 0 {name=l508 lab=WL3}
N 1040 640 1060 640 {}
C {lab_pin.sym} 1060 640 0 0 {name=l509 lab=VDD}
N 1040 560 1060 560 {}
C {lab_pin.sym} 1060 560 0 0 {name=l510 lab=VSS}
C {bitcell_6t.sym} 1200 600 0 0 {name=Xr3c6}
N 1160 640 1140 640 {}
C {lab_pin.sym} 1140 640 0 0 {name=l511 lab=BL6}
N 1160 600 1140 600 {}
C {lab_pin.sym} 1140 600 0 0 {name=l512 lab=BLB6}
N 1160 560 1140 560 {}
C {lab_pin.sym} 1140 560 0 0 {name=l513 lab=WL3}
N 1240 640 1260 640 {}
C {lab_pin.sym} 1260 640 0 0 {name=l514 lab=VDD}
N 1240 560 1260 560 {}
C {lab_pin.sym} 1260 560 0 0 {name=l515 lab=VSS}
C {bitcell_6t.sym} 1400 600 0 0 {name=Xr3c7}
N 1360 640 1340 640 {}
C {lab_pin.sym} 1340 640 0 0 {name=l516 lab=BL7}
N 1360 600 1340 600 {}
C {lab_pin.sym} 1340 600 0 0 {name=l517 lab=BLB7}
N 1360 560 1340 560 {}
C {lab_pin.sym} 1340 560 0 0 {name=l518 lab=WL3}
N 1440 640 1460 640 {}
C {lab_pin.sym} 1460 640 0 0 {name=l519 lab=VDD}
N 1440 560 1460 560 {}
C {lab_pin.sym} 1460 560 0 0 {name=l520 lab=VSS}
C {bitcell_6t.sym} 1600 600 0 0 {name=Xr3c8}
N 1560 640 1540 640 {}
C {lab_pin.sym} 1540 640 0 0 {name=l521 lab=BL8}
N 1560 600 1540 600 {}
C {lab_pin.sym} 1540 600 0 0 {name=l522 lab=BLB8}
N 1560 560 1540 560 {}
C {lab_pin.sym} 1540 560 0 0 {name=l523 lab=WL3}
N 1640 640 1660 640 {}
C {lab_pin.sym} 1660 640 0 0 {name=l524 lab=VDD}
N 1640 560 1660 560 {}
C {lab_pin.sym} 1660 560 0 0 {name=l525 lab=VSS}
C {bitcell_6t.sym} 1800 600 0 0 {name=Xr3c9}
N 1760 640 1740 640 {}
C {lab_pin.sym} 1740 640 0 0 {name=l526 lab=BL9}
N 1760 600 1740 600 {}
C {lab_pin.sym} 1740 600 0 0 {name=l527 lab=BLB9}
N 1760 560 1740 560 {}
C {lab_pin.sym} 1740 560 0 0 {name=l528 lab=WL3}
N 1840 640 1860 640 {}
C {lab_pin.sym} 1860 640 0 0 {name=l529 lab=VDD}
N 1840 560 1860 560 {}
C {lab_pin.sym} 1860 560 0 0 {name=l530 lab=VSS}
C {bitcell_6t.sym} 2000 600 0 0 {name=Xr3c10}
N 1960 640 1940 640 {}
C {lab_pin.sym} 1940 640 0 0 {name=l531 lab=BL10}
N 1960 600 1940 600 {}
C {lab_pin.sym} 1940 600 0 0 {name=l532 lab=BLB10}
N 1960 560 1940 560 {}
C {lab_pin.sym} 1940 560 0 0 {name=l533 lab=WL3}
N 2040 640 2060 640 {}
C {lab_pin.sym} 2060 640 0 0 {name=l534 lab=VDD}
N 2040 560 2060 560 {}
C {lab_pin.sym} 2060 560 0 0 {name=l535 lab=VSS}
C {bitcell_6t.sym} 2200 600 0 0 {name=Xr3c11}
N 2160 640 2140 640 {}
C {lab_pin.sym} 2140 640 0 0 {name=l536 lab=BL11}
N 2160 600 2140 600 {}
C {lab_pin.sym} 2140 600 0 0 {name=l537 lab=BLB11}
N 2160 560 2140 560 {}
C {lab_pin.sym} 2140 560 0 0 {name=l538 lab=WL3}
N 2240 640 2260 640 {}
C {lab_pin.sym} 2260 640 0 0 {name=l539 lab=VDD}
N 2240 560 2260 560 {}
C {lab_pin.sym} 2260 560 0 0 {name=l540 lab=VSS}
C {bitcell_6t.sym} 2400 600 0 0 {name=Xr3c12}
N 2360 640 2340 640 {}
C {lab_pin.sym} 2340 640 0 0 {name=l541 lab=BL12}
N 2360 600 2340 600 {}
C {lab_pin.sym} 2340 600 0 0 {name=l542 lab=BLB12}
N 2360 560 2340 560 {}
C {lab_pin.sym} 2340 560 0 0 {name=l543 lab=WL3}
N 2440 640 2460 640 {}
C {lab_pin.sym} 2460 640 0 0 {name=l544 lab=VDD}
N 2440 560 2460 560 {}
C {lab_pin.sym} 2460 560 0 0 {name=l545 lab=VSS}
C {bitcell_6t.sym} 2600 600 0 0 {name=Xr3c13}
N 2560 640 2540 640 {}
C {lab_pin.sym} 2540 640 0 0 {name=l546 lab=BL13}
N 2560 600 2540 600 {}
C {lab_pin.sym} 2540 600 0 0 {name=l547 lab=BLB13}
N 2560 560 2540 560 {}
C {lab_pin.sym} 2540 560 0 0 {name=l548 lab=WL3}
N 2640 640 2660 640 {}
C {lab_pin.sym} 2660 640 0 0 {name=l549 lab=VDD}
N 2640 560 2660 560 {}
C {lab_pin.sym} 2660 560 0 0 {name=l550 lab=VSS}
C {bitcell_6t.sym} 2800 600 0 0 {name=Xr3c14}
N 2760 640 2740 640 {}
C {lab_pin.sym} 2740 640 0 0 {name=l551 lab=BL14}
N 2760 600 2740 600 {}
C {lab_pin.sym} 2740 600 0 0 {name=l552 lab=BLB14}
N 2760 560 2740 560 {}
C {lab_pin.sym} 2740 560 0 0 {name=l553 lab=WL3}
N 2840 640 2860 640 {}
C {lab_pin.sym} 2860 640 0 0 {name=l554 lab=VDD}
N 2840 560 2860 560 {}
C {lab_pin.sym} 2860 560 0 0 {name=l555 lab=VSS}
C {bitcell_6t.sym} 3000 600 0 0 {name=Xr3c15}
N 2960 640 2940 640 {}
C {lab_pin.sym} 2940 640 0 0 {name=l556 lab=BL15}
N 2960 600 2940 600 {}
C {lab_pin.sym} 2940 600 0 0 {name=l557 lab=BLB15}
N 2960 560 2940 560 {}
C {lab_pin.sym} 2940 560 0 0 {name=l558 lab=WL3}
N 3040 640 3060 640 {}
C {lab_pin.sym} 3060 640 0 0 {name=l559 lab=VDD}
N 3040 560 3060 560 {}
C {lab_pin.sym} 3060 560 0 0 {name=l560 lab=VSS}
C {bitcell_6t.sym} 3200 600 0 0 {name=Xr3c16}
N 3160 640 3140 640 {}
C {lab_pin.sym} 3140 640 0 0 {name=l561 lab=BL16}
N 3160 600 3140 600 {}
C {lab_pin.sym} 3140 600 0 0 {name=l562 lab=BLB16}
N 3160 560 3140 560 {}
C {lab_pin.sym} 3140 560 0 0 {name=l563 lab=WL3}
N 3240 640 3260 640 {}
C {lab_pin.sym} 3260 640 0 0 {name=l564 lab=VDD}
N 3240 560 3260 560 {}
C {lab_pin.sym} 3260 560 0 0 {name=l565 lab=VSS}
C {bitcell_6t.sym} 3400 600 0 0 {name=Xr3c17}
N 3360 640 3340 640 {}
C {lab_pin.sym} 3340 640 0 0 {name=l566 lab=BL17}
N 3360 600 3340 600 {}
C {lab_pin.sym} 3340 600 0 0 {name=l567 lab=BLB17}
N 3360 560 3340 560 {}
C {lab_pin.sym} 3340 560 0 0 {name=l568 lab=WL3}
N 3440 640 3460 640 {}
C {lab_pin.sym} 3460 640 0 0 {name=l569 lab=VDD}
N 3440 560 3460 560 {}
C {lab_pin.sym} 3460 560 0 0 {name=l570 lab=VSS}
C {bitcell_6t.sym} 3600 600 0 0 {name=Xr3c18}
N 3560 640 3540 640 {}
C {lab_pin.sym} 3540 640 0 0 {name=l571 lab=BL18}
N 3560 600 3540 600 {}
C {lab_pin.sym} 3540 600 0 0 {name=l572 lab=BLB18}
N 3560 560 3540 560 {}
C {lab_pin.sym} 3540 560 0 0 {name=l573 lab=WL3}
N 3640 640 3660 640 {}
C {lab_pin.sym} 3660 640 0 0 {name=l574 lab=VDD}
N 3640 560 3660 560 {}
C {lab_pin.sym} 3660 560 0 0 {name=l575 lab=VSS}
C {bitcell_6t.sym} 3800 600 0 0 {name=Xr3c19}
N 3760 640 3740 640 {}
C {lab_pin.sym} 3740 640 0 0 {name=l576 lab=BL19}
N 3760 600 3740 600 {}
C {lab_pin.sym} 3740 600 0 0 {name=l577 lab=BLB19}
N 3760 560 3740 560 {}
C {lab_pin.sym} 3740 560 0 0 {name=l578 lab=WL3}
N 3840 640 3860 640 {}
C {lab_pin.sym} 3860 640 0 0 {name=l579 lab=VDD}
N 3840 560 3860 560 {}
C {lab_pin.sym} 3860 560 0 0 {name=l580 lab=VSS}
C {bitcell_6t.sym} 4000 600 0 0 {name=Xr3c20}
N 3960 640 3940 640 {}
C {lab_pin.sym} 3940 640 0 0 {name=l581 lab=BL20}
N 3960 600 3940 600 {}
C {lab_pin.sym} 3940 600 0 0 {name=l582 lab=BLB20}
N 3960 560 3940 560 {}
C {lab_pin.sym} 3940 560 0 0 {name=l583 lab=WL3}
N 4040 640 4060 640 {}
C {lab_pin.sym} 4060 640 0 0 {name=l584 lab=VDD}
N 4040 560 4060 560 {}
C {lab_pin.sym} 4060 560 0 0 {name=l585 lab=VSS}
C {bitcell_6t.sym} 4200 600 0 0 {name=Xr3c21}
N 4160 640 4140 640 {}
C {lab_pin.sym} 4140 640 0 0 {name=l586 lab=BL21}
N 4160 600 4140 600 {}
C {lab_pin.sym} 4140 600 0 0 {name=l587 lab=BLB21}
N 4160 560 4140 560 {}
C {lab_pin.sym} 4140 560 0 0 {name=l588 lab=WL3}
N 4240 640 4260 640 {}
C {lab_pin.sym} 4260 640 0 0 {name=l589 lab=VDD}
N 4240 560 4260 560 {}
C {lab_pin.sym} 4260 560 0 0 {name=l590 lab=VSS}
C {bitcell_6t.sym} 4400 600 0 0 {name=Xr3c22}
N 4360 640 4340 640 {}
C {lab_pin.sym} 4340 640 0 0 {name=l591 lab=BL22}
N 4360 600 4340 600 {}
C {lab_pin.sym} 4340 600 0 0 {name=l592 lab=BLB22}
N 4360 560 4340 560 {}
C {lab_pin.sym} 4340 560 0 0 {name=l593 lab=WL3}
N 4440 640 4460 640 {}
C {lab_pin.sym} 4460 640 0 0 {name=l594 lab=VDD}
N 4440 560 4460 560 {}
C {lab_pin.sym} 4460 560 0 0 {name=l595 lab=VSS}
C {bitcell_6t.sym} 4600 600 0 0 {name=Xr3c23}
N 4560 640 4540 640 {}
C {lab_pin.sym} 4540 640 0 0 {name=l596 lab=BL23}
N 4560 600 4540 600 {}
C {lab_pin.sym} 4540 600 0 0 {name=l597 lab=BLB23}
N 4560 560 4540 560 {}
C {lab_pin.sym} 4540 560 0 0 {name=l598 lab=WL3}
N 4640 640 4660 640 {}
C {lab_pin.sym} 4660 640 0 0 {name=l599 lab=VDD}
N 4640 560 4660 560 {}
C {lab_pin.sym} 4660 560 0 0 {name=l600 lab=VSS}
C {bitcell_6t.sym} 4800 600 0 0 {name=Xr3c24}
N 4760 640 4740 640 {}
C {lab_pin.sym} 4740 640 0 0 {name=l601 lab=BL24}
N 4760 600 4740 600 {}
C {lab_pin.sym} 4740 600 0 0 {name=l602 lab=BLB24}
N 4760 560 4740 560 {}
C {lab_pin.sym} 4740 560 0 0 {name=l603 lab=WL3}
N 4840 640 4860 640 {}
C {lab_pin.sym} 4860 640 0 0 {name=l604 lab=VDD}
N 4840 560 4860 560 {}
C {lab_pin.sym} 4860 560 0 0 {name=l605 lab=VSS}
C {bitcell_6t.sym} 5000 600 0 0 {name=Xr3c25}
N 4960 640 4940 640 {}
C {lab_pin.sym} 4940 640 0 0 {name=l606 lab=BL25}
N 4960 600 4940 600 {}
C {lab_pin.sym} 4940 600 0 0 {name=l607 lab=BLB25}
N 4960 560 4940 560 {}
C {lab_pin.sym} 4940 560 0 0 {name=l608 lab=WL3}
N 5040 640 5060 640 {}
C {lab_pin.sym} 5060 640 0 0 {name=l609 lab=VDD}
N 5040 560 5060 560 {}
C {lab_pin.sym} 5060 560 0 0 {name=l610 lab=VSS}
C {bitcell_6t.sym} 5200 600 0 0 {name=Xr3c26}
N 5160 640 5140 640 {}
C {lab_pin.sym} 5140 640 0 0 {name=l611 lab=BL26}
N 5160 600 5140 600 {}
C {lab_pin.sym} 5140 600 0 0 {name=l612 lab=BLB26}
N 5160 560 5140 560 {}
C {lab_pin.sym} 5140 560 0 0 {name=l613 lab=WL3}
N 5240 640 5260 640 {}
C {lab_pin.sym} 5260 640 0 0 {name=l614 lab=VDD}
N 5240 560 5260 560 {}
C {lab_pin.sym} 5260 560 0 0 {name=l615 lab=VSS}
C {bitcell_6t.sym} 5400 600 0 0 {name=Xr3c27}
N 5360 640 5340 640 {}
C {lab_pin.sym} 5340 640 0 0 {name=l616 lab=BL27}
N 5360 600 5340 600 {}
C {lab_pin.sym} 5340 600 0 0 {name=l617 lab=BLB27}
N 5360 560 5340 560 {}
C {lab_pin.sym} 5340 560 0 0 {name=l618 lab=WL3}
N 5440 640 5460 640 {}
C {lab_pin.sym} 5460 640 0 0 {name=l619 lab=VDD}
N 5440 560 5460 560 {}
C {lab_pin.sym} 5460 560 0 0 {name=l620 lab=VSS}
C {bitcell_6t.sym} 5600 600 0 0 {name=Xr3c28}
N 5560 640 5540 640 {}
C {lab_pin.sym} 5540 640 0 0 {name=l621 lab=BL28}
N 5560 600 5540 600 {}
C {lab_pin.sym} 5540 600 0 0 {name=l622 lab=BLB28}
N 5560 560 5540 560 {}
C {lab_pin.sym} 5540 560 0 0 {name=l623 lab=WL3}
N 5640 640 5660 640 {}
C {lab_pin.sym} 5660 640 0 0 {name=l624 lab=VDD}
N 5640 560 5660 560 {}
C {lab_pin.sym} 5660 560 0 0 {name=l625 lab=VSS}
C {bitcell_6t.sym} 5800 600 0 0 {name=Xr3c29}
N 5760 640 5740 640 {}
C {lab_pin.sym} 5740 640 0 0 {name=l626 lab=BL29}
N 5760 600 5740 600 {}
C {lab_pin.sym} 5740 600 0 0 {name=l627 lab=BLB29}
N 5760 560 5740 560 {}
C {lab_pin.sym} 5740 560 0 0 {name=l628 lab=WL3}
N 5840 640 5860 640 {}
C {lab_pin.sym} 5860 640 0 0 {name=l629 lab=VDD}
N 5840 560 5860 560 {}
C {lab_pin.sym} 5860 560 0 0 {name=l630 lab=VSS}
C {bitcell_6t.sym} 6000 600 0 0 {name=Xr3c30}
N 5960 640 5940 640 {}
C {lab_pin.sym} 5940 640 0 0 {name=l631 lab=BL30}
N 5960 600 5940 600 {}
C {lab_pin.sym} 5940 600 0 0 {name=l632 lab=BLB30}
N 5960 560 5940 560 {}
C {lab_pin.sym} 5940 560 0 0 {name=l633 lab=WL3}
N 6040 640 6060 640 {}
C {lab_pin.sym} 6060 640 0 0 {name=l634 lab=VDD}
N 6040 560 6060 560 {}
C {lab_pin.sym} 6060 560 0 0 {name=l635 lab=VSS}
C {bitcell_6t.sym} 6200 600 0 0 {name=Xr3c31}
N 6160 640 6140 640 {}
C {lab_pin.sym} 6140 640 0 0 {name=l636 lab=BL31}
N 6160 600 6140 600 {}
C {lab_pin.sym} 6140 600 0 0 {name=l637 lab=BLB31}
N 6160 560 6140 560 {}
C {lab_pin.sym} 6140 560 0 0 {name=l638 lab=WL3}
N 6240 640 6260 640 {}
C {lab_pin.sym} 6260 640 0 0 {name=l639 lab=VDD}
N 6240 560 6260 560 {}
C {lab_pin.sym} 6260 560 0 0 {name=l640 lab=VSS}
C {bitcell_6t.sym} 0 800 0 0 {name=Xr4c0}
N -40 840 -60 840 {}
C {lab_pin.sym} -60 840 0 0 {name=l641 lab=BL0}
N -40 800 -60 800 {}
C {lab_pin.sym} -60 800 0 0 {name=l642 lab=BLB0}
N -40 760 -60 760 {}
C {lab_pin.sym} -60 760 0 0 {name=l643 lab=WL4}
N 40 840 60 840 {}
C {lab_pin.sym} 60 840 0 0 {name=l644 lab=VDD}
N 40 760 60 760 {}
C {lab_pin.sym} 60 760 0 0 {name=l645 lab=VSS}
C {bitcell_6t.sym} 200 800 0 0 {name=Xr4c1}
N 160 840 140 840 {}
C {lab_pin.sym} 140 840 0 0 {name=l646 lab=BL1}
N 160 800 140 800 {}
C {lab_pin.sym} 140 800 0 0 {name=l647 lab=BLB1}
N 160 760 140 760 {}
C {lab_pin.sym} 140 760 0 0 {name=l648 lab=WL4}
N 240 840 260 840 {}
C {lab_pin.sym} 260 840 0 0 {name=l649 lab=VDD}
N 240 760 260 760 {}
C {lab_pin.sym} 260 760 0 0 {name=l650 lab=VSS}
C {bitcell_6t.sym} 400 800 0 0 {name=Xr4c2}
N 360 840 340 840 {}
C {lab_pin.sym} 340 840 0 0 {name=l651 lab=BL2}
N 360 800 340 800 {}
C {lab_pin.sym} 340 800 0 0 {name=l652 lab=BLB2}
N 360 760 340 760 {}
C {lab_pin.sym} 340 760 0 0 {name=l653 lab=WL4}
N 440 840 460 840 {}
C {lab_pin.sym} 460 840 0 0 {name=l654 lab=VDD}
N 440 760 460 760 {}
C {lab_pin.sym} 460 760 0 0 {name=l655 lab=VSS}
C {bitcell_6t.sym} 600 800 0 0 {name=Xr4c3}
N 560 840 540 840 {}
C {lab_pin.sym} 540 840 0 0 {name=l656 lab=BL3}
N 560 800 540 800 {}
C {lab_pin.sym} 540 800 0 0 {name=l657 lab=BLB3}
N 560 760 540 760 {}
C {lab_pin.sym} 540 760 0 0 {name=l658 lab=WL4}
N 640 840 660 840 {}
C {lab_pin.sym} 660 840 0 0 {name=l659 lab=VDD}
N 640 760 660 760 {}
C {lab_pin.sym} 660 760 0 0 {name=l660 lab=VSS}
C {bitcell_6t.sym} 800 800 0 0 {name=Xr4c4}
N 760 840 740 840 {}
C {lab_pin.sym} 740 840 0 0 {name=l661 lab=BL4}
N 760 800 740 800 {}
C {lab_pin.sym} 740 800 0 0 {name=l662 lab=BLB4}
N 760 760 740 760 {}
C {lab_pin.sym} 740 760 0 0 {name=l663 lab=WL4}
N 840 840 860 840 {}
C {lab_pin.sym} 860 840 0 0 {name=l664 lab=VDD}
N 840 760 860 760 {}
C {lab_pin.sym} 860 760 0 0 {name=l665 lab=VSS}
C {bitcell_6t.sym} 1000 800 0 0 {name=Xr4c5}
N 960 840 940 840 {}
C {lab_pin.sym} 940 840 0 0 {name=l666 lab=BL5}
N 960 800 940 800 {}
C {lab_pin.sym} 940 800 0 0 {name=l667 lab=BLB5}
N 960 760 940 760 {}
C {lab_pin.sym} 940 760 0 0 {name=l668 lab=WL4}
N 1040 840 1060 840 {}
C {lab_pin.sym} 1060 840 0 0 {name=l669 lab=VDD}
N 1040 760 1060 760 {}
C {lab_pin.sym} 1060 760 0 0 {name=l670 lab=VSS}
C {bitcell_6t.sym} 1200 800 0 0 {name=Xr4c6}
N 1160 840 1140 840 {}
C {lab_pin.sym} 1140 840 0 0 {name=l671 lab=BL6}
N 1160 800 1140 800 {}
C {lab_pin.sym} 1140 800 0 0 {name=l672 lab=BLB6}
N 1160 760 1140 760 {}
C {lab_pin.sym} 1140 760 0 0 {name=l673 lab=WL4}
N 1240 840 1260 840 {}
C {lab_pin.sym} 1260 840 0 0 {name=l674 lab=VDD}
N 1240 760 1260 760 {}
C {lab_pin.sym} 1260 760 0 0 {name=l675 lab=VSS}
C {bitcell_6t.sym} 1400 800 0 0 {name=Xr4c7}
N 1360 840 1340 840 {}
C {lab_pin.sym} 1340 840 0 0 {name=l676 lab=BL7}
N 1360 800 1340 800 {}
C {lab_pin.sym} 1340 800 0 0 {name=l677 lab=BLB7}
N 1360 760 1340 760 {}
C {lab_pin.sym} 1340 760 0 0 {name=l678 lab=WL4}
N 1440 840 1460 840 {}
C {lab_pin.sym} 1460 840 0 0 {name=l679 lab=VDD}
N 1440 760 1460 760 {}
C {lab_pin.sym} 1460 760 0 0 {name=l680 lab=VSS}
C {bitcell_6t.sym} 1600 800 0 0 {name=Xr4c8}
N 1560 840 1540 840 {}
C {lab_pin.sym} 1540 840 0 0 {name=l681 lab=BL8}
N 1560 800 1540 800 {}
C {lab_pin.sym} 1540 800 0 0 {name=l682 lab=BLB8}
N 1560 760 1540 760 {}
C {lab_pin.sym} 1540 760 0 0 {name=l683 lab=WL4}
N 1640 840 1660 840 {}
C {lab_pin.sym} 1660 840 0 0 {name=l684 lab=VDD}
N 1640 760 1660 760 {}
C {lab_pin.sym} 1660 760 0 0 {name=l685 lab=VSS}
C {bitcell_6t.sym} 1800 800 0 0 {name=Xr4c9}
N 1760 840 1740 840 {}
C {lab_pin.sym} 1740 840 0 0 {name=l686 lab=BL9}
N 1760 800 1740 800 {}
C {lab_pin.sym} 1740 800 0 0 {name=l687 lab=BLB9}
N 1760 760 1740 760 {}
C {lab_pin.sym} 1740 760 0 0 {name=l688 lab=WL4}
N 1840 840 1860 840 {}
C {lab_pin.sym} 1860 840 0 0 {name=l689 lab=VDD}
N 1840 760 1860 760 {}
C {lab_pin.sym} 1860 760 0 0 {name=l690 lab=VSS}
C {bitcell_6t.sym} 2000 800 0 0 {name=Xr4c10}
N 1960 840 1940 840 {}
C {lab_pin.sym} 1940 840 0 0 {name=l691 lab=BL10}
N 1960 800 1940 800 {}
C {lab_pin.sym} 1940 800 0 0 {name=l692 lab=BLB10}
N 1960 760 1940 760 {}
C {lab_pin.sym} 1940 760 0 0 {name=l693 lab=WL4}
N 2040 840 2060 840 {}
C {lab_pin.sym} 2060 840 0 0 {name=l694 lab=VDD}
N 2040 760 2060 760 {}
C {lab_pin.sym} 2060 760 0 0 {name=l695 lab=VSS}
C {bitcell_6t.sym} 2200 800 0 0 {name=Xr4c11}
N 2160 840 2140 840 {}
C {lab_pin.sym} 2140 840 0 0 {name=l696 lab=BL11}
N 2160 800 2140 800 {}
C {lab_pin.sym} 2140 800 0 0 {name=l697 lab=BLB11}
N 2160 760 2140 760 {}
C {lab_pin.sym} 2140 760 0 0 {name=l698 lab=WL4}
N 2240 840 2260 840 {}
C {lab_pin.sym} 2260 840 0 0 {name=l699 lab=VDD}
N 2240 760 2260 760 {}
C {lab_pin.sym} 2260 760 0 0 {name=l700 lab=VSS}
C {bitcell_6t.sym} 2400 800 0 0 {name=Xr4c12}
N 2360 840 2340 840 {}
C {lab_pin.sym} 2340 840 0 0 {name=l701 lab=BL12}
N 2360 800 2340 800 {}
C {lab_pin.sym} 2340 800 0 0 {name=l702 lab=BLB12}
N 2360 760 2340 760 {}
C {lab_pin.sym} 2340 760 0 0 {name=l703 lab=WL4}
N 2440 840 2460 840 {}
C {lab_pin.sym} 2460 840 0 0 {name=l704 lab=VDD}
N 2440 760 2460 760 {}
C {lab_pin.sym} 2460 760 0 0 {name=l705 lab=VSS}
C {bitcell_6t.sym} 2600 800 0 0 {name=Xr4c13}
N 2560 840 2540 840 {}
C {lab_pin.sym} 2540 840 0 0 {name=l706 lab=BL13}
N 2560 800 2540 800 {}
C {lab_pin.sym} 2540 800 0 0 {name=l707 lab=BLB13}
N 2560 760 2540 760 {}
C {lab_pin.sym} 2540 760 0 0 {name=l708 lab=WL4}
N 2640 840 2660 840 {}
C {lab_pin.sym} 2660 840 0 0 {name=l709 lab=VDD}
N 2640 760 2660 760 {}
C {lab_pin.sym} 2660 760 0 0 {name=l710 lab=VSS}
C {bitcell_6t.sym} 2800 800 0 0 {name=Xr4c14}
N 2760 840 2740 840 {}
C {lab_pin.sym} 2740 840 0 0 {name=l711 lab=BL14}
N 2760 800 2740 800 {}
C {lab_pin.sym} 2740 800 0 0 {name=l712 lab=BLB14}
N 2760 760 2740 760 {}
C {lab_pin.sym} 2740 760 0 0 {name=l713 lab=WL4}
N 2840 840 2860 840 {}
C {lab_pin.sym} 2860 840 0 0 {name=l714 lab=VDD}
N 2840 760 2860 760 {}
C {lab_pin.sym} 2860 760 0 0 {name=l715 lab=VSS}
C {bitcell_6t.sym} 3000 800 0 0 {name=Xr4c15}
N 2960 840 2940 840 {}
C {lab_pin.sym} 2940 840 0 0 {name=l716 lab=BL15}
N 2960 800 2940 800 {}
C {lab_pin.sym} 2940 800 0 0 {name=l717 lab=BLB15}
N 2960 760 2940 760 {}
C {lab_pin.sym} 2940 760 0 0 {name=l718 lab=WL4}
N 3040 840 3060 840 {}
C {lab_pin.sym} 3060 840 0 0 {name=l719 lab=VDD}
N 3040 760 3060 760 {}
C {lab_pin.sym} 3060 760 0 0 {name=l720 lab=VSS}
C {bitcell_6t.sym} 3200 800 0 0 {name=Xr4c16}
N 3160 840 3140 840 {}
C {lab_pin.sym} 3140 840 0 0 {name=l721 lab=BL16}
N 3160 800 3140 800 {}
C {lab_pin.sym} 3140 800 0 0 {name=l722 lab=BLB16}
N 3160 760 3140 760 {}
C {lab_pin.sym} 3140 760 0 0 {name=l723 lab=WL4}
N 3240 840 3260 840 {}
C {lab_pin.sym} 3260 840 0 0 {name=l724 lab=VDD}
N 3240 760 3260 760 {}
C {lab_pin.sym} 3260 760 0 0 {name=l725 lab=VSS}
C {bitcell_6t.sym} 3400 800 0 0 {name=Xr4c17}
N 3360 840 3340 840 {}
C {lab_pin.sym} 3340 840 0 0 {name=l726 lab=BL17}
N 3360 800 3340 800 {}
C {lab_pin.sym} 3340 800 0 0 {name=l727 lab=BLB17}
N 3360 760 3340 760 {}
C {lab_pin.sym} 3340 760 0 0 {name=l728 lab=WL4}
N 3440 840 3460 840 {}
C {lab_pin.sym} 3460 840 0 0 {name=l729 lab=VDD}
N 3440 760 3460 760 {}
C {lab_pin.sym} 3460 760 0 0 {name=l730 lab=VSS}
C {bitcell_6t.sym} 3600 800 0 0 {name=Xr4c18}
N 3560 840 3540 840 {}
C {lab_pin.sym} 3540 840 0 0 {name=l731 lab=BL18}
N 3560 800 3540 800 {}
C {lab_pin.sym} 3540 800 0 0 {name=l732 lab=BLB18}
N 3560 760 3540 760 {}
C {lab_pin.sym} 3540 760 0 0 {name=l733 lab=WL4}
N 3640 840 3660 840 {}
C {lab_pin.sym} 3660 840 0 0 {name=l734 lab=VDD}
N 3640 760 3660 760 {}
C {lab_pin.sym} 3660 760 0 0 {name=l735 lab=VSS}
C {bitcell_6t.sym} 3800 800 0 0 {name=Xr4c19}
N 3760 840 3740 840 {}
C {lab_pin.sym} 3740 840 0 0 {name=l736 lab=BL19}
N 3760 800 3740 800 {}
C {lab_pin.sym} 3740 800 0 0 {name=l737 lab=BLB19}
N 3760 760 3740 760 {}
C {lab_pin.sym} 3740 760 0 0 {name=l738 lab=WL4}
N 3840 840 3860 840 {}
C {lab_pin.sym} 3860 840 0 0 {name=l739 lab=VDD}
N 3840 760 3860 760 {}
C {lab_pin.sym} 3860 760 0 0 {name=l740 lab=VSS}
C {bitcell_6t.sym} 4000 800 0 0 {name=Xr4c20}
N 3960 840 3940 840 {}
C {lab_pin.sym} 3940 840 0 0 {name=l741 lab=BL20}
N 3960 800 3940 800 {}
C {lab_pin.sym} 3940 800 0 0 {name=l742 lab=BLB20}
N 3960 760 3940 760 {}
C {lab_pin.sym} 3940 760 0 0 {name=l743 lab=WL4}
N 4040 840 4060 840 {}
C {lab_pin.sym} 4060 840 0 0 {name=l744 lab=VDD}
N 4040 760 4060 760 {}
C {lab_pin.sym} 4060 760 0 0 {name=l745 lab=VSS}
C {bitcell_6t.sym} 4200 800 0 0 {name=Xr4c21}
N 4160 840 4140 840 {}
C {lab_pin.sym} 4140 840 0 0 {name=l746 lab=BL21}
N 4160 800 4140 800 {}
C {lab_pin.sym} 4140 800 0 0 {name=l747 lab=BLB21}
N 4160 760 4140 760 {}
C {lab_pin.sym} 4140 760 0 0 {name=l748 lab=WL4}
N 4240 840 4260 840 {}
C {lab_pin.sym} 4260 840 0 0 {name=l749 lab=VDD}
N 4240 760 4260 760 {}
C {lab_pin.sym} 4260 760 0 0 {name=l750 lab=VSS}
C {bitcell_6t.sym} 4400 800 0 0 {name=Xr4c22}
N 4360 840 4340 840 {}
C {lab_pin.sym} 4340 840 0 0 {name=l751 lab=BL22}
N 4360 800 4340 800 {}
C {lab_pin.sym} 4340 800 0 0 {name=l752 lab=BLB22}
N 4360 760 4340 760 {}
C {lab_pin.sym} 4340 760 0 0 {name=l753 lab=WL4}
N 4440 840 4460 840 {}
C {lab_pin.sym} 4460 840 0 0 {name=l754 lab=VDD}
N 4440 760 4460 760 {}
C {lab_pin.sym} 4460 760 0 0 {name=l755 lab=VSS}
C {bitcell_6t.sym} 4600 800 0 0 {name=Xr4c23}
N 4560 840 4540 840 {}
C {lab_pin.sym} 4540 840 0 0 {name=l756 lab=BL23}
N 4560 800 4540 800 {}
C {lab_pin.sym} 4540 800 0 0 {name=l757 lab=BLB23}
N 4560 760 4540 760 {}
C {lab_pin.sym} 4540 760 0 0 {name=l758 lab=WL4}
N 4640 840 4660 840 {}
C {lab_pin.sym} 4660 840 0 0 {name=l759 lab=VDD}
N 4640 760 4660 760 {}
C {lab_pin.sym} 4660 760 0 0 {name=l760 lab=VSS}
C {bitcell_6t.sym} 4800 800 0 0 {name=Xr4c24}
N 4760 840 4740 840 {}
C {lab_pin.sym} 4740 840 0 0 {name=l761 lab=BL24}
N 4760 800 4740 800 {}
C {lab_pin.sym} 4740 800 0 0 {name=l762 lab=BLB24}
N 4760 760 4740 760 {}
C {lab_pin.sym} 4740 760 0 0 {name=l763 lab=WL4}
N 4840 840 4860 840 {}
C {lab_pin.sym} 4860 840 0 0 {name=l764 lab=VDD}
N 4840 760 4860 760 {}
C {lab_pin.sym} 4860 760 0 0 {name=l765 lab=VSS}
C {bitcell_6t.sym} 5000 800 0 0 {name=Xr4c25}
N 4960 840 4940 840 {}
C {lab_pin.sym} 4940 840 0 0 {name=l766 lab=BL25}
N 4960 800 4940 800 {}
C {lab_pin.sym} 4940 800 0 0 {name=l767 lab=BLB25}
N 4960 760 4940 760 {}
C {lab_pin.sym} 4940 760 0 0 {name=l768 lab=WL4}
N 5040 840 5060 840 {}
C {lab_pin.sym} 5060 840 0 0 {name=l769 lab=VDD}
N 5040 760 5060 760 {}
C {lab_pin.sym} 5060 760 0 0 {name=l770 lab=VSS}
C {bitcell_6t.sym} 5200 800 0 0 {name=Xr4c26}
N 5160 840 5140 840 {}
C {lab_pin.sym} 5140 840 0 0 {name=l771 lab=BL26}
N 5160 800 5140 800 {}
C {lab_pin.sym} 5140 800 0 0 {name=l772 lab=BLB26}
N 5160 760 5140 760 {}
C {lab_pin.sym} 5140 760 0 0 {name=l773 lab=WL4}
N 5240 840 5260 840 {}
C {lab_pin.sym} 5260 840 0 0 {name=l774 lab=VDD}
N 5240 760 5260 760 {}
C {lab_pin.sym} 5260 760 0 0 {name=l775 lab=VSS}
C {bitcell_6t.sym} 5400 800 0 0 {name=Xr4c27}
N 5360 840 5340 840 {}
C {lab_pin.sym} 5340 840 0 0 {name=l776 lab=BL27}
N 5360 800 5340 800 {}
C {lab_pin.sym} 5340 800 0 0 {name=l777 lab=BLB27}
N 5360 760 5340 760 {}
C {lab_pin.sym} 5340 760 0 0 {name=l778 lab=WL4}
N 5440 840 5460 840 {}
C {lab_pin.sym} 5460 840 0 0 {name=l779 lab=VDD}
N 5440 760 5460 760 {}
C {lab_pin.sym} 5460 760 0 0 {name=l780 lab=VSS}
C {bitcell_6t.sym} 5600 800 0 0 {name=Xr4c28}
N 5560 840 5540 840 {}
C {lab_pin.sym} 5540 840 0 0 {name=l781 lab=BL28}
N 5560 800 5540 800 {}
C {lab_pin.sym} 5540 800 0 0 {name=l782 lab=BLB28}
N 5560 760 5540 760 {}
C {lab_pin.sym} 5540 760 0 0 {name=l783 lab=WL4}
N 5640 840 5660 840 {}
C {lab_pin.sym} 5660 840 0 0 {name=l784 lab=VDD}
N 5640 760 5660 760 {}
C {lab_pin.sym} 5660 760 0 0 {name=l785 lab=VSS}
C {bitcell_6t.sym} 5800 800 0 0 {name=Xr4c29}
N 5760 840 5740 840 {}
C {lab_pin.sym} 5740 840 0 0 {name=l786 lab=BL29}
N 5760 800 5740 800 {}
C {lab_pin.sym} 5740 800 0 0 {name=l787 lab=BLB29}
N 5760 760 5740 760 {}
C {lab_pin.sym} 5740 760 0 0 {name=l788 lab=WL4}
N 5840 840 5860 840 {}
C {lab_pin.sym} 5860 840 0 0 {name=l789 lab=VDD}
N 5840 760 5860 760 {}
C {lab_pin.sym} 5860 760 0 0 {name=l790 lab=VSS}
C {bitcell_6t.sym} 6000 800 0 0 {name=Xr4c30}
N 5960 840 5940 840 {}
C {lab_pin.sym} 5940 840 0 0 {name=l791 lab=BL30}
N 5960 800 5940 800 {}
C {lab_pin.sym} 5940 800 0 0 {name=l792 lab=BLB30}
N 5960 760 5940 760 {}
C {lab_pin.sym} 5940 760 0 0 {name=l793 lab=WL4}
N 6040 840 6060 840 {}
C {lab_pin.sym} 6060 840 0 0 {name=l794 lab=VDD}
N 6040 760 6060 760 {}
C {lab_pin.sym} 6060 760 0 0 {name=l795 lab=VSS}
C {bitcell_6t.sym} 6200 800 0 0 {name=Xr4c31}
N 6160 840 6140 840 {}
C {lab_pin.sym} 6140 840 0 0 {name=l796 lab=BL31}
N 6160 800 6140 800 {}
C {lab_pin.sym} 6140 800 0 0 {name=l797 lab=BLB31}
N 6160 760 6140 760 {}
C {lab_pin.sym} 6140 760 0 0 {name=l798 lab=WL4}
N 6240 840 6260 840 {}
C {lab_pin.sym} 6260 840 0 0 {name=l799 lab=VDD}
N 6240 760 6260 760 {}
C {lab_pin.sym} 6260 760 0 0 {name=l800 lab=VSS}
C {bitcell_6t.sym} 0 1000 0 0 {name=Xr5c0}
N -40 1040 -60 1040 {}
C {lab_pin.sym} -60 1040 0 0 {name=l801 lab=BL0}
N -40 1000 -60 1000 {}
C {lab_pin.sym} -60 1000 0 0 {name=l802 lab=BLB0}
N -40 960 -60 960 {}
C {lab_pin.sym} -60 960 0 0 {name=l803 lab=WL5}
N 40 1040 60 1040 {}
C {lab_pin.sym} 60 1040 0 0 {name=l804 lab=VDD}
N 40 960 60 960 {}
C {lab_pin.sym} 60 960 0 0 {name=l805 lab=VSS}
C {bitcell_6t.sym} 200 1000 0 0 {name=Xr5c1}
N 160 1040 140 1040 {}
C {lab_pin.sym} 140 1040 0 0 {name=l806 lab=BL1}
N 160 1000 140 1000 {}
C {lab_pin.sym} 140 1000 0 0 {name=l807 lab=BLB1}
N 160 960 140 960 {}
C {lab_pin.sym} 140 960 0 0 {name=l808 lab=WL5}
N 240 1040 260 1040 {}
C {lab_pin.sym} 260 1040 0 0 {name=l809 lab=VDD}
N 240 960 260 960 {}
C {lab_pin.sym} 260 960 0 0 {name=l810 lab=VSS}
C {bitcell_6t.sym} 400 1000 0 0 {name=Xr5c2}
N 360 1040 340 1040 {}
C {lab_pin.sym} 340 1040 0 0 {name=l811 lab=BL2}
N 360 1000 340 1000 {}
C {lab_pin.sym} 340 1000 0 0 {name=l812 lab=BLB2}
N 360 960 340 960 {}
C {lab_pin.sym} 340 960 0 0 {name=l813 lab=WL5}
N 440 1040 460 1040 {}
C {lab_pin.sym} 460 1040 0 0 {name=l814 lab=VDD}
N 440 960 460 960 {}
C {lab_pin.sym} 460 960 0 0 {name=l815 lab=VSS}
C {bitcell_6t.sym} 600 1000 0 0 {name=Xr5c3}
N 560 1040 540 1040 {}
C {lab_pin.sym} 540 1040 0 0 {name=l816 lab=BL3}
N 560 1000 540 1000 {}
C {lab_pin.sym} 540 1000 0 0 {name=l817 lab=BLB3}
N 560 960 540 960 {}
C {lab_pin.sym} 540 960 0 0 {name=l818 lab=WL5}
N 640 1040 660 1040 {}
C {lab_pin.sym} 660 1040 0 0 {name=l819 lab=VDD}
N 640 960 660 960 {}
C {lab_pin.sym} 660 960 0 0 {name=l820 lab=VSS}
C {bitcell_6t.sym} 800 1000 0 0 {name=Xr5c4}
N 760 1040 740 1040 {}
C {lab_pin.sym} 740 1040 0 0 {name=l821 lab=BL4}
N 760 1000 740 1000 {}
C {lab_pin.sym} 740 1000 0 0 {name=l822 lab=BLB4}
N 760 960 740 960 {}
C {lab_pin.sym} 740 960 0 0 {name=l823 lab=WL5}
N 840 1040 860 1040 {}
C {lab_pin.sym} 860 1040 0 0 {name=l824 lab=VDD}
N 840 960 860 960 {}
C {lab_pin.sym} 860 960 0 0 {name=l825 lab=VSS}
C {bitcell_6t.sym} 1000 1000 0 0 {name=Xr5c5}
N 960 1040 940 1040 {}
C {lab_pin.sym} 940 1040 0 0 {name=l826 lab=BL5}
N 960 1000 940 1000 {}
C {lab_pin.sym} 940 1000 0 0 {name=l827 lab=BLB5}
N 960 960 940 960 {}
C {lab_pin.sym} 940 960 0 0 {name=l828 lab=WL5}
N 1040 1040 1060 1040 {}
C {lab_pin.sym} 1060 1040 0 0 {name=l829 lab=VDD}
N 1040 960 1060 960 {}
C {lab_pin.sym} 1060 960 0 0 {name=l830 lab=VSS}
C {bitcell_6t.sym} 1200 1000 0 0 {name=Xr5c6}
N 1160 1040 1140 1040 {}
C {lab_pin.sym} 1140 1040 0 0 {name=l831 lab=BL6}
N 1160 1000 1140 1000 {}
C {lab_pin.sym} 1140 1000 0 0 {name=l832 lab=BLB6}
N 1160 960 1140 960 {}
C {lab_pin.sym} 1140 960 0 0 {name=l833 lab=WL5}
N 1240 1040 1260 1040 {}
C {lab_pin.sym} 1260 1040 0 0 {name=l834 lab=VDD}
N 1240 960 1260 960 {}
C {lab_pin.sym} 1260 960 0 0 {name=l835 lab=VSS}
C {bitcell_6t.sym} 1400 1000 0 0 {name=Xr5c7}
N 1360 1040 1340 1040 {}
C {lab_pin.sym} 1340 1040 0 0 {name=l836 lab=BL7}
N 1360 1000 1340 1000 {}
C {lab_pin.sym} 1340 1000 0 0 {name=l837 lab=BLB7}
N 1360 960 1340 960 {}
C {lab_pin.sym} 1340 960 0 0 {name=l838 lab=WL5}
N 1440 1040 1460 1040 {}
C {lab_pin.sym} 1460 1040 0 0 {name=l839 lab=VDD}
N 1440 960 1460 960 {}
C {lab_pin.sym} 1460 960 0 0 {name=l840 lab=VSS}
C {bitcell_6t.sym} 1600 1000 0 0 {name=Xr5c8}
N 1560 1040 1540 1040 {}
C {lab_pin.sym} 1540 1040 0 0 {name=l841 lab=BL8}
N 1560 1000 1540 1000 {}
C {lab_pin.sym} 1540 1000 0 0 {name=l842 lab=BLB8}
N 1560 960 1540 960 {}
C {lab_pin.sym} 1540 960 0 0 {name=l843 lab=WL5}
N 1640 1040 1660 1040 {}
C {lab_pin.sym} 1660 1040 0 0 {name=l844 lab=VDD}
N 1640 960 1660 960 {}
C {lab_pin.sym} 1660 960 0 0 {name=l845 lab=VSS}
C {bitcell_6t.sym} 1800 1000 0 0 {name=Xr5c9}
N 1760 1040 1740 1040 {}
C {lab_pin.sym} 1740 1040 0 0 {name=l846 lab=BL9}
N 1760 1000 1740 1000 {}
C {lab_pin.sym} 1740 1000 0 0 {name=l847 lab=BLB9}
N 1760 960 1740 960 {}
C {lab_pin.sym} 1740 960 0 0 {name=l848 lab=WL5}
N 1840 1040 1860 1040 {}
C {lab_pin.sym} 1860 1040 0 0 {name=l849 lab=VDD}
N 1840 960 1860 960 {}
C {lab_pin.sym} 1860 960 0 0 {name=l850 lab=VSS}
C {bitcell_6t.sym} 2000 1000 0 0 {name=Xr5c10}
N 1960 1040 1940 1040 {}
C {lab_pin.sym} 1940 1040 0 0 {name=l851 lab=BL10}
N 1960 1000 1940 1000 {}
C {lab_pin.sym} 1940 1000 0 0 {name=l852 lab=BLB10}
N 1960 960 1940 960 {}
C {lab_pin.sym} 1940 960 0 0 {name=l853 lab=WL5}
N 2040 1040 2060 1040 {}
C {lab_pin.sym} 2060 1040 0 0 {name=l854 lab=VDD}
N 2040 960 2060 960 {}
C {lab_pin.sym} 2060 960 0 0 {name=l855 lab=VSS}
C {bitcell_6t.sym} 2200 1000 0 0 {name=Xr5c11}
N 2160 1040 2140 1040 {}
C {lab_pin.sym} 2140 1040 0 0 {name=l856 lab=BL11}
N 2160 1000 2140 1000 {}
C {lab_pin.sym} 2140 1000 0 0 {name=l857 lab=BLB11}
N 2160 960 2140 960 {}
C {lab_pin.sym} 2140 960 0 0 {name=l858 lab=WL5}
N 2240 1040 2260 1040 {}
C {lab_pin.sym} 2260 1040 0 0 {name=l859 lab=VDD}
N 2240 960 2260 960 {}
C {lab_pin.sym} 2260 960 0 0 {name=l860 lab=VSS}
C {bitcell_6t.sym} 2400 1000 0 0 {name=Xr5c12}
N 2360 1040 2340 1040 {}
C {lab_pin.sym} 2340 1040 0 0 {name=l861 lab=BL12}
N 2360 1000 2340 1000 {}
C {lab_pin.sym} 2340 1000 0 0 {name=l862 lab=BLB12}
N 2360 960 2340 960 {}
C {lab_pin.sym} 2340 960 0 0 {name=l863 lab=WL5}
N 2440 1040 2460 1040 {}
C {lab_pin.sym} 2460 1040 0 0 {name=l864 lab=VDD}
N 2440 960 2460 960 {}
C {lab_pin.sym} 2460 960 0 0 {name=l865 lab=VSS}
C {bitcell_6t.sym} 2600 1000 0 0 {name=Xr5c13}
N 2560 1040 2540 1040 {}
C {lab_pin.sym} 2540 1040 0 0 {name=l866 lab=BL13}
N 2560 1000 2540 1000 {}
C {lab_pin.sym} 2540 1000 0 0 {name=l867 lab=BLB13}
N 2560 960 2540 960 {}
C {lab_pin.sym} 2540 960 0 0 {name=l868 lab=WL5}
N 2640 1040 2660 1040 {}
C {lab_pin.sym} 2660 1040 0 0 {name=l869 lab=VDD}
N 2640 960 2660 960 {}
C {lab_pin.sym} 2660 960 0 0 {name=l870 lab=VSS}
C {bitcell_6t.sym} 2800 1000 0 0 {name=Xr5c14}
N 2760 1040 2740 1040 {}
C {lab_pin.sym} 2740 1040 0 0 {name=l871 lab=BL14}
N 2760 1000 2740 1000 {}
C {lab_pin.sym} 2740 1000 0 0 {name=l872 lab=BLB14}
N 2760 960 2740 960 {}
C {lab_pin.sym} 2740 960 0 0 {name=l873 lab=WL5}
N 2840 1040 2860 1040 {}
C {lab_pin.sym} 2860 1040 0 0 {name=l874 lab=VDD}
N 2840 960 2860 960 {}
C {lab_pin.sym} 2860 960 0 0 {name=l875 lab=VSS}
C {bitcell_6t.sym} 3000 1000 0 0 {name=Xr5c15}
N 2960 1040 2940 1040 {}
C {lab_pin.sym} 2940 1040 0 0 {name=l876 lab=BL15}
N 2960 1000 2940 1000 {}
C {lab_pin.sym} 2940 1000 0 0 {name=l877 lab=BLB15}
N 2960 960 2940 960 {}
C {lab_pin.sym} 2940 960 0 0 {name=l878 lab=WL5}
N 3040 1040 3060 1040 {}
C {lab_pin.sym} 3060 1040 0 0 {name=l879 lab=VDD}
N 3040 960 3060 960 {}
C {lab_pin.sym} 3060 960 0 0 {name=l880 lab=VSS}
C {bitcell_6t.sym} 3200 1000 0 0 {name=Xr5c16}
N 3160 1040 3140 1040 {}
C {lab_pin.sym} 3140 1040 0 0 {name=l881 lab=BL16}
N 3160 1000 3140 1000 {}
C {lab_pin.sym} 3140 1000 0 0 {name=l882 lab=BLB16}
N 3160 960 3140 960 {}
C {lab_pin.sym} 3140 960 0 0 {name=l883 lab=WL5}
N 3240 1040 3260 1040 {}
C {lab_pin.sym} 3260 1040 0 0 {name=l884 lab=VDD}
N 3240 960 3260 960 {}
C {lab_pin.sym} 3260 960 0 0 {name=l885 lab=VSS}
C {bitcell_6t.sym} 3400 1000 0 0 {name=Xr5c17}
N 3360 1040 3340 1040 {}
C {lab_pin.sym} 3340 1040 0 0 {name=l886 lab=BL17}
N 3360 1000 3340 1000 {}
C {lab_pin.sym} 3340 1000 0 0 {name=l887 lab=BLB17}
N 3360 960 3340 960 {}
C {lab_pin.sym} 3340 960 0 0 {name=l888 lab=WL5}
N 3440 1040 3460 1040 {}
C {lab_pin.sym} 3460 1040 0 0 {name=l889 lab=VDD}
N 3440 960 3460 960 {}
C {lab_pin.sym} 3460 960 0 0 {name=l890 lab=VSS}
C {bitcell_6t.sym} 3600 1000 0 0 {name=Xr5c18}
N 3560 1040 3540 1040 {}
C {lab_pin.sym} 3540 1040 0 0 {name=l891 lab=BL18}
N 3560 1000 3540 1000 {}
C {lab_pin.sym} 3540 1000 0 0 {name=l892 lab=BLB18}
N 3560 960 3540 960 {}
C {lab_pin.sym} 3540 960 0 0 {name=l893 lab=WL5}
N 3640 1040 3660 1040 {}
C {lab_pin.sym} 3660 1040 0 0 {name=l894 lab=VDD}
N 3640 960 3660 960 {}
C {lab_pin.sym} 3660 960 0 0 {name=l895 lab=VSS}
C {bitcell_6t.sym} 3800 1000 0 0 {name=Xr5c19}
N 3760 1040 3740 1040 {}
C {lab_pin.sym} 3740 1040 0 0 {name=l896 lab=BL19}
N 3760 1000 3740 1000 {}
C {lab_pin.sym} 3740 1000 0 0 {name=l897 lab=BLB19}
N 3760 960 3740 960 {}
C {lab_pin.sym} 3740 960 0 0 {name=l898 lab=WL5}
N 3840 1040 3860 1040 {}
C {lab_pin.sym} 3860 1040 0 0 {name=l899 lab=VDD}
N 3840 960 3860 960 {}
C {lab_pin.sym} 3860 960 0 0 {name=l900 lab=VSS}
C {bitcell_6t.sym} 4000 1000 0 0 {name=Xr5c20}
N 3960 1040 3940 1040 {}
C {lab_pin.sym} 3940 1040 0 0 {name=l901 lab=BL20}
N 3960 1000 3940 1000 {}
C {lab_pin.sym} 3940 1000 0 0 {name=l902 lab=BLB20}
N 3960 960 3940 960 {}
C {lab_pin.sym} 3940 960 0 0 {name=l903 lab=WL5}
N 4040 1040 4060 1040 {}
C {lab_pin.sym} 4060 1040 0 0 {name=l904 lab=VDD}
N 4040 960 4060 960 {}
C {lab_pin.sym} 4060 960 0 0 {name=l905 lab=VSS}
C {bitcell_6t.sym} 4200 1000 0 0 {name=Xr5c21}
N 4160 1040 4140 1040 {}
C {lab_pin.sym} 4140 1040 0 0 {name=l906 lab=BL21}
N 4160 1000 4140 1000 {}
C {lab_pin.sym} 4140 1000 0 0 {name=l907 lab=BLB21}
N 4160 960 4140 960 {}
C {lab_pin.sym} 4140 960 0 0 {name=l908 lab=WL5}
N 4240 1040 4260 1040 {}
C {lab_pin.sym} 4260 1040 0 0 {name=l909 lab=VDD}
N 4240 960 4260 960 {}
C {lab_pin.sym} 4260 960 0 0 {name=l910 lab=VSS}
C {bitcell_6t.sym} 4400 1000 0 0 {name=Xr5c22}
N 4360 1040 4340 1040 {}
C {lab_pin.sym} 4340 1040 0 0 {name=l911 lab=BL22}
N 4360 1000 4340 1000 {}
C {lab_pin.sym} 4340 1000 0 0 {name=l912 lab=BLB22}
N 4360 960 4340 960 {}
C {lab_pin.sym} 4340 960 0 0 {name=l913 lab=WL5}
N 4440 1040 4460 1040 {}
C {lab_pin.sym} 4460 1040 0 0 {name=l914 lab=VDD}
N 4440 960 4460 960 {}
C {lab_pin.sym} 4460 960 0 0 {name=l915 lab=VSS}
C {bitcell_6t.sym} 4600 1000 0 0 {name=Xr5c23}
N 4560 1040 4540 1040 {}
C {lab_pin.sym} 4540 1040 0 0 {name=l916 lab=BL23}
N 4560 1000 4540 1000 {}
C {lab_pin.sym} 4540 1000 0 0 {name=l917 lab=BLB23}
N 4560 960 4540 960 {}
C {lab_pin.sym} 4540 960 0 0 {name=l918 lab=WL5}
N 4640 1040 4660 1040 {}
C {lab_pin.sym} 4660 1040 0 0 {name=l919 lab=VDD}
N 4640 960 4660 960 {}
C {lab_pin.sym} 4660 960 0 0 {name=l920 lab=VSS}
C {bitcell_6t.sym} 4800 1000 0 0 {name=Xr5c24}
N 4760 1040 4740 1040 {}
C {lab_pin.sym} 4740 1040 0 0 {name=l921 lab=BL24}
N 4760 1000 4740 1000 {}
C {lab_pin.sym} 4740 1000 0 0 {name=l922 lab=BLB24}
N 4760 960 4740 960 {}
C {lab_pin.sym} 4740 960 0 0 {name=l923 lab=WL5}
N 4840 1040 4860 1040 {}
C {lab_pin.sym} 4860 1040 0 0 {name=l924 lab=VDD}
N 4840 960 4860 960 {}
C {lab_pin.sym} 4860 960 0 0 {name=l925 lab=VSS}
C {bitcell_6t.sym} 5000 1000 0 0 {name=Xr5c25}
N 4960 1040 4940 1040 {}
C {lab_pin.sym} 4940 1040 0 0 {name=l926 lab=BL25}
N 4960 1000 4940 1000 {}
C {lab_pin.sym} 4940 1000 0 0 {name=l927 lab=BLB25}
N 4960 960 4940 960 {}
C {lab_pin.sym} 4940 960 0 0 {name=l928 lab=WL5}
N 5040 1040 5060 1040 {}
C {lab_pin.sym} 5060 1040 0 0 {name=l929 lab=VDD}
N 5040 960 5060 960 {}
C {lab_pin.sym} 5060 960 0 0 {name=l930 lab=VSS}
C {bitcell_6t.sym} 5200 1000 0 0 {name=Xr5c26}
N 5160 1040 5140 1040 {}
C {lab_pin.sym} 5140 1040 0 0 {name=l931 lab=BL26}
N 5160 1000 5140 1000 {}
C {lab_pin.sym} 5140 1000 0 0 {name=l932 lab=BLB26}
N 5160 960 5140 960 {}
C {lab_pin.sym} 5140 960 0 0 {name=l933 lab=WL5}
N 5240 1040 5260 1040 {}
C {lab_pin.sym} 5260 1040 0 0 {name=l934 lab=VDD}
N 5240 960 5260 960 {}
C {lab_pin.sym} 5260 960 0 0 {name=l935 lab=VSS}
C {bitcell_6t.sym} 5400 1000 0 0 {name=Xr5c27}
N 5360 1040 5340 1040 {}
C {lab_pin.sym} 5340 1040 0 0 {name=l936 lab=BL27}
N 5360 1000 5340 1000 {}
C {lab_pin.sym} 5340 1000 0 0 {name=l937 lab=BLB27}
N 5360 960 5340 960 {}
C {lab_pin.sym} 5340 960 0 0 {name=l938 lab=WL5}
N 5440 1040 5460 1040 {}
C {lab_pin.sym} 5460 1040 0 0 {name=l939 lab=VDD}
N 5440 960 5460 960 {}
C {lab_pin.sym} 5460 960 0 0 {name=l940 lab=VSS}
C {bitcell_6t.sym} 5600 1000 0 0 {name=Xr5c28}
N 5560 1040 5540 1040 {}
C {lab_pin.sym} 5540 1040 0 0 {name=l941 lab=BL28}
N 5560 1000 5540 1000 {}
C {lab_pin.sym} 5540 1000 0 0 {name=l942 lab=BLB28}
N 5560 960 5540 960 {}
C {lab_pin.sym} 5540 960 0 0 {name=l943 lab=WL5}
N 5640 1040 5660 1040 {}
C {lab_pin.sym} 5660 1040 0 0 {name=l944 lab=VDD}
N 5640 960 5660 960 {}
C {lab_pin.sym} 5660 960 0 0 {name=l945 lab=VSS}
C {bitcell_6t.sym} 5800 1000 0 0 {name=Xr5c29}
N 5760 1040 5740 1040 {}
C {lab_pin.sym} 5740 1040 0 0 {name=l946 lab=BL29}
N 5760 1000 5740 1000 {}
C {lab_pin.sym} 5740 1000 0 0 {name=l947 lab=BLB29}
N 5760 960 5740 960 {}
C {lab_pin.sym} 5740 960 0 0 {name=l948 lab=WL5}
N 5840 1040 5860 1040 {}
C {lab_pin.sym} 5860 1040 0 0 {name=l949 lab=VDD}
N 5840 960 5860 960 {}
C {lab_pin.sym} 5860 960 0 0 {name=l950 lab=VSS}
C {bitcell_6t.sym} 6000 1000 0 0 {name=Xr5c30}
N 5960 1040 5940 1040 {}
C {lab_pin.sym} 5940 1040 0 0 {name=l951 lab=BL30}
N 5960 1000 5940 1000 {}
C {lab_pin.sym} 5940 1000 0 0 {name=l952 lab=BLB30}
N 5960 960 5940 960 {}
C {lab_pin.sym} 5940 960 0 0 {name=l953 lab=WL5}
N 6040 1040 6060 1040 {}
C {lab_pin.sym} 6060 1040 0 0 {name=l954 lab=VDD}
N 6040 960 6060 960 {}
C {lab_pin.sym} 6060 960 0 0 {name=l955 lab=VSS}
C {bitcell_6t.sym} 6200 1000 0 0 {name=Xr5c31}
N 6160 1040 6140 1040 {}
C {lab_pin.sym} 6140 1040 0 0 {name=l956 lab=BL31}
N 6160 1000 6140 1000 {}
C {lab_pin.sym} 6140 1000 0 0 {name=l957 lab=BLB31}
N 6160 960 6140 960 {}
C {lab_pin.sym} 6140 960 0 0 {name=l958 lab=WL5}
N 6240 1040 6260 1040 {}
C {lab_pin.sym} 6260 1040 0 0 {name=l959 lab=VDD}
N 6240 960 6260 960 {}
C {lab_pin.sym} 6260 960 0 0 {name=l960 lab=VSS}
C {bitcell_6t.sym} 0 1200 0 0 {name=Xr6c0}
N -40 1240 -60 1240 {}
C {lab_pin.sym} -60 1240 0 0 {name=l961 lab=BL0}
N -40 1200 -60 1200 {}
C {lab_pin.sym} -60 1200 0 0 {name=l962 lab=BLB0}
N -40 1160 -60 1160 {}
C {lab_pin.sym} -60 1160 0 0 {name=l963 lab=WL6}
N 40 1240 60 1240 {}
C {lab_pin.sym} 60 1240 0 0 {name=l964 lab=VDD}
N 40 1160 60 1160 {}
C {lab_pin.sym} 60 1160 0 0 {name=l965 lab=VSS}
C {bitcell_6t.sym} 200 1200 0 0 {name=Xr6c1}
N 160 1240 140 1240 {}
C {lab_pin.sym} 140 1240 0 0 {name=l966 lab=BL1}
N 160 1200 140 1200 {}
C {lab_pin.sym} 140 1200 0 0 {name=l967 lab=BLB1}
N 160 1160 140 1160 {}
C {lab_pin.sym} 140 1160 0 0 {name=l968 lab=WL6}
N 240 1240 260 1240 {}
C {lab_pin.sym} 260 1240 0 0 {name=l969 lab=VDD}
N 240 1160 260 1160 {}
C {lab_pin.sym} 260 1160 0 0 {name=l970 lab=VSS}
C {bitcell_6t.sym} 400 1200 0 0 {name=Xr6c2}
N 360 1240 340 1240 {}
C {lab_pin.sym} 340 1240 0 0 {name=l971 lab=BL2}
N 360 1200 340 1200 {}
C {lab_pin.sym} 340 1200 0 0 {name=l972 lab=BLB2}
N 360 1160 340 1160 {}
C {lab_pin.sym} 340 1160 0 0 {name=l973 lab=WL6}
N 440 1240 460 1240 {}
C {lab_pin.sym} 460 1240 0 0 {name=l974 lab=VDD}
N 440 1160 460 1160 {}
C {lab_pin.sym} 460 1160 0 0 {name=l975 lab=VSS}
C {bitcell_6t.sym} 600 1200 0 0 {name=Xr6c3}
N 560 1240 540 1240 {}
C {lab_pin.sym} 540 1240 0 0 {name=l976 lab=BL3}
N 560 1200 540 1200 {}
C {lab_pin.sym} 540 1200 0 0 {name=l977 lab=BLB3}
N 560 1160 540 1160 {}
C {lab_pin.sym} 540 1160 0 0 {name=l978 lab=WL6}
N 640 1240 660 1240 {}
C {lab_pin.sym} 660 1240 0 0 {name=l979 lab=VDD}
N 640 1160 660 1160 {}
C {lab_pin.sym} 660 1160 0 0 {name=l980 lab=VSS}
C {bitcell_6t.sym} 800 1200 0 0 {name=Xr6c4}
N 760 1240 740 1240 {}
C {lab_pin.sym} 740 1240 0 0 {name=l981 lab=BL4}
N 760 1200 740 1200 {}
C {lab_pin.sym} 740 1200 0 0 {name=l982 lab=BLB4}
N 760 1160 740 1160 {}
C {lab_pin.sym} 740 1160 0 0 {name=l983 lab=WL6}
N 840 1240 860 1240 {}
C {lab_pin.sym} 860 1240 0 0 {name=l984 lab=VDD}
N 840 1160 860 1160 {}
C {lab_pin.sym} 860 1160 0 0 {name=l985 lab=VSS}
C {bitcell_6t.sym} 1000 1200 0 0 {name=Xr6c5}
N 960 1240 940 1240 {}
C {lab_pin.sym} 940 1240 0 0 {name=l986 lab=BL5}
N 960 1200 940 1200 {}
C {lab_pin.sym} 940 1200 0 0 {name=l987 lab=BLB5}
N 960 1160 940 1160 {}
C {lab_pin.sym} 940 1160 0 0 {name=l988 lab=WL6}
N 1040 1240 1060 1240 {}
C {lab_pin.sym} 1060 1240 0 0 {name=l989 lab=VDD}
N 1040 1160 1060 1160 {}
C {lab_pin.sym} 1060 1160 0 0 {name=l990 lab=VSS}
C {bitcell_6t.sym} 1200 1200 0 0 {name=Xr6c6}
N 1160 1240 1140 1240 {}
C {lab_pin.sym} 1140 1240 0 0 {name=l991 lab=BL6}
N 1160 1200 1140 1200 {}
C {lab_pin.sym} 1140 1200 0 0 {name=l992 lab=BLB6}
N 1160 1160 1140 1160 {}
C {lab_pin.sym} 1140 1160 0 0 {name=l993 lab=WL6}
N 1240 1240 1260 1240 {}
C {lab_pin.sym} 1260 1240 0 0 {name=l994 lab=VDD}
N 1240 1160 1260 1160 {}
C {lab_pin.sym} 1260 1160 0 0 {name=l995 lab=VSS}
C {bitcell_6t.sym} 1400 1200 0 0 {name=Xr6c7}
N 1360 1240 1340 1240 {}
C {lab_pin.sym} 1340 1240 0 0 {name=l996 lab=BL7}
N 1360 1200 1340 1200 {}
C {lab_pin.sym} 1340 1200 0 0 {name=l997 lab=BLB7}
N 1360 1160 1340 1160 {}
C {lab_pin.sym} 1340 1160 0 0 {name=l998 lab=WL6}
N 1440 1240 1460 1240 {}
C {lab_pin.sym} 1460 1240 0 0 {name=l999 lab=VDD}
N 1440 1160 1460 1160 {}
C {lab_pin.sym} 1460 1160 0 0 {name=l1000 lab=VSS}
C {bitcell_6t.sym} 1600 1200 0 0 {name=Xr6c8}
N 1560 1240 1540 1240 {}
C {lab_pin.sym} 1540 1240 0 0 {name=l1001 lab=BL8}
N 1560 1200 1540 1200 {}
C {lab_pin.sym} 1540 1200 0 0 {name=l1002 lab=BLB8}
N 1560 1160 1540 1160 {}
C {lab_pin.sym} 1540 1160 0 0 {name=l1003 lab=WL6}
N 1640 1240 1660 1240 {}
C {lab_pin.sym} 1660 1240 0 0 {name=l1004 lab=VDD}
N 1640 1160 1660 1160 {}
C {lab_pin.sym} 1660 1160 0 0 {name=l1005 lab=VSS}
C {bitcell_6t.sym} 1800 1200 0 0 {name=Xr6c9}
N 1760 1240 1740 1240 {}
C {lab_pin.sym} 1740 1240 0 0 {name=l1006 lab=BL9}
N 1760 1200 1740 1200 {}
C {lab_pin.sym} 1740 1200 0 0 {name=l1007 lab=BLB9}
N 1760 1160 1740 1160 {}
C {lab_pin.sym} 1740 1160 0 0 {name=l1008 lab=WL6}
N 1840 1240 1860 1240 {}
C {lab_pin.sym} 1860 1240 0 0 {name=l1009 lab=VDD}
N 1840 1160 1860 1160 {}
C {lab_pin.sym} 1860 1160 0 0 {name=l1010 lab=VSS}
C {bitcell_6t.sym} 2000 1200 0 0 {name=Xr6c10}
N 1960 1240 1940 1240 {}
C {lab_pin.sym} 1940 1240 0 0 {name=l1011 lab=BL10}
N 1960 1200 1940 1200 {}
C {lab_pin.sym} 1940 1200 0 0 {name=l1012 lab=BLB10}
N 1960 1160 1940 1160 {}
C {lab_pin.sym} 1940 1160 0 0 {name=l1013 lab=WL6}
N 2040 1240 2060 1240 {}
C {lab_pin.sym} 2060 1240 0 0 {name=l1014 lab=VDD}
N 2040 1160 2060 1160 {}
C {lab_pin.sym} 2060 1160 0 0 {name=l1015 lab=VSS}
C {bitcell_6t.sym} 2200 1200 0 0 {name=Xr6c11}
N 2160 1240 2140 1240 {}
C {lab_pin.sym} 2140 1240 0 0 {name=l1016 lab=BL11}
N 2160 1200 2140 1200 {}
C {lab_pin.sym} 2140 1200 0 0 {name=l1017 lab=BLB11}
N 2160 1160 2140 1160 {}
C {lab_pin.sym} 2140 1160 0 0 {name=l1018 lab=WL6}
N 2240 1240 2260 1240 {}
C {lab_pin.sym} 2260 1240 0 0 {name=l1019 lab=VDD}
N 2240 1160 2260 1160 {}
C {lab_pin.sym} 2260 1160 0 0 {name=l1020 lab=VSS}
C {bitcell_6t.sym} 2400 1200 0 0 {name=Xr6c12}
N 2360 1240 2340 1240 {}
C {lab_pin.sym} 2340 1240 0 0 {name=l1021 lab=BL12}
N 2360 1200 2340 1200 {}
C {lab_pin.sym} 2340 1200 0 0 {name=l1022 lab=BLB12}
N 2360 1160 2340 1160 {}
C {lab_pin.sym} 2340 1160 0 0 {name=l1023 lab=WL6}
N 2440 1240 2460 1240 {}
C {lab_pin.sym} 2460 1240 0 0 {name=l1024 lab=VDD}
N 2440 1160 2460 1160 {}
C {lab_pin.sym} 2460 1160 0 0 {name=l1025 lab=VSS}
C {bitcell_6t.sym} 2600 1200 0 0 {name=Xr6c13}
N 2560 1240 2540 1240 {}
C {lab_pin.sym} 2540 1240 0 0 {name=l1026 lab=BL13}
N 2560 1200 2540 1200 {}
C {lab_pin.sym} 2540 1200 0 0 {name=l1027 lab=BLB13}
N 2560 1160 2540 1160 {}
C {lab_pin.sym} 2540 1160 0 0 {name=l1028 lab=WL6}
N 2640 1240 2660 1240 {}
C {lab_pin.sym} 2660 1240 0 0 {name=l1029 lab=VDD}
N 2640 1160 2660 1160 {}
C {lab_pin.sym} 2660 1160 0 0 {name=l1030 lab=VSS}
C {bitcell_6t.sym} 2800 1200 0 0 {name=Xr6c14}
N 2760 1240 2740 1240 {}
C {lab_pin.sym} 2740 1240 0 0 {name=l1031 lab=BL14}
N 2760 1200 2740 1200 {}
C {lab_pin.sym} 2740 1200 0 0 {name=l1032 lab=BLB14}
N 2760 1160 2740 1160 {}
C {lab_pin.sym} 2740 1160 0 0 {name=l1033 lab=WL6}
N 2840 1240 2860 1240 {}
C {lab_pin.sym} 2860 1240 0 0 {name=l1034 lab=VDD}
N 2840 1160 2860 1160 {}
C {lab_pin.sym} 2860 1160 0 0 {name=l1035 lab=VSS}
C {bitcell_6t.sym} 3000 1200 0 0 {name=Xr6c15}
N 2960 1240 2940 1240 {}
C {lab_pin.sym} 2940 1240 0 0 {name=l1036 lab=BL15}
N 2960 1200 2940 1200 {}
C {lab_pin.sym} 2940 1200 0 0 {name=l1037 lab=BLB15}
N 2960 1160 2940 1160 {}
C {lab_pin.sym} 2940 1160 0 0 {name=l1038 lab=WL6}
N 3040 1240 3060 1240 {}
C {lab_pin.sym} 3060 1240 0 0 {name=l1039 lab=VDD}
N 3040 1160 3060 1160 {}
C {lab_pin.sym} 3060 1160 0 0 {name=l1040 lab=VSS}
C {bitcell_6t.sym} 3200 1200 0 0 {name=Xr6c16}
N 3160 1240 3140 1240 {}
C {lab_pin.sym} 3140 1240 0 0 {name=l1041 lab=BL16}
N 3160 1200 3140 1200 {}
C {lab_pin.sym} 3140 1200 0 0 {name=l1042 lab=BLB16}
N 3160 1160 3140 1160 {}
C {lab_pin.sym} 3140 1160 0 0 {name=l1043 lab=WL6}
N 3240 1240 3260 1240 {}
C {lab_pin.sym} 3260 1240 0 0 {name=l1044 lab=VDD}
N 3240 1160 3260 1160 {}
C {lab_pin.sym} 3260 1160 0 0 {name=l1045 lab=VSS}
C {bitcell_6t.sym} 3400 1200 0 0 {name=Xr6c17}
N 3360 1240 3340 1240 {}
C {lab_pin.sym} 3340 1240 0 0 {name=l1046 lab=BL17}
N 3360 1200 3340 1200 {}
C {lab_pin.sym} 3340 1200 0 0 {name=l1047 lab=BLB17}
N 3360 1160 3340 1160 {}
C {lab_pin.sym} 3340 1160 0 0 {name=l1048 lab=WL6}
N 3440 1240 3460 1240 {}
C {lab_pin.sym} 3460 1240 0 0 {name=l1049 lab=VDD}
N 3440 1160 3460 1160 {}
C {lab_pin.sym} 3460 1160 0 0 {name=l1050 lab=VSS}
C {bitcell_6t.sym} 3600 1200 0 0 {name=Xr6c18}
N 3560 1240 3540 1240 {}
C {lab_pin.sym} 3540 1240 0 0 {name=l1051 lab=BL18}
N 3560 1200 3540 1200 {}
C {lab_pin.sym} 3540 1200 0 0 {name=l1052 lab=BLB18}
N 3560 1160 3540 1160 {}
C {lab_pin.sym} 3540 1160 0 0 {name=l1053 lab=WL6}
N 3640 1240 3660 1240 {}
C {lab_pin.sym} 3660 1240 0 0 {name=l1054 lab=VDD}
N 3640 1160 3660 1160 {}
C {lab_pin.sym} 3660 1160 0 0 {name=l1055 lab=VSS}
C {bitcell_6t.sym} 3800 1200 0 0 {name=Xr6c19}
N 3760 1240 3740 1240 {}
C {lab_pin.sym} 3740 1240 0 0 {name=l1056 lab=BL19}
N 3760 1200 3740 1200 {}
C {lab_pin.sym} 3740 1200 0 0 {name=l1057 lab=BLB19}
N 3760 1160 3740 1160 {}
C {lab_pin.sym} 3740 1160 0 0 {name=l1058 lab=WL6}
N 3840 1240 3860 1240 {}
C {lab_pin.sym} 3860 1240 0 0 {name=l1059 lab=VDD}
N 3840 1160 3860 1160 {}
C {lab_pin.sym} 3860 1160 0 0 {name=l1060 lab=VSS}
C {bitcell_6t.sym} 4000 1200 0 0 {name=Xr6c20}
N 3960 1240 3940 1240 {}
C {lab_pin.sym} 3940 1240 0 0 {name=l1061 lab=BL20}
N 3960 1200 3940 1200 {}
C {lab_pin.sym} 3940 1200 0 0 {name=l1062 lab=BLB20}
N 3960 1160 3940 1160 {}
C {lab_pin.sym} 3940 1160 0 0 {name=l1063 lab=WL6}
N 4040 1240 4060 1240 {}
C {lab_pin.sym} 4060 1240 0 0 {name=l1064 lab=VDD}
N 4040 1160 4060 1160 {}
C {lab_pin.sym} 4060 1160 0 0 {name=l1065 lab=VSS}
C {bitcell_6t.sym} 4200 1200 0 0 {name=Xr6c21}
N 4160 1240 4140 1240 {}
C {lab_pin.sym} 4140 1240 0 0 {name=l1066 lab=BL21}
N 4160 1200 4140 1200 {}
C {lab_pin.sym} 4140 1200 0 0 {name=l1067 lab=BLB21}
N 4160 1160 4140 1160 {}
C {lab_pin.sym} 4140 1160 0 0 {name=l1068 lab=WL6}
N 4240 1240 4260 1240 {}
C {lab_pin.sym} 4260 1240 0 0 {name=l1069 lab=VDD}
N 4240 1160 4260 1160 {}
C {lab_pin.sym} 4260 1160 0 0 {name=l1070 lab=VSS}
C {bitcell_6t.sym} 4400 1200 0 0 {name=Xr6c22}
N 4360 1240 4340 1240 {}
C {lab_pin.sym} 4340 1240 0 0 {name=l1071 lab=BL22}
N 4360 1200 4340 1200 {}
C {lab_pin.sym} 4340 1200 0 0 {name=l1072 lab=BLB22}
N 4360 1160 4340 1160 {}
C {lab_pin.sym} 4340 1160 0 0 {name=l1073 lab=WL6}
N 4440 1240 4460 1240 {}
C {lab_pin.sym} 4460 1240 0 0 {name=l1074 lab=VDD}
N 4440 1160 4460 1160 {}
C {lab_pin.sym} 4460 1160 0 0 {name=l1075 lab=VSS}
C {bitcell_6t.sym} 4600 1200 0 0 {name=Xr6c23}
N 4560 1240 4540 1240 {}
C {lab_pin.sym} 4540 1240 0 0 {name=l1076 lab=BL23}
N 4560 1200 4540 1200 {}
C {lab_pin.sym} 4540 1200 0 0 {name=l1077 lab=BLB23}
N 4560 1160 4540 1160 {}
C {lab_pin.sym} 4540 1160 0 0 {name=l1078 lab=WL6}
N 4640 1240 4660 1240 {}
C {lab_pin.sym} 4660 1240 0 0 {name=l1079 lab=VDD}
N 4640 1160 4660 1160 {}
C {lab_pin.sym} 4660 1160 0 0 {name=l1080 lab=VSS}
C {bitcell_6t.sym} 4800 1200 0 0 {name=Xr6c24}
N 4760 1240 4740 1240 {}
C {lab_pin.sym} 4740 1240 0 0 {name=l1081 lab=BL24}
N 4760 1200 4740 1200 {}
C {lab_pin.sym} 4740 1200 0 0 {name=l1082 lab=BLB24}
N 4760 1160 4740 1160 {}
C {lab_pin.sym} 4740 1160 0 0 {name=l1083 lab=WL6}
N 4840 1240 4860 1240 {}
C {lab_pin.sym} 4860 1240 0 0 {name=l1084 lab=VDD}
N 4840 1160 4860 1160 {}
C {lab_pin.sym} 4860 1160 0 0 {name=l1085 lab=VSS}
C {bitcell_6t.sym} 5000 1200 0 0 {name=Xr6c25}
N 4960 1240 4940 1240 {}
C {lab_pin.sym} 4940 1240 0 0 {name=l1086 lab=BL25}
N 4960 1200 4940 1200 {}
C {lab_pin.sym} 4940 1200 0 0 {name=l1087 lab=BLB25}
N 4960 1160 4940 1160 {}
C {lab_pin.sym} 4940 1160 0 0 {name=l1088 lab=WL6}
N 5040 1240 5060 1240 {}
C {lab_pin.sym} 5060 1240 0 0 {name=l1089 lab=VDD}
N 5040 1160 5060 1160 {}
C {lab_pin.sym} 5060 1160 0 0 {name=l1090 lab=VSS}
C {bitcell_6t.sym} 5200 1200 0 0 {name=Xr6c26}
N 5160 1240 5140 1240 {}
C {lab_pin.sym} 5140 1240 0 0 {name=l1091 lab=BL26}
N 5160 1200 5140 1200 {}
C {lab_pin.sym} 5140 1200 0 0 {name=l1092 lab=BLB26}
N 5160 1160 5140 1160 {}
C {lab_pin.sym} 5140 1160 0 0 {name=l1093 lab=WL6}
N 5240 1240 5260 1240 {}
C {lab_pin.sym} 5260 1240 0 0 {name=l1094 lab=VDD}
N 5240 1160 5260 1160 {}
C {lab_pin.sym} 5260 1160 0 0 {name=l1095 lab=VSS}
C {bitcell_6t.sym} 5400 1200 0 0 {name=Xr6c27}
N 5360 1240 5340 1240 {}
C {lab_pin.sym} 5340 1240 0 0 {name=l1096 lab=BL27}
N 5360 1200 5340 1200 {}
C {lab_pin.sym} 5340 1200 0 0 {name=l1097 lab=BLB27}
N 5360 1160 5340 1160 {}
C {lab_pin.sym} 5340 1160 0 0 {name=l1098 lab=WL6}
N 5440 1240 5460 1240 {}
C {lab_pin.sym} 5460 1240 0 0 {name=l1099 lab=VDD}
N 5440 1160 5460 1160 {}
C {lab_pin.sym} 5460 1160 0 0 {name=l1100 lab=VSS}
C {bitcell_6t.sym} 5600 1200 0 0 {name=Xr6c28}
N 5560 1240 5540 1240 {}
C {lab_pin.sym} 5540 1240 0 0 {name=l1101 lab=BL28}
N 5560 1200 5540 1200 {}
C {lab_pin.sym} 5540 1200 0 0 {name=l1102 lab=BLB28}
N 5560 1160 5540 1160 {}
C {lab_pin.sym} 5540 1160 0 0 {name=l1103 lab=WL6}
N 5640 1240 5660 1240 {}
C {lab_pin.sym} 5660 1240 0 0 {name=l1104 lab=VDD}
N 5640 1160 5660 1160 {}
C {lab_pin.sym} 5660 1160 0 0 {name=l1105 lab=VSS}
C {bitcell_6t.sym} 5800 1200 0 0 {name=Xr6c29}
N 5760 1240 5740 1240 {}
C {lab_pin.sym} 5740 1240 0 0 {name=l1106 lab=BL29}
N 5760 1200 5740 1200 {}
C {lab_pin.sym} 5740 1200 0 0 {name=l1107 lab=BLB29}
N 5760 1160 5740 1160 {}
C {lab_pin.sym} 5740 1160 0 0 {name=l1108 lab=WL6}
N 5840 1240 5860 1240 {}
C {lab_pin.sym} 5860 1240 0 0 {name=l1109 lab=VDD}
N 5840 1160 5860 1160 {}
C {lab_pin.sym} 5860 1160 0 0 {name=l1110 lab=VSS}
C {bitcell_6t.sym} 6000 1200 0 0 {name=Xr6c30}
N 5960 1240 5940 1240 {}
C {lab_pin.sym} 5940 1240 0 0 {name=l1111 lab=BL30}
N 5960 1200 5940 1200 {}
C {lab_pin.sym} 5940 1200 0 0 {name=l1112 lab=BLB30}
N 5960 1160 5940 1160 {}
C {lab_pin.sym} 5940 1160 0 0 {name=l1113 lab=WL6}
N 6040 1240 6060 1240 {}
C {lab_pin.sym} 6060 1240 0 0 {name=l1114 lab=VDD}
N 6040 1160 6060 1160 {}
C {lab_pin.sym} 6060 1160 0 0 {name=l1115 lab=VSS}
C {bitcell_6t.sym} 6200 1200 0 0 {name=Xr6c31}
N 6160 1240 6140 1240 {}
C {lab_pin.sym} 6140 1240 0 0 {name=l1116 lab=BL31}
N 6160 1200 6140 1200 {}
C {lab_pin.sym} 6140 1200 0 0 {name=l1117 lab=BLB31}
N 6160 1160 6140 1160 {}
C {lab_pin.sym} 6140 1160 0 0 {name=l1118 lab=WL6}
N 6240 1240 6260 1240 {}
C {lab_pin.sym} 6260 1240 0 0 {name=l1119 lab=VDD}
N 6240 1160 6260 1160 {}
C {lab_pin.sym} 6260 1160 0 0 {name=l1120 lab=VSS}
C {bitcell_6t.sym} 0 1400 0 0 {name=Xr7c0}
N -40 1440 -60 1440 {}
C {lab_pin.sym} -60 1440 0 0 {name=l1121 lab=BL0}
N -40 1400 -60 1400 {}
C {lab_pin.sym} -60 1400 0 0 {name=l1122 lab=BLB0}
N -40 1360 -60 1360 {}
C {lab_pin.sym} -60 1360 0 0 {name=l1123 lab=WL7}
N 40 1440 60 1440 {}
C {lab_pin.sym} 60 1440 0 0 {name=l1124 lab=VDD}
N 40 1360 60 1360 {}
C {lab_pin.sym} 60 1360 0 0 {name=l1125 lab=VSS}
C {bitcell_6t.sym} 200 1400 0 0 {name=Xr7c1}
N 160 1440 140 1440 {}
C {lab_pin.sym} 140 1440 0 0 {name=l1126 lab=BL1}
N 160 1400 140 1400 {}
C {lab_pin.sym} 140 1400 0 0 {name=l1127 lab=BLB1}
N 160 1360 140 1360 {}
C {lab_pin.sym} 140 1360 0 0 {name=l1128 lab=WL7}
N 240 1440 260 1440 {}
C {lab_pin.sym} 260 1440 0 0 {name=l1129 lab=VDD}
N 240 1360 260 1360 {}
C {lab_pin.sym} 260 1360 0 0 {name=l1130 lab=VSS}
C {bitcell_6t.sym} 400 1400 0 0 {name=Xr7c2}
N 360 1440 340 1440 {}
C {lab_pin.sym} 340 1440 0 0 {name=l1131 lab=BL2}
N 360 1400 340 1400 {}
C {lab_pin.sym} 340 1400 0 0 {name=l1132 lab=BLB2}
N 360 1360 340 1360 {}
C {lab_pin.sym} 340 1360 0 0 {name=l1133 lab=WL7}
N 440 1440 460 1440 {}
C {lab_pin.sym} 460 1440 0 0 {name=l1134 lab=VDD}
N 440 1360 460 1360 {}
C {lab_pin.sym} 460 1360 0 0 {name=l1135 lab=VSS}
C {bitcell_6t.sym} 600 1400 0 0 {name=Xr7c3}
N 560 1440 540 1440 {}
C {lab_pin.sym} 540 1440 0 0 {name=l1136 lab=BL3}
N 560 1400 540 1400 {}
C {lab_pin.sym} 540 1400 0 0 {name=l1137 lab=BLB3}
N 560 1360 540 1360 {}
C {lab_pin.sym} 540 1360 0 0 {name=l1138 lab=WL7}
N 640 1440 660 1440 {}
C {lab_pin.sym} 660 1440 0 0 {name=l1139 lab=VDD}
N 640 1360 660 1360 {}
C {lab_pin.sym} 660 1360 0 0 {name=l1140 lab=VSS}
C {bitcell_6t.sym} 800 1400 0 0 {name=Xr7c4}
N 760 1440 740 1440 {}
C {lab_pin.sym} 740 1440 0 0 {name=l1141 lab=BL4}
N 760 1400 740 1400 {}
C {lab_pin.sym} 740 1400 0 0 {name=l1142 lab=BLB4}
N 760 1360 740 1360 {}
C {lab_pin.sym} 740 1360 0 0 {name=l1143 lab=WL7}
N 840 1440 860 1440 {}
C {lab_pin.sym} 860 1440 0 0 {name=l1144 lab=VDD}
N 840 1360 860 1360 {}
C {lab_pin.sym} 860 1360 0 0 {name=l1145 lab=VSS}
C {bitcell_6t.sym} 1000 1400 0 0 {name=Xr7c5}
N 960 1440 940 1440 {}
C {lab_pin.sym} 940 1440 0 0 {name=l1146 lab=BL5}
N 960 1400 940 1400 {}
C {lab_pin.sym} 940 1400 0 0 {name=l1147 lab=BLB5}
N 960 1360 940 1360 {}
C {lab_pin.sym} 940 1360 0 0 {name=l1148 lab=WL7}
N 1040 1440 1060 1440 {}
C {lab_pin.sym} 1060 1440 0 0 {name=l1149 lab=VDD}
N 1040 1360 1060 1360 {}
C {lab_pin.sym} 1060 1360 0 0 {name=l1150 lab=VSS}
C {bitcell_6t.sym} 1200 1400 0 0 {name=Xr7c6}
N 1160 1440 1140 1440 {}
C {lab_pin.sym} 1140 1440 0 0 {name=l1151 lab=BL6}
N 1160 1400 1140 1400 {}
C {lab_pin.sym} 1140 1400 0 0 {name=l1152 lab=BLB6}
N 1160 1360 1140 1360 {}
C {lab_pin.sym} 1140 1360 0 0 {name=l1153 lab=WL7}
N 1240 1440 1260 1440 {}
C {lab_pin.sym} 1260 1440 0 0 {name=l1154 lab=VDD}
N 1240 1360 1260 1360 {}
C {lab_pin.sym} 1260 1360 0 0 {name=l1155 lab=VSS}
C {bitcell_6t.sym} 1400 1400 0 0 {name=Xr7c7}
N 1360 1440 1340 1440 {}
C {lab_pin.sym} 1340 1440 0 0 {name=l1156 lab=BL7}
N 1360 1400 1340 1400 {}
C {lab_pin.sym} 1340 1400 0 0 {name=l1157 lab=BLB7}
N 1360 1360 1340 1360 {}
C {lab_pin.sym} 1340 1360 0 0 {name=l1158 lab=WL7}
N 1440 1440 1460 1440 {}
C {lab_pin.sym} 1460 1440 0 0 {name=l1159 lab=VDD}
N 1440 1360 1460 1360 {}
C {lab_pin.sym} 1460 1360 0 0 {name=l1160 lab=VSS}
C {bitcell_6t.sym} 1600 1400 0 0 {name=Xr7c8}
N 1560 1440 1540 1440 {}
C {lab_pin.sym} 1540 1440 0 0 {name=l1161 lab=BL8}
N 1560 1400 1540 1400 {}
C {lab_pin.sym} 1540 1400 0 0 {name=l1162 lab=BLB8}
N 1560 1360 1540 1360 {}
C {lab_pin.sym} 1540 1360 0 0 {name=l1163 lab=WL7}
N 1640 1440 1660 1440 {}
C {lab_pin.sym} 1660 1440 0 0 {name=l1164 lab=VDD}
N 1640 1360 1660 1360 {}
C {lab_pin.sym} 1660 1360 0 0 {name=l1165 lab=VSS}
C {bitcell_6t.sym} 1800 1400 0 0 {name=Xr7c9}
N 1760 1440 1740 1440 {}
C {lab_pin.sym} 1740 1440 0 0 {name=l1166 lab=BL9}
N 1760 1400 1740 1400 {}
C {lab_pin.sym} 1740 1400 0 0 {name=l1167 lab=BLB9}
N 1760 1360 1740 1360 {}
C {lab_pin.sym} 1740 1360 0 0 {name=l1168 lab=WL7}
N 1840 1440 1860 1440 {}
C {lab_pin.sym} 1860 1440 0 0 {name=l1169 lab=VDD}
N 1840 1360 1860 1360 {}
C {lab_pin.sym} 1860 1360 0 0 {name=l1170 lab=VSS}
C {bitcell_6t.sym} 2000 1400 0 0 {name=Xr7c10}
N 1960 1440 1940 1440 {}
C {lab_pin.sym} 1940 1440 0 0 {name=l1171 lab=BL10}
N 1960 1400 1940 1400 {}
C {lab_pin.sym} 1940 1400 0 0 {name=l1172 lab=BLB10}
N 1960 1360 1940 1360 {}
C {lab_pin.sym} 1940 1360 0 0 {name=l1173 lab=WL7}
N 2040 1440 2060 1440 {}
C {lab_pin.sym} 2060 1440 0 0 {name=l1174 lab=VDD}
N 2040 1360 2060 1360 {}
C {lab_pin.sym} 2060 1360 0 0 {name=l1175 lab=VSS}
C {bitcell_6t.sym} 2200 1400 0 0 {name=Xr7c11}
N 2160 1440 2140 1440 {}
C {lab_pin.sym} 2140 1440 0 0 {name=l1176 lab=BL11}
N 2160 1400 2140 1400 {}
C {lab_pin.sym} 2140 1400 0 0 {name=l1177 lab=BLB11}
N 2160 1360 2140 1360 {}
C {lab_pin.sym} 2140 1360 0 0 {name=l1178 lab=WL7}
N 2240 1440 2260 1440 {}
C {lab_pin.sym} 2260 1440 0 0 {name=l1179 lab=VDD}
N 2240 1360 2260 1360 {}
C {lab_pin.sym} 2260 1360 0 0 {name=l1180 lab=VSS}
C {bitcell_6t.sym} 2400 1400 0 0 {name=Xr7c12}
N 2360 1440 2340 1440 {}
C {lab_pin.sym} 2340 1440 0 0 {name=l1181 lab=BL12}
N 2360 1400 2340 1400 {}
C {lab_pin.sym} 2340 1400 0 0 {name=l1182 lab=BLB12}
N 2360 1360 2340 1360 {}
C {lab_pin.sym} 2340 1360 0 0 {name=l1183 lab=WL7}
N 2440 1440 2460 1440 {}
C {lab_pin.sym} 2460 1440 0 0 {name=l1184 lab=VDD}
N 2440 1360 2460 1360 {}
C {lab_pin.sym} 2460 1360 0 0 {name=l1185 lab=VSS}
C {bitcell_6t.sym} 2600 1400 0 0 {name=Xr7c13}
N 2560 1440 2540 1440 {}
C {lab_pin.sym} 2540 1440 0 0 {name=l1186 lab=BL13}
N 2560 1400 2540 1400 {}
C {lab_pin.sym} 2540 1400 0 0 {name=l1187 lab=BLB13}
N 2560 1360 2540 1360 {}
C {lab_pin.sym} 2540 1360 0 0 {name=l1188 lab=WL7}
N 2640 1440 2660 1440 {}
C {lab_pin.sym} 2660 1440 0 0 {name=l1189 lab=VDD}
N 2640 1360 2660 1360 {}
C {lab_pin.sym} 2660 1360 0 0 {name=l1190 lab=VSS}
C {bitcell_6t.sym} 2800 1400 0 0 {name=Xr7c14}
N 2760 1440 2740 1440 {}
C {lab_pin.sym} 2740 1440 0 0 {name=l1191 lab=BL14}
N 2760 1400 2740 1400 {}
C {lab_pin.sym} 2740 1400 0 0 {name=l1192 lab=BLB14}
N 2760 1360 2740 1360 {}
C {lab_pin.sym} 2740 1360 0 0 {name=l1193 lab=WL7}
N 2840 1440 2860 1440 {}
C {lab_pin.sym} 2860 1440 0 0 {name=l1194 lab=VDD}
N 2840 1360 2860 1360 {}
C {lab_pin.sym} 2860 1360 0 0 {name=l1195 lab=VSS}
C {bitcell_6t.sym} 3000 1400 0 0 {name=Xr7c15}
N 2960 1440 2940 1440 {}
C {lab_pin.sym} 2940 1440 0 0 {name=l1196 lab=BL15}
N 2960 1400 2940 1400 {}
C {lab_pin.sym} 2940 1400 0 0 {name=l1197 lab=BLB15}
N 2960 1360 2940 1360 {}
C {lab_pin.sym} 2940 1360 0 0 {name=l1198 lab=WL7}
N 3040 1440 3060 1440 {}
C {lab_pin.sym} 3060 1440 0 0 {name=l1199 lab=VDD}
N 3040 1360 3060 1360 {}
C {lab_pin.sym} 3060 1360 0 0 {name=l1200 lab=VSS}
C {bitcell_6t.sym} 3200 1400 0 0 {name=Xr7c16}
N 3160 1440 3140 1440 {}
C {lab_pin.sym} 3140 1440 0 0 {name=l1201 lab=BL16}
N 3160 1400 3140 1400 {}
C {lab_pin.sym} 3140 1400 0 0 {name=l1202 lab=BLB16}
N 3160 1360 3140 1360 {}
C {lab_pin.sym} 3140 1360 0 0 {name=l1203 lab=WL7}
N 3240 1440 3260 1440 {}
C {lab_pin.sym} 3260 1440 0 0 {name=l1204 lab=VDD}
N 3240 1360 3260 1360 {}
C {lab_pin.sym} 3260 1360 0 0 {name=l1205 lab=VSS}
C {bitcell_6t.sym} 3400 1400 0 0 {name=Xr7c17}
N 3360 1440 3340 1440 {}
C {lab_pin.sym} 3340 1440 0 0 {name=l1206 lab=BL17}
N 3360 1400 3340 1400 {}
C {lab_pin.sym} 3340 1400 0 0 {name=l1207 lab=BLB17}
N 3360 1360 3340 1360 {}
C {lab_pin.sym} 3340 1360 0 0 {name=l1208 lab=WL7}
N 3440 1440 3460 1440 {}
C {lab_pin.sym} 3460 1440 0 0 {name=l1209 lab=VDD}
N 3440 1360 3460 1360 {}
C {lab_pin.sym} 3460 1360 0 0 {name=l1210 lab=VSS}
C {bitcell_6t.sym} 3600 1400 0 0 {name=Xr7c18}
N 3560 1440 3540 1440 {}
C {lab_pin.sym} 3540 1440 0 0 {name=l1211 lab=BL18}
N 3560 1400 3540 1400 {}
C {lab_pin.sym} 3540 1400 0 0 {name=l1212 lab=BLB18}
N 3560 1360 3540 1360 {}
C {lab_pin.sym} 3540 1360 0 0 {name=l1213 lab=WL7}
N 3640 1440 3660 1440 {}
C {lab_pin.sym} 3660 1440 0 0 {name=l1214 lab=VDD}
N 3640 1360 3660 1360 {}
C {lab_pin.sym} 3660 1360 0 0 {name=l1215 lab=VSS}
C {bitcell_6t.sym} 3800 1400 0 0 {name=Xr7c19}
N 3760 1440 3740 1440 {}
C {lab_pin.sym} 3740 1440 0 0 {name=l1216 lab=BL19}
N 3760 1400 3740 1400 {}
C {lab_pin.sym} 3740 1400 0 0 {name=l1217 lab=BLB19}
N 3760 1360 3740 1360 {}
C {lab_pin.sym} 3740 1360 0 0 {name=l1218 lab=WL7}
N 3840 1440 3860 1440 {}
C {lab_pin.sym} 3860 1440 0 0 {name=l1219 lab=VDD}
N 3840 1360 3860 1360 {}
C {lab_pin.sym} 3860 1360 0 0 {name=l1220 lab=VSS}
C {bitcell_6t.sym} 4000 1400 0 0 {name=Xr7c20}
N 3960 1440 3940 1440 {}
C {lab_pin.sym} 3940 1440 0 0 {name=l1221 lab=BL20}
N 3960 1400 3940 1400 {}
C {lab_pin.sym} 3940 1400 0 0 {name=l1222 lab=BLB20}
N 3960 1360 3940 1360 {}
C {lab_pin.sym} 3940 1360 0 0 {name=l1223 lab=WL7}
N 4040 1440 4060 1440 {}
C {lab_pin.sym} 4060 1440 0 0 {name=l1224 lab=VDD}
N 4040 1360 4060 1360 {}
C {lab_pin.sym} 4060 1360 0 0 {name=l1225 lab=VSS}
C {bitcell_6t.sym} 4200 1400 0 0 {name=Xr7c21}
N 4160 1440 4140 1440 {}
C {lab_pin.sym} 4140 1440 0 0 {name=l1226 lab=BL21}
N 4160 1400 4140 1400 {}
C {lab_pin.sym} 4140 1400 0 0 {name=l1227 lab=BLB21}
N 4160 1360 4140 1360 {}
C {lab_pin.sym} 4140 1360 0 0 {name=l1228 lab=WL7}
N 4240 1440 4260 1440 {}
C {lab_pin.sym} 4260 1440 0 0 {name=l1229 lab=VDD}
N 4240 1360 4260 1360 {}
C {lab_pin.sym} 4260 1360 0 0 {name=l1230 lab=VSS}
C {bitcell_6t.sym} 4400 1400 0 0 {name=Xr7c22}
N 4360 1440 4340 1440 {}
C {lab_pin.sym} 4340 1440 0 0 {name=l1231 lab=BL22}
N 4360 1400 4340 1400 {}
C {lab_pin.sym} 4340 1400 0 0 {name=l1232 lab=BLB22}
N 4360 1360 4340 1360 {}
C {lab_pin.sym} 4340 1360 0 0 {name=l1233 lab=WL7}
N 4440 1440 4460 1440 {}
C {lab_pin.sym} 4460 1440 0 0 {name=l1234 lab=VDD}
N 4440 1360 4460 1360 {}
C {lab_pin.sym} 4460 1360 0 0 {name=l1235 lab=VSS}
C {bitcell_6t.sym} 4600 1400 0 0 {name=Xr7c23}
N 4560 1440 4540 1440 {}
C {lab_pin.sym} 4540 1440 0 0 {name=l1236 lab=BL23}
N 4560 1400 4540 1400 {}
C {lab_pin.sym} 4540 1400 0 0 {name=l1237 lab=BLB23}
N 4560 1360 4540 1360 {}
C {lab_pin.sym} 4540 1360 0 0 {name=l1238 lab=WL7}
N 4640 1440 4660 1440 {}
C {lab_pin.sym} 4660 1440 0 0 {name=l1239 lab=VDD}
N 4640 1360 4660 1360 {}
C {lab_pin.sym} 4660 1360 0 0 {name=l1240 lab=VSS}
C {bitcell_6t.sym} 4800 1400 0 0 {name=Xr7c24}
N 4760 1440 4740 1440 {}
C {lab_pin.sym} 4740 1440 0 0 {name=l1241 lab=BL24}
N 4760 1400 4740 1400 {}
C {lab_pin.sym} 4740 1400 0 0 {name=l1242 lab=BLB24}
N 4760 1360 4740 1360 {}
C {lab_pin.sym} 4740 1360 0 0 {name=l1243 lab=WL7}
N 4840 1440 4860 1440 {}
C {lab_pin.sym} 4860 1440 0 0 {name=l1244 lab=VDD}
N 4840 1360 4860 1360 {}
C {lab_pin.sym} 4860 1360 0 0 {name=l1245 lab=VSS}
C {bitcell_6t.sym} 5000 1400 0 0 {name=Xr7c25}
N 4960 1440 4940 1440 {}
C {lab_pin.sym} 4940 1440 0 0 {name=l1246 lab=BL25}
N 4960 1400 4940 1400 {}
C {lab_pin.sym} 4940 1400 0 0 {name=l1247 lab=BLB25}
N 4960 1360 4940 1360 {}
C {lab_pin.sym} 4940 1360 0 0 {name=l1248 lab=WL7}
N 5040 1440 5060 1440 {}
C {lab_pin.sym} 5060 1440 0 0 {name=l1249 lab=VDD}
N 5040 1360 5060 1360 {}
C {lab_pin.sym} 5060 1360 0 0 {name=l1250 lab=VSS}
C {bitcell_6t.sym} 5200 1400 0 0 {name=Xr7c26}
N 5160 1440 5140 1440 {}
C {lab_pin.sym} 5140 1440 0 0 {name=l1251 lab=BL26}
N 5160 1400 5140 1400 {}
C {lab_pin.sym} 5140 1400 0 0 {name=l1252 lab=BLB26}
N 5160 1360 5140 1360 {}
C {lab_pin.sym} 5140 1360 0 0 {name=l1253 lab=WL7}
N 5240 1440 5260 1440 {}
C {lab_pin.sym} 5260 1440 0 0 {name=l1254 lab=VDD}
N 5240 1360 5260 1360 {}
C {lab_pin.sym} 5260 1360 0 0 {name=l1255 lab=VSS}
C {bitcell_6t.sym} 5400 1400 0 0 {name=Xr7c27}
N 5360 1440 5340 1440 {}
C {lab_pin.sym} 5340 1440 0 0 {name=l1256 lab=BL27}
N 5360 1400 5340 1400 {}
C {lab_pin.sym} 5340 1400 0 0 {name=l1257 lab=BLB27}
N 5360 1360 5340 1360 {}
C {lab_pin.sym} 5340 1360 0 0 {name=l1258 lab=WL7}
N 5440 1440 5460 1440 {}
C {lab_pin.sym} 5460 1440 0 0 {name=l1259 lab=VDD}
N 5440 1360 5460 1360 {}
C {lab_pin.sym} 5460 1360 0 0 {name=l1260 lab=VSS}
C {bitcell_6t.sym} 5600 1400 0 0 {name=Xr7c28}
N 5560 1440 5540 1440 {}
C {lab_pin.sym} 5540 1440 0 0 {name=l1261 lab=BL28}
N 5560 1400 5540 1400 {}
C {lab_pin.sym} 5540 1400 0 0 {name=l1262 lab=BLB28}
N 5560 1360 5540 1360 {}
C {lab_pin.sym} 5540 1360 0 0 {name=l1263 lab=WL7}
N 5640 1440 5660 1440 {}
C {lab_pin.sym} 5660 1440 0 0 {name=l1264 lab=VDD}
N 5640 1360 5660 1360 {}
C {lab_pin.sym} 5660 1360 0 0 {name=l1265 lab=VSS}
C {bitcell_6t.sym} 5800 1400 0 0 {name=Xr7c29}
N 5760 1440 5740 1440 {}
C {lab_pin.sym} 5740 1440 0 0 {name=l1266 lab=BL29}
N 5760 1400 5740 1400 {}
C {lab_pin.sym} 5740 1400 0 0 {name=l1267 lab=BLB29}
N 5760 1360 5740 1360 {}
C {lab_pin.sym} 5740 1360 0 0 {name=l1268 lab=WL7}
N 5840 1440 5860 1440 {}
C {lab_pin.sym} 5860 1440 0 0 {name=l1269 lab=VDD}
N 5840 1360 5860 1360 {}
C {lab_pin.sym} 5860 1360 0 0 {name=l1270 lab=VSS}
C {bitcell_6t.sym} 6000 1400 0 0 {name=Xr7c30}
N 5960 1440 5940 1440 {}
C {lab_pin.sym} 5940 1440 0 0 {name=l1271 lab=BL30}
N 5960 1400 5940 1400 {}
C {lab_pin.sym} 5940 1400 0 0 {name=l1272 lab=BLB30}
N 5960 1360 5940 1360 {}
C {lab_pin.sym} 5940 1360 0 0 {name=l1273 lab=WL7}
N 6040 1440 6060 1440 {}
C {lab_pin.sym} 6060 1440 0 0 {name=l1274 lab=VDD}
N 6040 1360 6060 1360 {}
C {lab_pin.sym} 6060 1360 0 0 {name=l1275 lab=VSS}
C {bitcell_6t.sym} 6200 1400 0 0 {name=Xr7c31}
N 6160 1440 6140 1440 {}
C {lab_pin.sym} 6140 1440 0 0 {name=l1276 lab=BL31}
N 6160 1400 6140 1400 {}
C {lab_pin.sym} 6140 1400 0 0 {name=l1277 lab=BLB31}
N 6160 1360 6140 1360 {}
C {lab_pin.sym} 6140 1360 0 0 {name=l1278 lab=WL7}
N 6240 1440 6260 1440 {}
C {lab_pin.sym} 6260 1440 0 0 {name=l1279 lab=VDD}
N 6240 1360 6260 1360 {}
C {lab_pin.sym} 6260 1360 0 0 {name=l1280 lab=VSS}
C {bitcell_6t.sym} 0 1600 0 0 {name=Xr8c0}
N -40 1640 -60 1640 {}
C {lab_pin.sym} -60 1640 0 0 {name=l1281 lab=BL0}
N -40 1600 -60 1600 {}
C {lab_pin.sym} -60 1600 0 0 {name=l1282 lab=BLB0}
N -40 1560 -60 1560 {}
C {lab_pin.sym} -60 1560 0 0 {name=l1283 lab=WL8}
N 40 1640 60 1640 {}
C {lab_pin.sym} 60 1640 0 0 {name=l1284 lab=VDD}
N 40 1560 60 1560 {}
C {lab_pin.sym} 60 1560 0 0 {name=l1285 lab=VSS}
C {bitcell_6t.sym} 200 1600 0 0 {name=Xr8c1}
N 160 1640 140 1640 {}
C {lab_pin.sym} 140 1640 0 0 {name=l1286 lab=BL1}
N 160 1600 140 1600 {}
C {lab_pin.sym} 140 1600 0 0 {name=l1287 lab=BLB1}
N 160 1560 140 1560 {}
C {lab_pin.sym} 140 1560 0 0 {name=l1288 lab=WL8}
N 240 1640 260 1640 {}
C {lab_pin.sym} 260 1640 0 0 {name=l1289 lab=VDD}
N 240 1560 260 1560 {}
C {lab_pin.sym} 260 1560 0 0 {name=l1290 lab=VSS}
C {bitcell_6t.sym} 400 1600 0 0 {name=Xr8c2}
N 360 1640 340 1640 {}
C {lab_pin.sym} 340 1640 0 0 {name=l1291 lab=BL2}
N 360 1600 340 1600 {}
C {lab_pin.sym} 340 1600 0 0 {name=l1292 lab=BLB2}
N 360 1560 340 1560 {}
C {lab_pin.sym} 340 1560 0 0 {name=l1293 lab=WL8}
N 440 1640 460 1640 {}
C {lab_pin.sym} 460 1640 0 0 {name=l1294 lab=VDD}
N 440 1560 460 1560 {}
C {lab_pin.sym} 460 1560 0 0 {name=l1295 lab=VSS}
C {bitcell_6t.sym} 600 1600 0 0 {name=Xr8c3}
N 560 1640 540 1640 {}
C {lab_pin.sym} 540 1640 0 0 {name=l1296 lab=BL3}
N 560 1600 540 1600 {}
C {lab_pin.sym} 540 1600 0 0 {name=l1297 lab=BLB3}
N 560 1560 540 1560 {}
C {lab_pin.sym} 540 1560 0 0 {name=l1298 lab=WL8}
N 640 1640 660 1640 {}
C {lab_pin.sym} 660 1640 0 0 {name=l1299 lab=VDD}
N 640 1560 660 1560 {}
C {lab_pin.sym} 660 1560 0 0 {name=l1300 lab=VSS}
C {bitcell_6t.sym} 800 1600 0 0 {name=Xr8c4}
N 760 1640 740 1640 {}
C {lab_pin.sym} 740 1640 0 0 {name=l1301 lab=BL4}
N 760 1600 740 1600 {}
C {lab_pin.sym} 740 1600 0 0 {name=l1302 lab=BLB4}
N 760 1560 740 1560 {}
C {lab_pin.sym} 740 1560 0 0 {name=l1303 lab=WL8}
N 840 1640 860 1640 {}
C {lab_pin.sym} 860 1640 0 0 {name=l1304 lab=VDD}
N 840 1560 860 1560 {}
C {lab_pin.sym} 860 1560 0 0 {name=l1305 lab=VSS}
C {bitcell_6t.sym} 1000 1600 0 0 {name=Xr8c5}
N 960 1640 940 1640 {}
C {lab_pin.sym} 940 1640 0 0 {name=l1306 lab=BL5}
N 960 1600 940 1600 {}
C {lab_pin.sym} 940 1600 0 0 {name=l1307 lab=BLB5}
N 960 1560 940 1560 {}
C {lab_pin.sym} 940 1560 0 0 {name=l1308 lab=WL8}
N 1040 1640 1060 1640 {}
C {lab_pin.sym} 1060 1640 0 0 {name=l1309 lab=VDD}
N 1040 1560 1060 1560 {}
C {lab_pin.sym} 1060 1560 0 0 {name=l1310 lab=VSS}
C {bitcell_6t.sym} 1200 1600 0 0 {name=Xr8c6}
N 1160 1640 1140 1640 {}
C {lab_pin.sym} 1140 1640 0 0 {name=l1311 lab=BL6}
N 1160 1600 1140 1600 {}
C {lab_pin.sym} 1140 1600 0 0 {name=l1312 lab=BLB6}
N 1160 1560 1140 1560 {}
C {lab_pin.sym} 1140 1560 0 0 {name=l1313 lab=WL8}
N 1240 1640 1260 1640 {}
C {lab_pin.sym} 1260 1640 0 0 {name=l1314 lab=VDD}
N 1240 1560 1260 1560 {}
C {lab_pin.sym} 1260 1560 0 0 {name=l1315 lab=VSS}
C {bitcell_6t.sym} 1400 1600 0 0 {name=Xr8c7}
N 1360 1640 1340 1640 {}
C {lab_pin.sym} 1340 1640 0 0 {name=l1316 lab=BL7}
N 1360 1600 1340 1600 {}
C {lab_pin.sym} 1340 1600 0 0 {name=l1317 lab=BLB7}
N 1360 1560 1340 1560 {}
C {lab_pin.sym} 1340 1560 0 0 {name=l1318 lab=WL8}
N 1440 1640 1460 1640 {}
C {lab_pin.sym} 1460 1640 0 0 {name=l1319 lab=VDD}
N 1440 1560 1460 1560 {}
C {lab_pin.sym} 1460 1560 0 0 {name=l1320 lab=VSS}
C {bitcell_6t.sym} 1600 1600 0 0 {name=Xr8c8}
N 1560 1640 1540 1640 {}
C {lab_pin.sym} 1540 1640 0 0 {name=l1321 lab=BL8}
N 1560 1600 1540 1600 {}
C {lab_pin.sym} 1540 1600 0 0 {name=l1322 lab=BLB8}
N 1560 1560 1540 1560 {}
C {lab_pin.sym} 1540 1560 0 0 {name=l1323 lab=WL8}
N 1640 1640 1660 1640 {}
C {lab_pin.sym} 1660 1640 0 0 {name=l1324 lab=VDD}
N 1640 1560 1660 1560 {}
C {lab_pin.sym} 1660 1560 0 0 {name=l1325 lab=VSS}
C {bitcell_6t.sym} 1800 1600 0 0 {name=Xr8c9}
N 1760 1640 1740 1640 {}
C {lab_pin.sym} 1740 1640 0 0 {name=l1326 lab=BL9}
N 1760 1600 1740 1600 {}
C {lab_pin.sym} 1740 1600 0 0 {name=l1327 lab=BLB9}
N 1760 1560 1740 1560 {}
C {lab_pin.sym} 1740 1560 0 0 {name=l1328 lab=WL8}
N 1840 1640 1860 1640 {}
C {lab_pin.sym} 1860 1640 0 0 {name=l1329 lab=VDD}
N 1840 1560 1860 1560 {}
C {lab_pin.sym} 1860 1560 0 0 {name=l1330 lab=VSS}
C {bitcell_6t.sym} 2000 1600 0 0 {name=Xr8c10}
N 1960 1640 1940 1640 {}
C {lab_pin.sym} 1940 1640 0 0 {name=l1331 lab=BL10}
N 1960 1600 1940 1600 {}
C {lab_pin.sym} 1940 1600 0 0 {name=l1332 lab=BLB10}
N 1960 1560 1940 1560 {}
C {lab_pin.sym} 1940 1560 0 0 {name=l1333 lab=WL8}
N 2040 1640 2060 1640 {}
C {lab_pin.sym} 2060 1640 0 0 {name=l1334 lab=VDD}
N 2040 1560 2060 1560 {}
C {lab_pin.sym} 2060 1560 0 0 {name=l1335 lab=VSS}
C {bitcell_6t.sym} 2200 1600 0 0 {name=Xr8c11}
N 2160 1640 2140 1640 {}
C {lab_pin.sym} 2140 1640 0 0 {name=l1336 lab=BL11}
N 2160 1600 2140 1600 {}
C {lab_pin.sym} 2140 1600 0 0 {name=l1337 lab=BLB11}
N 2160 1560 2140 1560 {}
C {lab_pin.sym} 2140 1560 0 0 {name=l1338 lab=WL8}
N 2240 1640 2260 1640 {}
C {lab_pin.sym} 2260 1640 0 0 {name=l1339 lab=VDD}
N 2240 1560 2260 1560 {}
C {lab_pin.sym} 2260 1560 0 0 {name=l1340 lab=VSS}
C {bitcell_6t.sym} 2400 1600 0 0 {name=Xr8c12}
N 2360 1640 2340 1640 {}
C {lab_pin.sym} 2340 1640 0 0 {name=l1341 lab=BL12}
N 2360 1600 2340 1600 {}
C {lab_pin.sym} 2340 1600 0 0 {name=l1342 lab=BLB12}
N 2360 1560 2340 1560 {}
C {lab_pin.sym} 2340 1560 0 0 {name=l1343 lab=WL8}
N 2440 1640 2460 1640 {}
C {lab_pin.sym} 2460 1640 0 0 {name=l1344 lab=VDD}
N 2440 1560 2460 1560 {}
C {lab_pin.sym} 2460 1560 0 0 {name=l1345 lab=VSS}
C {bitcell_6t.sym} 2600 1600 0 0 {name=Xr8c13}
N 2560 1640 2540 1640 {}
C {lab_pin.sym} 2540 1640 0 0 {name=l1346 lab=BL13}
N 2560 1600 2540 1600 {}
C {lab_pin.sym} 2540 1600 0 0 {name=l1347 lab=BLB13}
N 2560 1560 2540 1560 {}
C {lab_pin.sym} 2540 1560 0 0 {name=l1348 lab=WL8}
N 2640 1640 2660 1640 {}
C {lab_pin.sym} 2660 1640 0 0 {name=l1349 lab=VDD}
N 2640 1560 2660 1560 {}
C {lab_pin.sym} 2660 1560 0 0 {name=l1350 lab=VSS}
C {bitcell_6t.sym} 2800 1600 0 0 {name=Xr8c14}
N 2760 1640 2740 1640 {}
C {lab_pin.sym} 2740 1640 0 0 {name=l1351 lab=BL14}
N 2760 1600 2740 1600 {}
C {lab_pin.sym} 2740 1600 0 0 {name=l1352 lab=BLB14}
N 2760 1560 2740 1560 {}
C {lab_pin.sym} 2740 1560 0 0 {name=l1353 lab=WL8}
N 2840 1640 2860 1640 {}
C {lab_pin.sym} 2860 1640 0 0 {name=l1354 lab=VDD}
N 2840 1560 2860 1560 {}
C {lab_pin.sym} 2860 1560 0 0 {name=l1355 lab=VSS}
C {bitcell_6t.sym} 3000 1600 0 0 {name=Xr8c15}
N 2960 1640 2940 1640 {}
C {lab_pin.sym} 2940 1640 0 0 {name=l1356 lab=BL15}
N 2960 1600 2940 1600 {}
C {lab_pin.sym} 2940 1600 0 0 {name=l1357 lab=BLB15}
N 2960 1560 2940 1560 {}
C {lab_pin.sym} 2940 1560 0 0 {name=l1358 lab=WL8}
N 3040 1640 3060 1640 {}
C {lab_pin.sym} 3060 1640 0 0 {name=l1359 lab=VDD}
N 3040 1560 3060 1560 {}
C {lab_pin.sym} 3060 1560 0 0 {name=l1360 lab=VSS}
C {bitcell_6t.sym} 3200 1600 0 0 {name=Xr8c16}
N 3160 1640 3140 1640 {}
C {lab_pin.sym} 3140 1640 0 0 {name=l1361 lab=BL16}
N 3160 1600 3140 1600 {}
C {lab_pin.sym} 3140 1600 0 0 {name=l1362 lab=BLB16}
N 3160 1560 3140 1560 {}
C {lab_pin.sym} 3140 1560 0 0 {name=l1363 lab=WL8}
N 3240 1640 3260 1640 {}
C {lab_pin.sym} 3260 1640 0 0 {name=l1364 lab=VDD}
N 3240 1560 3260 1560 {}
C {lab_pin.sym} 3260 1560 0 0 {name=l1365 lab=VSS}
C {bitcell_6t.sym} 3400 1600 0 0 {name=Xr8c17}
N 3360 1640 3340 1640 {}
C {lab_pin.sym} 3340 1640 0 0 {name=l1366 lab=BL17}
N 3360 1600 3340 1600 {}
C {lab_pin.sym} 3340 1600 0 0 {name=l1367 lab=BLB17}
N 3360 1560 3340 1560 {}
C {lab_pin.sym} 3340 1560 0 0 {name=l1368 lab=WL8}
N 3440 1640 3460 1640 {}
C {lab_pin.sym} 3460 1640 0 0 {name=l1369 lab=VDD}
N 3440 1560 3460 1560 {}
C {lab_pin.sym} 3460 1560 0 0 {name=l1370 lab=VSS}
C {bitcell_6t.sym} 3600 1600 0 0 {name=Xr8c18}
N 3560 1640 3540 1640 {}
C {lab_pin.sym} 3540 1640 0 0 {name=l1371 lab=BL18}
N 3560 1600 3540 1600 {}
C {lab_pin.sym} 3540 1600 0 0 {name=l1372 lab=BLB18}
N 3560 1560 3540 1560 {}
C {lab_pin.sym} 3540 1560 0 0 {name=l1373 lab=WL8}
N 3640 1640 3660 1640 {}
C {lab_pin.sym} 3660 1640 0 0 {name=l1374 lab=VDD}
N 3640 1560 3660 1560 {}
C {lab_pin.sym} 3660 1560 0 0 {name=l1375 lab=VSS}
C {bitcell_6t.sym} 3800 1600 0 0 {name=Xr8c19}
N 3760 1640 3740 1640 {}
C {lab_pin.sym} 3740 1640 0 0 {name=l1376 lab=BL19}
N 3760 1600 3740 1600 {}
C {lab_pin.sym} 3740 1600 0 0 {name=l1377 lab=BLB19}
N 3760 1560 3740 1560 {}
C {lab_pin.sym} 3740 1560 0 0 {name=l1378 lab=WL8}
N 3840 1640 3860 1640 {}
C {lab_pin.sym} 3860 1640 0 0 {name=l1379 lab=VDD}
N 3840 1560 3860 1560 {}
C {lab_pin.sym} 3860 1560 0 0 {name=l1380 lab=VSS}
C {bitcell_6t.sym} 4000 1600 0 0 {name=Xr8c20}
N 3960 1640 3940 1640 {}
C {lab_pin.sym} 3940 1640 0 0 {name=l1381 lab=BL20}
N 3960 1600 3940 1600 {}
C {lab_pin.sym} 3940 1600 0 0 {name=l1382 lab=BLB20}
N 3960 1560 3940 1560 {}
C {lab_pin.sym} 3940 1560 0 0 {name=l1383 lab=WL8}
N 4040 1640 4060 1640 {}
C {lab_pin.sym} 4060 1640 0 0 {name=l1384 lab=VDD}
N 4040 1560 4060 1560 {}
C {lab_pin.sym} 4060 1560 0 0 {name=l1385 lab=VSS}
C {bitcell_6t.sym} 4200 1600 0 0 {name=Xr8c21}
N 4160 1640 4140 1640 {}
C {lab_pin.sym} 4140 1640 0 0 {name=l1386 lab=BL21}
N 4160 1600 4140 1600 {}
C {lab_pin.sym} 4140 1600 0 0 {name=l1387 lab=BLB21}
N 4160 1560 4140 1560 {}
C {lab_pin.sym} 4140 1560 0 0 {name=l1388 lab=WL8}
N 4240 1640 4260 1640 {}
C {lab_pin.sym} 4260 1640 0 0 {name=l1389 lab=VDD}
N 4240 1560 4260 1560 {}
C {lab_pin.sym} 4260 1560 0 0 {name=l1390 lab=VSS}
C {bitcell_6t.sym} 4400 1600 0 0 {name=Xr8c22}
N 4360 1640 4340 1640 {}
C {lab_pin.sym} 4340 1640 0 0 {name=l1391 lab=BL22}
N 4360 1600 4340 1600 {}
C {lab_pin.sym} 4340 1600 0 0 {name=l1392 lab=BLB22}
N 4360 1560 4340 1560 {}
C {lab_pin.sym} 4340 1560 0 0 {name=l1393 lab=WL8}
N 4440 1640 4460 1640 {}
C {lab_pin.sym} 4460 1640 0 0 {name=l1394 lab=VDD}
N 4440 1560 4460 1560 {}
C {lab_pin.sym} 4460 1560 0 0 {name=l1395 lab=VSS}
C {bitcell_6t.sym} 4600 1600 0 0 {name=Xr8c23}
N 4560 1640 4540 1640 {}
C {lab_pin.sym} 4540 1640 0 0 {name=l1396 lab=BL23}
N 4560 1600 4540 1600 {}
C {lab_pin.sym} 4540 1600 0 0 {name=l1397 lab=BLB23}
N 4560 1560 4540 1560 {}
C {lab_pin.sym} 4540 1560 0 0 {name=l1398 lab=WL8}
N 4640 1640 4660 1640 {}
C {lab_pin.sym} 4660 1640 0 0 {name=l1399 lab=VDD}
N 4640 1560 4660 1560 {}
C {lab_pin.sym} 4660 1560 0 0 {name=l1400 lab=VSS}
C {bitcell_6t.sym} 4800 1600 0 0 {name=Xr8c24}
N 4760 1640 4740 1640 {}
C {lab_pin.sym} 4740 1640 0 0 {name=l1401 lab=BL24}
N 4760 1600 4740 1600 {}
C {lab_pin.sym} 4740 1600 0 0 {name=l1402 lab=BLB24}
N 4760 1560 4740 1560 {}
C {lab_pin.sym} 4740 1560 0 0 {name=l1403 lab=WL8}
N 4840 1640 4860 1640 {}
C {lab_pin.sym} 4860 1640 0 0 {name=l1404 lab=VDD}
N 4840 1560 4860 1560 {}
C {lab_pin.sym} 4860 1560 0 0 {name=l1405 lab=VSS}
C {bitcell_6t.sym} 5000 1600 0 0 {name=Xr8c25}
N 4960 1640 4940 1640 {}
C {lab_pin.sym} 4940 1640 0 0 {name=l1406 lab=BL25}
N 4960 1600 4940 1600 {}
C {lab_pin.sym} 4940 1600 0 0 {name=l1407 lab=BLB25}
N 4960 1560 4940 1560 {}
C {lab_pin.sym} 4940 1560 0 0 {name=l1408 lab=WL8}
N 5040 1640 5060 1640 {}
C {lab_pin.sym} 5060 1640 0 0 {name=l1409 lab=VDD}
N 5040 1560 5060 1560 {}
C {lab_pin.sym} 5060 1560 0 0 {name=l1410 lab=VSS}
C {bitcell_6t.sym} 5200 1600 0 0 {name=Xr8c26}
N 5160 1640 5140 1640 {}
C {lab_pin.sym} 5140 1640 0 0 {name=l1411 lab=BL26}
N 5160 1600 5140 1600 {}
C {lab_pin.sym} 5140 1600 0 0 {name=l1412 lab=BLB26}
N 5160 1560 5140 1560 {}
C {lab_pin.sym} 5140 1560 0 0 {name=l1413 lab=WL8}
N 5240 1640 5260 1640 {}
C {lab_pin.sym} 5260 1640 0 0 {name=l1414 lab=VDD}
N 5240 1560 5260 1560 {}
C {lab_pin.sym} 5260 1560 0 0 {name=l1415 lab=VSS}
C {bitcell_6t.sym} 5400 1600 0 0 {name=Xr8c27}
N 5360 1640 5340 1640 {}
C {lab_pin.sym} 5340 1640 0 0 {name=l1416 lab=BL27}
N 5360 1600 5340 1600 {}
C {lab_pin.sym} 5340 1600 0 0 {name=l1417 lab=BLB27}
N 5360 1560 5340 1560 {}
C {lab_pin.sym} 5340 1560 0 0 {name=l1418 lab=WL8}
N 5440 1640 5460 1640 {}
C {lab_pin.sym} 5460 1640 0 0 {name=l1419 lab=VDD}
N 5440 1560 5460 1560 {}
C {lab_pin.sym} 5460 1560 0 0 {name=l1420 lab=VSS}
C {bitcell_6t.sym} 5600 1600 0 0 {name=Xr8c28}
N 5560 1640 5540 1640 {}
C {lab_pin.sym} 5540 1640 0 0 {name=l1421 lab=BL28}
N 5560 1600 5540 1600 {}
C {lab_pin.sym} 5540 1600 0 0 {name=l1422 lab=BLB28}
N 5560 1560 5540 1560 {}
C {lab_pin.sym} 5540 1560 0 0 {name=l1423 lab=WL8}
N 5640 1640 5660 1640 {}
C {lab_pin.sym} 5660 1640 0 0 {name=l1424 lab=VDD}
N 5640 1560 5660 1560 {}
C {lab_pin.sym} 5660 1560 0 0 {name=l1425 lab=VSS}
C {bitcell_6t.sym} 5800 1600 0 0 {name=Xr8c29}
N 5760 1640 5740 1640 {}
C {lab_pin.sym} 5740 1640 0 0 {name=l1426 lab=BL29}
N 5760 1600 5740 1600 {}
C {lab_pin.sym} 5740 1600 0 0 {name=l1427 lab=BLB29}
N 5760 1560 5740 1560 {}
C {lab_pin.sym} 5740 1560 0 0 {name=l1428 lab=WL8}
N 5840 1640 5860 1640 {}
C {lab_pin.sym} 5860 1640 0 0 {name=l1429 lab=VDD}
N 5840 1560 5860 1560 {}
C {lab_pin.sym} 5860 1560 0 0 {name=l1430 lab=VSS}
C {bitcell_6t.sym} 6000 1600 0 0 {name=Xr8c30}
N 5960 1640 5940 1640 {}
C {lab_pin.sym} 5940 1640 0 0 {name=l1431 lab=BL30}
N 5960 1600 5940 1600 {}
C {lab_pin.sym} 5940 1600 0 0 {name=l1432 lab=BLB30}
N 5960 1560 5940 1560 {}
C {lab_pin.sym} 5940 1560 0 0 {name=l1433 lab=WL8}
N 6040 1640 6060 1640 {}
C {lab_pin.sym} 6060 1640 0 0 {name=l1434 lab=VDD}
N 6040 1560 6060 1560 {}
C {lab_pin.sym} 6060 1560 0 0 {name=l1435 lab=VSS}
C {bitcell_6t.sym} 6200 1600 0 0 {name=Xr8c31}
N 6160 1640 6140 1640 {}
C {lab_pin.sym} 6140 1640 0 0 {name=l1436 lab=BL31}
N 6160 1600 6140 1600 {}
C {lab_pin.sym} 6140 1600 0 0 {name=l1437 lab=BLB31}
N 6160 1560 6140 1560 {}
C {lab_pin.sym} 6140 1560 0 0 {name=l1438 lab=WL8}
N 6240 1640 6260 1640 {}
C {lab_pin.sym} 6260 1640 0 0 {name=l1439 lab=VDD}
N 6240 1560 6260 1560 {}
C {lab_pin.sym} 6260 1560 0 0 {name=l1440 lab=VSS}
C {bitcell_6t.sym} 0 1800 0 0 {name=Xr9c0}
N -40 1840 -60 1840 {}
C {lab_pin.sym} -60 1840 0 0 {name=l1441 lab=BL0}
N -40 1800 -60 1800 {}
C {lab_pin.sym} -60 1800 0 0 {name=l1442 lab=BLB0}
N -40 1760 -60 1760 {}
C {lab_pin.sym} -60 1760 0 0 {name=l1443 lab=WL9}
N 40 1840 60 1840 {}
C {lab_pin.sym} 60 1840 0 0 {name=l1444 lab=VDD}
N 40 1760 60 1760 {}
C {lab_pin.sym} 60 1760 0 0 {name=l1445 lab=VSS}
C {bitcell_6t.sym} 200 1800 0 0 {name=Xr9c1}
N 160 1840 140 1840 {}
C {lab_pin.sym} 140 1840 0 0 {name=l1446 lab=BL1}
N 160 1800 140 1800 {}
C {lab_pin.sym} 140 1800 0 0 {name=l1447 lab=BLB1}
N 160 1760 140 1760 {}
C {lab_pin.sym} 140 1760 0 0 {name=l1448 lab=WL9}
N 240 1840 260 1840 {}
C {lab_pin.sym} 260 1840 0 0 {name=l1449 lab=VDD}
N 240 1760 260 1760 {}
C {lab_pin.sym} 260 1760 0 0 {name=l1450 lab=VSS}
C {bitcell_6t.sym} 400 1800 0 0 {name=Xr9c2}
N 360 1840 340 1840 {}
C {lab_pin.sym} 340 1840 0 0 {name=l1451 lab=BL2}
N 360 1800 340 1800 {}
C {lab_pin.sym} 340 1800 0 0 {name=l1452 lab=BLB2}
N 360 1760 340 1760 {}
C {lab_pin.sym} 340 1760 0 0 {name=l1453 lab=WL9}
N 440 1840 460 1840 {}
C {lab_pin.sym} 460 1840 0 0 {name=l1454 lab=VDD}
N 440 1760 460 1760 {}
C {lab_pin.sym} 460 1760 0 0 {name=l1455 lab=VSS}
C {bitcell_6t.sym} 600 1800 0 0 {name=Xr9c3}
N 560 1840 540 1840 {}
C {lab_pin.sym} 540 1840 0 0 {name=l1456 lab=BL3}
N 560 1800 540 1800 {}
C {lab_pin.sym} 540 1800 0 0 {name=l1457 lab=BLB3}
N 560 1760 540 1760 {}
C {lab_pin.sym} 540 1760 0 0 {name=l1458 lab=WL9}
N 640 1840 660 1840 {}
C {lab_pin.sym} 660 1840 0 0 {name=l1459 lab=VDD}
N 640 1760 660 1760 {}
C {lab_pin.sym} 660 1760 0 0 {name=l1460 lab=VSS}
C {bitcell_6t.sym} 800 1800 0 0 {name=Xr9c4}
N 760 1840 740 1840 {}
C {lab_pin.sym} 740 1840 0 0 {name=l1461 lab=BL4}
N 760 1800 740 1800 {}
C {lab_pin.sym} 740 1800 0 0 {name=l1462 lab=BLB4}
N 760 1760 740 1760 {}
C {lab_pin.sym} 740 1760 0 0 {name=l1463 lab=WL9}
N 840 1840 860 1840 {}
C {lab_pin.sym} 860 1840 0 0 {name=l1464 lab=VDD}
N 840 1760 860 1760 {}
C {lab_pin.sym} 860 1760 0 0 {name=l1465 lab=VSS}
C {bitcell_6t.sym} 1000 1800 0 0 {name=Xr9c5}
N 960 1840 940 1840 {}
C {lab_pin.sym} 940 1840 0 0 {name=l1466 lab=BL5}
N 960 1800 940 1800 {}
C {lab_pin.sym} 940 1800 0 0 {name=l1467 lab=BLB5}
N 960 1760 940 1760 {}
C {lab_pin.sym} 940 1760 0 0 {name=l1468 lab=WL9}
N 1040 1840 1060 1840 {}
C {lab_pin.sym} 1060 1840 0 0 {name=l1469 lab=VDD}
N 1040 1760 1060 1760 {}
C {lab_pin.sym} 1060 1760 0 0 {name=l1470 lab=VSS}
C {bitcell_6t.sym} 1200 1800 0 0 {name=Xr9c6}
N 1160 1840 1140 1840 {}
C {lab_pin.sym} 1140 1840 0 0 {name=l1471 lab=BL6}
N 1160 1800 1140 1800 {}
C {lab_pin.sym} 1140 1800 0 0 {name=l1472 lab=BLB6}
N 1160 1760 1140 1760 {}
C {lab_pin.sym} 1140 1760 0 0 {name=l1473 lab=WL9}
N 1240 1840 1260 1840 {}
C {lab_pin.sym} 1260 1840 0 0 {name=l1474 lab=VDD}
N 1240 1760 1260 1760 {}
C {lab_pin.sym} 1260 1760 0 0 {name=l1475 lab=VSS}
C {bitcell_6t.sym} 1400 1800 0 0 {name=Xr9c7}
N 1360 1840 1340 1840 {}
C {lab_pin.sym} 1340 1840 0 0 {name=l1476 lab=BL7}
N 1360 1800 1340 1800 {}
C {lab_pin.sym} 1340 1800 0 0 {name=l1477 lab=BLB7}
N 1360 1760 1340 1760 {}
C {lab_pin.sym} 1340 1760 0 0 {name=l1478 lab=WL9}
N 1440 1840 1460 1840 {}
C {lab_pin.sym} 1460 1840 0 0 {name=l1479 lab=VDD}
N 1440 1760 1460 1760 {}
C {lab_pin.sym} 1460 1760 0 0 {name=l1480 lab=VSS}
C {bitcell_6t.sym} 1600 1800 0 0 {name=Xr9c8}
N 1560 1840 1540 1840 {}
C {lab_pin.sym} 1540 1840 0 0 {name=l1481 lab=BL8}
N 1560 1800 1540 1800 {}
C {lab_pin.sym} 1540 1800 0 0 {name=l1482 lab=BLB8}
N 1560 1760 1540 1760 {}
C {lab_pin.sym} 1540 1760 0 0 {name=l1483 lab=WL9}
N 1640 1840 1660 1840 {}
C {lab_pin.sym} 1660 1840 0 0 {name=l1484 lab=VDD}
N 1640 1760 1660 1760 {}
C {lab_pin.sym} 1660 1760 0 0 {name=l1485 lab=VSS}
C {bitcell_6t.sym} 1800 1800 0 0 {name=Xr9c9}
N 1760 1840 1740 1840 {}
C {lab_pin.sym} 1740 1840 0 0 {name=l1486 lab=BL9}
N 1760 1800 1740 1800 {}
C {lab_pin.sym} 1740 1800 0 0 {name=l1487 lab=BLB9}
N 1760 1760 1740 1760 {}
C {lab_pin.sym} 1740 1760 0 0 {name=l1488 lab=WL9}
N 1840 1840 1860 1840 {}
C {lab_pin.sym} 1860 1840 0 0 {name=l1489 lab=VDD}
N 1840 1760 1860 1760 {}
C {lab_pin.sym} 1860 1760 0 0 {name=l1490 lab=VSS}
C {bitcell_6t.sym} 2000 1800 0 0 {name=Xr9c10}
N 1960 1840 1940 1840 {}
C {lab_pin.sym} 1940 1840 0 0 {name=l1491 lab=BL10}
N 1960 1800 1940 1800 {}
C {lab_pin.sym} 1940 1800 0 0 {name=l1492 lab=BLB10}
N 1960 1760 1940 1760 {}
C {lab_pin.sym} 1940 1760 0 0 {name=l1493 lab=WL9}
N 2040 1840 2060 1840 {}
C {lab_pin.sym} 2060 1840 0 0 {name=l1494 lab=VDD}
N 2040 1760 2060 1760 {}
C {lab_pin.sym} 2060 1760 0 0 {name=l1495 lab=VSS}
C {bitcell_6t.sym} 2200 1800 0 0 {name=Xr9c11}
N 2160 1840 2140 1840 {}
C {lab_pin.sym} 2140 1840 0 0 {name=l1496 lab=BL11}
N 2160 1800 2140 1800 {}
C {lab_pin.sym} 2140 1800 0 0 {name=l1497 lab=BLB11}
N 2160 1760 2140 1760 {}
C {lab_pin.sym} 2140 1760 0 0 {name=l1498 lab=WL9}
N 2240 1840 2260 1840 {}
C {lab_pin.sym} 2260 1840 0 0 {name=l1499 lab=VDD}
N 2240 1760 2260 1760 {}
C {lab_pin.sym} 2260 1760 0 0 {name=l1500 lab=VSS}
C {bitcell_6t.sym} 2400 1800 0 0 {name=Xr9c12}
N 2360 1840 2340 1840 {}
C {lab_pin.sym} 2340 1840 0 0 {name=l1501 lab=BL12}
N 2360 1800 2340 1800 {}
C {lab_pin.sym} 2340 1800 0 0 {name=l1502 lab=BLB12}
N 2360 1760 2340 1760 {}
C {lab_pin.sym} 2340 1760 0 0 {name=l1503 lab=WL9}
N 2440 1840 2460 1840 {}
C {lab_pin.sym} 2460 1840 0 0 {name=l1504 lab=VDD}
N 2440 1760 2460 1760 {}
C {lab_pin.sym} 2460 1760 0 0 {name=l1505 lab=VSS}
C {bitcell_6t.sym} 2600 1800 0 0 {name=Xr9c13}
N 2560 1840 2540 1840 {}
C {lab_pin.sym} 2540 1840 0 0 {name=l1506 lab=BL13}
N 2560 1800 2540 1800 {}
C {lab_pin.sym} 2540 1800 0 0 {name=l1507 lab=BLB13}
N 2560 1760 2540 1760 {}
C {lab_pin.sym} 2540 1760 0 0 {name=l1508 lab=WL9}
N 2640 1840 2660 1840 {}
C {lab_pin.sym} 2660 1840 0 0 {name=l1509 lab=VDD}
N 2640 1760 2660 1760 {}
C {lab_pin.sym} 2660 1760 0 0 {name=l1510 lab=VSS}
C {bitcell_6t.sym} 2800 1800 0 0 {name=Xr9c14}
N 2760 1840 2740 1840 {}
C {lab_pin.sym} 2740 1840 0 0 {name=l1511 lab=BL14}
N 2760 1800 2740 1800 {}
C {lab_pin.sym} 2740 1800 0 0 {name=l1512 lab=BLB14}
N 2760 1760 2740 1760 {}
C {lab_pin.sym} 2740 1760 0 0 {name=l1513 lab=WL9}
N 2840 1840 2860 1840 {}
C {lab_pin.sym} 2860 1840 0 0 {name=l1514 lab=VDD}
N 2840 1760 2860 1760 {}
C {lab_pin.sym} 2860 1760 0 0 {name=l1515 lab=VSS}
C {bitcell_6t.sym} 3000 1800 0 0 {name=Xr9c15}
N 2960 1840 2940 1840 {}
C {lab_pin.sym} 2940 1840 0 0 {name=l1516 lab=BL15}
N 2960 1800 2940 1800 {}
C {lab_pin.sym} 2940 1800 0 0 {name=l1517 lab=BLB15}
N 2960 1760 2940 1760 {}
C {lab_pin.sym} 2940 1760 0 0 {name=l1518 lab=WL9}
N 3040 1840 3060 1840 {}
C {lab_pin.sym} 3060 1840 0 0 {name=l1519 lab=VDD}
N 3040 1760 3060 1760 {}
C {lab_pin.sym} 3060 1760 0 0 {name=l1520 lab=VSS}
C {bitcell_6t.sym} 3200 1800 0 0 {name=Xr9c16}
N 3160 1840 3140 1840 {}
C {lab_pin.sym} 3140 1840 0 0 {name=l1521 lab=BL16}
N 3160 1800 3140 1800 {}
C {lab_pin.sym} 3140 1800 0 0 {name=l1522 lab=BLB16}
N 3160 1760 3140 1760 {}
C {lab_pin.sym} 3140 1760 0 0 {name=l1523 lab=WL9}
N 3240 1840 3260 1840 {}
C {lab_pin.sym} 3260 1840 0 0 {name=l1524 lab=VDD}
N 3240 1760 3260 1760 {}
C {lab_pin.sym} 3260 1760 0 0 {name=l1525 lab=VSS}
C {bitcell_6t.sym} 3400 1800 0 0 {name=Xr9c17}
N 3360 1840 3340 1840 {}
C {lab_pin.sym} 3340 1840 0 0 {name=l1526 lab=BL17}
N 3360 1800 3340 1800 {}
C {lab_pin.sym} 3340 1800 0 0 {name=l1527 lab=BLB17}
N 3360 1760 3340 1760 {}
C {lab_pin.sym} 3340 1760 0 0 {name=l1528 lab=WL9}
N 3440 1840 3460 1840 {}
C {lab_pin.sym} 3460 1840 0 0 {name=l1529 lab=VDD}
N 3440 1760 3460 1760 {}
C {lab_pin.sym} 3460 1760 0 0 {name=l1530 lab=VSS}
C {bitcell_6t.sym} 3600 1800 0 0 {name=Xr9c18}
N 3560 1840 3540 1840 {}
C {lab_pin.sym} 3540 1840 0 0 {name=l1531 lab=BL18}
N 3560 1800 3540 1800 {}
C {lab_pin.sym} 3540 1800 0 0 {name=l1532 lab=BLB18}
N 3560 1760 3540 1760 {}
C {lab_pin.sym} 3540 1760 0 0 {name=l1533 lab=WL9}
N 3640 1840 3660 1840 {}
C {lab_pin.sym} 3660 1840 0 0 {name=l1534 lab=VDD}
N 3640 1760 3660 1760 {}
C {lab_pin.sym} 3660 1760 0 0 {name=l1535 lab=VSS}
C {bitcell_6t.sym} 3800 1800 0 0 {name=Xr9c19}
N 3760 1840 3740 1840 {}
C {lab_pin.sym} 3740 1840 0 0 {name=l1536 lab=BL19}
N 3760 1800 3740 1800 {}
C {lab_pin.sym} 3740 1800 0 0 {name=l1537 lab=BLB19}
N 3760 1760 3740 1760 {}
C {lab_pin.sym} 3740 1760 0 0 {name=l1538 lab=WL9}
N 3840 1840 3860 1840 {}
C {lab_pin.sym} 3860 1840 0 0 {name=l1539 lab=VDD}
N 3840 1760 3860 1760 {}
C {lab_pin.sym} 3860 1760 0 0 {name=l1540 lab=VSS}
C {bitcell_6t.sym} 4000 1800 0 0 {name=Xr9c20}
N 3960 1840 3940 1840 {}
C {lab_pin.sym} 3940 1840 0 0 {name=l1541 lab=BL20}
N 3960 1800 3940 1800 {}
C {lab_pin.sym} 3940 1800 0 0 {name=l1542 lab=BLB20}
N 3960 1760 3940 1760 {}
C {lab_pin.sym} 3940 1760 0 0 {name=l1543 lab=WL9}
N 4040 1840 4060 1840 {}
C {lab_pin.sym} 4060 1840 0 0 {name=l1544 lab=VDD}
N 4040 1760 4060 1760 {}
C {lab_pin.sym} 4060 1760 0 0 {name=l1545 lab=VSS}
C {bitcell_6t.sym} 4200 1800 0 0 {name=Xr9c21}
N 4160 1840 4140 1840 {}
C {lab_pin.sym} 4140 1840 0 0 {name=l1546 lab=BL21}
N 4160 1800 4140 1800 {}
C {lab_pin.sym} 4140 1800 0 0 {name=l1547 lab=BLB21}
N 4160 1760 4140 1760 {}
C {lab_pin.sym} 4140 1760 0 0 {name=l1548 lab=WL9}
N 4240 1840 4260 1840 {}
C {lab_pin.sym} 4260 1840 0 0 {name=l1549 lab=VDD}
N 4240 1760 4260 1760 {}
C {lab_pin.sym} 4260 1760 0 0 {name=l1550 lab=VSS}
C {bitcell_6t.sym} 4400 1800 0 0 {name=Xr9c22}
N 4360 1840 4340 1840 {}
C {lab_pin.sym} 4340 1840 0 0 {name=l1551 lab=BL22}
N 4360 1800 4340 1800 {}
C {lab_pin.sym} 4340 1800 0 0 {name=l1552 lab=BLB22}
N 4360 1760 4340 1760 {}
C {lab_pin.sym} 4340 1760 0 0 {name=l1553 lab=WL9}
N 4440 1840 4460 1840 {}
C {lab_pin.sym} 4460 1840 0 0 {name=l1554 lab=VDD}
N 4440 1760 4460 1760 {}
C {lab_pin.sym} 4460 1760 0 0 {name=l1555 lab=VSS}
C {bitcell_6t.sym} 4600 1800 0 0 {name=Xr9c23}
N 4560 1840 4540 1840 {}
C {lab_pin.sym} 4540 1840 0 0 {name=l1556 lab=BL23}
N 4560 1800 4540 1800 {}
C {lab_pin.sym} 4540 1800 0 0 {name=l1557 lab=BLB23}
N 4560 1760 4540 1760 {}
C {lab_pin.sym} 4540 1760 0 0 {name=l1558 lab=WL9}
N 4640 1840 4660 1840 {}
C {lab_pin.sym} 4660 1840 0 0 {name=l1559 lab=VDD}
N 4640 1760 4660 1760 {}
C {lab_pin.sym} 4660 1760 0 0 {name=l1560 lab=VSS}
C {bitcell_6t.sym} 4800 1800 0 0 {name=Xr9c24}
N 4760 1840 4740 1840 {}
C {lab_pin.sym} 4740 1840 0 0 {name=l1561 lab=BL24}
N 4760 1800 4740 1800 {}
C {lab_pin.sym} 4740 1800 0 0 {name=l1562 lab=BLB24}
N 4760 1760 4740 1760 {}
C {lab_pin.sym} 4740 1760 0 0 {name=l1563 lab=WL9}
N 4840 1840 4860 1840 {}
C {lab_pin.sym} 4860 1840 0 0 {name=l1564 lab=VDD}
N 4840 1760 4860 1760 {}
C {lab_pin.sym} 4860 1760 0 0 {name=l1565 lab=VSS}
C {bitcell_6t.sym} 5000 1800 0 0 {name=Xr9c25}
N 4960 1840 4940 1840 {}
C {lab_pin.sym} 4940 1840 0 0 {name=l1566 lab=BL25}
N 4960 1800 4940 1800 {}
C {lab_pin.sym} 4940 1800 0 0 {name=l1567 lab=BLB25}
N 4960 1760 4940 1760 {}
C {lab_pin.sym} 4940 1760 0 0 {name=l1568 lab=WL9}
N 5040 1840 5060 1840 {}
C {lab_pin.sym} 5060 1840 0 0 {name=l1569 lab=VDD}
N 5040 1760 5060 1760 {}
C {lab_pin.sym} 5060 1760 0 0 {name=l1570 lab=VSS}
C {bitcell_6t.sym} 5200 1800 0 0 {name=Xr9c26}
N 5160 1840 5140 1840 {}
C {lab_pin.sym} 5140 1840 0 0 {name=l1571 lab=BL26}
N 5160 1800 5140 1800 {}
C {lab_pin.sym} 5140 1800 0 0 {name=l1572 lab=BLB26}
N 5160 1760 5140 1760 {}
C {lab_pin.sym} 5140 1760 0 0 {name=l1573 lab=WL9}
N 5240 1840 5260 1840 {}
C {lab_pin.sym} 5260 1840 0 0 {name=l1574 lab=VDD}
N 5240 1760 5260 1760 {}
C {lab_pin.sym} 5260 1760 0 0 {name=l1575 lab=VSS}
C {bitcell_6t.sym} 5400 1800 0 0 {name=Xr9c27}
N 5360 1840 5340 1840 {}
C {lab_pin.sym} 5340 1840 0 0 {name=l1576 lab=BL27}
N 5360 1800 5340 1800 {}
C {lab_pin.sym} 5340 1800 0 0 {name=l1577 lab=BLB27}
N 5360 1760 5340 1760 {}
C {lab_pin.sym} 5340 1760 0 0 {name=l1578 lab=WL9}
N 5440 1840 5460 1840 {}
C {lab_pin.sym} 5460 1840 0 0 {name=l1579 lab=VDD}
N 5440 1760 5460 1760 {}
C {lab_pin.sym} 5460 1760 0 0 {name=l1580 lab=VSS}
C {bitcell_6t.sym} 5600 1800 0 0 {name=Xr9c28}
N 5560 1840 5540 1840 {}
C {lab_pin.sym} 5540 1840 0 0 {name=l1581 lab=BL28}
N 5560 1800 5540 1800 {}
C {lab_pin.sym} 5540 1800 0 0 {name=l1582 lab=BLB28}
N 5560 1760 5540 1760 {}
C {lab_pin.sym} 5540 1760 0 0 {name=l1583 lab=WL9}
N 5640 1840 5660 1840 {}
C {lab_pin.sym} 5660 1840 0 0 {name=l1584 lab=VDD}
N 5640 1760 5660 1760 {}
C {lab_pin.sym} 5660 1760 0 0 {name=l1585 lab=VSS}
C {bitcell_6t.sym} 5800 1800 0 0 {name=Xr9c29}
N 5760 1840 5740 1840 {}
C {lab_pin.sym} 5740 1840 0 0 {name=l1586 lab=BL29}
N 5760 1800 5740 1800 {}
C {lab_pin.sym} 5740 1800 0 0 {name=l1587 lab=BLB29}
N 5760 1760 5740 1760 {}
C {lab_pin.sym} 5740 1760 0 0 {name=l1588 lab=WL9}
N 5840 1840 5860 1840 {}
C {lab_pin.sym} 5860 1840 0 0 {name=l1589 lab=VDD}
N 5840 1760 5860 1760 {}
C {lab_pin.sym} 5860 1760 0 0 {name=l1590 lab=VSS}
C {bitcell_6t.sym} 6000 1800 0 0 {name=Xr9c30}
N 5960 1840 5940 1840 {}
C {lab_pin.sym} 5940 1840 0 0 {name=l1591 lab=BL30}
N 5960 1800 5940 1800 {}
C {lab_pin.sym} 5940 1800 0 0 {name=l1592 lab=BLB30}
N 5960 1760 5940 1760 {}
C {lab_pin.sym} 5940 1760 0 0 {name=l1593 lab=WL9}
N 6040 1840 6060 1840 {}
C {lab_pin.sym} 6060 1840 0 0 {name=l1594 lab=VDD}
N 6040 1760 6060 1760 {}
C {lab_pin.sym} 6060 1760 0 0 {name=l1595 lab=VSS}
C {bitcell_6t.sym} 6200 1800 0 0 {name=Xr9c31}
N 6160 1840 6140 1840 {}
C {lab_pin.sym} 6140 1840 0 0 {name=l1596 lab=BL31}
N 6160 1800 6140 1800 {}
C {lab_pin.sym} 6140 1800 0 0 {name=l1597 lab=BLB31}
N 6160 1760 6140 1760 {}
C {lab_pin.sym} 6140 1760 0 0 {name=l1598 lab=WL9}
N 6240 1840 6260 1840 {}
C {lab_pin.sym} 6260 1840 0 0 {name=l1599 lab=VDD}
N 6240 1760 6260 1760 {}
C {lab_pin.sym} 6260 1760 0 0 {name=l1600 lab=VSS}
C {bitcell_6t.sym} 0 2000 0 0 {name=Xr10c0}
N -40 2040 -60 2040 {}
C {lab_pin.sym} -60 2040 0 0 {name=l1601 lab=BL0}
N -40 2000 -60 2000 {}
C {lab_pin.sym} -60 2000 0 0 {name=l1602 lab=BLB0}
N -40 1960 -60 1960 {}
C {lab_pin.sym} -60 1960 0 0 {name=l1603 lab=WL10}
N 40 2040 60 2040 {}
C {lab_pin.sym} 60 2040 0 0 {name=l1604 lab=VDD}
N 40 1960 60 1960 {}
C {lab_pin.sym} 60 1960 0 0 {name=l1605 lab=VSS}
C {bitcell_6t.sym} 200 2000 0 0 {name=Xr10c1}
N 160 2040 140 2040 {}
C {lab_pin.sym} 140 2040 0 0 {name=l1606 lab=BL1}
N 160 2000 140 2000 {}
C {lab_pin.sym} 140 2000 0 0 {name=l1607 lab=BLB1}
N 160 1960 140 1960 {}
C {lab_pin.sym} 140 1960 0 0 {name=l1608 lab=WL10}
N 240 2040 260 2040 {}
C {lab_pin.sym} 260 2040 0 0 {name=l1609 lab=VDD}
N 240 1960 260 1960 {}
C {lab_pin.sym} 260 1960 0 0 {name=l1610 lab=VSS}
C {bitcell_6t.sym} 400 2000 0 0 {name=Xr10c2}
N 360 2040 340 2040 {}
C {lab_pin.sym} 340 2040 0 0 {name=l1611 lab=BL2}
N 360 2000 340 2000 {}
C {lab_pin.sym} 340 2000 0 0 {name=l1612 lab=BLB2}
N 360 1960 340 1960 {}
C {lab_pin.sym} 340 1960 0 0 {name=l1613 lab=WL10}
N 440 2040 460 2040 {}
C {lab_pin.sym} 460 2040 0 0 {name=l1614 lab=VDD}
N 440 1960 460 1960 {}
C {lab_pin.sym} 460 1960 0 0 {name=l1615 lab=VSS}
C {bitcell_6t.sym} 600 2000 0 0 {name=Xr10c3}
N 560 2040 540 2040 {}
C {lab_pin.sym} 540 2040 0 0 {name=l1616 lab=BL3}
N 560 2000 540 2000 {}
C {lab_pin.sym} 540 2000 0 0 {name=l1617 lab=BLB3}
N 560 1960 540 1960 {}
C {lab_pin.sym} 540 1960 0 0 {name=l1618 lab=WL10}
N 640 2040 660 2040 {}
C {lab_pin.sym} 660 2040 0 0 {name=l1619 lab=VDD}
N 640 1960 660 1960 {}
C {lab_pin.sym} 660 1960 0 0 {name=l1620 lab=VSS}
C {bitcell_6t.sym} 800 2000 0 0 {name=Xr10c4}
N 760 2040 740 2040 {}
C {lab_pin.sym} 740 2040 0 0 {name=l1621 lab=BL4}
N 760 2000 740 2000 {}
C {lab_pin.sym} 740 2000 0 0 {name=l1622 lab=BLB4}
N 760 1960 740 1960 {}
C {lab_pin.sym} 740 1960 0 0 {name=l1623 lab=WL10}
N 840 2040 860 2040 {}
C {lab_pin.sym} 860 2040 0 0 {name=l1624 lab=VDD}
N 840 1960 860 1960 {}
C {lab_pin.sym} 860 1960 0 0 {name=l1625 lab=VSS}
C {bitcell_6t.sym} 1000 2000 0 0 {name=Xr10c5}
N 960 2040 940 2040 {}
C {lab_pin.sym} 940 2040 0 0 {name=l1626 lab=BL5}
N 960 2000 940 2000 {}
C {lab_pin.sym} 940 2000 0 0 {name=l1627 lab=BLB5}
N 960 1960 940 1960 {}
C {lab_pin.sym} 940 1960 0 0 {name=l1628 lab=WL10}
N 1040 2040 1060 2040 {}
C {lab_pin.sym} 1060 2040 0 0 {name=l1629 lab=VDD}
N 1040 1960 1060 1960 {}
C {lab_pin.sym} 1060 1960 0 0 {name=l1630 lab=VSS}
C {bitcell_6t.sym} 1200 2000 0 0 {name=Xr10c6}
N 1160 2040 1140 2040 {}
C {lab_pin.sym} 1140 2040 0 0 {name=l1631 lab=BL6}
N 1160 2000 1140 2000 {}
C {lab_pin.sym} 1140 2000 0 0 {name=l1632 lab=BLB6}
N 1160 1960 1140 1960 {}
C {lab_pin.sym} 1140 1960 0 0 {name=l1633 lab=WL10}
N 1240 2040 1260 2040 {}
C {lab_pin.sym} 1260 2040 0 0 {name=l1634 lab=VDD}
N 1240 1960 1260 1960 {}
C {lab_pin.sym} 1260 1960 0 0 {name=l1635 lab=VSS}
C {bitcell_6t.sym} 1400 2000 0 0 {name=Xr10c7}
N 1360 2040 1340 2040 {}
C {lab_pin.sym} 1340 2040 0 0 {name=l1636 lab=BL7}
N 1360 2000 1340 2000 {}
C {lab_pin.sym} 1340 2000 0 0 {name=l1637 lab=BLB7}
N 1360 1960 1340 1960 {}
C {lab_pin.sym} 1340 1960 0 0 {name=l1638 lab=WL10}
N 1440 2040 1460 2040 {}
C {lab_pin.sym} 1460 2040 0 0 {name=l1639 lab=VDD}
N 1440 1960 1460 1960 {}
C {lab_pin.sym} 1460 1960 0 0 {name=l1640 lab=VSS}
C {bitcell_6t.sym} 1600 2000 0 0 {name=Xr10c8}
N 1560 2040 1540 2040 {}
C {lab_pin.sym} 1540 2040 0 0 {name=l1641 lab=BL8}
N 1560 2000 1540 2000 {}
C {lab_pin.sym} 1540 2000 0 0 {name=l1642 lab=BLB8}
N 1560 1960 1540 1960 {}
C {lab_pin.sym} 1540 1960 0 0 {name=l1643 lab=WL10}
N 1640 2040 1660 2040 {}
C {lab_pin.sym} 1660 2040 0 0 {name=l1644 lab=VDD}
N 1640 1960 1660 1960 {}
C {lab_pin.sym} 1660 1960 0 0 {name=l1645 lab=VSS}
C {bitcell_6t.sym} 1800 2000 0 0 {name=Xr10c9}
N 1760 2040 1740 2040 {}
C {lab_pin.sym} 1740 2040 0 0 {name=l1646 lab=BL9}
N 1760 2000 1740 2000 {}
C {lab_pin.sym} 1740 2000 0 0 {name=l1647 lab=BLB9}
N 1760 1960 1740 1960 {}
C {lab_pin.sym} 1740 1960 0 0 {name=l1648 lab=WL10}
N 1840 2040 1860 2040 {}
C {lab_pin.sym} 1860 2040 0 0 {name=l1649 lab=VDD}
N 1840 1960 1860 1960 {}
C {lab_pin.sym} 1860 1960 0 0 {name=l1650 lab=VSS}
C {bitcell_6t.sym} 2000 2000 0 0 {name=Xr10c10}
N 1960 2040 1940 2040 {}
C {lab_pin.sym} 1940 2040 0 0 {name=l1651 lab=BL10}
N 1960 2000 1940 2000 {}
C {lab_pin.sym} 1940 2000 0 0 {name=l1652 lab=BLB10}
N 1960 1960 1940 1960 {}
C {lab_pin.sym} 1940 1960 0 0 {name=l1653 lab=WL10}
N 2040 2040 2060 2040 {}
C {lab_pin.sym} 2060 2040 0 0 {name=l1654 lab=VDD}
N 2040 1960 2060 1960 {}
C {lab_pin.sym} 2060 1960 0 0 {name=l1655 lab=VSS}
C {bitcell_6t.sym} 2200 2000 0 0 {name=Xr10c11}
N 2160 2040 2140 2040 {}
C {lab_pin.sym} 2140 2040 0 0 {name=l1656 lab=BL11}
N 2160 2000 2140 2000 {}
C {lab_pin.sym} 2140 2000 0 0 {name=l1657 lab=BLB11}
N 2160 1960 2140 1960 {}
C {lab_pin.sym} 2140 1960 0 0 {name=l1658 lab=WL10}
N 2240 2040 2260 2040 {}
C {lab_pin.sym} 2260 2040 0 0 {name=l1659 lab=VDD}
N 2240 1960 2260 1960 {}
C {lab_pin.sym} 2260 1960 0 0 {name=l1660 lab=VSS}
C {bitcell_6t.sym} 2400 2000 0 0 {name=Xr10c12}
N 2360 2040 2340 2040 {}
C {lab_pin.sym} 2340 2040 0 0 {name=l1661 lab=BL12}
N 2360 2000 2340 2000 {}
C {lab_pin.sym} 2340 2000 0 0 {name=l1662 lab=BLB12}
N 2360 1960 2340 1960 {}
C {lab_pin.sym} 2340 1960 0 0 {name=l1663 lab=WL10}
N 2440 2040 2460 2040 {}
C {lab_pin.sym} 2460 2040 0 0 {name=l1664 lab=VDD}
N 2440 1960 2460 1960 {}
C {lab_pin.sym} 2460 1960 0 0 {name=l1665 lab=VSS}
C {bitcell_6t.sym} 2600 2000 0 0 {name=Xr10c13}
N 2560 2040 2540 2040 {}
C {lab_pin.sym} 2540 2040 0 0 {name=l1666 lab=BL13}
N 2560 2000 2540 2000 {}
C {lab_pin.sym} 2540 2000 0 0 {name=l1667 lab=BLB13}
N 2560 1960 2540 1960 {}
C {lab_pin.sym} 2540 1960 0 0 {name=l1668 lab=WL10}
N 2640 2040 2660 2040 {}
C {lab_pin.sym} 2660 2040 0 0 {name=l1669 lab=VDD}
N 2640 1960 2660 1960 {}
C {lab_pin.sym} 2660 1960 0 0 {name=l1670 lab=VSS}
C {bitcell_6t.sym} 2800 2000 0 0 {name=Xr10c14}
N 2760 2040 2740 2040 {}
C {lab_pin.sym} 2740 2040 0 0 {name=l1671 lab=BL14}
N 2760 2000 2740 2000 {}
C {lab_pin.sym} 2740 2000 0 0 {name=l1672 lab=BLB14}
N 2760 1960 2740 1960 {}
C {lab_pin.sym} 2740 1960 0 0 {name=l1673 lab=WL10}
N 2840 2040 2860 2040 {}
C {lab_pin.sym} 2860 2040 0 0 {name=l1674 lab=VDD}
N 2840 1960 2860 1960 {}
C {lab_pin.sym} 2860 1960 0 0 {name=l1675 lab=VSS}
C {bitcell_6t.sym} 3000 2000 0 0 {name=Xr10c15}
N 2960 2040 2940 2040 {}
C {lab_pin.sym} 2940 2040 0 0 {name=l1676 lab=BL15}
N 2960 2000 2940 2000 {}
C {lab_pin.sym} 2940 2000 0 0 {name=l1677 lab=BLB15}
N 2960 1960 2940 1960 {}
C {lab_pin.sym} 2940 1960 0 0 {name=l1678 lab=WL10}
N 3040 2040 3060 2040 {}
C {lab_pin.sym} 3060 2040 0 0 {name=l1679 lab=VDD}
N 3040 1960 3060 1960 {}
C {lab_pin.sym} 3060 1960 0 0 {name=l1680 lab=VSS}
C {bitcell_6t.sym} 3200 2000 0 0 {name=Xr10c16}
N 3160 2040 3140 2040 {}
C {lab_pin.sym} 3140 2040 0 0 {name=l1681 lab=BL16}
N 3160 2000 3140 2000 {}
C {lab_pin.sym} 3140 2000 0 0 {name=l1682 lab=BLB16}
N 3160 1960 3140 1960 {}
C {lab_pin.sym} 3140 1960 0 0 {name=l1683 lab=WL10}
N 3240 2040 3260 2040 {}
C {lab_pin.sym} 3260 2040 0 0 {name=l1684 lab=VDD}
N 3240 1960 3260 1960 {}
C {lab_pin.sym} 3260 1960 0 0 {name=l1685 lab=VSS}
C {bitcell_6t.sym} 3400 2000 0 0 {name=Xr10c17}
N 3360 2040 3340 2040 {}
C {lab_pin.sym} 3340 2040 0 0 {name=l1686 lab=BL17}
N 3360 2000 3340 2000 {}
C {lab_pin.sym} 3340 2000 0 0 {name=l1687 lab=BLB17}
N 3360 1960 3340 1960 {}
C {lab_pin.sym} 3340 1960 0 0 {name=l1688 lab=WL10}
N 3440 2040 3460 2040 {}
C {lab_pin.sym} 3460 2040 0 0 {name=l1689 lab=VDD}
N 3440 1960 3460 1960 {}
C {lab_pin.sym} 3460 1960 0 0 {name=l1690 lab=VSS}
C {bitcell_6t.sym} 3600 2000 0 0 {name=Xr10c18}
N 3560 2040 3540 2040 {}
C {lab_pin.sym} 3540 2040 0 0 {name=l1691 lab=BL18}
N 3560 2000 3540 2000 {}
C {lab_pin.sym} 3540 2000 0 0 {name=l1692 lab=BLB18}
N 3560 1960 3540 1960 {}
C {lab_pin.sym} 3540 1960 0 0 {name=l1693 lab=WL10}
N 3640 2040 3660 2040 {}
C {lab_pin.sym} 3660 2040 0 0 {name=l1694 lab=VDD}
N 3640 1960 3660 1960 {}
C {lab_pin.sym} 3660 1960 0 0 {name=l1695 lab=VSS}
C {bitcell_6t.sym} 3800 2000 0 0 {name=Xr10c19}
N 3760 2040 3740 2040 {}
C {lab_pin.sym} 3740 2040 0 0 {name=l1696 lab=BL19}
N 3760 2000 3740 2000 {}
C {lab_pin.sym} 3740 2000 0 0 {name=l1697 lab=BLB19}
N 3760 1960 3740 1960 {}
C {lab_pin.sym} 3740 1960 0 0 {name=l1698 lab=WL10}
N 3840 2040 3860 2040 {}
C {lab_pin.sym} 3860 2040 0 0 {name=l1699 lab=VDD}
N 3840 1960 3860 1960 {}
C {lab_pin.sym} 3860 1960 0 0 {name=l1700 lab=VSS}
C {bitcell_6t.sym} 4000 2000 0 0 {name=Xr10c20}
N 3960 2040 3940 2040 {}
C {lab_pin.sym} 3940 2040 0 0 {name=l1701 lab=BL20}
N 3960 2000 3940 2000 {}
C {lab_pin.sym} 3940 2000 0 0 {name=l1702 lab=BLB20}
N 3960 1960 3940 1960 {}
C {lab_pin.sym} 3940 1960 0 0 {name=l1703 lab=WL10}
N 4040 2040 4060 2040 {}
C {lab_pin.sym} 4060 2040 0 0 {name=l1704 lab=VDD}
N 4040 1960 4060 1960 {}
C {lab_pin.sym} 4060 1960 0 0 {name=l1705 lab=VSS}
C {bitcell_6t.sym} 4200 2000 0 0 {name=Xr10c21}
N 4160 2040 4140 2040 {}
C {lab_pin.sym} 4140 2040 0 0 {name=l1706 lab=BL21}
N 4160 2000 4140 2000 {}
C {lab_pin.sym} 4140 2000 0 0 {name=l1707 lab=BLB21}
N 4160 1960 4140 1960 {}
C {lab_pin.sym} 4140 1960 0 0 {name=l1708 lab=WL10}
N 4240 2040 4260 2040 {}
C {lab_pin.sym} 4260 2040 0 0 {name=l1709 lab=VDD}
N 4240 1960 4260 1960 {}
C {lab_pin.sym} 4260 1960 0 0 {name=l1710 lab=VSS}
C {bitcell_6t.sym} 4400 2000 0 0 {name=Xr10c22}
N 4360 2040 4340 2040 {}
C {lab_pin.sym} 4340 2040 0 0 {name=l1711 lab=BL22}
N 4360 2000 4340 2000 {}
C {lab_pin.sym} 4340 2000 0 0 {name=l1712 lab=BLB22}
N 4360 1960 4340 1960 {}
C {lab_pin.sym} 4340 1960 0 0 {name=l1713 lab=WL10}
N 4440 2040 4460 2040 {}
C {lab_pin.sym} 4460 2040 0 0 {name=l1714 lab=VDD}
N 4440 1960 4460 1960 {}
C {lab_pin.sym} 4460 1960 0 0 {name=l1715 lab=VSS}
C {bitcell_6t.sym} 4600 2000 0 0 {name=Xr10c23}
N 4560 2040 4540 2040 {}
C {lab_pin.sym} 4540 2040 0 0 {name=l1716 lab=BL23}
N 4560 2000 4540 2000 {}
C {lab_pin.sym} 4540 2000 0 0 {name=l1717 lab=BLB23}
N 4560 1960 4540 1960 {}
C {lab_pin.sym} 4540 1960 0 0 {name=l1718 lab=WL10}
N 4640 2040 4660 2040 {}
C {lab_pin.sym} 4660 2040 0 0 {name=l1719 lab=VDD}
N 4640 1960 4660 1960 {}
C {lab_pin.sym} 4660 1960 0 0 {name=l1720 lab=VSS}
C {bitcell_6t.sym} 4800 2000 0 0 {name=Xr10c24}
N 4760 2040 4740 2040 {}
C {lab_pin.sym} 4740 2040 0 0 {name=l1721 lab=BL24}
N 4760 2000 4740 2000 {}
C {lab_pin.sym} 4740 2000 0 0 {name=l1722 lab=BLB24}
N 4760 1960 4740 1960 {}
C {lab_pin.sym} 4740 1960 0 0 {name=l1723 lab=WL10}
N 4840 2040 4860 2040 {}
C {lab_pin.sym} 4860 2040 0 0 {name=l1724 lab=VDD}
N 4840 1960 4860 1960 {}
C {lab_pin.sym} 4860 1960 0 0 {name=l1725 lab=VSS}
C {bitcell_6t.sym} 5000 2000 0 0 {name=Xr10c25}
N 4960 2040 4940 2040 {}
C {lab_pin.sym} 4940 2040 0 0 {name=l1726 lab=BL25}
N 4960 2000 4940 2000 {}
C {lab_pin.sym} 4940 2000 0 0 {name=l1727 lab=BLB25}
N 4960 1960 4940 1960 {}
C {lab_pin.sym} 4940 1960 0 0 {name=l1728 lab=WL10}
N 5040 2040 5060 2040 {}
C {lab_pin.sym} 5060 2040 0 0 {name=l1729 lab=VDD}
N 5040 1960 5060 1960 {}
C {lab_pin.sym} 5060 1960 0 0 {name=l1730 lab=VSS}
C {bitcell_6t.sym} 5200 2000 0 0 {name=Xr10c26}
N 5160 2040 5140 2040 {}
C {lab_pin.sym} 5140 2040 0 0 {name=l1731 lab=BL26}
N 5160 2000 5140 2000 {}
C {lab_pin.sym} 5140 2000 0 0 {name=l1732 lab=BLB26}
N 5160 1960 5140 1960 {}
C {lab_pin.sym} 5140 1960 0 0 {name=l1733 lab=WL10}
N 5240 2040 5260 2040 {}
C {lab_pin.sym} 5260 2040 0 0 {name=l1734 lab=VDD}
N 5240 1960 5260 1960 {}
C {lab_pin.sym} 5260 1960 0 0 {name=l1735 lab=VSS}
C {bitcell_6t.sym} 5400 2000 0 0 {name=Xr10c27}
N 5360 2040 5340 2040 {}
C {lab_pin.sym} 5340 2040 0 0 {name=l1736 lab=BL27}
N 5360 2000 5340 2000 {}
C {lab_pin.sym} 5340 2000 0 0 {name=l1737 lab=BLB27}
N 5360 1960 5340 1960 {}
C {lab_pin.sym} 5340 1960 0 0 {name=l1738 lab=WL10}
N 5440 2040 5460 2040 {}
C {lab_pin.sym} 5460 2040 0 0 {name=l1739 lab=VDD}
N 5440 1960 5460 1960 {}
C {lab_pin.sym} 5460 1960 0 0 {name=l1740 lab=VSS}
C {bitcell_6t.sym} 5600 2000 0 0 {name=Xr10c28}
N 5560 2040 5540 2040 {}
C {lab_pin.sym} 5540 2040 0 0 {name=l1741 lab=BL28}
N 5560 2000 5540 2000 {}
C {lab_pin.sym} 5540 2000 0 0 {name=l1742 lab=BLB28}
N 5560 1960 5540 1960 {}
C {lab_pin.sym} 5540 1960 0 0 {name=l1743 lab=WL10}
N 5640 2040 5660 2040 {}
C {lab_pin.sym} 5660 2040 0 0 {name=l1744 lab=VDD}
N 5640 1960 5660 1960 {}
C {lab_pin.sym} 5660 1960 0 0 {name=l1745 lab=VSS}
C {bitcell_6t.sym} 5800 2000 0 0 {name=Xr10c29}
N 5760 2040 5740 2040 {}
C {lab_pin.sym} 5740 2040 0 0 {name=l1746 lab=BL29}
N 5760 2000 5740 2000 {}
C {lab_pin.sym} 5740 2000 0 0 {name=l1747 lab=BLB29}
N 5760 1960 5740 1960 {}
C {lab_pin.sym} 5740 1960 0 0 {name=l1748 lab=WL10}
N 5840 2040 5860 2040 {}
C {lab_pin.sym} 5860 2040 0 0 {name=l1749 lab=VDD}
N 5840 1960 5860 1960 {}
C {lab_pin.sym} 5860 1960 0 0 {name=l1750 lab=VSS}
C {bitcell_6t.sym} 6000 2000 0 0 {name=Xr10c30}
N 5960 2040 5940 2040 {}
C {lab_pin.sym} 5940 2040 0 0 {name=l1751 lab=BL30}
N 5960 2000 5940 2000 {}
C {lab_pin.sym} 5940 2000 0 0 {name=l1752 lab=BLB30}
N 5960 1960 5940 1960 {}
C {lab_pin.sym} 5940 1960 0 0 {name=l1753 lab=WL10}
N 6040 2040 6060 2040 {}
C {lab_pin.sym} 6060 2040 0 0 {name=l1754 lab=VDD}
N 6040 1960 6060 1960 {}
C {lab_pin.sym} 6060 1960 0 0 {name=l1755 lab=VSS}
C {bitcell_6t.sym} 6200 2000 0 0 {name=Xr10c31}
N 6160 2040 6140 2040 {}
C {lab_pin.sym} 6140 2040 0 0 {name=l1756 lab=BL31}
N 6160 2000 6140 2000 {}
C {lab_pin.sym} 6140 2000 0 0 {name=l1757 lab=BLB31}
N 6160 1960 6140 1960 {}
C {lab_pin.sym} 6140 1960 0 0 {name=l1758 lab=WL10}
N 6240 2040 6260 2040 {}
C {lab_pin.sym} 6260 2040 0 0 {name=l1759 lab=VDD}
N 6240 1960 6260 1960 {}
C {lab_pin.sym} 6260 1960 0 0 {name=l1760 lab=VSS}
C {bitcell_6t.sym} 0 2200 0 0 {name=Xr11c0}
N -40 2240 -60 2240 {}
C {lab_pin.sym} -60 2240 0 0 {name=l1761 lab=BL0}
N -40 2200 -60 2200 {}
C {lab_pin.sym} -60 2200 0 0 {name=l1762 lab=BLB0}
N -40 2160 -60 2160 {}
C {lab_pin.sym} -60 2160 0 0 {name=l1763 lab=WL11}
N 40 2240 60 2240 {}
C {lab_pin.sym} 60 2240 0 0 {name=l1764 lab=VDD}
N 40 2160 60 2160 {}
C {lab_pin.sym} 60 2160 0 0 {name=l1765 lab=VSS}
C {bitcell_6t.sym} 200 2200 0 0 {name=Xr11c1}
N 160 2240 140 2240 {}
C {lab_pin.sym} 140 2240 0 0 {name=l1766 lab=BL1}
N 160 2200 140 2200 {}
C {lab_pin.sym} 140 2200 0 0 {name=l1767 lab=BLB1}
N 160 2160 140 2160 {}
C {lab_pin.sym} 140 2160 0 0 {name=l1768 lab=WL11}
N 240 2240 260 2240 {}
C {lab_pin.sym} 260 2240 0 0 {name=l1769 lab=VDD}
N 240 2160 260 2160 {}
C {lab_pin.sym} 260 2160 0 0 {name=l1770 lab=VSS}
C {bitcell_6t.sym} 400 2200 0 0 {name=Xr11c2}
N 360 2240 340 2240 {}
C {lab_pin.sym} 340 2240 0 0 {name=l1771 lab=BL2}
N 360 2200 340 2200 {}
C {lab_pin.sym} 340 2200 0 0 {name=l1772 lab=BLB2}
N 360 2160 340 2160 {}
C {lab_pin.sym} 340 2160 0 0 {name=l1773 lab=WL11}
N 440 2240 460 2240 {}
C {lab_pin.sym} 460 2240 0 0 {name=l1774 lab=VDD}
N 440 2160 460 2160 {}
C {lab_pin.sym} 460 2160 0 0 {name=l1775 lab=VSS}
C {bitcell_6t.sym} 600 2200 0 0 {name=Xr11c3}
N 560 2240 540 2240 {}
C {lab_pin.sym} 540 2240 0 0 {name=l1776 lab=BL3}
N 560 2200 540 2200 {}
C {lab_pin.sym} 540 2200 0 0 {name=l1777 lab=BLB3}
N 560 2160 540 2160 {}
C {lab_pin.sym} 540 2160 0 0 {name=l1778 lab=WL11}
N 640 2240 660 2240 {}
C {lab_pin.sym} 660 2240 0 0 {name=l1779 lab=VDD}
N 640 2160 660 2160 {}
C {lab_pin.sym} 660 2160 0 0 {name=l1780 lab=VSS}
C {bitcell_6t.sym} 800 2200 0 0 {name=Xr11c4}
N 760 2240 740 2240 {}
C {lab_pin.sym} 740 2240 0 0 {name=l1781 lab=BL4}
N 760 2200 740 2200 {}
C {lab_pin.sym} 740 2200 0 0 {name=l1782 lab=BLB4}
N 760 2160 740 2160 {}
C {lab_pin.sym} 740 2160 0 0 {name=l1783 lab=WL11}
N 840 2240 860 2240 {}
C {lab_pin.sym} 860 2240 0 0 {name=l1784 lab=VDD}
N 840 2160 860 2160 {}
C {lab_pin.sym} 860 2160 0 0 {name=l1785 lab=VSS}
C {bitcell_6t.sym} 1000 2200 0 0 {name=Xr11c5}
N 960 2240 940 2240 {}
C {lab_pin.sym} 940 2240 0 0 {name=l1786 lab=BL5}
N 960 2200 940 2200 {}
C {lab_pin.sym} 940 2200 0 0 {name=l1787 lab=BLB5}
N 960 2160 940 2160 {}
C {lab_pin.sym} 940 2160 0 0 {name=l1788 lab=WL11}
N 1040 2240 1060 2240 {}
C {lab_pin.sym} 1060 2240 0 0 {name=l1789 lab=VDD}
N 1040 2160 1060 2160 {}
C {lab_pin.sym} 1060 2160 0 0 {name=l1790 lab=VSS}
C {bitcell_6t.sym} 1200 2200 0 0 {name=Xr11c6}
N 1160 2240 1140 2240 {}
C {lab_pin.sym} 1140 2240 0 0 {name=l1791 lab=BL6}
N 1160 2200 1140 2200 {}
C {lab_pin.sym} 1140 2200 0 0 {name=l1792 lab=BLB6}
N 1160 2160 1140 2160 {}
C {lab_pin.sym} 1140 2160 0 0 {name=l1793 lab=WL11}
N 1240 2240 1260 2240 {}
C {lab_pin.sym} 1260 2240 0 0 {name=l1794 lab=VDD}
N 1240 2160 1260 2160 {}
C {lab_pin.sym} 1260 2160 0 0 {name=l1795 lab=VSS}
C {bitcell_6t.sym} 1400 2200 0 0 {name=Xr11c7}
N 1360 2240 1340 2240 {}
C {lab_pin.sym} 1340 2240 0 0 {name=l1796 lab=BL7}
N 1360 2200 1340 2200 {}
C {lab_pin.sym} 1340 2200 0 0 {name=l1797 lab=BLB7}
N 1360 2160 1340 2160 {}
C {lab_pin.sym} 1340 2160 0 0 {name=l1798 lab=WL11}
N 1440 2240 1460 2240 {}
C {lab_pin.sym} 1460 2240 0 0 {name=l1799 lab=VDD}
N 1440 2160 1460 2160 {}
C {lab_pin.sym} 1460 2160 0 0 {name=l1800 lab=VSS}
C {bitcell_6t.sym} 1600 2200 0 0 {name=Xr11c8}
N 1560 2240 1540 2240 {}
C {lab_pin.sym} 1540 2240 0 0 {name=l1801 lab=BL8}
N 1560 2200 1540 2200 {}
C {lab_pin.sym} 1540 2200 0 0 {name=l1802 lab=BLB8}
N 1560 2160 1540 2160 {}
C {lab_pin.sym} 1540 2160 0 0 {name=l1803 lab=WL11}
N 1640 2240 1660 2240 {}
C {lab_pin.sym} 1660 2240 0 0 {name=l1804 lab=VDD}
N 1640 2160 1660 2160 {}
C {lab_pin.sym} 1660 2160 0 0 {name=l1805 lab=VSS}
C {bitcell_6t.sym} 1800 2200 0 0 {name=Xr11c9}
N 1760 2240 1740 2240 {}
C {lab_pin.sym} 1740 2240 0 0 {name=l1806 lab=BL9}
N 1760 2200 1740 2200 {}
C {lab_pin.sym} 1740 2200 0 0 {name=l1807 lab=BLB9}
N 1760 2160 1740 2160 {}
C {lab_pin.sym} 1740 2160 0 0 {name=l1808 lab=WL11}
N 1840 2240 1860 2240 {}
C {lab_pin.sym} 1860 2240 0 0 {name=l1809 lab=VDD}
N 1840 2160 1860 2160 {}
C {lab_pin.sym} 1860 2160 0 0 {name=l1810 lab=VSS}
C {bitcell_6t.sym} 2000 2200 0 0 {name=Xr11c10}
N 1960 2240 1940 2240 {}
C {lab_pin.sym} 1940 2240 0 0 {name=l1811 lab=BL10}
N 1960 2200 1940 2200 {}
C {lab_pin.sym} 1940 2200 0 0 {name=l1812 lab=BLB10}
N 1960 2160 1940 2160 {}
C {lab_pin.sym} 1940 2160 0 0 {name=l1813 lab=WL11}
N 2040 2240 2060 2240 {}
C {lab_pin.sym} 2060 2240 0 0 {name=l1814 lab=VDD}
N 2040 2160 2060 2160 {}
C {lab_pin.sym} 2060 2160 0 0 {name=l1815 lab=VSS}
C {bitcell_6t.sym} 2200 2200 0 0 {name=Xr11c11}
N 2160 2240 2140 2240 {}
C {lab_pin.sym} 2140 2240 0 0 {name=l1816 lab=BL11}
N 2160 2200 2140 2200 {}
C {lab_pin.sym} 2140 2200 0 0 {name=l1817 lab=BLB11}
N 2160 2160 2140 2160 {}
C {lab_pin.sym} 2140 2160 0 0 {name=l1818 lab=WL11}
N 2240 2240 2260 2240 {}
C {lab_pin.sym} 2260 2240 0 0 {name=l1819 lab=VDD}
N 2240 2160 2260 2160 {}
C {lab_pin.sym} 2260 2160 0 0 {name=l1820 lab=VSS}
C {bitcell_6t.sym} 2400 2200 0 0 {name=Xr11c12}
N 2360 2240 2340 2240 {}
C {lab_pin.sym} 2340 2240 0 0 {name=l1821 lab=BL12}
N 2360 2200 2340 2200 {}
C {lab_pin.sym} 2340 2200 0 0 {name=l1822 lab=BLB12}
N 2360 2160 2340 2160 {}
C {lab_pin.sym} 2340 2160 0 0 {name=l1823 lab=WL11}
N 2440 2240 2460 2240 {}
C {lab_pin.sym} 2460 2240 0 0 {name=l1824 lab=VDD}
N 2440 2160 2460 2160 {}
C {lab_pin.sym} 2460 2160 0 0 {name=l1825 lab=VSS}
C {bitcell_6t.sym} 2600 2200 0 0 {name=Xr11c13}
N 2560 2240 2540 2240 {}
C {lab_pin.sym} 2540 2240 0 0 {name=l1826 lab=BL13}
N 2560 2200 2540 2200 {}
C {lab_pin.sym} 2540 2200 0 0 {name=l1827 lab=BLB13}
N 2560 2160 2540 2160 {}
C {lab_pin.sym} 2540 2160 0 0 {name=l1828 lab=WL11}
N 2640 2240 2660 2240 {}
C {lab_pin.sym} 2660 2240 0 0 {name=l1829 lab=VDD}
N 2640 2160 2660 2160 {}
C {lab_pin.sym} 2660 2160 0 0 {name=l1830 lab=VSS}
C {bitcell_6t.sym} 2800 2200 0 0 {name=Xr11c14}
N 2760 2240 2740 2240 {}
C {lab_pin.sym} 2740 2240 0 0 {name=l1831 lab=BL14}
N 2760 2200 2740 2200 {}
C {lab_pin.sym} 2740 2200 0 0 {name=l1832 lab=BLB14}
N 2760 2160 2740 2160 {}
C {lab_pin.sym} 2740 2160 0 0 {name=l1833 lab=WL11}
N 2840 2240 2860 2240 {}
C {lab_pin.sym} 2860 2240 0 0 {name=l1834 lab=VDD}
N 2840 2160 2860 2160 {}
C {lab_pin.sym} 2860 2160 0 0 {name=l1835 lab=VSS}
C {bitcell_6t.sym} 3000 2200 0 0 {name=Xr11c15}
N 2960 2240 2940 2240 {}
C {lab_pin.sym} 2940 2240 0 0 {name=l1836 lab=BL15}
N 2960 2200 2940 2200 {}
C {lab_pin.sym} 2940 2200 0 0 {name=l1837 lab=BLB15}
N 2960 2160 2940 2160 {}
C {lab_pin.sym} 2940 2160 0 0 {name=l1838 lab=WL11}
N 3040 2240 3060 2240 {}
C {lab_pin.sym} 3060 2240 0 0 {name=l1839 lab=VDD}
N 3040 2160 3060 2160 {}
C {lab_pin.sym} 3060 2160 0 0 {name=l1840 lab=VSS}
C {bitcell_6t.sym} 3200 2200 0 0 {name=Xr11c16}
N 3160 2240 3140 2240 {}
C {lab_pin.sym} 3140 2240 0 0 {name=l1841 lab=BL16}
N 3160 2200 3140 2200 {}
C {lab_pin.sym} 3140 2200 0 0 {name=l1842 lab=BLB16}
N 3160 2160 3140 2160 {}
C {lab_pin.sym} 3140 2160 0 0 {name=l1843 lab=WL11}
N 3240 2240 3260 2240 {}
C {lab_pin.sym} 3260 2240 0 0 {name=l1844 lab=VDD}
N 3240 2160 3260 2160 {}
C {lab_pin.sym} 3260 2160 0 0 {name=l1845 lab=VSS}
C {bitcell_6t.sym} 3400 2200 0 0 {name=Xr11c17}
N 3360 2240 3340 2240 {}
C {lab_pin.sym} 3340 2240 0 0 {name=l1846 lab=BL17}
N 3360 2200 3340 2200 {}
C {lab_pin.sym} 3340 2200 0 0 {name=l1847 lab=BLB17}
N 3360 2160 3340 2160 {}
C {lab_pin.sym} 3340 2160 0 0 {name=l1848 lab=WL11}
N 3440 2240 3460 2240 {}
C {lab_pin.sym} 3460 2240 0 0 {name=l1849 lab=VDD}
N 3440 2160 3460 2160 {}
C {lab_pin.sym} 3460 2160 0 0 {name=l1850 lab=VSS}
C {bitcell_6t.sym} 3600 2200 0 0 {name=Xr11c18}
N 3560 2240 3540 2240 {}
C {lab_pin.sym} 3540 2240 0 0 {name=l1851 lab=BL18}
N 3560 2200 3540 2200 {}
C {lab_pin.sym} 3540 2200 0 0 {name=l1852 lab=BLB18}
N 3560 2160 3540 2160 {}
C {lab_pin.sym} 3540 2160 0 0 {name=l1853 lab=WL11}
N 3640 2240 3660 2240 {}
C {lab_pin.sym} 3660 2240 0 0 {name=l1854 lab=VDD}
N 3640 2160 3660 2160 {}
C {lab_pin.sym} 3660 2160 0 0 {name=l1855 lab=VSS}
C {bitcell_6t.sym} 3800 2200 0 0 {name=Xr11c19}
N 3760 2240 3740 2240 {}
C {lab_pin.sym} 3740 2240 0 0 {name=l1856 lab=BL19}
N 3760 2200 3740 2200 {}
C {lab_pin.sym} 3740 2200 0 0 {name=l1857 lab=BLB19}
N 3760 2160 3740 2160 {}
C {lab_pin.sym} 3740 2160 0 0 {name=l1858 lab=WL11}
N 3840 2240 3860 2240 {}
C {lab_pin.sym} 3860 2240 0 0 {name=l1859 lab=VDD}
N 3840 2160 3860 2160 {}
C {lab_pin.sym} 3860 2160 0 0 {name=l1860 lab=VSS}
C {bitcell_6t.sym} 4000 2200 0 0 {name=Xr11c20}
N 3960 2240 3940 2240 {}
C {lab_pin.sym} 3940 2240 0 0 {name=l1861 lab=BL20}
N 3960 2200 3940 2200 {}
C {lab_pin.sym} 3940 2200 0 0 {name=l1862 lab=BLB20}
N 3960 2160 3940 2160 {}
C {lab_pin.sym} 3940 2160 0 0 {name=l1863 lab=WL11}
N 4040 2240 4060 2240 {}
C {lab_pin.sym} 4060 2240 0 0 {name=l1864 lab=VDD}
N 4040 2160 4060 2160 {}
C {lab_pin.sym} 4060 2160 0 0 {name=l1865 lab=VSS}
C {bitcell_6t.sym} 4200 2200 0 0 {name=Xr11c21}
N 4160 2240 4140 2240 {}
C {lab_pin.sym} 4140 2240 0 0 {name=l1866 lab=BL21}
N 4160 2200 4140 2200 {}
C {lab_pin.sym} 4140 2200 0 0 {name=l1867 lab=BLB21}
N 4160 2160 4140 2160 {}
C {lab_pin.sym} 4140 2160 0 0 {name=l1868 lab=WL11}
N 4240 2240 4260 2240 {}
C {lab_pin.sym} 4260 2240 0 0 {name=l1869 lab=VDD}
N 4240 2160 4260 2160 {}
C {lab_pin.sym} 4260 2160 0 0 {name=l1870 lab=VSS}
C {bitcell_6t.sym} 4400 2200 0 0 {name=Xr11c22}
N 4360 2240 4340 2240 {}
C {lab_pin.sym} 4340 2240 0 0 {name=l1871 lab=BL22}
N 4360 2200 4340 2200 {}
C {lab_pin.sym} 4340 2200 0 0 {name=l1872 lab=BLB22}
N 4360 2160 4340 2160 {}
C {lab_pin.sym} 4340 2160 0 0 {name=l1873 lab=WL11}
N 4440 2240 4460 2240 {}
C {lab_pin.sym} 4460 2240 0 0 {name=l1874 lab=VDD}
N 4440 2160 4460 2160 {}
C {lab_pin.sym} 4460 2160 0 0 {name=l1875 lab=VSS}
C {bitcell_6t.sym} 4600 2200 0 0 {name=Xr11c23}
N 4560 2240 4540 2240 {}
C {lab_pin.sym} 4540 2240 0 0 {name=l1876 lab=BL23}
N 4560 2200 4540 2200 {}
C {lab_pin.sym} 4540 2200 0 0 {name=l1877 lab=BLB23}
N 4560 2160 4540 2160 {}
C {lab_pin.sym} 4540 2160 0 0 {name=l1878 lab=WL11}
N 4640 2240 4660 2240 {}
C {lab_pin.sym} 4660 2240 0 0 {name=l1879 lab=VDD}
N 4640 2160 4660 2160 {}
C {lab_pin.sym} 4660 2160 0 0 {name=l1880 lab=VSS}
C {bitcell_6t.sym} 4800 2200 0 0 {name=Xr11c24}
N 4760 2240 4740 2240 {}
C {lab_pin.sym} 4740 2240 0 0 {name=l1881 lab=BL24}
N 4760 2200 4740 2200 {}
C {lab_pin.sym} 4740 2200 0 0 {name=l1882 lab=BLB24}
N 4760 2160 4740 2160 {}
C {lab_pin.sym} 4740 2160 0 0 {name=l1883 lab=WL11}
N 4840 2240 4860 2240 {}
C {lab_pin.sym} 4860 2240 0 0 {name=l1884 lab=VDD}
N 4840 2160 4860 2160 {}
C {lab_pin.sym} 4860 2160 0 0 {name=l1885 lab=VSS}
C {bitcell_6t.sym} 5000 2200 0 0 {name=Xr11c25}
N 4960 2240 4940 2240 {}
C {lab_pin.sym} 4940 2240 0 0 {name=l1886 lab=BL25}
N 4960 2200 4940 2200 {}
C {lab_pin.sym} 4940 2200 0 0 {name=l1887 lab=BLB25}
N 4960 2160 4940 2160 {}
C {lab_pin.sym} 4940 2160 0 0 {name=l1888 lab=WL11}
N 5040 2240 5060 2240 {}
C {lab_pin.sym} 5060 2240 0 0 {name=l1889 lab=VDD}
N 5040 2160 5060 2160 {}
C {lab_pin.sym} 5060 2160 0 0 {name=l1890 lab=VSS}
C {bitcell_6t.sym} 5200 2200 0 0 {name=Xr11c26}
N 5160 2240 5140 2240 {}
C {lab_pin.sym} 5140 2240 0 0 {name=l1891 lab=BL26}
N 5160 2200 5140 2200 {}
C {lab_pin.sym} 5140 2200 0 0 {name=l1892 lab=BLB26}
N 5160 2160 5140 2160 {}
C {lab_pin.sym} 5140 2160 0 0 {name=l1893 lab=WL11}
N 5240 2240 5260 2240 {}
C {lab_pin.sym} 5260 2240 0 0 {name=l1894 lab=VDD}
N 5240 2160 5260 2160 {}
C {lab_pin.sym} 5260 2160 0 0 {name=l1895 lab=VSS}
C {bitcell_6t.sym} 5400 2200 0 0 {name=Xr11c27}
N 5360 2240 5340 2240 {}
C {lab_pin.sym} 5340 2240 0 0 {name=l1896 lab=BL27}
N 5360 2200 5340 2200 {}
C {lab_pin.sym} 5340 2200 0 0 {name=l1897 lab=BLB27}
N 5360 2160 5340 2160 {}
C {lab_pin.sym} 5340 2160 0 0 {name=l1898 lab=WL11}
N 5440 2240 5460 2240 {}
C {lab_pin.sym} 5460 2240 0 0 {name=l1899 lab=VDD}
N 5440 2160 5460 2160 {}
C {lab_pin.sym} 5460 2160 0 0 {name=l1900 lab=VSS}
C {bitcell_6t.sym} 5600 2200 0 0 {name=Xr11c28}
N 5560 2240 5540 2240 {}
C {lab_pin.sym} 5540 2240 0 0 {name=l1901 lab=BL28}
N 5560 2200 5540 2200 {}
C {lab_pin.sym} 5540 2200 0 0 {name=l1902 lab=BLB28}
N 5560 2160 5540 2160 {}
C {lab_pin.sym} 5540 2160 0 0 {name=l1903 lab=WL11}
N 5640 2240 5660 2240 {}
C {lab_pin.sym} 5660 2240 0 0 {name=l1904 lab=VDD}
N 5640 2160 5660 2160 {}
C {lab_pin.sym} 5660 2160 0 0 {name=l1905 lab=VSS}
C {bitcell_6t.sym} 5800 2200 0 0 {name=Xr11c29}
N 5760 2240 5740 2240 {}
C {lab_pin.sym} 5740 2240 0 0 {name=l1906 lab=BL29}
N 5760 2200 5740 2200 {}
C {lab_pin.sym} 5740 2200 0 0 {name=l1907 lab=BLB29}
N 5760 2160 5740 2160 {}
C {lab_pin.sym} 5740 2160 0 0 {name=l1908 lab=WL11}
N 5840 2240 5860 2240 {}
C {lab_pin.sym} 5860 2240 0 0 {name=l1909 lab=VDD}
N 5840 2160 5860 2160 {}
C {lab_pin.sym} 5860 2160 0 0 {name=l1910 lab=VSS}
C {bitcell_6t.sym} 6000 2200 0 0 {name=Xr11c30}
N 5960 2240 5940 2240 {}
C {lab_pin.sym} 5940 2240 0 0 {name=l1911 lab=BL30}
N 5960 2200 5940 2200 {}
C {lab_pin.sym} 5940 2200 0 0 {name=l1912 lab=BLB30}
N 5960 2160 5940 2160 {}
C {lab_pin.sym} 5940 2160 0 0 {name=l1913 lab=WL11}
N 6040 2240 6060 2240 {}
C {lab_pin.sym} 6060 2240 0 0 {name=l1914 lab=VDD}
N 6040 2160 6060 2160 {}
C {lab_pin.sym} 6060 2160 0 0 {name=l1915 lab=VSS}
C {bitcell_6t.sym} 6200 2200 0 0 {name=Xr11c31}
N 6160 2240 6140 2240 {}
C {lab_pin.sym} 6140 2240 0 0 {name=l1916 lab=BL31}
N 6160 2200 6140 2200 {}
C {lab_pin.sym} 6140 2200 0 0 {name=l1917 lab=BLB31}
N 6160 2160 6140 2160 {}
C {lab_pin.sym} 6140 2160 0 0 {name=l1918 lab=WL11}
N 6240 2240 6260 2240 {}
C {lab_pin.sym} 6260 2240 0 0 {name=l1919 lab=VDD}
N 6240 2160 6260 2160 {}
C {lab_pin.sym} 6260 2160 0 0 {name=l1920 lab=VSS}
C {bitcell_6t.sym} 0 2400 0 0 {name=Xr12c0}
N -40 2440 -60 2440 {}
C {lab_pin.sym} -60 2440 0 0 {name=l1921 lab=BL0}
N -40 2400 -60 2400 {}
C {lab_pin.sym} -60 2400 0 0 {name=l1922 lab=BLB0}
N -40 2360 -60 2360 {}
C {lab_pin.sym} -60 2360 0 0 {name=l1923 lab=WL12}
N 40 2440 60 2440 {}
C {lab_pin.sym} 60 2440 0 0 {name=l1924 lab=VDD}
N 40 2360 60 2360 {}
C {lab_pin.sym} 60 2360 0 0 {name=l1925 lab=VSS}
C {bitcell_6t.sym} 200 2400 0 0 {name=Xr12c1}
N 160 2440 140 2440 {}
C {lab_pin.sym} 140 2440 0 0 {name=l1926 lab=BL1}
N 160 2400 140 2400 {}
C {lab_pin.sym} 140 2400 0 0 {name=l1927 lab=BLB1}
N 160 2360 140 2360 {}
C {lab_pin.sym} 140 2360 0 0 {name=l1928 lab=WL12}
N 240 2440 260 2440 {}
C {lab_pin.sym} 260 2440 0 0 {name=l1929 lab=VDD}
N 240 2360 260 2360 {}
C {lab_pin.sym} 260 2360 0 0 {name=l1930 lab=VSS}
C {bitcell_6t.sym} 400 2400 0 0 {name=Xr12c2}
N 360 2440 340 2440 {}
C {lab_pin.sym} 340 2440 0 0 {name=l1931 lab=BL2}
N 360 2400 340 2400 {}
C {lab_pin.sym} 340 2400 0 0 {name=l1932 lab=BLB2}
N 360 2360 340 2360 {}
C {lab_pin.sym} 340 2360 0 0 {name=l1933 lab=WL12}
N 440 2440 460 2440 {}
C {lab_pin.sym} 460 2440 0 0 {name=l1934 lab=VDD}
N 440 2360 460 2360 {}
C {lab_pin.sym} 460 2360 0 0 {name=l1935 lab=VSS}
C {bitcell_6t.sym} 600 2400 0 0 {name=Xr12c3}
N 560 2440 540 2440 {}
C {lab_pin.sym} 540 2440 0 0 {name=l1936 lab=BL3}
N 560 2400 540 2400 {}
C {lab_pin.sym} 540 2400 0 0 {name=l1937 lab=BLB3}
N 560 2360 540 2360 {}
C {lab_pin.sym} 540 2360 0 0 {name=l1938 lab=WL12}
N 640 2440 660 2440 {}
C {lab_pin.sym} 660 2440 0 0 {name=l1939 lab=VDD}
N 640 2360 660 2360 {}
C {lab_pin.sym} 660 2360 0 0 {name=l1940 lab=VSS}
C {bitcell_6t.sym} 800 2400 0 0 {name=Xr12c4}
N 760 2440 740 2440 {}
C {lab_pin.sym} 740 2440 0 0 {name=l1941 lab=BL4}
N 760 2400 740 2400 {}
C {lab_pin.sym} 740 2400 0 0 {name=l1942 lab=BLB4}
N 760 2360 740 2360 {}
C {lab_pin.sym} 740 2360 0 0 {name=l1943 lab=WL12}
N 840 2440 860 2440 {}
C {lab_pin.sym} 860 2440 0 0 {name=l1944 lab=VDD}
N 840 2360 860 2360 {}
C {lab_pin.sym} 860 2360 0 0 {name=l1945 lab=VSS}
C {bitcell_6t.sym} 1000 2400 0 0 {name=Xr12c5}
N 960 2440 940 2440 {}
C {lab_pin.sym} 940 2440 0 0 {name=l1946 lab=BL5}
N 960 2400 940 2400 {}
C {lab_pin.sym} 940 2400 0 0 {name=l1947 lab=BLB5}
N 960 2360 940 2360 {}
C {lab_pin.sym} 940 2360 0 0 {name=l1948 lab=WL12}
N 1040 2440 1060 2440 {}
C {lab_pin.sym} 1060 2440 0 0 {name=l1949 lab=VDD}
N 1040 2360 1060 2360 {}
C {lab_pin.sym} 1060 2360 0 0 {name=l1950 lab=VSS}
C {bitcell_6t.sym} 1200 2400 0 0 {name=Xr12c6}
N 1160 2440 1140 2440 {}
C {lab_pin.sym} 1140 2440 0 0 {name=l1951 lab=BL6}
N 1160 2400 1140 2400 {}
C {lab_pin.sym} 1140 2400 0 0 {name=l1952 lab=BLB6}
N 1160 2360 1140 2360 {}
C {lab_pin.sym} 1140 2360 0 0 {name=l1953 lab=WL12}
N 1240 2440 1260 2440 {}
C {lab_pin.sym} 1260 2440 0 0 {name=l1954 lab=VDD}
N 1240 2360 1260 2360 {}
C {lab_pin.sym} 1260 2360 0 0 {name=l1955 lab=VSS}
C {bitcell_6t.sym} 1400 2400 0 0 {name=Xr12c7}
N 1360 2440 1340 2440 {}
C {lab_pin.sym} 1340 2440 0 0 {name=l1956 lab=BL7}
N 1360 2400 1340 2400 {}
C {lab_pin.sym} 1340 2400 0 0 {name=l1957 lab=BLB7}
N 1360 2360 1340 2360 {}
C {lab_pin.sym} 1340 2360 0 0 {name=l1958 lab=WL12}
N 1440 2440 1460 2440 {}
C {lab_pin.sym} 1460 2440 0 0 {name=l1959 lab=VDD}
N 1440 2360 1460 2360 {}
C {lab_pin.sym} 1460 2360 0 0 {name=l1960 lab=VSS}
C {bitcell_6t.sym} 1600 2400 0 0 {name=Xr12c8}
N 1560 2440 1540 2440 {}
C {lab_pin.sym} 1540 2440 0 0 {name=l1961 lab=BL8}
N 1560 2400 1540 2400 {}
C {lab_pin.sym} 1540 2400 0 0 {name=l1962 lab=BLB8}
N 1560 2360 1540 2360 {}
C {lab_pin.sym} 1540 2360 0 0 {name=l1963 lab=WL12}
N 1640 2440 1660 2440 {}
C {lab_pin.sym} 1660 2440 0 0 {name=l1964 lab=VDD}
N 1640 2360 1660 2360 {}
C {lab_pin.sym} 1660 2360 0 0 {name=l1965 lab=VSS}
C {bitcell_6t.sym} 1800 2400 0 0 {name=Xr12c9}
N 1760 2440 1740 2440 {}
C {lab_pin.sym} 1740 2440 0 0 {name=l1966 lab=BL9}
N 1760 2400 1740 2400 {}
C {lab_pin.sym} 1740 2400 0 0 {name=l1967 lab=BLB9}
N 1760 2360 1740 2360 {}
C {lab_pin.sym} 1740 2360 0 0 {name=l1968 lab=WL12}
N 1840 2440 1860 2440 {}
C {lab_pin.sym} 1860 2440 0 0 {name=l1969 lab=VDD}
N 1840 2360 1860 2360 {}
C {lab_pin.sym} 1860 2360 0 0 {name=l1970 lab=VSS}
C {bitcell_6t.sym} 2000 2400 0 0 {name=Xr12c10}
N 1960 2440 1940 2440 {}
C {lab_pin.sym} 1940 2440 0 0 {name=l1971 lab=BL10}
N 1960 2400 1940 2400 {}
C {lab_pin.sym} 1940 2400 0 0 {name=l1972 lab=BLB10}
N 1960 2360 1940 2360 {}
C {lab_pin.sym} 1940 2360 0 0 {name=l1973 lab=WL12}
N 2040 2440 2060 2440 {}
C {lab_pin.sym} 2060 2440 0 0 {name=l1974 lab=VDD}
N 2040 2360 2060 2360 {}
C {lab_pin.sym} 2060 2360 0 0 {name=l1975 lab=VSS}
C {bitcell_6t.sym} 2200 2400 0 0 {name=Xr12c11}
N 2160 2440 2140 2440 {}
C {lab_pin.sym} 2140 2440 0 0 {name=l1976 lab=BL11}
N 2160 2400 2140 2400 {}
C {lab_pin.sym} 2140 2400 0 0 {name=l1977 lab=BLB11}
N 2160 2360 2140 2360 {}
C {lab_pin.sym} 2140 2360 0 0 {name=l1978 lab=WL12}
N 2240 2440 2260 2440 {}
C {lab_pin.sym} 2260 2440 0 0 {name=l1979 lab=VDD}
N 2240 2360 2260 2360 {}
C {lab_pin.sym} 2260 2360 0 0 {name=l1980 lab=VSS}
C {bitcell_6t.sym} 2400 2400 0 0 {name=Xr12c12}
N 2360 2440 2340 2440 {}
C {lab_pin.sym} 2340 2440 0 0 {name=l1981 lab=BL12}
N 2360 2400 2340 2400 {}
C {lab_pin.sym} 2340 2400 0 0 {name=l1982 lab=BLB12}
N 2360 2360 2340 2360 {}
C {lab_pin.sym} 2340 2360 0 0 {name=l1983 lab=WL12}
N 2440 2440 2460 2440 {}
C {lab_pin.sym} 2460 2440 0 0 {name=l1984 lab=VDD}
N 2440 2360 2460 2360 {}
C {lab_pin.sym} 2460 2360 0 0 {name=l1985 lab=VSS}
C {bitcell_6t.sym} 2600 2400 0 0 {name=Xr12c13}
N 2560 2440 2540 2440 {}
C {lab_pin.sym} 2540 2440 0 0 {name=l1986 lab=BL13}
N 2560 2400 2540 2400 {}
C {lab_pin.sym} 2540 2400 0 0 {name=l1987 lab=BLB13}
N 2560 2360 2540 2360 {}
C {lab_pin.sym} 2540 2360 0 0 {name=l1988 lab=WL12}
N 2640 2440 2660 2440 {}
C {lab_pin.sym} 2660 2440 0 0 {name=l1989 lab=VDD}
N 2640 2360 2660 2360 {}
C {lab_pin.sym} 2660 2360 0 0 {name=l1990 lab=VSS}
C {bitcell_6t.sym} 2800 2400 0 0 {name=Xr12c14}
N 2760 2440 2740 2440 {}
C {lab_pin.sym} 2740 2440 0 0 {name=l1991 lab=BL14}
N 2760 2400 2740 2400 {}
C {lab_pin.sym} 2740 2400 0 0 {name=l1992 lab=BLB14}
N 2760 2360 2740 2360 {}
C {lab_pin.sym} 2740 2360 0 0 {name=l1993 lab=WL12}
N 2840 2440 2860 2440 {}
C {lab_pin.sym} 2860 2440 0 0 {name=l1994 lab=VDD}
N 2840 2360 2860 2360 {}
C {lab_pin.sym} 2860 2360 0 0 {name=l1995 lab=VSS}
C {bitcell_6t.sym} 3000 2400 0 0 {name=Xr12c15}
N 2960 2440 2940 2440 {}
C {lab_pin.sym} 2940 2440 0 0 {name=l1996 lab=BL15}
N 2960 2400 2940 2400 {}
C {lab_pin.sym} 2940 2400 0 0 {name=l1997 lab=BLB15}
N 2960 2360 2940 2360 {}
C {lab_pin.sym} 2940 2360 0 0 {name=l1998 lab=WL12}
N 3040 2440 3060 2440 {}
C {lab_pin.sym} 3060 2440 0 0 {name=l1999 lab=VDD}
N 3040 2360 3060 2360 {}
C {lab_pin.sym} 3060 2360 0 0 {name=l2000 lab=VSS}
C {bitcell_6t.sym} 3200 2400 0 0 {name=Xr12c16}
N 3160 2440 3140 2440 {}
C {lab_pin.sym} 3140 2440 0 0 {name=l2001 lab=BL16}
N 3160 2400 3140 2400 {}
C {lab_pin.sym} 3140 2400 0 0 {name=l2002 lab=BLB16}
N 3160 2360 3140 2360 {}
C {lab_pin.sym} 3140 2360 0 0 {name=l2003 lab=WL12}
N 3240 2440 3260 2440 {}
C {lab_pin.sym} 3260 2440 0 0 {name=l2004 lab=VDD}
N 3240 2360 3260 2360 {}
C {lab_pin.sym} 3260 2360 0 0 {name=l2005 lab=VSS}
C {bitcell_6t.sym} 3400 2400 0 0 {name=Xr12c17}
N 3360 2440 3340 2440 {}
C {lab_pin.sym} 3340 2440 0 0 {name=l2006 lab=BL17}
N 3360 2400 3340 2400 {}
C {lab_pin.sym} 3340 2400 0 0 {name=l2007 lab=BLB17}
N 3360 2360 3340 2360 {}
C {lab_pin.sym} 3340 2360 0 0 {name=l2008 lab=WL12}
N 3440 2440 3460 2440 {}
C {lab_pin.sym} 3460 2440 0 0 {name=l2009 lab=VDD}
N 3440 2360 3460 2360 {}
C {lab_pin.sym} 3460 2360 0 0 {name=l2010 lab=VSS}
C {bitcell_6t.sym} 3600 2400 0 0 {name=Xr12c18}
N 3560 2440 3540 2440 {}
C {lab_pin.sym} 3540 2440 0 0 {name=l2011 lab=BL18}
N 3560 2400 3540 2400 {}
C {lab_pin.sym} 3540 2400 0 0 {name=l2012 lab=BLB18}
N 3560 2360 3540 2360 {}
C {lab_pin.sym} 3540 2360 0 0 {name=l2013 lab=WL12}
N 3640 2440 3660 2440 {}
C {lab_pin.sym} 3660 2440 0 0 {name=l2014 lab=VDD}
N 3640 2360 3660 2360 {}
C {lab_pin.sym} 3660 2360 0 0 {name=l2015 lab=VSS}
C {bitcell_6t.sym} 3800 2400 0 0 {name=Xr12c19}
N 3760 2440 3740 2440 {}
C {lab_pin.sym} 3740 2440 0 0 {name=l2016 lab=BL19}
N 3760 2400 3740 2400 {}
C {lab_pin.sym} 3740 2400 0 0 {name=l2017 lab=BLB19}
N 3760 2360 3740 2360 {}
C {lab_pin.sym} 3740 2360 0 0 {name=l2018 lab=WL12}
N 3840 2440 3860 2440 {}
C {lab_pin.sym} 3860 2440 0 0 {name=l2019 lab=VDD}
N 3840 2360 3860 2360 {}
C {lab_pin.sym} 3860 2360 0 0 {name=l2020 lab=VSS}
C {bitcell_6t.sym} 4000 2400 0 0 {name=Xr12c20}
N 3960 2440 3940 2440 {}
C {lab_pin.sym} 3940 2440 0 0 {name=l2021 lab=BL20}
N 3960 2400 3940 2400 {}
C {lab_pin.sym} 3940 2400 0 0 {name=l2022 lab=BLB20}
N 3960 2360 3940 2360 {}
C {lab_pin.sym} 3940 2360 0 0 {name=l2023 lab=WL12}
N 4040 2440 4060 2440 {}
C {lab_pin.sym} 4060 2440 0 0 {name=l2024 lab=VDD}
N 4040 2360 4060 2360 {}
C {lab_pin.sym} 4060 2360 0 0 {name=l2025 lab=VSS}
C {bitcell_6t.sym} 4200 2400 0 0 {name=Xr12c21}
N 4160 2440 4140 2440 {}
C {lab_pin.sym} 4140 2440 0 0 {name=l2026 lab=BL21}
N 4160 2400 4140 2400 {}
C {lab_pin.sym} 4140 2400 0 0 {name=l2027 lab=BLB21}
N 4160 2360 4140 2360 {}
C {lab_pin.sym} 4140 2360 0 0 {name=l2028 lab=WL12}
N 4240 2440 4260 2440 {}
C {lab_pin.sym} 4260 2440 0 0 {name=l2029 lab=VDD}
N 4240 2360 4260 2360 {}
C {lab_pin.sym} 4260 2360 0 0 {name=l2030 lab=VSS}
C {bitcell_6t.sym} 4400 2400 0 0 {name=Xr12c22}
N 4360 2440 4340 2440 {}
C {lab_pin.sym} 4340 2440 0 0 {name=l2031 lab=BL22}
N 4360 2400 4340 2400 {}
C {lab_pin.sym} 4340 2400 0 0 {name=l2032 lab=BLB22}
N 4360 2360 4340 2360 {}
C {lab_pin.sym} 4340 2360 0 0 {name=l2033 lab=WL12}
N 4440 2440 4460 2440 {}
C {lab_pin.sym} 4460 2440 0 0 {name=l2034 lab=VDD}
N 4440 2360 4460 2360 {}
C {lab_pin.sym} 4460 2360 0 0 {name=l2035 lab=VSS}
C {bitcell_6t.sym} 4600 2400 0 0 {name=Xr12c23}
N 4560 2440 4540 2440 {}
C {lab_pin.sym} 4540 2440 0 0 {name=l2036 lab=BL23}
N 4560 2400 4540 2400 {}
C {lab_pin.sym} 4540 2400 0 0 {name=l2037 lab=BLB23}
N 4560 2360 4540 2360 {}
C {lab_pin.sym} 4540 2360 0 0 {name=l2038 lab=WL12}
N 4640 2440 4660 2440 {}
C {lab_pin.sym} 4660 2440 0 0 {name=l2039 lab=VDD}
N 4640 2360 4660 2360 {}
C {lab_pin.sym} 4660 2360 0 0 {name=l2040 lab=VSS}
C {bitcell_6t.sym} 4800 2400 0 0 {name=Xr12c24}
N 4760 2440 4740 2440 {}
C {lab_pin.sym} 4740 2440 0 0 {name=l2041 lab=BL24}
N 4760 2400 4740 2400 {}
C {lab_pin.sym} 4740 2400 0 0 {name=l2042 lab=BLB24}
N 4760 2360 4740 2360 {}
C {lab_pin.sym} 4740 2360 0 0 {name=l2043 lab=WL12}
N 4840 2440 4860 2440 {}
C {lab_pin.sym} 4860 2440 0 0 {name=l2044 lab=VDD}
N 4840 2360 4860 2360 {}
C {lab_pin.sym} 4860 2360 0 0 {name=l2045 lab=VSS}
C {bitcell_6t.sym} 5000 2400 0 0 {name=Xr12c25}
N 4960 2440 4940 2440 {}
C {lab_pin.sym} 4940 2440 0 0 {name=l2046 lab=BL25}
N 4960 2400 4940 2400 {}
C {lab_pin.sym} 4940 2400 0 0 {name=l2047 lab=BLB25}
N 4960 2360 4940 2360 {}
C {lab_pin.sym} 4940 2360 0 0 {name=l2048 lab=WL12}
N 5040 2440 5060 2440 {}
C {lab_pin.sym} 5060 2440 0 0 {name=l2049 lab=VDD}
N 5040 2360 5060 2360 {}
C {lab_pin.sym} 5060 2360 0 0 {name=l2050 lab=VSS}
C {bitcell_6t.sym} 5200 2400 0 0 {name=Xr12c26}
N 5160 2440 5140 2440 {}
C {lab_pin.sym} 5140 2440 0 0 {name=l2051 lab=BL26}
N 5160 2400 5140 2400 {}
C {lab_pin.sym} 5140 2400 0 0 {name=l2052 lab=BLB26}
N 5160 2360 5140 2360 {}
C {lab_pin.sym} 5140 2360 0 0 {name=l2053 lab=WL12}
N 5240 2440 5260 2440 {}
C {lab_pin.sym} 5260 2440 0 0 {name=l2054 lab=VDD}
N 5240 2360 5260 2360 {}
C {lab_pin.sym} 5260 2360 0 0 {name=l2055 lab=VSS}
C {bitcell_6t.sym} 5400 2400 0 0 {name=Xr12c27}
N 5360 2440 5340 2440 {}
C {lab_pin.sym} 5340 2440 0 0 {name=l2056 lab=BL27}
N 5360 2400 5340 2400 {}
C {lab_pin.sym} 5340 2400 0 0 {name=l2057 lab=BLB27}
N 5360 2360 5340 2360 {}
C {lab_pin.sym} 5340 2360 0 0 {name=l2058 lab=WL12}
N 5440 2440 5460 2440 {}
C {lab_pin.sym} 5460 2440 0 0 {name=l2059 lab=VDD}
N 5440 2360 5460 2360 {}
C {lab_pin.sym} 5460 2360 0 0 {name=l2060 lab=VSS}
C {bitcell_6t.sym} 5600 2400 0 0 {name=Xr12c28}
N 5560 2440 5540 2440 {}
C {lab_pin.sym} 5540 2440 0 0 {name=l2061 lab=BL28}
N 5560 2400 5540 2400 {}
C {lab_pin.sym} 5540 2400 0 0 {name=l2062 lab=BLB28}
N 5560 2360 5540 2360 {}
C {lab_pin.sym} 5540 2360 0 0 {name=l2063 lab=WL12}
N 5640 2440 5660 2440 {}
C {lab_pin.sym} 5660 2440 0 0 {name=l2064 lab=VDD}
N 5640 2360 5660 2360 {}
C {lab_pin.sym} 5660 2360 0 0 {name=l2065 lab=VSS}
C {bitcell_6t.sym} 5800 2400 0 0 {name=Xr12c29}
N 5760 2440 5740 2440 {}
C {lab_pin.sym} 5740 2440 0 0 {name=l2066 lab=BL29}
N 5760 2400 5740 2400 {}
C {lab_pin.sym} 5740 2400 0 0 {name=l2067 lab=BLB29}
N 5760 2360 5740 2360 {}
C {lab_pin.sym} 5740 2360 0 0 {name=l2068 lab=WL12}
N 5840 2440 5860 2440 {}
C {lab_pin.sym} 5860 2440 0 0 {name=l2069 lab=VDD}
N 5840 2360 5860 2360 {}
C {lab_pin.sym} 5860 2360 0 0 {name=l2070 lab=VSS}
C {bitcell_6t.sym} 6000 2400 0 0 {name=Xr12c30}
N 5960 2440 5940 2440 {}
C {lab_pin.sym} 5940 2440 0 0 {name=l2071 lab=BL30}
N 5960 2400 5940 2400 {}
C {lab_pin.sym} 5940 2400 0 0 {name=l2072 lab=BLB30}
N 5960 2360 5940 2360 {}
C {lab_pin.sym} 5940 2360 0 0 {name=l2073 lab=WL12}
N 6040 2440 6060 2440 {}
C {lab_pin.sym} 6060 2440 0 0 {name=l2074 lab=VDD}
N 6040 2360 6060 2360 {}
C {lab_pin.sym} 6060 2360 0 0 {name=l2075 lab=VSS}
C {bitcell_6t.sym} 6200 2400 0 0 {name=Xr12c31}
N 6160 2440 6140 2440 {}
C {lab_pin.sym} 6140 2440 0 0 {name=l2076 lab=BL31}
N 6160 2400 6140 2400 {}
C {lab_pin.sym} 6140 2400 0 0 {name=l2077 lab=BLB31}
N 6160 2360 6140 2360 {}
C {lab_pin.sym} 6140 2360 0 0 {name=l2078 lab=WL12}
N 6240 2440 6260 2440 {}
C {lab_pin.sym} 6260 2440 0 0 {name=l2079 lab=VDD}
N 6240 2360 6260 2360 {}
C {lab_pin.sym} 6260 2360 0 0 {name=l2080 lab=VSS}
C {bitcell_6t.sym} 0 2600 0 0 {name=Xr13c0}
N -40 2640 -60 2640 {}
C {lab_pin.sym} -60 2640 0 0 {name=l2081 lab=BL0}
N -40 2600 -60 2600 {}
C {lab_pin.sym} -60 2600 0 0 {name=l2082 lab=BLB0}
N -40 2560 -60 2560 {}
C {lab_pin.sym} -60 2560 0 0 {name=l2083 lab=WL13}
N 40 2640 60 2640 {}
C {lab_pin.sym} 60 2640 0 0 {name=l2084 lab=VDD}
N 40 2560 60 2560 {}
C {lab_pin.sym} 60 2560 0 0 {name=l2085 lab=VSS}
C {bitcell_6t.sym} 200 2600 0 0 {name=Xr13c1}
N 160 2640 140 2640 {}
C {lab_pin.sym} 140 2640 0 0 {name=l2086 lab=BL1}
N 160 2600 140 2600 {}
C {lab_pin.sym} 140 2600 0 0 {name=l2087 lab=BLB1}
N 160 2560 140 2560 {}
C {lab_pin.sym} 140 2560 0 0 {name=l2088 lab=WL13}
N 240 2640 260 2640 {}
C {lab_pin.sym} 260 2640 0 0 {name=l2089 lab=VDD}
N 240 2560 260 2560 {}
C {lab_pin.sym} 260 2560 0 0 {name=l2090 lab=VSS}
C {bitcell_6t.sym} 400 2600 0 0 {name=Xr13c2}
N 360 2640 340 2640 {}
C {lab_pin.sym} 340 2640 0 0 {name=l2091 lab=BL2}
N 360 2600 340 2600 {}
C {lab_pin.sym} 340 2600 0 0 {name=l2092 lab=BLB2}
N 360 2560 340 2560 {}
C {lab_pin.sym} 340 2560 0 0 {name=l2093 lab=WL13}
N 440 2640 460 2640 {}
C {lab_pin.sym} 460 2640 0 0 {name=l2094 lab=VDD}
N 440 2560 460 2560 {}
C {lab_pin.sym} 460 2560 0 0 {name=l2095 lab=VSS}
C {bitcell_6t.sym} 600 2600 0 0 {name=Xr13c3}
N 560 2640 540 2640 {}
C {lab_pin.sym} 540 2640 0 0 {name=l2096 lab=BL3}
N 560 2600 540 2600 {}
C {lab_pin.sym} 540 2600 0 0 {name=l2097 lab=BLB3}
N 560 2560 540 2560 {}
C {lab_pin.sym} 540 2560 0 0 {name=l2098 lab=WL13}
N 640 2640 660 2640 {}
C {lab_pin.sym} 660 2640 0 0 {name=l2099 lab=VDD}
N 640 2560 660 2560 {}
C {lab_pin.sym} 660 2560 0 0 {name=l2100 lab=VSS}
C {bitcell_6t.sym} 800 2600 0 0 {name=Xr13c4}
N 760 2640 740 2640 {}
C {lab_pin.sym} 740 2640 0 0 {name=l2101 lab=BL4}
N 760 2600 740 2600 {}
C {lab_pin.sym} 740 2600 0 0 {name=l2102 lab=BLB4}
N 760 2560 740 2560 {}
C {lab_pin.sym} 740 2560 0 0 {name=l2103 lab=WL13}
N 840 2640 860 2640 {}
C {lab_pin.sym} 860 2640 0 0 {name=l2104 lab=VDD}
N 840 2560 860 2560 {}
C {lab_pin.sym} 860 2560 0 0 {name=l2105 lab=VSS}
C {bitcell_6t.sym} 1000 2600 0 0 {name=Xr13c5}
N 960 2640 940 2640 {}
C {lab_pin.sym} 940 2640 0 0 {name=l2106 lab=BL5}
N 960 2600 940 2600 {}
C {lab_pin.sym} 940 2600 0 0 {name=l2107 lab=BLB5}
N 960 2560 940 2560 {}
C {lab_pin.sym} 940 2560 0 0 {name=l2108 lab=WL13}
N 1040 2640 1060 2640 {}
C {lab_pin.sym} 1060 2640 0 0 {name=l2109 lab=VDD}
N 1040 2560 1060 2560 {}
C {lab_pin.sym} 1060 2560 0 0 {name=l2110 lab=VSS}
C {bitcell_6t.sym} 1200 2600 0 0 {name=Xr13c6}
N 1160 2640 1140 2640 {}
C {lab_pin.sym} 1140 2640 0 0 {name=l2111 lab=BL6}
N 1160 2600 1140 2600 {}
C {lab_pin.sym} 1140 2600 0 0 {name=l2112 lab=BLB6}
N 1160 2560 1140 2560 {}
C {lab_pin.sym} 1140 2560 0 0 {name=l2113 lab=WL13}
N 1240 2640 1260 2640 {}
C {lab_pin.sym} 1260 2640 0 0 {name=l2114 lab=VDD}
N 1240 2560 1260 2560 {}
C {lab_pin.sym} 1260 2560 0 0 {name=l2115 lab=VSS}
C {bitcell_6t.sym} 1400 2600 0 0 {name=Xr13c7}
N 1360 2640 1340 2640 {}
C {lab_pin.sym} 1340 2640 0 0 {name=l2116 lab=BL7}
N 1360 2600 1340 2600 {}
C {lab_pin.sym} 1340 2600 0 0 {name=l2117 lab=BLB7}
N 1360 2560 1340 2560 {}
C {lab_pin.sym} 1340 2560 0 0 {name=l2118 lab=WL13}
N 1440 2640 1460 2640 {}
C {lab_pin.sym} 1460 2640 0 0 {name=l2119 lab=VDD}
N 1440 2560 1460 2560 {}
C {lab_pin.sym} 1460 2560 0 0 {name=l2120 lab=VSS}
C {bitcell_6t.sym} 1600 2600 0 0 {name=Xr13c8}
N 1560 2640 1540 2640 {}
C {lab_pin.sym} 1540 2640 0 0 {name=l2121 lab=BL8}
N 1560 2600 1540 2600 {}
C {lab_pin.sym} 1540 2600 0 0 {name=l2122 lab=BLB8}
N 1560 2560 1540 2560 {}
C {lab_pin.sym} 1540 2560 0 0 {name=l2123 lab=WL13}
N 1640 2640 1660 2640 {}
C {lab_pin.sym} 1660 2640 0 0 {name=l2124 lab=VDD}
N 1640 2560 1660 2560 {}
C {lab_pin.sym} 1660 2560 0 0 {name=l2125 lab=VSS}
C {bitcell_6t.sym} 1800 2600 0 0 {name=Xr13c9}
N 1760 2640 1740 2640 {}
C {lab_pin.sym} 1740 2640 0 0 {name=l2126 lab=BL9}
N 1760 2600 1740 2600 {}
C {lab_pin.sym} 1740 2600 0 0 {name=l2127 lab=BLB9}
N 1760 2560 1740 2560 {}
C {lab_pin.sym} 1740 2560 0 0 {name=l2128 lab=WL13}
N 1840 2640 1860 2640 {}
C {lab_pin.sym} 1860 2640 0 0 {name=l2129 lab=VDD}
N 1840 2560 1860 2560 {}
C {lab_pin.sym} 1860 2560 0 0 {name=l2130 lab=VSS}
C {bitcell_6t.sym} 2000 2600 0 0 {name=Xr13c10}
N 1960 2640 1940 2640 {}
C {lab_pin.sym} 1940 2640 0 0 {name=l2131 lab=BL10}
N 1960 2600 1940 2600 {}
C {lab_pin.sym} 1940 2600 0 0 {name=l2132 lab=BLB10}
N 1960 2560 1940 2560 {}
C {lab_pin.sym} 1940 2560 0 0 {name=l2133 lab=WL13}
N 2040 2640 2060 2640 {}
C {lab_pin.sym} 2060 2640 0 0 {name=l2134 lab=VDD}
N 2040 2560 2060 2560 {}
C {lab_pin.sym} 2060 2560 0 0 {name=l2135 lab=VSS}
C {bitcell_6t.sym} 2200 2600 0 0 {name=Xr13c11}
N 2160 2640 2140 2640 {}
C {lab_pin.sym} 2140 2640 0 0 {name=l2136 lab=BL11}
N 2160 2600 2140 2600 {}
C {lab_pin.sym} 2140 2600 0 0 {name=l2137 lab=BLB11}
N 2160 2560 2140 2560 {}
C {lab_pin.sym} 2140 2560 0 0 {name=l2138 lab=WL13}
N 2240 2640 2260 2640 {}
C {lab_pin.sym} 2260 2640 0 0 {name=l2139 lab=VDD}
N 2240 2560 2260 2560 {}
C {lab_pin.sym} 2260 2560 0 0 {name=l2140 lab=VSS}
C {bitcell_6t.sym} 2400 2600 0 0 {name=Xr13c12}
N 2360 2640 2340 2640 {}
C {lab_pin.sym} 2340 2640 0 0 {name=l2141 lab=BL12}
N 2360 2600 2340 2600 {}
C {lab_pin.sym} 2340 2600 0 0 {name=l2142 lab=BLB12}
N 2360 2560 2340 2560 {}
C {lab_pin.sym} 2340 2560 0 0 {name=l2143 lab=WL13}
N 2440 2640 2460 2640 {}
C {lab_pin.sym} 2460 2640 0 0 {name=l2144 lab=VDD}
N 2440 2560 2460 2560 {}
C {lab_pin.sym} 2460 2560 0 0 {name=l2145 lab=VSS}
C {bitcell_6t.sym} 2600 2600 0 0 {name=Xr13c13}
N 2560 2640 2540 2640 {}
C {lab_pin.sym} 2540 2640 0 0 {name=l2146 lab=BL13}
N 2560 2600 2540 2600 {}
C {lab_pin.sym} 2540 2600 0 0 {name=l2147 lab=BLB13}
N 2560 2560 2540 2560 {}
C {lab_pin.sym} 2540 2560 0 0 {name=l2148 lab=WL13}
N 2640 2640 2660 2640 {}
C {lab_pin.sym} 2660 2640 0 0 {name=l2149 lab=VDD}
N 2640 2560 2660 2560 {}
C {lab_pin.sym} 2660 2560 0 0 {name=l2150 lab=VSS}
C {bitcell_6t.sym} 2800 2600 0 0 {name=Xr13c14}
N 2760 2640 2740 2640 {}
C {lab_pin.sym} 2740 2640 0 0 {name=l2151 lab=BL14}
N 2760 2600 2740 2600 {}
C {lab_pin.sym} 2740 2600 0 0 {name=l2152 lab=BLB14}
N 2760 2560 2740 2560 {}
C {lab_pin.sym} 2740 2560 0 0 {name=l2153 lab=WL13}
N 2840 2640 2860 2640 {}
C {lab_pin.sym} 2860 2640 0 0 {name=l2154 lab=VDD}
N 2840 2560 2860 2560 {}
C {lab_pin.sym} 2860 2560 0 0 {name=l2155 lab=VSS}
C {bitcell_6t.sym} 3000 2600 0 0 {name=Xr13c15}
N 2960 2640 2940 2640 {}
C {lab_pin.sym} 2940 2640 0 0 {name=l2156 lab=BL15}
N 2960 2600 2940 2600 {}
C {lab_pin.sym} 2940 2600 0 0 {name=l2157 lab=BLB15}
N 2960 2560 2940 2560 {}
C {lab_pin.sym} 2940 2560 0 0 {name=l2158 lab=WL13}
N 3040 2640 3060 2640 {}
C {lab_pin.sym} 3060 2640 0 0 {name=l2159 lab=VDD}
N 3040 2560 3060 2560 {}
C {lab_pin.sym} 3060 2560 0 0 {name=l2160 lab=VSS}
C {bitcell_6t.sym} 3200 2600 0 0 {name=Xr13c16}
N 3160 2640 3140 2640 {}
C {lab_pin.sym} 3140 2640 0 0 {name=l2161 lab=BL16}
N 3160 2600 3140 2600 {}
C {lab_pin.sym} 3140 2600 0 0 {name=l2162 lab=BLB16}
N 3160 2560 3140 2560 {}
C {lab_pin.sym} 3140 2560 0 0 {name=l2163 lab=WL13}
N 3240 2640 3260 2640 {}
C {lab_pin.sym} 3260 2640 0 0 {name=l2164 lab=VDD}
N 3240 2560 3260 2560 {}
C {lab_pin.sym} 3260 2560 0 0 {name=l2165 lab=VSS}
C {bitcell_6t.sym} 3400 2600 0 0 {name=Xr13c17}
N 3360 2640 3340 2640 {}
C {lab_pin.sym} 3340 2640 0 0 {name=l2166 lab=BL17}
N 3360 2600 3340 2600 {}
C {lab_pin.sym} 3340 2600 0 0 {name=l2167 lab=BLB17}
N 3360 2560 3340 2560 {}
C {lab_pin.sym} 3340 2560 0 0 {name=l2168 lab=WL13}
N 3440 2640 3460 2640 {}
C {lab_pin.sym} 3460 2640 0 0 {name=l2169 lab=VDD}
N 3440 2560 3460 2560 {}
C {lab_pin.sym} 3460 2560 0 0 {name=l2170 lab=VSS}
C {bitcell_6t.sym} 3600 2600 0 0 {name=Xr13c18}
N 3560 2640 3540 2640 {}
C {lab_pin.sym} 3540 2640 0 0 {name=l2171 lab=BL18}
N 3560 2600 3540 2600 {}
C {lab_pin.sym} 3540 2600 0 0 {name=l2172 lab=BLB18}
N 3560 2560 3540 2560 {}
C {lab_pin.sym} 3540 2560 0 0 {name=l2173 lab=WL13}
N 3640 2640 3660 2640 {}
C {lab_pin.sym} 3660 2640 0 0 {name=l2174 lab=VDD}
N 3640 2560 3660 2560 {}
C {lab_pin.sym} 3660 2560 0 0 {name=l2175 lab=VSS}
C {bitcell_6t.sym} 3800 2600 0 0 {name=Xr13c19}
N 3760 2640 3740 2640 {}
C {lab_pin.sym} 3740 2640 0 0 {name=l2176 lab=BL19}
N 3760 2600 3740 2600 {}
C {lab_pin.sym} 3740 2600 0 0 {name=l2177 lab=BLB19}
N 3760 2560 3740 2560 {}
C {lab_pin.sym} 3740 2560 0 0 {name=l2178 lab=WL13}
N 3840 2640 3860 2640 {}
C {lab_pin.sym} 3860 2640 0 0 {name=l2179 lab=VDD}
N 3840 2560 3860 2560 {}
C {lab_pin.sym} 3860 2560 0 0 {name=l2180 lab=VSS}
C {bitcell_6t.sym} 4000 2600 0 0 {name=Xr13c20}
N 3960 2640 3940 2640 {}
C {lab_pin.sym} 3940 2640 0 0 {name=l2181 lab=BL20}
N 3960 2600 3940 2600 {}
C {lab_pin.sym} 3940 2600 0 0 {name=l2182 lab=BLB20}
N 3960 2560 3940 2560 {}
C {lab_pin.sym} 3940 2560 0 0 {name=l2183 lab=WL13}
N 4040 2640 4060 2640 {}
C {lab_pin.sym} 4060 2640 0 0 {name=l2184 lab=VDD}
N 4040 2560 4060 2560 {}
C {lab_pin.sym} 4060 2560 0 0 {name=l2185 lab=VSS}
C {bitcell_6t.sym} 4200 2600 0 0 {name=Xr13c21}
N 4160 2640 4140 2640 {}
C {lab_pin.sym} 4140 2640 0 0 {name=l2186 lab=BL21}
N 4160 2600 4140 2600 {}
C {lab_pin.sym} 4140 2600 0 0 {name=l2187 lab=BLB21}
N 4160 2560 4140 2560 {}
C {lab_pin.sym} 4140 2560 0 0 {name=l2188 lab=WL13}
N 4240 2640 4260 2640 {}
C {lab_pin.sym} 4260 2640 0 0 {name=l2189 lab=VDD}
N 4240 2560 4260 2560 {}
C {lab_pin.sym} 4260 2560 0 0 {name=l2190 lab=VSS}
C {bitcell_6t.sym} 4400 2600 0 0 {name=Xr13c22}
N 4360 2640 4340 2640 {}
C {lab_pin.sym} 4340 2640 0 0 {name=l2191 lab=BL22}
N 4360 2600 4340 2600 {}
C {lab_pin.sym} 4340 2600 0 0 {name=l2192 lab=BLB22}
N 4360 2560 4340 2560 {}
C {lab_pin.sym} 4340 2560 0 0 {name=l2193 lab=WL13}
N 4440 2640 4460 2640 {}
C {lab_pin.sym} 4460 2640 0 0 {name=l2194 lab=VDD}
N 4440 2560 4460 2560 {}
C {lab_pin.sym} 4460 2560 0 0 {name=l2195 lab=VSS}
C {bitcell_6t.sym} 4600 2600 0 0 {name=Xr13c23}
N 4560 2640 4540 2640 {}
C {lab_pin.sym} 4540 2640 0 0 {name=l2196 lab=BL23}
N 4560 2600 4540 2600 {}
C {lab_pin.sym} 4540 2600 0 0 {name=l2197 lab=BLB23}
N 4560 2560 4540 2560 {}
C {lab_pin.sym} 4540 2560 0 0 {name=l2198 lab=WL13}
N 4640 2640 4660 2640 {}
C {lab_pin.sym} 4660 2640 0 0 {name=l2199 lab=VDD}
N 4640 2560 4660 2560 {}
C {lab_pin.sym} 4660 2560 0 0 {name=l2200 lab=VSS}
C {bitcell_6t.sym} 4800 2600 0 0 {name=Xr13c24}
N 4760 2640 4740 2640 {}
C {lab_pin.sym} 4740 2640 0 0 {name=l2201 lab=BL24}
N 4760 2600 4740 2600 {}
C {lab_pin.sym} 4740 2600 0 0 {name=l2202 lab=BLB24}
N 4760 2560 4740 2560 {}
C {lab_pin.sym} 4740 2560 0 0 {name=l2203 lab=WL13}
N 4840 2640 4860 2640 {}
C {lab_pin.sym} 4860 2640 0 0 {name=l2204 lab=VDD}
N 4840 2560 4860 2560 {}
C {lab_pin.sym} 4860 2560 0 0 {name=l2205 lab=VSS}
C {bitcell_6t.sym} 5000 2600 0 0 {name=Xr13c25}
N 4960 2640 4940 2640 {}
C {lab_pin.sym} 4940 2640 0 0 {name=l2206 lab=BL25}
N 4960 2600 4940 2600 {}
C {lab_pin.sym} 4940 2600 0 0 {name=l2207 lab=BLB25}
N 4960 2560 4940 2560 {}
C {lab_pin.sym} 4940 2560 0 0 {name=l2208 lab=WL13}
N 5040 2640 5060 2640 {}
C {lab_pin.sym} 5060 2640 0 0 {name=l2209 lab=VDD}
N 5040 2560 5060 2560 {}
C {lab_pin.sym} 5060 2560 0 0 {name=l2210 lab=VSS}
C {bitcell_6t.sym} 5200 2600 0 0 {name=Xr13c26}
N 5160 2640 5140 2640 {}
C {lab_pin.sym} 5140 2640 0 0 {name=l2211 lab=BL26}
N 5160 2600 5140 2600 {}
C {lab_pin.sym} 5140 2600 0 0 {name=l2212 lab=BLB26}
N 5160 2560 5140 2560 {}
C {lab_pin.sym} 5140 2560 0 0 {name=l2213 lab=WL13}
N 5240 2640 5260 2640 {}
C {lab_pin.sym} 5260 2640 0 0 {name=l2214 lab=VDD}
N 5240 2560 5260 2560 {}
C {lab_pin.sym} 5260 2560 0 0 {name=l2215 lab=VSS}
C {bitcell_6t.sym} 5400 2600 0 0 {name=Xr13c27}
N 5360 2640 5340 2640 {}
C {lab_pin.sym} 5340 2640 0 0 {name=l2216 lab=BL27}
N 5360 2600 5340 2600 {}
C {lab_pin.sym} 5340 2600 0 0 {name=l2217 lab=BLB27}
N 5360 2560 5340 2560 {}
C {lab_pin.sym} 5340 2560 0 0 {name=l2218 lab=WL13}
N 5440 2640 5460 2640 {}
C {lab_pin.sym} 5460 2640 0 0 {name=l2219 lab=VDD}
N 5440 2560 5460 2560 {}
C {lab_pin.sym} 5460 2560 0 0 {name=l2220 lab=VSS}
C {bitcell_6t.sym} 5600 2600 0 0 {name=Xr13c28}
N 5560 2640 5540 2640 {}
C {lab_pin.sym} 5540 2640 0 0 {name=l2221 lab=BL28}
N 5560 2600 5540 2600 {}
C {lab_pin.sym} 5540 2600 0 0 {name=l2222 lab=BLB28}
N 5560 2560 5540 2560 {}
C {lab_pin.sym} 5540 2560 0 0 {name=l2223 lab=WL13}
N 5640 2640 5660 2640 {}
C {lab_pin.sym} 5660 2640 0 0 {name=l2224 lab=VDD}
N 5640 2560 5660 2560 {}
C {lab_pin.sym} 5660 2560 0 0 {name=l2225 lab=VSS}
C {bitcell_6t.sym} 5800 2600 0 0 {name=Xr13c29}
N 5760 2640 5740 2640 {}
C {lab_pin.sym} 5740 2640 0 0 {name=l2226 lab=BL29}
N 5760 2600 5740 2600 {}
C {lab_pin.sym} 5740 2600 0 0 {name=l2227 lab=BLB29}
N 5760 2560 5740 2560 {}
C {lab_pin.sym} 5740 2560 0 0 {name=l2228 lab=WL13}
N 5840 2640 5860 2640 {}
C {lab_pin.sym} 5860 2640 0 0 {name=l2229 lab=VDD}
N 5840 2560 5860 2560 {}
C {lab_pin.sym} 5860 2560 0 0 {name=l2230 lab=VSS}
C {bitcell_6t.sym} 6000 2600 0 0 {name=Xr13c30}
N 5960 2640 5940 2640 {}
C {lab_pin.sym} 5940 2640 0 0 {name=l2231 lab=BL30}
N 5960 2600 5940 2600 {}
C {lab_pin.sym} 5940 2600 0 0 {name=l2232 lab=BLB30}
N 5960 2560 5940 2560 {}
C {lab_pin.sym} 5940 2560 0 0 {name=l2233 lab=WL13}
N 6040 2640 6060 2640 {}
C {lab_pin.sym} 6060 2640 0 0 {name=l2234 lab=VDD}
N 6040 2560 6060 2560 {}
C {lab_pin.sym} 6060 2560 0 0 {name=l2235 lab=VSS}
C {bitcell_6t.sym} 6200 2600 0 0 {name=Xr13c31}
N 6160 2640 6140 2640 {}
C {lab_pin.sym} 6140 2640 0 0 {name=l2236 lab=BL31}
N 6160 2600 6140 2600 {}
C {lab_pin.sym} 6140 2600 0 0 {name=l2237 lab=BLB31}
N 6160 2560 6140 2560 {}
C {lab_pin.sym} 6140 2560 0 0 {name=l2238 lab=WL13}
N 6240 2640 6260 2640 {}
C {lab_pin.sym} 6260 2640 0 0 {name=l2239 lab=VDD}
N 6240 2560 6260 2560 {}
C {lab_pin.sym} 6260 2560 0 0 {name=l2240 lab=VSS}
C {bitcell_6t.sym} 0 2800 0 0 {name=Xr14c0}
N -40 2840 -60 2840 {}
C {lab_pin.sym} -60 2840 0 0 {name=l2241 lab=BL0}
N -40 2800 -60 2800 {}
C {lab_pin.sym} -60 2800 0 0 {name=l2242 lab=BLB0}
N -40 2760 -60 2760 {}
C {lab_pin.sym} -60 2760 0 0 {name=l2243 lab=WL14}
N 40 2840 60 2840 {}
C {lab_pin.sym} 60 2840 0 0 {name=l2244 lab=VDD}
N 40 2760 60 2760 {}
C {lab_pin.sym} 60 2760 0 0 {name=l2245 lab=VSS}
C {bitcell_6t.sym} 200 2800 0 0 {name=Xr14c1}
N 160 2840 140 2840 {}
C {lab_pin.sym} 140 2840 0 0 {name=l2246 lab=BL1}
N 160 2800 140 2800 {}
C {lab_pin.sym} 140 2800 0 0 {name=l2247 lab=BLB1}
N 160 2760 140 2760 {}
C {lab_pin.sym} 140 2760 0 0 {name=l2248 lab=WL14}
N 240 2840 260 2840 {}
C {lab_pin.sym} 260 2840 0 0 {name=l2249 lab=VDD}
N 240 2760 260 2760 {}
C {lab_pin.sym} 260 2760 0 0 {name=l2250 lab=VSS}
C {bitcell_6t.sym} 400 2800 0 0 {name=Xr14c2}
N 360 2840 340 2840 {}
C {lab_pin.sym} 340 2840 0 0 {name=l2251 lab=BL2}
N 360 2800 340 2800 {}
C {lab_pin.sym} 340 2800 0 0 {name=l2252 lab=BLB2}
N 360 2760 340 2760 {}
C {lab_pin.sym} 340 2760 0 0 {name=l2253 lab=WL14}
N 440 2840 460 2840 {}
C {lab_pin.sym} 460 2840 0 0 {name=l2254 lab=VDD}
N 440 2760 460 2760 {}
C {lab_pin.sym} 460 2760 0 0 {name=l2255 lab=VSS}
C {bitcell_6t.sym} 600 2800 0 0 {name=Xr14c3}
N 560 2840 540 2840 {}
C {lab_pin.sym} 540 2840 0 0 {name=l2256 lab=BL3}
N 560 2800 540 2800 {}
C {lab_pin.sym} 540 2800 0 0 {name=l2257 lab=BLB3}
N 560 2760 540 2760 {}
C {lab_pin.sym} 540 2760 0 0 {name=l2258 lab=WL14}
N 640 2840 660 2840 {}
C {lab_pin.sym} 660 2840 0 0 {name=l2259 lab=VDD}
N 640 2760 660 2760 {}
C {lab_pin.sym} 660 2760 0 0 {name=l2260 lab=VSS}
C {bitcell_6t.sym} 800 2800 0 0 {name=Xr14c4}
N 760 2840 740 2840 {}
C {lab_pin.sym} 740 2840 0 0 {name=l2261 lab=BL4}
N 760 2800 740 2800 {}
C {lab_pin.sym} 740 2800 0 0 {name=l2262 lab=BLB4}
N 760 2760 740 2760 {}
C {lab_pin.sym} 740 2760 0 0 {name=l2263 lab=WL14}
N 840 2840 860 2840 {}
C {lab_pin.sym} 860 2840 0 0 {name=l2264 lab=VDD}
N 840 2760 860 2760 {}
C {lab_pin.sym} 860 2760 0 0 {name=l2265 lab=VSS}
C {bitcell_6t.sym} 1000 2800 0 0 {name=Xr14c5}
N 960 2840 940 2840 {}
C {lab_pin.sym} 940 2840 0 0 {name=l2266 lab=BL5}
N 960 2800 940 2800 {}
C {lab_pin.sym} 940 2800 0 0 {name=l2267 lab=BLB5}
N 960 2760 940 2760 {}
C {lab_pin.sym} 940 2760 0 0 {name=l2268 lab=WL14}
N 1040 2840 1060 2840 {}
C {lab_pin.sym} 1060 2840 0 0 {name=l2269 lab=VDD}
N 1040 2760 1060 2760 {}
C {lab_pin.sym} 1060 2760 0 0 {name=l2270 lab=VSS}
C {bitcell_6t.sym} 1200 2800 0 0 {name=Xr14c6}
N 1160 2840 1140 2840 {}
C {lab_pin.sym} 1140 2840 0 0 {name=l2271 lab=BL6}
N 1160 2800 1140 2800 {}
C {lab_pin.sym} 1140 2800 0 0 {name=l2272 lab=BLB6}
N 1160 2760 1140 2760 {}
C {lab_pin.sym} 1140 2760 0 0 {name=l2273 lab=WL14}
N 1240 2840 1260 2840 {}
C {lab_pin.sym} 1260 2840 0 0 {name=l2274 lab=VDD}
N 1240 2760 1260 2760 {}
C {lab_pin.sym} 1260 2760 0 0 {name=l2275 lab=VSS}
C {bitcell_6t.sym} 1400 2800 0 0 {name=Xr14c7}
N 1360 2840 1340 2840 {}
C {lab_pin.sym} 1340 2840 0 0 {name=l2276 lab=BL7}
N 1360 2800 1340 2800 {}
C {lab_pin.sym} 1340 2800 0 0 {name=l2277 lab=BLB7}
N 1360 2760 1340 2760 {}
C {lab_pin.sym} 1340 2760 0 0 {name=l2278 lab=WL14}
N 1440 2840 1460 2840 {}
C {lab_pin.sym} 1460 2840 0 0 {name=l2279 lab=VDD}
N 1440 2760 1460 2760 {}
C {lab_pin.sym} 1460 2760 0 0 {name=l2280 lab=VSS}
C {bitcell_6t.sym} 1600 2800 0 0 {name=Xr14c8}
N 1560 2840 1540 2840 {}
C {lab_pin.sym} 1540 2840 0 0 {name=l2281 lab=BL8}
N 1560 2800 1540 2800 {}
C {lab_pin.sym} 1540 2800 0 0 {name=l2282 lab=BLB8}
N 1560 2760 1540 2760 {}
C {lab_pin.sym} 1540 2760 0 0 {name=l2283 lab=WL14}
N 1640 2840 1660 2840 {}
C {lab_pin.sym} 1660 2840 0 0 {name=l2284 lab=VDD}
N 1640 2760 1660 2760 {}
C {lab_pin.sym} 1660 2760 0 0 {name=l2285 lab=VSS}
C {bitcell_6t.sym} 1800 2800 0 0 {name=Xr14c9}
N 1760 2840 1740 2840 {}
C {lab_pin.sym} 1740 2840 0 0 {name=l2286 lab=BL9}
N 1760 2800 1740 2800 {}
C {lab_pin.sym} 1740 2800 0 0 {name=l2287 lab=BLB9}
N 1760 2760 1740 2760 {}
C {lab_pin.sym} 1740 2760 0 0 {name=l2288 lab=WL14}
N 1840 2840 1860 2840 {}
C {lab_pin.sym} 1860 2840 0 0 {name=l2289 lab=VDD}
N 1840 2760 1860 2760 {}
C {lab_pin.sym} 1860 2760 0 0 {name=l2290 lab=VSS}
C {bitcell_6t.sym} 2000 2800 0 0 {name=Xr14c10}
N 1960 2840 1940 2840 {}
C {lab_pin.sym} 1940 2840 0 0 {name=l2291 lab=BL10}
N 1960 2800 1940 2800 {}
C {lab_pin.sym} 1940 2800 0 0 {name=l2292 lab=BLB10}
N 1960 2760 1940 2760 {}
C {lab_pin.sym} 1940 2760 0 0 {name=l2293 lab=WL14}
N 2040 2840 2060 2840 {}
C {lab_pin.sym} 2060 2840 0 0 {name=l2294 lab=VDD}
N 2040 2760 2060 2760 {}
C {lab_pin.sym} 2060 2760 0 0 {name=l2295 lab=VSS}
C {bitcell_6t.sym} 2200 2800 0 0 {name=Xr14c11}
N 2160 2840 2140 2840 {}
C {lab_pin.sym} 2140 2840 0 0 {name=l2296 lab=BL11}
N 2160 2800 2140 2800 {}
C {lab_pin.sym} 2140 2800 0 0 {name=l2297 lab=BLB11}
N 2160 2760 2140 2760 {}
C {lab_pin.sym} 2140 2760 0 0 {name=l2298 lab=WL14}
N 2240 2840 2260 2840 {}
C {lab_pin.sym} 2260 2840 0 0 {name=l2299 lab=VDD}
N 2240 2760 2260 2760 {}
C {lab_pin.sym} 2260 2760 0 0 {name=l2300 lab=VSS}
C {bitcell_6t.sym} 2400 2800 0 0 {name=Xr14c12}
N 2360 2840 2340 2840 {}
C {lab_pin.sym} 2340 2840 0 0 {name=l2301 lab=BL12}
N 2360 2800 2340 2800 {}
C {lab_pin.sym} 2340 2800 0 0 {name=l2302 lab=BLB12}
N 2360 2760 2340 2760 {}
C {lab_pin.sym} 2340 2760 0 0 {name=l2303 lab=WL14}
N 2440 2840 2460 2840 {}
C {lab_pin.sym} 2460 2840 0 0 {name=l2304 lab=VDD}
N 2440 2760 2460 2760 {}
C {lab_pin.sym} 2460 2760 0 0 {name=l2305 lab=VSS}
C {bitcell_6t.sym} 2600 2800 0 0 {name=Xr14c13}
N 2560 2840 2540 2840 {}
C {lab_pin.sym} 2540 2840 0 0 {name=l2306 lab=BL13}
N 2560 2800 2540 2800 {}
C {lab_pin.sym} 2540 2800 0 0 {name=l2307 lab=BLB13}
N 2560 2760 2540 2760 {}
C {lab_pin.sym} 2540 2760 0 0 {name=l2308 lab=WL14}
N 2640 2840 2660 2840 {}
C {lab_pin.sym} 2660 2840 0 0 {name=l2309 lab=VDD}
N 2640 2760 2660 2760 {}
C {lab_pin.sym} 2660 2760 0 0 {name=l2310 lab=VSS}
C {bitcell_6t.sym} 2800 2800 0 0 {name=Xr14c14}
N 2760 2840 2740 2840 {}
C {lab_pin.sym} 2740 2840 0 0 {name=l2311 lab=BL14}
N 2760 2800 2740 2800 {}
C {lab_pin.sym} 2740 2800 0 0 {name=l2312 lab=BLB14}
N 2760 2760 2740 2760 {}
C {lab_pin.sym} 2740 2760 0 0 {name=l2313 lab=WL14}
N 2840 2840 2860 2840 {}
C {lab_pin.sym} 2860 2840 0 0 {name=l2314 lab=VDD}
N 2840 2760 2860 2760 {}
C {lab_pin.sym} 2860 2760 0 0 {name=l2315 lab=VSS}
C {bitcell_6t.sym} 3000 2800 0 0 {name=Xr14c15}
N 2960 2840 2940 2840 {}
C {lab_pin.sym} 2940 2840 0 0 {name=l2316 lab=BL15}
N 2960 2800 2940 2800 {}
C {lab_pin.sym} 2940 2800 0 0 {name=l2317 lab=BLB15}
N 2960 2760 2940 2760 {}
C {lab_pin.sym} 2940 2760 0 0 {name=l2318 lab=WL14}
N 3040 2840 3060 2840 {}
C {lab_pin.sym} 3060 2840 0 0 {name=l2319 lab=VDD}
N 3040 2760 3060 2760 {}
C {lab_pin.sym} 3060 2760 0 0 {name=l2320 lab=VSS}
C {bitcell_6t.sym} 3200 2800 0 0 {name=Xr14c16}
N 3160 2840 3140 2840 {}
C {lab_pin.sym} 3140 2840 0 0 {name=l2321 lab=BL16}
N 3160 2800 3140 2800 {}
C {lab_pin.sym} 3140 2800 0 0 {name=l2322 lab=BLB16}
N 3160 2760 3140 2760 {}
C {lab_pin.sym} 3140 2760 0 0 {name=l2323 lab=WL14}
N 3240 2840 3260 2840 {}
C {lab_pin.sym} 3260 2840 0 0 {name=l2324 lab=VDD}
N 3240 2760 3260 2760 {}
C {lab_pin.sym} 3260 2760 0 0 {name=l2325 lab=VSS}
C {bitcell_6t.sym} 3400 2800 0 0 {name=Xr14c17}
N 3360 2840 3340 2840 {}
C {lab_pin.sym} 3340 2840 0 0 {name=l2326 lab=BL17}
N 3360 2800 3340 2800 {}
C {lab_pin.sym} 3340 2800 0 0 {name=l2327 lab=BLB17}
N 3360 2760 3340 2760 {}
C {lab_pin.sym} 3340 2760 0 0 {name=l2328 lab=WL14}
N 3440 2840 3460 2840 {}
C {lab_pin.sym} 3460 2840 0 0 {name=l2329 lab=VDD}
N 3440 2760 3460 2760 {}
C {lab_pin.sym} 3460 2760 0 0 {name=l2330 lab=VSS}
C {bitcell_6t.sym} 3600 2800 0 0 {name=Xr14c18}
N 3560 2840 3540 2840 {}
C {lab_pin.sym} 3540 2840 0 0 {name=l2331 lab=BL18}
N 3560 2800 3540 2800 {}
C {lab_pin.sym} 3540 2800 0 0 {name=l2332 lab=BLB18}
N 3560 2760 3540 2760 {}
C {lab_pin.sym} 3540 2760 0 0 {name=l2333 lab=WL14}
N 3640 2840 3660 2840 {}
C {lab_pin.sym} 3660 2840 0 0 {name=l2334 lab=VDD}
N 3640 2760 3660 2760 {}
C {lab_pin.sym} 3660 2760 0 0 {name=l2335 lab=VSS}
C {bitcell_6t.sym} 3800 2800 0 0 {name=Xr14c19}
N 3760 2840 3740 2840 {}
C {lab_pin.sym} 3740 2840 0 0 {name=l2336 lab=BL19}
N 3760 2800 3740 2800 {}
C {lab_pin.sym} 3740 2800 0 0 {name=l2337 lab=BLB19}
N 3760 2760 3740 2760 {}
C {lab_pin.sym} 3740 2760 0 0 {name=l2338 lab=WL14}
N 3840 2840 3860 2840 {}
C {lab_pin.sym} 3860 2840 0 0 {name=l2339 lab=VDD}
N 3840 2760 3860 2760 {}
C {lab_pin.sym} 3860 2760 0 0 {name=l2340 lab=VSS}
C {bitcell_6t.sym} 4000 2800 0 0 {name=Xr14c20}
N 3960 2840 3940 2840 {}
C {lab_pin.sym} 3940 2840 0 0 {name=l2341 lab=BL20}
N 3960 2800 3940 2800 {}
C {lab_pin.sym} 3940 2800 0 0 {name=l2342 lab=BLB20}
N 3960 2760 3940 2760 {}
C {lab_pin.sym} 3940 2760 0 0 {name=l2343 lab=WL14}
N 4040 2840 4060 2840 {}
C {lab_pin.sym} 4060 2840 0 0 {name=l2344 lab=VDD}
N 4040 2760 4060 2760 {}
C {lab_pin.sym} 4060 2760 0 0 {name=l2345 lab=VSS}
C {bitcell_6t.sym} 4200 2800 0 0 {name=Xr14c21}
N 4160 2840 4140 2840 {}
C {lab_pin.sym} 4140 2840 0 0 {name=l2346 lab=BL21}
N 4160 2800 4140 2800 {}
C {lab_pin.sym} 4140 2800 0 0 {name=l2347 lab=BLB21}
N 4160 2760 4140 2760 {}
C {lab_pin.sym} 4140 2760 0 0 {name=l2348 lab=WL14}
N 4240 2840 4260 2840 {}
C {lab_pin.sym} 4260 2840 0 0 {name=l2349 lab=VDD}
N 4240 2760 4260 2760 {}
C {lab_pin.sym} 4260 2760 0 0 {name=l2350 lab=VSS}
C {bitcell_6t.sym} 4400 2800 0 0 {name=Xr14c22}
N 4360 2840 4340 2840 {}
C {lab_pin.sym} 4340 2840 0 0 {name=l2351 lab=BL22}
N 4360 2800 4340 2800 {}
C {lab_pin.sym} 4340 2800 0 0 {name=l2352 lab=BLB22}
N 4360 2760 4340 2760 {}
C {lab_pin.sym} 4340 2760 0 0 {name=l2353 lab=WL14}
N 4440 2840 4460 2840 {}
C {lab_pin.sym} 4460 2840 0 0 {name=l2354 lab=VDD}
N 4440 2760 4460 2760 {}
C {lab_pin.sym} 4460 2760 0 0 {name=l2355 lab=VSS}
C {bitcell_6t.sym} 4600 2800 0 0 {name=Xr14c23}
N 4560 2840 4540 2840 {}
C {lab_pin.sym} 4540 2840 0 0 {name=l2356 lab=BL23}
N 4560 2800 4540 2800 {}
C {lab_pin.sym} 4540 2800 0 0 {name=l2357 lab=BLB23}
N 4560 2760 4540 2760 {}
C {lab_pin.sym} 4540 2760 0 0 {name=l2358 lab=WL14}
N 4640 2840 4660 2840 {}
C {lab_pin.sym} 4660 2840 0 0 {name=l2359 lab=VDD}
N 4640 2760 4660 2760 {}
C {lab_pin.sym} 4660 2760 0 0 {name=l2360 lab=VSS}
C {bitcell_6t.sym} 4800 2800 0 0 {name=Xr14c24}
N 4760 2840 4740 2840 {}
C {lab_pin.sym} 4740 2840 0 0 {name=l2361 lab=BL24}
N 4760 2800 4740 2800 {}
C {lab_pin.sym} 4740 2800 0 0 {name=l2362 lab=BLB24}
N 4760 2760 4740 2760 {}
C {lab_pin.sym} 4740 2760 0 0 {name=l2363 lab=WL14}
N 4840 2840 4860 2840 {}
C {lab_pin.sym} 4860 2840 0 0 {name=l2364 lab=VDD}
N 4840 2760 4860 2760 {}
C {lab_pin.sym} 4860 2760 0 0 {name=l2365 lab=VSS}
C {bitcell_6t.sym} 5000 2800 0 0 {name=Xr14c25}
N 4960 2840 4940 2840 {}
C {lab_pin.sym} 4940 2840 0 0 {name=l2366 lab=BL25}
N 4960 2800 4940 2800 {}
C {lab_pin.sym} 4940 2800 0 0 {name=l2367 lab=BLB25}
N 4960 2760 4940 2760 {}
C {lab_pin.sym} 4940 2760 0 0 {name=l2368 lab=WL14}
N 5040 2840 5060 2840 {}
C {lab_pin.sym} 5060 2840 0 0 {name=l2369 lab=VDD}
N 5040 2760 5060 2760 {}
C {lab_pin.sym} 5060 2760 0 0 {name=l2370 lab=VSS}
C {bitcell_6t.sym} 5200 2800 0 0 {name=Xr14c26}
N 5160 2840 5140 2840 {}
C {lab_pin.sym} 5140 2840 0 0 {name=l2371 lab=BL26}
N 5160 2800 5140 2800 {}
C {lab_pin.sym} 5140 2800 0 0 {name=l2372 lab=BLB26}
N 5160 2760 5140 2760 {}
C {lab_pin.sym} 5140 2760 0 0 {name=l2373 lab=WL14}
N 5240 2840 5260 2840 {}
C {lab_pin.sym} 5260 2840 0 0 {name=l2374 lab=VDD}
N 5240 2760 5260 2760 {}
C {lab_pin.sym} 5260 2760 0 0 {name=l2375 lab=VSS}
C {bitcell_6t.sym} 5400 2800 0 0 {name=Xr14c27}
N 5360 2840 5340 2840 {}
C {lab_pin.sym} 5340 2840 0 0 {name=l2376 lab=BL27}
N 5360 2800 5340 2800 {}
C {lab_pin.sym} 5340 2800 0 0 {name=l2377 lab=BLB27}
N 5360 2760 5340 2760 {}
C {lab_pin.sym} 5340 2760 0 0 {name=l2378 lab=WL14}
N 5440 2840 5460 2840 {}
C {lab_pin.sym} 5460 2840 0 0 {name=l2379 lab=VDD}
N 5440 2760 5460 2760 {}
C {lab_pin.sym} 5460 2760 0 0 {name=l2380 lab=VSS}
C {bitcell_6t.sym} 5600 2800 0 0 {name=Xr14c28}
N 5560 2840 5540 2840 {}
C {lab_pin.sym} 5540 2840 0 0 {name=l2381 lab=BL28}
N 5560 2800 5540 2800 {}
C {lab_pin.sym} 5540 2800 0 0 {name=l2382 lab=BLB28}
N 5560 2760 5540 2760 {}
C {lab_pin.sym} 5540 2760 0 0 {name=l2383 lab=WL14}
N 5640 2840 5660 2840 {}
C {lab_pin.sym} 5660 2840 0 0 {name=l2384 lab=VDD}
N 5640 2760 5660 2760 {}
C {lab_pin.sym} 5660 2760 0 0 {name=l2385 lab=VSS}
C {bitcell_6t.sym} 5800 2800 0 0 {name=Xr14c29}
N 5760 2840 5740 2840 {}
C {lab_pin.sym} 5740 2840 0 0 {name=l2386 lab=BL29}
N 5760 2800 5740 2800 {}
C {lab_pin.sym} 5740 2800 0 0 {name=l2387 lab=BLB29}
N 5760 2760 5740 2760 {}
C {lab_pin.sym} 5740 2760 0 0 {name=l2388 lab=WL14}
N 5840 2840 5860 2840 {}
C {lab_pin.sym} 5860 2840 0 0 {name=l2389 lab=VDD}
N 5840 2760 5860 2760 {}
C {lab_pin.sym} 5860 2760 0 0 {name=l2390 lab=VSS}
C {bitcell_6t.sym} 6000 2800 0 0 {name=Xr14c30}
N 5960 2840 5940 2840 {}
C {lab_pin.sym} 5940 2840 0 0 {name=l2391 lab=BL30}
N 5960 2800 5940 2800 {}
C {lab_pin.sym} 5940 2800 0 0 {name=l2392 lab=BLB30}
N 5960 2760 5940 2760 {}
C {lab_pin.sym} 5940 2760 0 0 {name=l2393 lab=WL14}
N 6040 2840 6060 2840 {}
C {lab_pin.sym} 6060 2840 0 0 {name=l2394 lab=VDD}
N 6040 2760 6060 2760 {}
C {lab_pin.sym} 6060 2760 0 0 {name=l2395 lab=VSS}
C {bitcell_6t.sym} 6200 2800 0 0 {name=Xr14c31}
N 6160 2840 6140 2840 {}
C {lab_pin.sym} 6140 2840 0 0 {name=l2396 lab=BL31}
N 6160 2800 6140 2800 {}
C {lab_pin.sym} 6140 2800 0 0 {name=l2397 lab=BLB31}
N 6160 2760 6140 2760 {}
C {lab_pin.sym} 6140 2760 0 0 {name=l2398 lab=WL14}
N 6240 2840 6260 2840 {}
C {lab_pin.sym} 6260 2840 0 0 {name=l2399 lab=VDD}
N 6240 2760 6260 2760 {}
C {lab_pin.sym} 6260 2760 0 0 {name=l2400 lab=VSS}
C {bitcell_6t.sym} 0 3000 0 0 {name=Xr15c0}
N -40 3040 -60 3040 {}
C {lab_pin.sym} -60 3040 0 0 {name=l2401 lab=BL0}
N -40 3000 -60 3000 {}
C {lab_pin.sym} -60 3000 0 0 {name=l2402 lab=BLB0}
N -40 2960 -60 2960 {}
C {lab_pin.sym} -60 2960 0 0 {name=l2403 lab=WL15}
N 40 3040 60 3040 {}
C {lab_pin.sym} 60 3040 0 0 {name=l2404 lab=VDD}
N 40 2960 60 2960 {}
C {lab_pin.sym} 60 2960 0 0 {name=l2405 lab=VSS}
C {bitcell_6t.sym} 200 3000 0 0 {name=Xr15c1}
N 160 3040 140 3040 {}
C {lab_pin.sym} 140 3040 0 0 {name=l2406 lab=BL1}
N 160 3000 140 3000 {}
C {lab_pin.sym} 140 3000 0 0 {name=l2407 lab=BLB1}
N 160 2960 140 2960 {}
C {lab_pin.sym} 140 2960 0 0 {name=l2408 lab=WL15}
N 240 3040 260 3040 {}
C {lab_pin.sym} 260 3040 0 0 {name=l2409 lab=VDD}
N 240 2960 260 2960 {}
C {lab_pin.sym} 260 2960 0 0 {name=l2410 lab=VSS}
C {bitcell_6t.sym} 400 3000 0 0 {name=Xr15c2}
N 360 3040 340 3040 {}
C {lab_pin.sym} 340 3040 0 0 {name=l2411 lab=BL2}
N 360 3000 340 3000 {}
C {lab_pin.sym} 340 3000 0 0 {name=l2412 lab=BLB2}
N 360 2960 340 2960 {}
C {lab_pin.sym} 340 2960 0 0 {name=l2413 lab=WL15}
N 440 3040 460 3040 {}
C {lab_pin.sym} 460 3040 0 0 {name=l2414 lab=VDD}
N 440 2960 460 2960 {}
C {lab_pin.sym} 460 2960 0 0 {name=l2415 lab=VSS}
C {bitcell_6t.sym} 600 3000 0 0 {name=Xr15c3}
N 560 3040 540 3040 {}
C {lab_pin.sym} 540 3040 0 0 {name=l2416 lab=BL3}
N 560 3000 540 3000 {}
C {lab_pin.sym} 540 3000 0 0 {name=l2417 lab=BLB3}
N 560 2960 540 2960 {}
C {lab_pin.sym} 540 2960 0 0 {name=l2418 lab=WL15}
N 640 3040 660 3040 {}
C {lab_pin.sym} 660 3040 0 0 {name=l2419 lab=VDD}
N 640 2960 660 2960 {}
C {lab_pin.sym} 660 2960 0 0 {name=l2420 lab=VSS}
C {bitcell_6t.sym} 800 3000 0 0 {name=Xr15c4}
N 760 3040 740 3040 {}
C {lab_pin.sym} 740 3040 0 0 {name=l2421 lab=BL4}
N 760 3000 740 3000 {}
C {lab_pin.sym} 740 3000 0 0 {name=l2422 lab=BLB4}
N 760 2960 740 2960 {}
C {lab_pin.sym} 740 2960 0 0 {name=l2423 lab=WL15}
N 840 3040 860 3040 {}
C {lab_pin.sym} 860 3040 0 0 {name=l2424 lab=VDD}
N 840 2960 860 2960 {}
C {lab_pin.sym} 860 2960 0 0 {name=l2425 lab=VSS}
C {bitcell_6t.sym} 1000 3000 0 0 {name=Xr15c5}
N 960 3040 940 3040 {}
C {lab_pin.sym} 940 3040 0 0 {name=l2426 lab=BL5}
N 960 3000 940 3000 {}
C {lab_pin.sym} 940 3000 0 0 {name=l2427 lab=BLB5}
N 960 2960 940 2960 {}
C {lab_pin.sym} 940 2960 0 0 {name=l2428 lab=WL15}
N 1040 3040 1060 3040 {}
C {lab_pin.sym} 1060 3040 0 0 {name=l2429 lab=VDD}
N 1040 2960 1060 2960 {}
C {lab_pin.sym} 1060 2960 0 0 {name=l2430 lab=VSS}
C {bitcell_6t.sym} 1200 3000 0 0 {name=Xr15c6}
N 1160 3040 1140 3040 {}
C {lab_pin.sym} 1140 3040 0 0 {name=l2431 lab=BL6}
N 1160 3000 1140 3000 {}
C {lab_pin.sym} 1140 3000 0 0 {name=l2432 lab=BLB6}
N 1160 2960 1140 2960 {}
C {lab_pin.sym} 1140 2960 0 0 {name=l2433 lab=WL15}
N 1240 3040 1260 3040 {}
C {lab_pin.sym} 1260 3040 0 0 {name=l2434 lab=VDD}
N 1240 2960 1260 2960 {}
C {lab_pin.sym} 1260 2960 0 0 {name=l2435 lab=VSS}
C {bitcell_6t.sym} 1400 3000 0 0 {name=Xr15c7}
N 1360 3040 1340 3040 {}
C {lab_pin.sym} 1340 3040 0 0 {name=l2436 lab=BL7}
N 1360 3000 1340 3000 {}
C {lab_pin.sym} 1340 3000 0 0 {name=l2437 lab=BLB7}
N 1360 2960 1340 2960 {}
C {lab_pin.sym} 1340 2960 0 0 {name=l2438 lab=WL15}
N 1440 3040 1460 3040 {}
C {lab_pin.sym} 1460 3040 0 0 {name=l2439 lab=VDD}
N 1440 2960 1460 2960 {}
C {lab_pin.sym} 1460 2960 0 0 {name=l2440 lab=VSS}
C {bitcell_6t.sym} 1600 3000 0 0 {name=Xr15c8}
N 1560 3040 1540 3040 {}
C {lab_pin.sym} 1540 3040 0 0 {name=l2441 lab=BL8}
N 1560 3000 1540 3000 {}
C {lab_pin.sym} 1540 3000 0 0 {name=l2442 lab=BLB8}
N 1560 2960 1540 2960 {}
C {lab_pin.sym} 1540 2960 0 0 {name=l2443 lab=WL15}
N 1640 3040 1660 3040 {}
C {lab_pin.sym} 1660 3040 0 0 {name=l2444 lab=VDD}
N 1640 2960 1660 2960 {}
C {lab_pin.sym} 1660 2960 0 0 {name=l2445 lab=VSS}
C {bitcell_6t.sym} 1800 3000 0 0 {name=Xr15c9}
N 1760 3040 1740 3040 {}
C {lab_pin.sym} 1740 3040 0 0 {name=l2446 lab=BL9}
N 1760 3000 1740 3000 {}
C {lab_pin.sym} 1740 3000 0 0 {name=l2447 lab=BLB9}
N 1760 2960 1740 2960 {}
C {lab_pin.sym} 1740 2960 0 0 {name=l2448 lab=WL15}
N 1840 3040 1860 3040 {}
C {lab_pin.sym} 1860 3040 0 0 {name=l2449 lab=VDD}
N 1840 2960 1860 2960 {}
C {lab_pin.sym} 1860 2960 0 0 {name=l2450 lab=VSS}
C {bitcell_6t.sym} 2000 3000 0 0 {name=Xr15c10}
N 1960 3040 1940 3040 {}
C {lab_pin.sym} 1940 3040 0 0 {name=l2451 lab=BL10}
N 1960 3000 1940 3000 {}
C {lab_pin.sym} 1940 3000 0 0 {name=l2452 lab=BLB10}
N 1960 2960 1940 2960 {}
C {lab_pin.sym} 1940 2960 0 0 {name=l2453 lab=WL15}
N 2040 3040 2060 3040 {}
C {lab_pin.sym} 2060 3040 0 0 {name=l2454 lab=VDD}
N 2040 2960 2060 2960 {}
C {lab_pin.sym} 2060 2960 0 0 {name=l2455 lab=VSS}
C {bitcell_6t.sym} 2200 3000 0 0 {name=Xr15c11}
N 2160 3040 2140 3040 {}
C {lab_pin.sym} 2140 3040 0 0 {name=l2456 lab=BL11}
N 2160 3000 2140 3000 {}
C {lab_pin.sym} 2140 3000 0 0 {name=l2457 lab=BLB11}
N 2160 2960 2140 2960 {}
C {lab_pin.sym} 2140 2960 0 0 {name=l2458 lab=WL15}
N 2240 3040 2260 3040 {}
C {lab_pin.sym} 2260 3040 0 0 {name=l2459 lab=VDD}
N 2240 2960 2260 2960 {}
C {lab_pin.sym} 2260 2960 0 0 {name=l2460 lab=VSS}
C {bitcell_6t.sym} 2400 3000 0 0 {name=Xr15c12}
N 2360 3040 2340 3040 {}
C {lab_pin.sym} 2340 3040 0 0 {name=l2461 lab=BL12}
N 2360 3000 2340 3000 {}
C {lab_pin.sym} 2340 3000 0 0 {name=l2462 lab=BLB12}
N 2360 2960 2340 2960 {}
C {lab_pin.sym} 2340 2960 0 0 {name=l2463 lab=WL15}
N 2440 3040 2460 3040 {}
C {lab_pin.sym} 2460 3040 0 0 {name=l2464 lab=VDD}
N 2440 2960 2460 2960 {}
C {lab_pin.sym} 2460 2960 0 0 {name=l2465 lab=VSS}
C {bitcell_6t.sym} 2600 3000 0 0 {name=Xr15c13}
N 2560 3040 2540 3040 {}
C {lab_pin.sym} 2540 3040 0 0 {name=l2466 lab=BL13}
N 2560 3000 2540 3000 {}
C {lab_pin.sym} 2540 3000 0 0 {name=l2467 lab=BLB13}
N 2560 2960 2540 2960 {}
C {lab_pin.sym} 2540 2960 0 0 {name=l2468 lab=WL15}
N 2640 3040 2660 3040 {}
C {lab_pin.sym} 2660 3040 0 0 {name=l2469 lab=VDD}
N 2640 2960 2660 2960 {}
C {lab_pin.sym} 2660 2960 0 0 {name=l2470 lab=VSS}
C {bitcell_6t.sym} 2800 3000 0 0 {name=Xr15c14}
N 2760 3040 2740 3040 {}
C {lab_pin.sym} 2740 3040 0 0 {name=l2471 lab=BL14}
N 2760 3000 2740 3000 {}
C {lab_pin.sym} 2740 3000 0 0 {name=l2472 lab=BLB14}
N 2760 2960 2740 2960 {}
C {lab_pin.sym} 2740 2960 0 0 {name=l2473 lab=WL15}
N 2840 3040 2860 3040 {}
C {lab_pin.sym} 2860 3040 0 0 {name=l2474 lab=VDD}
N 2840 2960 2860 2960 {}
C {lab_pin.sym} 2860 2960 0 0 {name=l2475 lab=VSS}
C {bitcell_6t.sym} 3000 3000 0 0 {name=Xr15c15}
N 2960 3040 2940 3040 {}
C {lab_pin.sym} 2940 3040 0 0 {name=l2476 lab=BL15}
N 2960 3000 2940 3000 {}
C {lab_pin.sym} 2940 3000 0 0 {name=l2477 lab=BLB15}
N 2960 2960 2940 2960 {}
C {lab_pin.sym} 2940 2960 0 0 {name=l2478 lab=WL15}
N 3040 3040 3060 3040 {}
C {lab_pin.sym} 3060 3040 0 0 {name=l2479 lab=VDD}
N 3040 2960 3060 2960 {}
C {lab_pin.sym} 3060 2960 0 0 {name=l2480 lab=VSS}
C {bitcell_6t.sym} 3200 3000 0 0 {name=Xr15c16}
N 3160 3040 3140 3040 {}
C {lab_pin.sym} 3140 3040 0 0 {name=l2481 lab=BL16}
N 3160 3000 3140 3000 {}
C {lab_pin.sym} 3140 3000 0 0 {name=l2482 lab=BLB16}
N 3160 2960 3140 2960 {}
C {lab_pin.sym} 3140 2960 0 0 {name=l2483 lab=WL15}
N 3240 3040 3260 3040 {}
C {lab_pin.sym} 3260 3040 0 0 {name=l2484 lab=VDD}
N 3240 2960 3260 2960 {}
C {lab_pin.sym} 3260 2960 0 0 {name=l2485 lab=VSS}
C {bitcell_6t.sym} 3400 3000 0 0 {name=Xr15c17}
N 3360 3040 3340 3040 {}
C {lab_pin.sym} 3340 3040 0 0 {name=l2486 lab=BL17}
N 3360 3000 3340 3000 {}
C {lab_pin.sym} 3340 3000 0 0 {name=l2487 lab=BLB17}
N 3360 2960 3340 2960 {}
C {lab_pin.sym} 3340 2960 0 0 {name=l2488 lab=WL15}
N 3440 3040 3460 3040 {}
C {lab_pin.sym} 3460 3040 0 0 {name=l2489 lab=VDD}
N 3440 2960 3460 2960 {}
C {lab_pin.sym} 3460 2960 0 0 {name=l2490 lab=VSS}
C {bitcell_6t.sym} 3600 3000 0 0 {name=Xr15c18}
N 3560 3040 3540 3040 {}
C {lab_pin.sym} 3540 3040 0 0 {name=l2491 lab=BL18}
N 3560 3000 3540 3000 {}
C {lab_pin.sym} 3540 3000 0 0 {name=l2492 lab=BLB18}
N 3560 2960 3540 2960 {}
C {lab_pin.sym} 3540 2960 0 0 {name=l2493 lab=WL15}
N 3640 3040 3660 3040 {}
C {lab_pin.sym} 3660 3040 0 0 {name=l2494 lab=VDD}
N 3640 2960 3660 2960 {}
C {lab_pin.sym} 3660 2960 0 0 {name=l2495 lab=VSS}
C {bitcell_6t.sym} 3800 3000 0 0 {name=Xr15c19}
N 3760 3040 3740 3040 {}
C {lab_pin.sym} 3740 3040 0 0 {name=l2496 lab=BL19}
N 3760 3000 3740 3000 {}
C {lab_pin.sym} 3740 3000 0 0 {name=l2497 lab=BLB19}
N 3760 2960 3740 2960 {}
C {lab_pin.sym} 3740 2960 0 0 {name=l2498 lab=WL15}
N 3840 3040 3860 3040 {}
C {lab_pin.sym} 3860 3040 0 0 {name=l2499 lab=VDD}
N 3840 2960 3860 2960 {}
C {lab_pin.sym} 3860 2960 0 0 {name=l2500 lab=VSS}
C {bitcell_6t.sym} 4000 3000 0 0 {name=Xr15c20}
N 3960 3040 3940 3040 {}
C {lab_pin.sym} 3940 3040 0 0 {name=l2501 lab=BL20}
N 3960 3000 3940 3000 {}
C {lab_pin.sym} 3940 3000 0 0 {name=l2502 lab=BLB20}
N 3960 2960 3940 2960 {}
C {lab_pin.sym} 3940 2960 0 0 {name=l2503 lab=WL15}
N 4040 3040 4060 3040 {}
C {lab_pin.sym} 4060 3040 0 0 {name=l2504 lab=VDD}
N 4040 2960 4060 2960 {}
C {lab_pin.sym} 4060 2960 0 0 {name=l2505 lab=VSS}
C {bitcell_6t.sym} 4200 3000 0 0 {name=Xr15c21}
N 4160 3040 4140 3040 {}
C {lab_pin.sym} 4140 3040 0 0 {name=l2506 lab=BL21}
N 4160 3000 4140 3000 {}
C {lab_pin.sym} 4140 3000 0 0 {name=l2507 lab=BLB21}
N 4160 2960 4140 2960 {}
C {lab_pin.sym} 4140 2960 0 0 {name=l2508 lab=WL15}
N 4240 3040 4260 3040 {}
C {lab_pin.sym} 4260 3040 0 0 {name=l2509 lab=VDD}
N 4240 2960 4260 2960 {}
C {lab_pin.sym} 4260 2960 0 0 {name=l2510 lab=VSS}
C {bitcell_6t.sym} 4400 3000 0 0 {name=Xr15c22}
N 4360 3040 4340 3040 {}
C {lab_pin.sym} 4340 3040 0 0 {name=l2511 lab=BL22}
N 4360 3000 4340 3000 {}
C {lab_pin.sym} 4340 3000 0 0 {name=l2512 lab=BLB22}
N 4360 2960 4340 2960 {}
C {lab_pin.sym} 4340 2960 0 0 {name=l2513 lab=WL15}
N 4440 3040 4460 3040 {}
C {lab_pin.sym} 4460 3040 0 0 {name=l2514 lab=VDD}
N 4440 2960 4460 2960 {}
C {lab_pin.sym} 4460 2960 0 0 {name=l2515 lab=VSS}
C {bitcell_6t.sym} 4600 3000 0 0 {name=Xr15c23}
N 4560 3040 4540 3040 {}
C {lab_pin.sym} 4540 3040 0 0 {name=l2516 lab=BL23}
N 4560 3000 4540 3000 {}
C {lab_pin.sym} 4540 3000 0 0 {name=l2517 lab=BLB23}
N 4560 2960 4540 2960 {}
C {lab_pin.sym} 4540 2960 0 0 {name=l2518 lab=WL15}
N 4640 3040 4660 3040 {}
C {lab_pin.sym} 4660 3040 0 0 {name=l2519 lab=VDD}
N 4640 2960 4660 2960 {}
C {lab_pin.sym} 4660 2960 0 0 {name=l2520 lab=VSS}
C {bitcell_6t.sym} 4800 3000 0 0 {name=Xr15c24}
N 4760 3040 4740 3040 {}
C {lab_pin.sym} 4740 3040 0 0 {name=l2521 lab=BL24}
N 4760 3000 4740 3000 {}
C {lab_pin.sym} 4740 3000 0 0 {name=l2522 lab=BLB24}
N 4760 2960 4740 2960 {}
C {lab_pin.sym} 4740 2960 0 0 {name=l2523 lab=WL15}
N 4840 3040 4860 3040 {}
C {lab_pin.sym} 4860 3040 0 0 {name=l2524 lab=VDD}
N 4840 2960 4860 2960 {}
C {lab_pin.sym} 4860 2960 0 0 {name=l2525 lab=VSS}
C {bitcell_6t.sym} 5000 3000 0 0 {name=Xr15c25}
N 4960 3040 4940 3040 {}
C {lab_pin.sym} 4940 3040 0 0 {name=l2526 lab=BL25}
N 4960 3000 4940 3000 {}
C {lab_pin.sym} 4940 3000 0 0 {name=l2527 lab=BLB25}
N 4960 2960 4940 2960 {}
C {lab_pin.sym} 4940 2960 0 0 {name=l2528 lab=WL15}
N 5040 3040 5060 3040 {}
C {lab_pin.sym} 5060 3040 0 0 {name=l2529 lab=VDD}
N 5040 2960 5060 2960 {}
C {lab_pin.sym} 5060 2960 0 0 {name=l2530 lab=VSS}
C {bitcell_6t.sym} 5200 3000 0 0 {name=Xr15c26}
N 5160 3040 5140 3040 {}
C {lab_pin.sym} 5140 3040 0 0 {name=l2531 lab=BL26}
N 5160 3000 5140 3000 {}
C {lab_pin.sym} 5140 3000 0 0 {name=l2532 lab=BLB26}
N 5160 2960 5140 2960 {}
C {lab_pin.sym} 5140 2960 0 0 {name=l2533 lab=WL15}
N 5240 3040 5260 3040 {}
C {lab_pin.sym} 5260 3040 0 0 {name=l2534 lab=VDD}
N 5240 2960 5260 2960 {}
C {lab_pin.sym} 5260 2960 0 0 {name=l2535 lab=VSS}
C {bitcell_6t.sym} 5400 3000 0 0 {name=Xr15c27}
N 5360 3040 5340 3040 {}
C {lab_pin.sym} 5340 3040 0 0 {name=l2536 lab=BL27}
N 5360 3000 5340 3000 {}
C {lab_pin.sym} 5340 3000 0 0 {name=l2537 lab=BLB27}
N 5360 2960 5340 2960 {}
C {lab_pin.sym} 5340 2960 0 0 {name=l2538 lab=WL15}
N 5440 3040 5460 3040 {}
C {lab_pin.sym} 5460 3040 0 0 {name=l2539 lab=VDD}
N 5440 2960 5460 2960 {}
C {lab_pin.sym} 5460 2960 0 0 {name=l2540 lab=VSS}
C {bitcell_6t.sym} 5600 3000 0 0 {name=Xr15c28}
N 5560 3040 5540 3040 {}
C {lab_pin.sym} 5540 3040 0 0 {name=l2541 lab=BL28}
N 5560 3000 5540 3000 {}
C {lab_pin.sym} 5540 3000 0 0 {name=l2542 lab=BLB28}
N 5560 2960 5540 2960 {}
C {lab_pin.sym} 5540 2960 0 0 {name=l2543 lab=WL15}
N 5640 3040 5660 3040 {}
C {lab_pin.sym} 5660 3040 0 0 {name=l2544 lab=VDD}
N 5640 2960 5660 2960 {}
C {lab_pin.sym} 5660 2960 0 0 {name=l2545 lab=VSS}
C {bitcell_6t.sym} 5800 3000 0 0 {name=Xr15c29}
N 5760 3040 5740 3040 {}
C {lab_pin.sym} 5740 3040 0 0 {name=l2546 lab=BL29}
N 5760 3000 5740 3000 {}
C {lab_pin.sym} 5740 3000 0 0 {name=l2547 lab=BLB29}
N 5760 2960 5740 2960 {}
C {lab_pin.sym} 5740 2960 0 0 {name=l2548 lab=WL15}
N 5840 3040 5860 3040 {}
C {lab_pin.sym} 5860 3040 0 0 {name=l2549 lab=VDD}
N 5840 2960 5860 2960 {}
C {lab_pin.sym} 5860 2960 0 0 {name=l2550 lab=VSS}
C {bitcell_6t.sym} 6000 3000 0 0 {name=Xr15c30}
N 5960 3040 5940 3040 {}
C {lab_pin.sym} 5940 3040 0 0 {name=l2551 lab=BL30}
N 5960 3000 5940 3000 {}
C {lab_pin.sym} 5940 3000 0 0 {name=l2552 lab=BLB30}
N 5960 2960 5940 2960 {}
C {lab_pin.sym} 5940 2960 0 0 {name=l2553 lab=WL15}
N 6040 3040 6060 3040 {}
C {lab_pin.sym} 6060 3040 0 0 {name=l2554 lab=VDD}
N 6040 2960 6060 2960 {}
C {lab_pin.sym} 6060 2960 0 0 {name=l2555 lab=VSS}
C {bitcell_6t.sym} 6200 3000 0 0 {name=Xr15c31}
N 6160 3040 6140 3040 {}
C {lab_pin.sym} 6140 3040 0 0 {name=l2556 lab=BL31}
N 6160 3000 6140 3000 {}
C {lab_pin.sym} 6140 3000 0 0 {name=l2557 lab=BLB31}
N 6160 2960 6140 2960 {}
C {lab_pin.sym} 6140 2960 0 0 {name=l2558 lab=WL15}
N 6240 3040 6260 3040 {}
C {lab_pin.sym} 6260 3040 0 0 {name=l2559 lab=VDD}
N 6240 2960 6260 2960 {}
C {lab_pin.sym} 6260 2960 0 0 {name=l2560 lab=VSS}
C {bitcell_6t.sym} 0 3200 0 0 {name=Xr16c0}
N -40 3240 -60 3240 {}
C {lab_pin.sym} -60 3240 0 0 {name=l2561 lab=BL0}
N -40 3200 -60 3200 {}
C {lab_pin.sym} -60 3200 0 0 {name=l2562 lab=BLB0}
N -40 3160 -60 3160 {}
C {lab_pin.sym} -60 3160 0 0 {name=l2563 lab=WL16}
N 40 3240 60 3240 {}
C {lab_pin.sym} 60 3240 0 0 {name=l2564 lab=VDD}
N 40 3160 60 3160 {}
C {lab_pin.sym} 60 3160 0 0 {name=l2565 lab=VSS}
C {bitcell_6t.sym} 200 3200 0 0 {name=Xr16c1}
N 160 3240 140 3240 {}
C {lab_pin.sym} 140 3240 0 0 {name=l2566 lab=BL1}
N 160 3200 140 3200 {}
C {lab_pin.sym} 140 3200 0 0 {name=l2567 lab=BLB1}
N 160 3160 140 3160 {}
C {lab_pin.sym} 140 3160 0 0 {name=l2568 lab=WL16}
N 240 3240 260 3240 {}
C {lab_pin.sym} 260 3240 0 0 {name=l2569 lab=VDD}
N 240 3160 260 3160 {}
C {lab_pin.sym} 260 3160 0 0 {name=l2570 lab=VSS}
C {bitcell_6t.sym} 400 3200 0 0 {name=Xr16c2}
N 360 3240 340 3240 {}
C {lab_pin.sym} 340 3240 0 0 {name=l2571 lab=BL2}
N 360 3200 340 3200 {}
C {lab_pin.sym} 340 3200 0 0 {name=l2572 lab=BLB2}
N 360 3160 340 3160 {}
C {lab_pin.sym} 340 3160 0 0 {name=l2573 lab=WL16}
N 440 3240 460 3240 {}
C {lab_pin.sym} 460 3240 0 0 {name=l2574 lab=VDD}
N 440 3160 460 3160 {}
C {lab_pin.sym} 460 3160 0 0 {name=l2575 lab=VSS}
C {bitcell_6t.sym} 600 3200 0 0 {name=Xr16c3}
N 560 3240 540 3240 {}
C {lab_pin.sym} 540 3240 0 0 {name=l2576 lab=BL3}
N 560 3200 540 3200 {}
C {lab_pin.sym} 540 3200 0 0 {name=l2577 lab=BLB3}
N 560 3160 540 3160 {}
C {lab_pin.sym} 540 3160 0 0 {name=l2578 lab=WL16}
N 640 3240 660 3240 {}
C {lab_pin.sym} 660 3240 0 0 {name=l2579 lab=VDD}
N 640 3160 660 3160 {}
C {lab_pin.sym} 660 3160 0 0 {name=l2580 lab=VSS}
C {bitcell_6t.sym} 800 3200 0 0 {name=Xr16c4}
N 760 3240 740 3240 {}
C {lab_pin.sym} 740 3240 0 0 {name=l2581 lab=BL4}
N 760 3200 740 3200 {}
C {lab_pin.sym} 740 3200 0 0 {name=l2582 lab=BLB4}
N 760 3160 740 3160 {}
C {lab_pin.sym} 740 3160 0 0 {name=l2583 lab=WL16}
N 840 3240 860 3240 {}
C {lab_pin.sym} 860 3240 0 0 {name=l2584 lab=VDD}
N 840 3160 860 3160 {}
C {lab_pin.sym} 860 3160 0 0 {name=l2585 lab=VSS}
C {bitcell_6t.sym} 1000 3200 0 0 {name=Xr16c5}
N 960 3240 940 3240 {}
C {lab_pin.sym} 940 3240 0 0 {name=l2586 lab=BL5}
N 960 3200 940 3200 {}
C {lab_pin.sym} 940 3200 0 0 {name=l2587 lab=BLB5}
N 960 3160 940 3160 {}
C {lab_pin.sym} 940 3160 0 0 {name=l2588 lab=WL16}
N 1040 3240 1060 3240 {}
C {lab_pin.sym} 1060 3240 0 0 {name=l2589 lab=VDD}
N 1040 3160 1060 3160 {}
C {lab_pin.sym} 1060 3160 0 0 {name=l2590 lab=VSS}
C {bitcell_6t.sym} 1200 3200 0 0 {name=Xr16c6}
N 1160 3240 1140 3240 {}
C {lab_pin.sym} 1140 3240 0 0 {name=l2591 lab=BL6}
N 1160 3200 1140 3200 {}
C {lab_pin.sym} 1140 3200 0 0 {name=l2592 lab=BLB6}
N 1160 3160 1140 3160 {}
C {lab_pin.sym} 1140 3160 0 0 {name=l2593 lab=WL16}
N 1240 3240 1260 3240 {}
C {lab_pin.sym} 1260 3240 0 0 {name=l2594 lab=VDD}
N 1240 3160 1260 3160 {}
C {lab_pin.sym} 1260 3160 0 0 {name=l2595 lab=VSS}
C {bitcell_6t.sym} 1400 3200 0 0 {name=Xr16c7}
N 1360 3240 1340 3240 {}
C {lab_pin.sym} 1340 3240 0 0 {name=l2596 lab=BL7}
N 1360 3200 1340 3200 {}
C {lab_pin.sym} 1340 3200 0 0 {name=l2597 lab=BLB7}
N 1360 3160 1340 3160 {}
C {lab_pin.sym} 1340 3160 0 0 {name=l2598 lab=WL16}
N 1440 3240 1460 3240 {}
C {lab_pin.sym} 1460 3240 0 0 {name=l2599 lab=VDD}
N 1440 3160 1460 3160 {}
C {lab_pin.sym} 1460 3160 0 0 {name=l2600 lab=VSS}
C {bitcell_6t.sym} 1600 3200 0 0 {name=Xr16c8}
N 1560 3240 1540 3240 {}
C {lab_pin.sym} 1540 3240 0 0 {name=l2601 lab=BL8}
N 1560 3200 1540 3200 {}
C {lab_pin.sym} 1540 3200 0 0 {name=l2602 lab=BLB8}
N 1560 3160 1540 3160 {}
C {lab_pin.sym} 1540 3160 0 0 {name=l2603 lab=WL16}
N 1640 3240 1660 3240 {}
C {lab_pin.sym} 1660 3240 0 0 {name=l2604 lab=VDD}
N 1640 3160 1660 3160 {}
C {lab_pin.sym} 1660 3160 0 0 {name=l2605 lab=VSS}
C {bitcell_6t.sym} 1800 3200 0 0 {name=Xr16c9}
N 1760 3240 1740 3240 {}
C {lab_pin.sym} 1740 3240 0 0 {name=l2606 lab=BL9}
N 1760 3200 1740 3200 {}
C {lab_pin.sym} 1740 3200 0 0 {name=l2607 lab=BLB9}
N 1760 3160 1740 3160 {}
C {lab_pin.sym} 1740 3160 0 0 {name=l2608 lab=WL16}
N 1840 3240 1860 3240 {}
C {lab_pin.sym} 1860 3240 0 0 {name=l2609 lab=VDD}
N 1840 3160 1860 3160 {}
C {lab_pin.sym} 1860 3160 0 0 {name=l2610 lab=VSS}
C {bitcell_6t.sym} 2000 3200 0 0 {name=Xr16c10}
N 1960 3240 1940 3240 {}
C {lab_pin.sym} 1940 3240 0 0 {name=l2611 lab=BL10}
N 1960 3200 1940 3200 {}
C {lab_pin.sym} 1940 3200 0 0 {name=l2612 lab=BLB10}
N 1960 3160 1940 3160 {}
C {lab_pin.sym} 1940 3160 0 0 {name=l2613 lab=WL16}
N 2040 3240 2060 3240 {}
C {lab_pin.sym} 2060 3240 0 0 {name=l2614 lab=VDD}
N 2040 3160 2060 3160 {}
C {lab_pin.sym} 2060 3160 0 0 {name=l2615 lab=VSS}
C {bitcell_6t.sym} 2200 3200 0 0 {name=Xr16c11}
N 2160 3240 2140 3240 {}
C {lab_pin.sym} 2140 3240 0 0 {name=l2616 lab=BL11}
N 2160 3200 2140 3200 {}
C {lab_pin.sym} 2140 3200 0 0 {name=l2617 lab=BLB11}
N 2160 3160 2140 3160 {}
C {lab_pin.sym} 2140 3160 0 0 {name=l2618 lab=WL16}
N 2240 3240 2260 3240 {}
C {lab_pin.sym} 2260 3240 0 0 {name=l2619 lab=VDD}
N 2240 3160 2260 3160 {}
C {lab_pin.sym} 2260 3160 0 0 {name=l2620 lab=VSS}
C {bitcell_6t.sym} 2400 3200 0 0 {name=Xr16c12}
N 2360 3240 2340 3240 {}
C {lab_pin.sym} 2340 3240 0 0 {name=l2621 lab=BL12}
N 2360 3200 2340 3200 {}
C {lab_pin.sym} 2340 3200 0 0 {name=l2622 lab=BLB12}
N 2360 3160 2340 3160 {}
C {lab_pin.sym} 2340 3160 0 0 {name=l2623 lab=WL16}
N 2440 3240 2460 3240 {}
C {lab_pin.sym} 2460 3240 0 0 {name=l2624 lab=VDD}
N 2440 3160 2460 3160 {}
C {lab_pin.sym} 2460 3160 0 0 {name=l2625 lab=VSS}
C {bitcell_6t.sym} 2600 3200 0 0 {name=Xr16c13}
N 2560 3240 2540 3240 {}
C {lab_pin.sym} 2540 3240 0 0 {name=l2626 lab=BL13}
N 2560 3200 2540 3200 {}
C {lab_pin.sym} 2540 3200 0 0 {name=l2627 lab=BLB13}
N 2560 3160 2540 3160 {}
C {lab_pin.sym} 2540 3160 0 0 {name=l2628 lab=WL16}
N 2640 3240 2660 3240 {}
C {lab_pin.sym} 2660 3240 0 0 {name=l2629 lab=VDD}
N 2640 3160 2660 3160 {}
C {lab_pin.sym} 2660 3160 0 0 {name=l2630 lab=VSS}
C {bitcell_6t.sym} 2800 3200 0 0 {name=Xr16c14}
N 2760 3240 2740 3240 {}
C {lab_pin.sym} 2740 3240 0 0 {name=l2631 lab=BL14}
N 2760 3200 2740 3200 {}
C {lab_pin.sym} 2740 3200 0 0 {name=l2632 lab=BLB14}
N 2760 3160 2740 3160 {}
C {lab_pin.sym} 2740 3160 0 0 {name=l2633 lab=WL16}
N 2840 3240 2860 3240 {}
C {lab_pin.sym} 2860 3240 0 0 {name=l2634 lab=VDD}
N 2840 3160 2860 3160 {}
C {lab_pin.sym} 2860 3160 0 0 {name=l2635 lab=VSS}
C {bitcell_6t.sym} 3000 3200 0 0 {name=Xr16c15}
N 2960 3240 2940 3240 {}
C {lab_pin.sym} 2940 3240 0 0 {name=l2636 lab=BL15}
N 2960 3200 2940 3200 {}
C {lab_pin.sym} 2940 3200 0 0 {name=l2637 lab=BLB15}
N 2960 3160 2940 3160 {}
C {lab_pin.sym} 2940 3160 0 0 {name=l2638 lab=WL16}
N 3040 3240 3060 3240 {}
C {lab_pin.sym} 3060 3240 0 0 {name=l2639 lab=VDD}
N 3040 3160 3060 3160 {}
C {lab_pin.sym} 3060 3160 0 0 {name=l2640 lab=VSS}
C {bitcell_6t.sym} 3200 3200 0 0 {name=Xr16c16}
N 3160 3240 3140 3240 {}
C {lab_pin.sym} 3140 3240 0 0 {name=l2641 lab=BL16}
N 3160 3200 3140 3200 {}
C {lab_pin.sym} 3140 3200 0 0 {name=l2642 lab=BLB16}
N 3160 3160 3140 3160 {}
C {lab_pin.sym} 3140 3160 0 0 {name=l2643 lab=WL16}
N 3240 3240 3260 3240 {}
C {lab_pin.sym} 3260 3240 0 0 {name=l2644 lab=VDD}
N 3240 3160 3260 3160 {}
C {lab_pin.sym} 3260 3160 0 0 {name=l2645 lab=VSS}
C {bitcell_6t.sym} 3400 3200 0 0 {name=Xr16c17}
N 3360 3240 3340 3240 {}
C {lab_pin.sym} 3340 3240 0 0 {name=l2646 lab=BL17}
N 3360 3200 3340 3200 {}
C {lab_pin.sym} 3340 3200 0 0 {name=l2647 lab=BLB17}
N 3360 3160 3340 3160 {}
C {lab_pin.sym} 3340 3160 0 0 {name=l2648 lab=WL16}
N 3440 3240 3460 3240 {}
C {lab_pin.sym} 3460 3240 0 0 {name=l2649 lab=VDD}
N 3440 3160 3460 3160 {}
C {lab_pin.sym} 3460 3160 0 0 {name=l2650 lab=VSS}
C {bitcell_6t.sym} 3600 3200 0 0 {name=Xr16c18}
N 3560 3240 3540 3240 {}
C {lab_pin.sym} 3540 3240 0 0 {name=l2651 lab=BL18}
N 3560 3200 3540 3200 {}
C {lab_pin.sym} 3540 3200 0 0 {name=l2652 lab=BLB18}
N 3560 3160 3540 3160 {}
C {lab_pin.sym} 3540 3160 0 0 {name=l2653 lab=WL16}
N 3640 3240 3660 3240 {}
C {lab_pin.sym} 3660 3240 0 0 {name=l2654 lab=VDD}
N 3640 3160 3660 3160 {}
C {lab_pin.sym} 3660 3160 0 0 {name=l2655 lab=VSS}
C {bitcell_6t.sym} 3800 3200 0 0 {name=Xr16c19}
N 3760 3240 3740 3240 {}
C {lab_pin.sym} 3740 3240 0 0 {name=l2656 lab=BL19}
N 3760 3200 3740 3200 {}
C {lab_pin.sym} 3740 3200 0 0 {name=l2657 lab=BLB19}
N 3760 3160 3740 3160 {}
C {lab_pin.sym} 3740 3160 0 0 {name=l2658 lab=WL16}
N 3840 3240 3860 3240 {}
C {lab_pin.sym} 3860 3240 0 0 {name=l2659 lab=VDD}
N 3840 3160 3860 3160 {}
C {lab_pin.sym} 3860 3160 0 0 {name=l2660 lab=VSS}
C {bitcell_6t.sym} 4000 3200 0 0 {name=Xr16c20}
N 3960 3240 3940 3240 {}
C {lab_pin.sym} 3940 3240 0 0 {name=l2661 lab=BL20}
N 3960 3200 3940 3200 {}
C {lab_pin.sym} 3940 3200 0 0 {name=l2662 lab=BLB20}
N 3960 3160 3940 3160 {}
C {lab_pin.sym} 3940 3160 0 0 {name=l2663 lab=WL16}
N 4040 3240 4060 3240 {}
C {lab_pin.sym} 4060 3240 0 0 {name=l2664 lab=VDD}
N 4040 3160 4060 3160 {}
C {lab_pin.sym} 4060 3160 0 0 {name=l2665 lab=VSS}
C {bitcell_6t.sym} 4200 3200 0 0 {name=Xr16c21}
N 4160 3240 4140 3240 {}
C {lab_pin.sym} 4140 3240 0 0 {name=l2666 lab=BL21}
N 4160 3200 4140 3200 {}
C {lab_pin.sym} 4140 3200 0 0 {name=l2667 lab=BLB21}
N 4160 3160 4140 3160 {}
C {lab_pin.sym} 4140 3160 0 0 {name=l2668 lab=WL16}
N 4240 3240 4260 3240 {}
C {lab_pin.sym} 4260 3240 0 0 {name=l2669 lab=VDD}
N 4240 3160 4260 3160 {}
C {lab_pin.sym} 4260 3160 0 0 {name=l2670 lab=VSS}
C {bitcell_6t.sym} 4400 3200 0 0 {name=Xr16c22}
N 4360 3240 4340 3240 {}
C {lab_pin.sym} 4340 3240 0 0 {name=l2671 lab=BL22}
N 4360 3200 4340 3200 {}
C {lab_pin.sym} 4340 3200 0 0 {name=l2672 lab=BLB22}
N 4360 3160 4340 3160 {}
C {lab_pin.sym} 4340 3160 0 0 {name=l2673 lab=WL16}
N 4440 3240 4460 3240 {}
C {lab_pin.sym} 4460 3240 0 0 {name=l2674 lab=VDD}
N 4440 3160 4460 3160 {}
C {lab_pin.sym} 4460 3160 0 0 {name=l2675 lab=VSS}
C {bitcell_6t.sym} 4600 3200 0 0 {name=Xr16c23}
N 4560 3240 4540 3240 {}
C {lab_pin.sym} 4540 3240 0 0 {name=l2676 lab=BL23}
N 4560 3200 4540 3200 {}
C {lab_pin.sym} 4540 3200 0 0 {name=l2677 lab=BLB23}
N 4560 3160 4540 3160 {}
C {lab_pin.sym} 4540 3160 0 0 {name=l2678 lab=WL16}
N 4640 3240 4660 3240 {}
C {lab_pin.sym} 4660 3240 0 0 {name=l2679 lab=VDD}
N 4640 3160 4660 3160 {}
C {lab_pin.sym} 4660 3160 0 0 {name=l2680 lab=VSS}
C {bitcell_6t.sym} 4800 3200 0 0 {name=Xr16c24}
N 4760 3240 4740 3240 {}
C {lab_pin.sym} 4740 3240 0 0 {name=l2681 lab=BL24}
N 4760 3200 4740 3200 {}
C {lab_pin.sym} 4740 3200 0 0 {name=l2682 lab=BLB24}
N 4760 3160 4740 3160 {}
C {lab_pin.sym} 4740 3160 0 0 {name=l2683 lab=WL16}
N 4840 3240 4860 3240 {}
C {lab_pin.sym} 4860 3240 0 0 {name=l2684 lab=VDD}
N 4840 3160 4860 3160 {}
C {lab_pin.sym} 4860 3160 0 0 {name=l2685 lab=VSS}
C {bitcell_6t.sym} 5000 3200 0 0 {name=Xr16c25}
N 4960 3240 4940 3240 {}
C {lab_pin.sym} 4940 3240 0 0 {name=l2686 lab=BL25}
N 4960 3200 4940 3200 {}
C {lab_pin.sym} 4940 3200 0 0 {name=l2687 lab=BLB25}
N 4960 3160 4940 3160 {}
C {lab_pin.sym} 4940 3160 0 0 {name=l2688 lab=WL16}
N 5040 3240 5060 3240 {}
C {lab_pin.sym} 5060 3240 0 0 {name=l2689 lab=VDD}
N 5040 3160 5060 3160 {}
C {lab_pin.sym} 5060 3160 0 0 {name=l2690 lab=VSS}
C {bitcell_6t.sym} 5200 3200 0 0 {name=Xr16c26}
N 5160 3240 5140 3240 {}
C {lab_pin.sym} 5140 3240 0 0 {name=l2691 lab=BL26}
N 5160 3200 5140 3200 {}
C {lab_pin.sym} 5140 3200 0 0 {name=l2692 lab=BLB26}
N 5160 3160 5140 3160 {}
C {lab_pin.sym} 5140 3160 0 0 {name=l2693 lab=WL16}
N 5240 3240 5260 3240 {}
C {lab_pin.sym} 5260 3240 0 0 {name=l2694 lab=VDD}
N 5240 3160 5260 3160 {}
C {lab_pin.sym} 5260 3160 0 0 {name=l2695 lab=VSS}
C {bitcell_6t.sym} 5400 3200 0 0 {name=Xr16c27}
N 5360 3240 5340 3240 {}
C {lab_pin.sym} 5340 3240 0 0 {name=l2696 lab=BL27}
N 5360 3200 5340 3200 {}
C {lab_pin.sym} 5340 3200 0 0 {name=l2697 lab=BLB27}
N 5360 3160 5340 3160 {}
C {lab_pin.sym} 5340 3160 0 0 {name=l2698 lab=WL16}
N 5440 3240 5460 3240 {}
C {lab_pin.sym} 5460 3240 0 0 {name=l2699 lab=VDD}
N 5440 3160 5460 3160 {}
C {lab_pin.sym} 5460 3160 0 0 {name=l2700 lab=VSS}
C {bitcell_6t.sym} 5600 3200 0 0 {name=Xr16c28}
N 5560 3240 5540 3240 {}
C {lab_pin.sym} 5540 3240 0 0 {name=l2701 lab=BL28}
N 5560 3200 5540 3200 {}
C {lab_pin.sym} 5540 3200 0 0 {name=l2702 lab=BLB28}
N 5560 3160 5540 3160 {}
C {lab_pin.sym} 5540 3160 0 0 {name=l2703 lab=WL16}
N 5640 3240 5660 3240 {}
C {lab_pin.sym} 5660 3240 0 0 {name=l2704 lab=VDD}
N 5640 3160 5660 3160 {}
C {lab_pin.sym} 5660 3160 0 0 {name=l2705 lab=VSS}
C {bitcell_6t.sym} 5800 3200 0 0 {name=Xr16c29}
N 5760 3240 5740 3240 {}
C {lab_pin.sym} 5740 3240 0 0 {name=l2706 lab=BL29}
N 5760 3200 5740 3200 {}
C {lab_pin.sym} 5740 3200 0 0 {name=l2707 lab=BLB29}
N 5760 3160 5740 3160 {}
C {lab_pin.sym} 5740 3160 0 0 {name=l2708 lab=WL16}
N 5840 3240 5860 3240 {}
C {lab_pin.sym} 5860 3240 0 0 {name=l2709 lab=VDD}
N 5840 3160 5860 3160 {}
C {lab_pin.sym} 5860 3160 0 0 {name=l2710 lab=VSS}
C {bitcell_6t.sym} 6000 3200 0 0 {name=Xr16c30}
N 5960 3240 5940 3240 {}
C {lab_pin.sym} 5940 3240 0 0 {name=l2711 lab=BL30}
N 5960 3200 5940 3200 {}
C {lab_pin.sym} 5940 3200 0 0 {name=l2712 lab=BLB30}
N 5960 3160 5940 3160 {}
C {lab_pin.sym} 5940 3160 0 0 {name=l2713 lab=WL16}
N 6040 3240 6060 3240 {}
C {lab_pin.sym} 6060 3240 0 0 {name=l2714 lab=VDD}
N 6040 3160 6060 3160 {}
C {lab_pin.sym} 6060 3160 0 0 {name=l2715 lab=VSS}
C {bitcell_6t.sym} 6200 3200 0 0 {name=Xr16c31}
N 6160 3240 6140 3240 {}
C {lab_pin.sym} 6140 3240 0 0 {name=l2716 lab=BL31}
N 6160 3200 6140 3200 {}
C {lab_pin.sym} 6140 3200 0 0 {name=l2717 lab=BLB31}
N 6160 3160 6140 3160 {}
C {lab_pin.sym} 6140 3160 0 0 {name=l2718 lab=WL16}
N 6240 3240 6260 3240 {}
C {lab_pin.sym} 6260 3240 0 0 {name=l2719 lab=VDD}
N 6240 3160 6260 3160 {}
C {lab_pin.sym} 6260 3160 0 0 {name=l2720 lab=VSS}
C {bitcell_6t.sym} 0 3400 0 0 {name=Xr17c0}
N -40 3440 -60 3440 {}
C {lab_pin.sym} -60 3440 0 0 {name=l2721 lab=BL0}
N -40 3400 -60 3400 {}
C {lab_pin.sym} -60 3400 0 0 {name=l2722 lab=BLB0}
N -40 3360 -60 3360 {}
C {lab_pin.sym} -60 3360 0 0 {name=l2723 lab=WL17}
N 40 3440 60 3440 {}
C {lab_pin.sym} 60 3440 0 0 {name=l2724 lab=VDD}
N 40 3360 60 3360 {}
C {lab_pin.sym} 60 3360 0 0 {name=l2725 lab=VSS}
C {bitcell_6t.sym} 200 3400 0 0 {name=Xr17c1}
N 160 3440 140 3440 {}
C {lab_pin.sym} 140 3440 0 0 {name=l2726 lab=BL1}
N 160 3400 140 3400 {}
C {lab_pin.sym} 140 3400 0 0 {name=l2727 lab=BLB1}
N 160 3360 140 3360 {}
C {lab_pin.sym} 140 3360 0 0 {name=l2728 lab=WL17}
N 240 3440 260 3440 {}
C {lab_pin.sym} 260 3440 0 0 {name=l2729 lab=VDD}
N 240 3360 260 3360 {}
C {lab_pin.sym} 260 3360 0 0 {name=l2730 lab=VSS}
C {bitcell_6t.sym} 400 3400 0 0 {name=Xr17c2}
N 360 3440 340 3440 {}
C {lab_pin.sym} 340 3440 0 0 {name=l2731 lab=BL2}
N 360 3400 340 3400 {}
C {lab_pin.sym} 340 3400 0 0 {name=l2732 lab=BLB2}
N 360 3360 340 3360 {}
C {lab_pin.sym} 340 3360 0 0 {name=l2733 lab=WL17}
N 440 3440 460 3440 {}
C {lab_pin.sym} 460 3440 0 0 {name=l2734 lab=VDD}
N 440 3360 460 3360 {}
C {lab_pin.sym} 460 3360 0 0 {name=l2735 lab=VSS}
C {bitcell_6t.sym} 600 3400 0 0 {name=Xr17c3}
N 560 3440 540 3440 {}
C {lab_pin.sym} 540 3440 0 0 {name=l2736 lab=BL3}
N 560 3400 540 3400 {}
C {lab_pin.sym} 540 3400 0 0 {name=l2737 lab=BLB3}
N 560 3360 540 3360 {}
C {lab_pin.sym} 540 3360 0 0 {name=l2738 lab=WL17}
N 640 3440 660 3440 {}
C {lab_pin.sym} 660 3440 0 0 {name=l2739 lab=VDD}
N 640 3360 660 3360 {}
C {lab_pin.sym} 660 3360 0 0 {name=l2740 lab=VSS}
C {bitcell_6t.sym} 800 3400 0 0 {name=Xr17c4}
N 760 3440 740 3440 {}
C {lab_pin.sym} 740 3440 0 0 {name=l2741 lab=BL4}
N 760 3400 740 3400 {}
C {lab_pin.sym} 740 3400 0 0 {name=l2742 lab=BLB4}
N 760 3360 740 3360 {}
C {lab_pin.sym} 740 3360 0 0 {name=l2743 lab=WL17}
N 840 3440 860 3440 {}
C {lab_pin.sym} 860 3440 0 0 {name=l2744 lab=VDD}
N 840 3360 860 3360 {}
C {lab_pin.sym} 860 3360 0 0 {name=l2745 lab=VSS}
C {bitcell_6t.sym} 1000 3400 0 0 {name=Xr17c5}
N 960 3440 940 3440 {}
C {lab_pin.sym} 940 3440 0 0 {name=l2746 lab=BL5}
N 960 3400 940 3400 {}
C {lab_pin.sym} 940 3400 0 0 {name=l2747 lab=BLB5}
N 960 3360 940 3360 {}
C {lab_pin.sym} 940 3360 0 0 {name=l2748 lab=WL17}
N 1040 3440 1060 3440 {}
C {lab_pin.sym} 1060 3440 0 0 {name=l2749 lab=VDD}
N 1040 3360 1060 3360 {}
C {lab_pin.sym} 1060 3360 0 0 {name=l2750 lab=VSS}
C {bitcell_6t.sym} 1200 3400 0 0 {name=Xr17c6}
N 1160 3440 1140 3440 {}
C {lab_pin.sym} 1140 3440 0 0 {name=l2751 lab=BL6}
N 1160 3400 1140 3400 {}
C {lab_pin.sym} 1140 3400 0 0 {name=l2752 lab=BLB6}
N 1160 3360 1140 3360 {}
C {lab_pin.sym} 1140 3360 0 0 {name=l2753 lab=WL17}
N 1240 3440 1260 3440 {}
C {lab_pin.sym} 1260 3440 0 0 {name=l2754 lab=VDD}
N 1240 3360 1260 3360 {}
C {lab_pin.sym} 1260 3360 0 0 {name=l2755 lab=VSS}
C {bitcell_6t.sym} 1400 3400 0 0 {name=Xr17c7}
N 1360 3440 1340 3440 {}
C {lab_pin.sym} 1340 3440 0 0 {name=l2756 lab=BL7}
N 1360 3400 1340 3400 {}
C {lab_pin.sym} 1340 3400 0 0 {name=l2757 lab=BLB7}
N 1360 3360 1340 3360 {}
C {lab_pin.sym} 1340 3360 0 0 {name=l2758 lab=WL17}
N 1440 3440 1460 3440 {}
C {lab_pin.sym} 1460 3440 0 0 {name=l2759 lab=VDD}
N 1440 3360 1460 3360 {}
C {lab_pin.sym} 1460 3360 0 0 {name=l2760 lab=VSS}
C {bitcell_6t.sym} 1600 3400 0 0 {name=Xr17c8}
N 1560 3440 1540 3440 {}
C {lab_pin.sym} 1540 3440 0 0 {name=l2761 lab=BL8}
N 1560 3400 1540 3400 {}
C {lab_pin.sym} 1540 3400 0 0 {name=l2762 lab=BLB8}
N 1560 3360 1540 3360 {}
C {lab_pin.sym} 1540 3360 0 0 {name=l2763 lab=WL17}
N 1640 3440 1660 3440 {}
C {lab_pin.sym} 1660 3440 0 0 {name=l2764 lab=VDD}
N 1640 3360 1660 3360 {}
C {lab_pin.sym} 1660 3360 0 0 {name=l2765 lab=VSS}
C {bitcell_6t.sym} 1800 3400 0 0 {name=Xr17c9}
N 1760 3440 1740 3440 {}
C {lab_pin.sym} 1740 3440 0 0 {name=l2766 lab=BL9}
N 1760 3400 1740 3400 {}
C {lab_pin.sym} 1740 3400 0 0 {name=l2767 lab=BLB9}
N 1760 3360 1740 3360 {}
C {lab_pin.sym} 1740 3360 0 0 {name=l2768 lab=WL17}
N 1840 3440 1860 3440 {}
C {lab_pin.sym} 1860 3440 0 0 {name=l2769 lab=VDD}
N 1840 3360 1860 3360 {}
C {lab_pin.sym} 1860 3360 0 0 {name=l2770 lab=VSS}
C {bitcell_6t.sym} 2000 3400 0 0 {name=Xr17c10}
N 1960 3440 1940 3440 {}
C {lab_pin.sym} 1940 3440 0 0 {name=l2771 lab=BL10}
N 1960 3400 1940 3400 {}
C {lab_pin.sym} 1940 3400 0 0 {name=l2772 lab=BLB10}
N 1960 3360 1940 3360 {}
C {lab_pin.sym} 1940 3360 0 0 {name=l2773 lab=WL17}
N 2040 3440 2060 3440 {}
C {lab_pin.sym} 2060 3440 0 0 {name=l2774 lab=VDD}
N 2040 3360 2060 3360 {}
C {lab_pin.sym} 2060 3360 0 0 {name=l2775 lab=VSS}
C {bitcell_6t.sym} 2200 3400 0 0 {name=Xr17c11}
N 2160 3440 2140 3440 {}
C {lab_pin.sym} 2140 3440 0 0 {name=l2776 lab=BL11}
N 2160 3400 2140 3400 {}
C {lab_pin.sym} 2140 3400 0 0 {name=l2777 lab=BLB11}
N 2160 3360 2140 3360 {}
C {lab_pin.sym} 2140 3360 0 0 {name=l2778 lab=WL17}
N 2240 3440 2260 3440 {}
C {lab_pin.sym} 2260 3440 0 0 {name=l2779 lab=VDD}
N 2240 3360 2260 3360 {}
C {lab_pin.sym} 2260 3360 0 0 {name=l2780 lab=VSS}
C {bitcell_6t.sym} 2400 3400 0 0 {name=Xr17c12}
N 2360 3440 2340 3440 {}
C {lab_pin.sym} 2340 3440 0 0 {name=l2781 lab=BL12}
N 2360 3400 2340 3400 {}
C {lab_pin.sym} 2340 3400 0 0 {name=l2782 lab=BLB12}
N 2360 3360 2340 3360 {}
C {lab_pin.sym} 2340 3360 0 0 {name=l2783 lab=WL17}
N 2440 3440 2460 3440 {}
C {lab_pin.sym} 2460 3440 0 0 {name=l2784 lab=VDD}
N 2440 3360 2460 3360 {}
C {lab_pin.sym} 2460 3360 0 0 {name=l2785 lab=VSS}
C {bitcell_6t.sym} 2600 3400 0 0 {name=Xr17c13}
N 2560 3440 2540 3440 {}
C {lab_pin.sym} 2540 3440 0 0 {name=l2786 lab=BL13}
N 2560 3400 2540 3400 {}
C {lab_pin.sym} 2540 3400 0 0 {name=l2787 lab=BLB13}
N 2560 3360 2540 3360 {}
C {lab_pin.sym} 2540 3360 0 0 {name=l2788 lab=WL17}
N 2640 3440 2660 3440 {}
C {lab_pin.sym} 2660 3440 0 0 {name=l2789 lab=VDD}
N 2640 3360 2660 3360 {}
C {lab_pin.sym} 2660 3360 0 0 {name=l2790 lab=VSS}
C {bitcell_6t.sym} 2800 3400 0 0 {name=Xr17c14}
N 2760 3440 2740 3440 {}
C {lab_pin.sym} 2740 3440 0 0 {name=l2791 lab=BL14}
N 2760 3400 2740 3400 {}
C {lab_pin.sym} 2740 3400 0 0 {name=l2792 lab=BLB14}
N 2760 3360 2740 3360 {}
C {lab_pin.sym} 2740 3360 0 0 {name=l2793 lab=WL17}
N 2840 3440 2860 3440 {}
C {lab_pin.sym} 2860 3440 0 0 {name=l2794 lab=VDD}
N 2840 3360 2860 3360 {}
C {lab_pin.sym} 2860 3360 0 0 {name=l2795 lab=VSS}
C {bitcell_6t.sym} 3000 3400 0 0 {name=Xr17c15}
N 2960 3440 2940 3440 {}
C {lab_pin.sym} 2940 3440 0 0 {name=l2796 lab=BL15}
N 2960 3400 2940 3400 {}
C {lab_pin.sym} 2940 3400 0 0 {name=l2797 lab=BLB15}
N 2960 3360 2940 3360 {}
C {lab_pin.sym} 2940 3360 0 0 {name=l2798 lab=WL17}
N 3040 3440 3060 3440 {}
C {lab_pin.sym} 3060 3440 0 0 {name=l2799 lab=VDD}
N 3040 3360 3060 3360 {}
C {lab_pin.sym} 3060 3360 0 0 {name=l2800 lab=VSS}
C {bitcell_6t.sym} 3200 3400 0 0 {name=Xr17c16}
N 3160 3440 3140 3440 {}
C {lab_pin.sym} 3140 3440 0 0 {name=l2801 lab=BL16}
N 3160 3400 3140 3400 {}
C {lab_pin.sym} 3140 3400 0 0 {name=l2802 lab=BLB16}
N 3160 3360 3140 3360 {}
C {lab_pin.sym} 3140 3360 0 0 {name=l2803 lab=WL17}
N 3240 3440 3260 3440 {}
C {lab_pin.sym} 3260 3440 0 0 {name=l2804 lab=VDD}
N 3240 3360 3260 3360 {}
C {lab_pin.sym} 3260 3360 0 0 {name=l2805 lab=VSS}
C {bitcell_6t.sym} 3400 3400 0 0 {name=Xr17c17}
N 3360 3440 3340 3440 {}
C {lab_pin.sym} 3340 3440 0 0 {name=l2806 lab=BL17}
N 3360 3400 3340 3400 {}
C {lab_pin.sym} 3340 3400 0 0 {name=l2807 lab=BLB17}
N 3360 3360 3340 3360 {}
C {lab_pin.sym} 3340 3360 0 0 {name=l2808 lab=WL17}
N 3440 3440 3460 3440 {}
C {lab_pin.sym} 3460 3440 0 0 {name=l2809 lab=VDD}
N 3440 3360 3460 3360 {}
C {lab_pin.sym} 3460 3360 0 0 {name=l2810 lab=VSS}
C {bitcell_6t.sym} 3600 3400 0 0 {name=Xr17c18}
N 3560 3440 3540 3440 {}
C {lab_pin.sym} 3540 3440 0 0 {name=l2811 lab=BL18}
N 3560 3400 3540 3400 {}
C {lab_pin.sym} 3540 3400 0 0 {name=l2812 lab=BLB18}
N 3560 3360 3540 3360 {}
C {lab_pin.sym} 3540 3360 0 0 {name=l2813 lab=WL17}
N 3640 3440 3660 3440 {}
C {lab_pin.sym} 3660 3440 0 0 {name=l2814 lab=VDD}
N 3640 3360 3660 3360 {}
C {lab_pin.sym} 3660 3360 0 0 {name=l2815 lab=VSS}
C {bitcell_6t.sym} 3800 3400 0 0 {name=Xr17c19}
N 3760 3440 3740 3440 {}
C {lab_pin.sym} 3740 3440 0 0 {name=l2816 lab=BL19}
N 3760 3400 3740 3400 {}
C {lab_pin.sym} 3740 3400 0 0 {name=l2817 lab=BLB19}
N 3760 3360 3740 3360 {}
C {lab_pin.sym} 3740 3360 0 0 {name=l2818 lab=WL17}
N 3840 3440 3860 3440 {}
C {lab_pin.sym} 3860 3440 0 0 {name=l2819 lab=VDD}
N 3840 3360 3860 3360 {}
C {lab_pin.sym} 3860 3360 0 0 {name=l2820 lab=VSS}
C {bitcell_6t.sym} 4000 3400 0 0 {name=Xr17c20}
N 3960 3440 3940 3440 {}
C {lab_pin.sym} 3940 3440 0 0 {name=l2821 lab=BL20}
N 3960 3400 3940 3400 {}
C {lab_pin.sym} 3940 3400 0 0 {name=l2822 lab=BLB20}
N 3960 3360 3940 3360 {}
C {lab_pin.sym} 3940 3360 0 0 {name=l2823 lab=WL17}
N 4040 3440 4060 3440 {}
C {lab_pin.sym} 4060 3440 0 0 {name=l2824 lab=VDD}
N 4040 3360 4060 3360 {}
C {lab_pin.sym} 4060 3360 0 0 {name=l2825 lab=VSS}
C {bitcell_6t.sym} 4200 3400 0 0 {name=Xr17c21}
N 4160 3440 4140 3440 {}
C {lab_pin.sym} 4140 3440 0 0 {name=l2826 lab=BL21}
N 4160 3400 4140 3400 {}
C {lab_pin.sym} 4140 3400 0 0 {name=l2827 lab=BLB21}
N 4160 3360 4140 3360 {}
C {lab_pin.sym} 4140 3360 0 0 {name=l2828 lab=WL17}
N 4240 3440 4260 3440 {}
C {lab_pin.sym} 4260 3440 0 0 {name=l2829 lab=VDD}
N 4240 3360 4260 3360 {}
C {lab_pin.sym} 4260 3360 0 0 {name=l2830 lab=VSS}
C {bitcell_6t.sym} 4400 3400 0 0 {name=Xr17c22}
N 4360 3440 4340 3440 {}
C {lab_pin.sym} 4340 3440 0 0 {name=l2831 lab=BL22}
N 4360 3400 4340 3400 {}
C {lab_pin.sym} 4340 3400 0 0 {name=l2832 lab=BLB22}
N 4360 3360 4340 3360 {}
C {lab_pin.sym} 4340 3360 0 0 {name=l2833 lab=WL17}
N 4440 3440 4460 3440 {}
C {lab_pin.sym} 4460 3440 0 0 {name=l2834 lab=VDD}
N 4440 3360 4460 3360 {}
C {lab_pin.sym} 4460 3360 0 0 {name=l2835 lab=VSS}
C {bitcell_6t.sym} 4600 3400 0 0 {name=Xr17c23}
N 4560 3440 4540 3440 {}
C {lab_pin.sym} 4540 3440 0 0 {name=l2836 lab=BL23}
N 4560 3400 4540 3400 {}
C {lab_pin.sym} 4540 3400 0 0 {name=l2837 lab=BLB23}
N 4560 3360 4540 3360 {}
C {lab_pin.sym} 4540 3360 0 0 {name=l2838 lab=WL17}
N 4640 3440 4660 3440 {}
C {lab_pin.sym} 4660 3440 0 0 {name=l2839 lab=VDD}
N 4640 3360 4660 3360 {}
C {lab_pin.sym} 4660 3360 0 0 {name=l2840 lab=VSS}
C {bitcell_6t.sym} 4800 3400 0 0 {name=Xr17c24}
N 4760 3440 4740 3440 {}
C {lab_pin.sym} 4740 3440 0 0 {name=l2841 lab=BL24}
N 4760 3400 4740 3400 {}
C {lab_pin.sym} 4740 3400 0 0 {name=l2842 lab=BLB24}
N 4760 3360 4740 3360 {}
C {lab_pin.sym} 4740 3360 0 0 {name=l2843 lab=WL17}
N 4840 3440 4860 3440 {}
C {lab_pin.sym} 4860 3440 0 0 {name=l2844 lab=VDD}
N 4840 3360 4860 3360 {}
C {lab_pin.sym} 4860 3360 0 0 {name=l2845 lab=VSS}
C {bitcell_6t.sym} 5000 3400 0 0 {name=Xr17c25}
N 4960 3440 4940 3440 {}
C {lab_pin.sym} 4940 3440 0 0 {name=l2846 lab=BL25}
N 4960 3400 4940 3400 {}
C {lab_pin.sym} 4940 3400 0 0 {name=l2847 lab=BLB25}
N 4960 3360 4940 3360 {}
C {lab_pin.sym} 4940 3360 0 0 {name=l2848 lab=WL17}
N 5040 3440 5060 3440 {}
C {lab_pin.sym} 5060 3440 0 0 {name=l2849 lab=VDD}
N 5040 3360 5060 3360 {}
C {lab_pin.sym} 5060 3360 0 0 {name=l2850 lab=VSS}
C {bitcell_6t.sym} 5200 3400 0 0 {name=Xr17c26}
N 5160 3440 5140 3440 {}
C {lab_pin.sym} 5140 3440 0 0 {name=l2851 lab=BL26}
N 5160 3400 5140 3400 {}
C {lab_pin.sym} 5140 3400 0 0 {name=l2852 lab=BLB26}
N 5160 3360 5140 3360 {}
C {lab_pin.sym} 5140 3360 0 0 {name=l2853 lab=WL17}
N 5240 3440 5260 3440 {}
C {lab_pin.sym} 5260 3440 0 0 {name=l2854 lab=VDD}
N 5240 3360 5260 3360 {}
C {lab_pin.sym} 5260 3360 0 0 {name=l2855 lab=VSS}
C {bitcell_6t.sym} 5400 3400 0 0 {name=Xr17c27}
N 5360 3440 5340 3440 {}
C {lab_pin.sym} 5340 3440 0 0 {name=l2856 lab=BL27}
N 5360 3400 5340 3400 {}
C {lab_pin.sym} 5340 3400 0 0 {name=l2857 lab=BLB27}
N 5360 3360 5340 3360 {}
C {lab_pin.sym} 5340 3360 0 0 {name=l2858 lab=WL17}
N 5440 3440 5460 3440 {}
C {lab_pin.sym} 5460 3440 0 0 {name=l2859 lab=VDD}
N 5440 3360 5460 3360 {}
C {lab_pin.sym} 5460 3360 0 0 {name=l2860 lab=VSS}
C {bitcell_6t.sym} 5600 3400 0 0 {name=Xr17c28}
N 5560 3440 5540 3440 {}
C {lab_pin.sym} 5540 3440 0 0 {name=l2861 lab=BL28}
N 5560 3400 5540 3400 {}
C {lab_pin.sym} 5540 3400 0 0 {name=l2862 lab=BLB28}
N 5560 3360 5540 3360 {}
C {lab_pin.sym} 5540 3360 0 0 {name=l2863 lab=WL17}
N 5640 3440 5660 3440 {}
C {lab_pin.sym} 5660 3440 0 0 {name=l2864 lab=VDD}
N 5640 3360 5660 3360 {}
C {lab_pin.sym} 5660 3360 0 0 {name=l2865 lab=VSS}
C {bitcell_6t.sym} 5800 3400 0 0 {name=Xr17c29}
N 5760 3440 5740 3440 {}
C {lab_pin.sym} 5740 3440 0 0 {name=l2866 lab=BL29}
N 5760 3400 5740 3400 {}
C {lab_pin.sym} 5740 3400 0 0 {name=l2867 lab=BLB29}
N 5760 3360 5740 3360 {}
C {lab_pin.sym} 5740 3360 0 0 {name=l2868 lab=WL17}
N 5840 3440 5860 3440 {}
C {lab_pin.sym} 5860 3440 0 0 {name=l2869 lab=VDD}
N 5840 3360 5860 3360 {}
C {lab_pin.sym} 5860 3360 0 0 {name=l2870 lab=VSS}
C {bitcell_6t.sym} 6000 3400 0 0 {name=Xr17c30}
N 5960 3440 5940 3440 {}
C {lab_pin.sym} 5940 3440 0 0 {name=l2871 lab=BL30}
N 5960 3400 5940 3400 {}
C {lab_pin.sym} 5940 3400 0 0 {name=l2872 lab=BLB30}
N 5960 3360 5940 3360 {}
C {lab_pin.sym} 5940 3360 0 0 {name=l2873 lab=WL17}
N 6040 3440 6060 3440 {}
C {lab_pin.sym} 6060 3440 0 0 {name=l2874 lab=VDD}
N 6040 3360 6060 3360 {}
C {lab_pin.sym} 6060 3360 0 0 {name=l2875 lab=VSS}
C {bitcell_6t.sym} 6200 3400 0 0 {name=Xr17c31}
N 6160 3440 6140 3440 {}
C {lab_pin.sym} 6140 3440 0 0 {name=l2876 lab=BL31}
N 6160 3400 6140 3400 {}
C {lab_pin.sym} 6140 3400 0 0 {name=l2877 lab=BLB31}
N 6160 3360 6140 3360 {}
C {lab_pin.sym} 6140 3360 0 0 {name=l2878 lab=WL17}
N 6240 3440 6260 3440 {}
C {lab_pin.sym} 6260 3440 0 0 {name=l2879 lab=VDD}
N 6240 3360 6260 3360 {}
C {lab_pin.sym} 6260 3360 0 0 {name=l2880 lab=VSS}
C {bitcell_6t.sym} 0 3600 0 0 {name=Xr18c0}
N -40 3640 -60 3640 {}
C {lab_pin.sym} -60 3640 0 0 {name=l2881 lab=BL0}
N -40 3600 -60 3600 {}
C {lab_pin.sym} -60 3600 0 0 {name=l2882 lab=BLB0}
N -40 3560 -60 3560 {}
C {lab_pin.sym} -60 3560 0 0 {name=l2883 lab=WL18}
N 40 3640 60 3640 {}
C {lab_pin.sym} 60 3640 0 0 {name=l2884 lab=VDD}
N 40 3560 60 3560 {}
C {lab_pin.sym} 60 3560 0 0 {name=l2885 lab=VSS}
C {bitcell_6t.sym} 200 3600 0 0 {name=Xr18c1}
N 160 3640 140 3640 {}
C {lab_pin.sym} 140 3640 0 0 {name=l2886 lab=BL1}
N 160 3600 140 3600 {}
C {lab_pin.sym} 140 3600 0 0 {name=l2887 lab=BLB1}
N 160 3560 140 3560 {}
C {lab_pin.sym} 140 3560 0 0 {name=l2888 lab=WL18}
N 240 3640 260 3640 {}
C {lab_pin.sym} 260 3640 0 0 {name=l2889 lab=VDD}
N 240 3560 260 3560 {}
C {lab_pin.sym} 260 3560 0 0 {name=l2890 lab=VSS}
C {bitcell_6t.sym} 400 3600 0 0 {name=Xr18c2}
N 360 3640 340 3640 {}
C {lab_pin.sym} 340 3640 0 0 {name=l2891 lab=BL2}
N 360 3600 340 3600 {}
C {lab_pin.sym} 340 3600 0 0 {name=l2892 lab=BLB2}
N 360 3560 340 3560 {}
C {lab_pin.sym} 340 3560 0 0 {name=l2893 lab=WL18}
N 440 3640 460 3640 {}
C {lab_pin.sym} 460 3640 0 0 {name=l2894 lab=VDD}
N 440 3560 460 3560 {}
C {lab_pin.sym} 460 3560 0 0 {name=l2895 lab=VSS}
C {bitcell_6t.sym} 600 3600 0 0 {name=Xr18c3}
N 560 3640 540 3640 {}
C {lab_pin.sym} 540 3640 0 0 {name=l2896 lab=BL3}
N 560 3600 540 3600 {}
C {lab_pin.sym} 540 3600 0 0 {name=l2897 lab=BLB3}
N 560 3560 540 3560 {}
C {lab_pin.sym} 540 3560 0 0 {name=l2898 lab=WL18}
N 640 3640 660 3640 {}
C {lab_pin.sym} 660 3640 0 0 {name=l2899 lab=VDD}
N 640 3560 660 3560 {}
C {lab_pin.sym} 660 3560 0 0 {name=l2900 lab=VSS}
C {bitcell_6t.sym} 800 3600 0 0 {name=Xr18c4}
N 760 3640 740 3640 {}
C {lab_pin.sym} 740 3640 0 0 {name=l2901 lab=BL4}
N 760 3600 740 3600 {}
C {lab_pin.sym} 740 3600 0 0 {name=l2902 lab=BLB4}
N 760 3560 740 3560 {}
C {lab_pin.sym} 740 3560 0 0 {name=l2903 lab=WL18}
N 840 3640 860 3640 {}
C {lab_pin.sym} 860 3640 0 0 {name=l2904 lab=VDD}
N 840 3560 860 3560 {}
C {lab_pin.sym} 860 3560 0 0 {name=l2905 lab=VSS}
C {bitcell_6t.sym} 1000 3600 0 0 {name=Xr18c5}
N 960 3640 940 3640 {}
C {lab_pin.sym} 940 3640 0 0 {name=l2906 lab=BL5}
N 960 3600 940 3600 {}
C {lab_pin.sym} 940 3600 0 0 {name=l2907 lab=BLB5}
N 960 3560 940 3560 {}
C {lab_pin.sym} 940 3560 0 0 {name=l2908 lab=WL18}
N 1040 3640 1060 3640 {}
C {lab_pin.sym} 1060 3640 0 0 {name=l2909 lab=VDD}
N 1040 3560 1060 3560 {}
C {lab_pin.sym} 1060 3560 0 0 {name=l2910 lab=VSS}
C {bitcell_6t.sym} 1200 3600 0 0 {name=Xr18c6}
N 1160 3640 1140 3640 {}
C {lab_pin.sym} 1140 3640 0 0 {name=l2911 lab=BL6}
N 1160 3600 1140 3600 {}
C {lab_pin.sym} 1140 3600 0 0 {name=l2912 lab=BLB6}
N 1160 3560 1140 3560 {}
C {lab_pin.sym} 1140 3560 0 0 {name=l2913 lab=WL18}
N 1240 3640 1260 3640 {}
C {lab_pin.sym} 1260 3640 0 0 {name=l2914 lab=VDD}
N 1240 3560 1260 3560 {}
C {lab_pin.sym} 1260 3560 0 0 {name=l2915 lab=VSS}
C {bitcell_6t.sym} 1400 3600 0 0 {name=Xr18c7}
N 1360 3640 1340 3640 {}
C {lab_pin.sym} 1340 3640 0 0 {name=l2916 lab=BL7}
N 1360 3600 1340 3600 {}
C {lab_pin.sym} 1340 3600 0 0 {name=l2917 lab=BLB7}
N 1360 3560 1340 3560 {}
C {lab_pin.sym} 1340 3560 0 0 {name=l2918 lab=WL18}
N 1440 3640 1460 3640 {}
C {lab_pin.sym} 1460 3640 0 0 {name=l2919 lab=VDD}
N 1440 3560 1460 3560 {}
C {lab_pin.sym} 1460 3560 0 0 {name=l2920 lab=VSS}
C {bitcell_6t.sym} 1600 3600 0 0 {name=Xr18c8}
N 1560 3640 1540 3640 {}
C {lab_pin.sym} 1540 3640 0 0 {name=l2921 lab=BL8}
N 1560 3600 1540 3600 {}
C {lab_pin.sym} 1540 3600 0 0 {name=l2922 lab=BLB8}
N 1560 3560 1540 3560 {}
C {lab_pin.sym} 1540 3560 0 0 {name=l2923 lab=WL18}
N 1640 3640 1660 3640 {}
C {lab_pin.sym} 1660 3640 0 0 {name=l2924 lab=VDD}
N 1640 3560 1660 3560 {}
C {lab_pin.sym} 1660 3560 0 0 {name=l2925 lab=VSS}
C {bitcell_6t.sym} 1800 3600 0 0 {name=Xr18c9}
N 1760 3640 1740 3640 {}
C {lab_pin.sym} 1740 3640 0 0 {name=l2926 lab=BL9}
N 1760 3600 1740 3600 {}
C {lab_pin.sym} 1740 3600 0 0 {name=l2927 lab=BLB9}
N 1760 3560 1740 3560 {}
C {lab_pin.sym} 1740 3560 0 0 {name=l2928 lab=WL18}
N 1840 3640 1860 3640 {}
C {lab_pin.sym} 1860 3640 0 0 {name=l2929 lab=VDD}
N 1840 3560 1860 3560 {}
C {lab_pin.sym} 1860 3560 0 0 {name=l2930 lab=VSS}
C {bitcell_6t.sym} 2000 3600 0 0 {name=Xr18c10}
N 1960 3640 1940 3640 {}
C {lab_pin.sym} 1940 3640 0 0 {name=l2931 lab=BL10}
N 1960 3600 1940 3600 {}
C {lab_pin.sym} 1940 3600 0 0 {name=l2932 lab=BLB10}
N 1960 3560 1940 3560 {}
C {lab_pin.sym} 1940 3560 0 0 {name=l2933 lab=WL18}
N 2040 3640 2060 3640 {}
C {lab_pin.sym} 2060 3640 0 0 {name=l2934 lab=VDD}
N 2040 3560 2060 3560 {}
C {lab_pin.sym} 2060 3560 0 0 {name=l2935 lab=VSS}
C {bitcell_6t.sym} 2200 3600 0 0 {name=Xr18c11}
N 2160 3640 2140 3640 {}
C {lab_pin.sym} 2140 3640 0 0 {name=l2936 lab=BL11}
N 2160 3600 2140 3600 {}
C {lab_pin.sym} 2140 3600 0 0 {name=l2937 lab=BLB11}
N 2160 3560 2140 3560 {}
C {lab_pin.sym} 2140 3560 0 0 {name=l2938 lab=WL18}
N 2240 3640 2260 3640 {}
C {lab_pin.sym} 2260 3640 0 0 {name=l2939 lab=VDD}
N 2240 3560 2260 3560 {}
C {lab_pin.sym} 2260 3560 0 0 {name=l2940 lab=VSS}
C {bitcell_6t.sym} 2400 3600 0 0 {name=Xr18c12}
N 2360 3640 2340 3640 {}
C {lab_pin.sym} 2340 3640 0 0 {name=l2941 lab=BL12}
N 2360 3600 2340 3600 {}
C {lab_pin.sym} 2340 3600 0 0 {name=l2942 lab=BLB12}
N 2360 3560 2340 3560 {}
C {lab_pin.sym} 2340 3560 0 0 {name=l2943 lab=WL18}
N 2440 3640 2460 3640 {}
C {lab_pin.sym} 2460 3640 0 0 {name=l2944 lab=VDD}
N 2440 3560 2460 3560 {}
C {lab_pin.sym} 2460 3560 0 0 {name=l2945 lab=VSS}
C {bitcell_6t.sym} 2600 3600 0 0 {name=Xr18c13}
N 2560 3640 2540 3640 {}
C {lab_pin.sym} 2540 3640 0 0 {name=l2946 lab=BL13}
N 2560 3600 2540 3600 {}
C {lab_pin.sym} 2540 3600 0 0 {name=l2947 lab=BLB13}
N 2560 3560 2540 3560 {}
C {lab_pin.sym} 2540 3560 0 0 {name=l2948 lab=WL18}
N 2640 3640 2660 3640 {}
C {lab_pin.sym} 2660 3640 0 0 {name=l2949 lab=VDD}
N 2640 3560 2660 3560 {}
C {lab_pin.sym} 2660 3560 0 0 {name=l2950 lab=VSS}
C {bitcell_6t.sym} 2800 3600 0 0 {name=Xr18c14}
N 2760 3640 2740 3640 {}
C {lab_pin.sym} 2740 3640 0 0 {name=l2951 lab=BL14}
N 2760 3600 2740 3600 {}
C {lab_pin.sym} 2740 3600 0 0 {name=l2952 lab=BLB14}
N 2760 3560 2740 3560 {}
C {lab_pin.sym} 2740 3560 0 0 {name=l2953 lab=WL18}
N 2840 3640 2860 3640 {}
C {lab_pin.sym} 2860 3640 0 0 {name=l2954 lab=VDD}
N 2840 3560 2860 3560 {}
C {lab_pin.sym} 2860 3560 0 0 {name=l2955 lab=VSS}
C {bitcell_6t.sym} 3000 3600 0 0 {name=Xr18c15}
N 2960 3640 2940 3640 {}
C {lab_pin.sym} 2940 3640 0 0 {name=l2956 lab=BL15}
N 2960 3600 2940 3600 {}
C {lab_pin.sym} 2940 3600 0 0 {name=l2957 lab=BLB15}
N 2960 3560 2940 3560 {}
C {lab_pin.sym} 2940 3560 0 0 {name=l2958 lab=WL18}
N 3040 3640 3060 3640 {}
C {lab_pin.sym} 3060 3640 0 0 {name=l2959 lab=VDD}
N 3040 3560 3060 3560 {}
C {lab_pin.sym} 3060 3560 0 0 {name=l2960 lab=VSS}
C {bitcell_6t.sym} 3200 3600 0 0 {name=Xr18c16}
N 3160 3640 3140 3640 {}
C {lab_pin.sym} 3140 3640 0 0 {name=l2961 lab=BL16}
N 3160 3600 3140 3600 {}
C {lab_pin.sym} 3140 3600 0 0 {name=l2962 lab=BLB16}
N 3160 3560 3140 3560 {}
C {lab_pin.sym} 3140 3560 0 0 {name=l2963 lab=WL18}
N 3240 3640 3260 3640 {}
C {lab_pin.sym} 3260 3640 0 0 {name=l2964 lab=VDD}
N 3240 3560 3260 3560 {}
C {lab_pin.sym} 3260 3560 0 0 {name=l2965 lab=VSS}
C {bitcell_6t.sym} 3400 3600 0 0 {name=Xr18c17}
N 3360 3640 3340 3640 {}
C {lab_pin.sym} 3340 3640 0 0 {name=l2966 lab=BL17}
N 3360 3600 3340 3600 {}
C {lab_pin.sym} 3340 3600 0 0 {name=l2967 lab=BLB17}
N 3360 3560 3340 3560 {}
C {lab_pin.sym} 3340 3560 0 0 {name=l2968 lab=WL18}
N 3440 3640 3460 3640 {}
C {lab_pin.sym} 3460 3640 0 0 {name=l2969 lab=VDD}
N 3440 3560 3460 3560 {}
C {lab_pin.sym} 3460 3560 0 0 {name=l2970 lab=VSS}
C {bitcell_6t.sym} 3600 3600 0 0 {name=Xr18c18}
N 3560 3640 3540 3640 {}
C {lab_pin.sym} 3540 3640 0 0 {name=l2971 lab=BL18}
N 3560 3600 3540 3600 {}
C {lab_pin.sym} 3540 3600 0 0 {name=l2972 lab=BLB18}
N 3560 3560 3540 3560 {}
C {lab_pin.sym} 3540 3560 0 0 {name=l2973 lab=WL18}
N 3640 3640 3660 3640 {}
C {lab_pin.sym} 3660 3640 0 0 {name=l2974 lab=VDD}
N 3640 3560 3660 3560 {}
C {lab_pin.sym} 3660 3560 0 0 {name=l2975 lab=VSS}
C {bitcell_6t.sym} 3800 3600 0 0 {name=Xr18c19}
N 3760 3640 3740 3640 {}
C {lab_pin.sym} 3740 3640 0 0 {name=l2976 lab=BL19}
N 3760 3600 3740 3600 {}
C {lab_pin.sym} 3740 3600 0 0 {name=l2977 lab=BLB19}
N 3760 3560 3740 3560 {}
C {lab_pin.sym} 3740 3560 0 0 {name=l2978 lab=WL18}
N 3840 3640 3860 3640 {}
C {lab_pin.sym} 3860 3640 0 0 {name=l2979 lab=VDD}
N 3840 3560 3860 3560 {}
C {lab_pin.sym} 3860 3560 0 0 {name=l2980 lab=VSS}
C {bitcell_6t.sym} 4000 3600 0 0 {name=Xr18c20}
N 3960 3640 3940 3640 {}
C {lab_pin.sym} 3940 3640 0 0 {name=l2981 lab=BL20}
N 3960 3600 3940 3600 {}
C {lab_pin.sym} 3940 3600 0 0 {name=l2982 lab=BLB20}
N 3960 3560 3940 3560 {}
C {lab_pin.sym} 3940 3560 0 0 {name=l2983 lab=WL18}
N 4040 3640 4060 3640 {}
C {lab_pin.sym} 4060 3640 0 0 {name=l2984 lab=VDD}
N 4040 3560 4060 3560 {}
C {lab_pin.sym} 4060 3560 0 0 {name=l2985 lab=VSS}
C {bitcell_6t.sym} 4200 3600 0 0 {name=Xr18c21}
N 4160 3640 4140 3640 {}
C {lab_pin.sym} 4140 3640 0 0 {name=l2986 lab=BL21}
N 4160 3600 4140 3600 {}
C {lab_pin.sym} 4140 3600 0 0 {name=l2987 lab=BLB21}
N 4160 3560 4140 3560 {}
C {lab_pin.sym} 4140 3560 0 0 {name=l2988 lab=WL18}
N 4240 3640 4260 3640 {}
C {lab_pin.sym} 4260 3640 0 0 {name=l2989 lab=VDD}
N 4240 3560 4260 3560 {}
C {lab_pin.sym} 4260 3560 0 0 {name=l2990 lab=VSS}
C {bitcell_6t.sym} 4400 3600 0 0 {name=Xr18c22}
N 4360 3640 4340 3640 {}
C {lab_pin.sym} 4340 3640 0 0 {name=l2991 lab=BL22}
N 4360 3600 4340 3600 {}
C {lab_pin.sym} 4340 3600 0 0 {name=l2992 lab=BLB22}
N 4360 3560 4340 3560 {}
C {lab_pin.sym} 4340 3560 0 0 {name=l2993 lab=WL18}
N 4440 3640 4460 3640 {}
C {lab_pin.sym} 4460 3640 0 0 {name=l2994 lab=VDD}
N 4440 3560 4460 3560 {}
C {lab_pin.sym} 4460 3560 0 0 {name=l2995 lab=VSS}
C {bitcell_6t.sym} 4600 3600 0 0 {name=Xr18c23}
N 4560 3640 4540 3640 {}
C {lab_pin.sym} 4540 3640 0 0 {name=l2996 lab=BL23}
N 4560 3600 4540 3600 {}
C {lab_pin.sym} 4540 3600 0 0 {name=l2997 lab=BLB23}
N 4560 3560 4540 3560 {}
C {lab_pin.sym} 4540 3560 0 0 {name=l2998 lab=WL18}
N 4640 3640 4660 3640 {}
C {lab_pin.sym} 4660 3640 0 0 {name=l2999 lab=VDD}
N 4640 3560 4660 3560 {}
C {lab_pin.sym} 4660 3560 0 0 {name=l3000 lab=VSS}
C {bitcell_6t.sym} 4800 3600 0 0 {name=Xr18c24}
N 4760 3640 4740 3640 {}
C {lab_pin.sym} 4740 3640 0 0 {name=l3001 lab=BL24}
N 4760 3600 4740 3600 {}
C {lab_pin.sym} 4740 3600 0 0 {name=l3002 lab=BLB24}
N 4760 3560 4740 3560 {}
C {lab_pin.sym} 4740 3560 0 0 {name=l3003 lab=WL18}
N 4840 3640 4860 3640 {}
C {lab_pin.sym} 4860 3640 0 0 {name=l3004 lab=VDD}
N 4840 3560 4860 3560 {}
C {lab_pin.sym} 4860 3560 0 0 {name=l3005 lab=VSS}
C {bitcell_6t.sym} 5000 3600 0 0 {name=Xr18c25}
N 4960 3640 4940 3640 {}
C {lab_pin.sym} 4940 3640 0 0 {name=l3006 lab=BL25}
N 4960 3600 4940 3600 {}
C {lab_pin.sym} 4940 3600 0 0 {name=l3007 lab=BLB25}
N 4960 3560 4940 3560 {}
C {lab_pin.sym} 4940 3560 0 0 {name=l3008 lab=WL18}
N 5040 3640 5060 3640 {}
C {lab_pin.sym} 5060 3640 0 0 {name=l3009 lab=VDD}
N 5040 3560 5060 3560 {}
C {lab_pin.sym} 5060 3560 0 0 {name=l3010 lab=VSS}
C {bitcell_6t.sym} 5200 3600 0 0 {name=Xr18c26}
N 5160 3640 5140 3640 {}
C {lab_pin.sym} 5140 3640 0 0 {name=l3011 lab=BL26}
N 5160 3600 5140 3600 {}
C {lab_pin.sym} 5140 3600 0 0 {name=l3012 lab=BLB26}
N 5160 3560 5140 3560 {}
C {lab_pin.sym} 5140 3560 0 0 {name=l3013 lab=WL18}
N 5240 3640 5260 3640 {}
C {lab_pin.sym} 5260 3640 0 0 {name=l3014 lab=VDD}
N 5240 3560 5260 3560 {}
C {lab_pin.sym} 5260 3560 0 0 {name=l3015 lab=VSS}
C {bitcell_6t.sym} 5400 3600 0 0 {name=Xr18c27}
N 5360 3640 5340 3640 {}
C {lab_pin.sym} 5340 3640 0 0 {name=l3016 lab=BL27}
N 5360 3600 5340 3600 {}
C {lab_pin.sym} 5340 3600 0 0 {name=l3017 lab=BLB27}
N 5360 3560 5340 3560 {}
C {lab_pin.sym} 5340 3560 0 0 {name=l3018 lab=WL18}
N 5440 3640 5460 3640 {}
C {lab_pin.sym} 5460 3640 0 0 {name=l3019 lab=VDD}
N 5440 3560 5460 3560 {}
C {lab_pin.sym} 5460 3560 0 0 {name=l3020 lab=VSS}
C {bitcell_6t.sym} 5600 3600 0 0 {name=Xr18c28}
N 5560 3640 5540 3640 {}
C {lab_pin.sym} 5540 3640 0 0 {name=l3021 lab=BL28}
N 5560 3600 5540 3600 {}
C {lab_pin.sym} 5540 3600 0 0 {name=l3022 lab=BLB28}
N 5560 3560 5540 3560 {}
C {lab_pin.sym} 5540 3560 0 0 {name=l3023 lab=WL18}
N 5640 3640 5660 3640 {}
C {lab_pin.sym} 5660 3640 0 0 {name=l3024 lab=VDD}
N 5640 3560 5660 3560 {}
C {lab_pin.sym} 5660 3560 0 0 {name=l3025 lab=VSS}
C {bitcell_6t.sym} 5800 3600 0 0 {name=Xr18c29}
N 5760 3640 5740 3640 {}
C {lab_pin.sym} 5740 3640 0 0 {name=l3026 lab=BL29}
N 5760 3600 5740 3600 {}
C {lab_pin.sym} 5740 3600 0 0 {name=l3027 lab=BLB29}
N 5760 3560 5740 3560 {}
C {lab_pin.sym} 5740 3560 0 0 {name=l3028 lab=WL18}
N 5840 3640 5860 3640 {}
C {lab_pin.sym} 5860 3640 0 0 {name=l3029 lab=VDD}
N 5840 3560 5860 3560 {}
C {lab_pin.sym} 5860 3560 0 0 {name=l3030 lab=VSS}
C {bitcell_6t.sym} 6000 3600 0 0 {name=Xr18c30}
N 5960 3640 5940 3640 {}
C {lab_pin.sym} 5940 3640 0 0 {name=l3031 lab=BL30}
N 5960 3600 5940 3600 {}
C {lab_pin.sym} 5940 3600 0 0 {name=l3032 lab=BLB30}
N 5960 3560 5940 3560 {}
C {lab_pin.sym} 5940 3560 0 0 {name=l3033 lab=WL18}
N 6040 3640 6060 3640 {}
C {lab_pin.sym} 6060 3640 0 0 {name=l3034 lab=VDD}
N 6040 3560 6060 3560 {}
C {lab_pin.sym} 6060 3560 0 0 {name=l3035 lab=VSS}
C {bitcell_6t.sym} 6200 3600 0 0 {name=Xr18c31}
N 6160 3640 6140 3640 {}
C {lab_pin.sym} 6140 3640 0 0 {name=l3036 lab=BL31}
N 6160 3600 6140 3600 {}
C {lab_pin.sym} 6140 3600 0 0 {name=l3037 lab=BLB31}
N 6160 3560 6140 3560 {}
C {lab_pin.sym} 6140 3560 0 0 {name=l3038 lab=WL18}
N 6240 3640 6260 3640 {}
C {lab_pin.sym} 6260 3640 0 0 {name=l3039 lab=VDD}
N 6240 3560 6260 3560 {}
C {lab_pin.sym} 6260 3560 0 0 {name=l3040 lab=VSS}
C {bitcell_6t.sym} 0 3800 0 0 {name=Xr19c0}
N -40 3840 -60 3840 {}
C {lab_pin.sym} -60 3840 0 0 {name=l3041 lab=BL0}
N -40 3800 -60 3800 {}
C {lab_pin.sym} -60 3800 0 0 {name=l3042 lab=BLB0}
N -40 3760 -60 3760 {}
C {lab_pin.sym} -60 3760 0 0 {name=l3043 lab=WL19}
N 40 3840 60 3840 {}
C {lab_pin.sym} 60 3840 0 0 {name=l3044 lab=VDD}
N 40 3760 60 3760 {}
C {lab_pin.sym} 60 3760 0 0 {name=l3045 lab=VSS}
C {bitcell_6t.sym} 200 3800 0 0 {name=Xr19c1}
N 160 3840 140 3840 {}
C {lab_pin.sym} 140 3840 0 0 {name=l3046 lab=BL1}
N 160 3800 140 3800 {}
C {lab_pin.sym} 140 3800 0 0 {name=l3047 lab=BLB1}
N 160 3760 140 3760 {}
C {lab_pin.sym} 140 3760 0 0 {name=l3048 lab=WL19}
N 240 3840 260 3840 {}
C {lab_pin.sym} 260 3840 0 0 {name=l3049 lab=VDD}
N 240 3760 260 3760 {}
C {lab_pin.sym} 260 3760 0 0 {name=l3050 lab=VSS}
C {bitcell_6t.sym} 400 3800 0 0 {name=Xr19c2}
N 360 3840 340 3840 {}
C {lab_pin.sym} 340 3840 0 0 {name=l3051 lab=BL2}
N 360 3800 340 3800 {}
C {lab_pin.sym} 340 3800 0 0 {name=l3052 lab=BLB2}
N 360 3760 340 3760 {}
C {lab_pin.sym} 340 3760 0 0 {name=l3053 lab=WL19}
N 440 3840 460 3840 {}
C {lab_pin.sym} 460 3840 0 0 {name=l3054 lab=VDD}
N 440 3760 460 3760 {}
C {lab_pin.sym} 460 3760 0 0 {name=l3055 lab=VSS}
C {bitcell_6t.sym} 600 3800 0 0 {name=Xr19c3}
N 560 3840 540 3840 {}
C {lab_pin.sym} 540 3840 0 0 {name=l3056 lab=BL3}
N 560 3800 540 3800 {}
C {lab_pin.sym} 540 3800 0 0 {name=l3057 lab=BLB3}
N 560 3760 540 3760 {}
C {lab_pin.sym} 540 3760 0 0 {name=l3058 lab=WL19}
N 640 3840 660 3840 {}
C {lab_pin.sym} 660 3840 0 0 {name=l3059 lab=VDD}
N 640 3760 660 3760 {}
C {lab_pin.sym} 660 3760 0 0 {name=l3060 lab=VSS}
C {bitcell_6t.sym} 800 3800 0 0 {name=Xr19c4}
N 760 3840 740 3840 {}
C {lab_pin.sym} 740 3840 0 0 {name=l3061 lab=BL4}
N 760 3800 740 3800 {}
C {lab_pin.sym} 740 3800 0 0 {name=l3062 lab=BLB4}
N 760 3760 740 3760 {}
C {lab_pin.sym} 740 3760 0 0 {name=l3063 lab=WL19}
N 840 3840 860 3840 {}
C {lab_pin.sym} 860 3840 0 0 {name=l3064 lab=VDD}
N 840 3760 860 3760 {}
C {lab_pin.sym} 860 3760 0 0 {name=l3065 lab=VSS}
C {bitcell_6t.sym} 1000 3800 0 0 {name=Xr19c5}
N 960 3840 940 3840 {}
C {lab_pin.sym} 940 3840 0 0 {name=l3066 lab=BL5}
N 960 3800 940 3800 {}
C {lab_pin.sym} 940 3800 0 0 {name=l3067 lab=BLB5}
N 960 3760 940 3760 {}
C {lab_pin.sym} 940 3760 0 0 {name=l3068 lab=WL19}
N 1040 3840 1060 3840 {}
C {lab_pin.sym} 1060 3840 0 0 {name=l3069 lab=VDD}
N 1040 3760 1060 3760 {}
C {lab_pin.sym} 1060 3760 0 0 {name=l3070 lab=VSS}
C {bitcell_6t.sym} 1200 3800 0 0 {name=Xr19c6}
N 1160 3840 1140 3840 {}
C {lab_pin.sym} 1140 3840 0 0 {name=l3071 lab=BL6}
N 1160 3800 1140 3800 {}
C {lab_pin.sym} 1140 3800 0 0 {name=l3072 lab=BLB6}
N 1160 3760 1140 3760 {}
C {lab_pin.sym} 1140 3760 0 0 {name=l3073 lab=WL19}
N 1240 3840 1260 3840 {}
C {lab_pin.sym} 1260 3840 0 0 {name=l3074 lab=VDD}
N 1240 3760 1260 3760 {}
C {lab_pin.sym} 1260 3760 0 0 {name=l3075 lab=VSS}
C {bitcell_6t.sym} 1400 3800 0 0 {name=Xr19c7}
N 1360 3840 1340 3840 {}
C {lab_pin.sym} 1340 3840 0 0 {name=l3076 lab=BL7}
N 1360 3800 1340 3800 {}
C {lab_pin.sym} 1340 3800 0 0 {name=l3077 lab=BLB7}
N 1360 3760 1340 3760 {}
C {lab_pin.sym} 1340 3760 0 0 {name=l3078 lab=WL19}
N 1440 3840 1460 3840 {}
C {lab_pin.sym} 1460 3840 0 0 {name=l3079 lab=VDD}
N 1440 3760 1460 3760 {}
C {lab_pin.sym} 1460 3760 0 0 {name=l3080 lab=VSS}
C {bitcell_6t.sym} 1600 3800 0 0 {name=Xr19c8}
N 1560 3840 1540 3840 {}
C {lab_pin.sym} 1540 3840 0 0 {name=l3081 lab=BL8}
N 1560 3800 1540 3800 {}
C {lab_pin.sym} 1540 3800 0 0 {name=l3082 lab=BLB8}
N 1560 3760 1540 3760 {}
C {lab_pin.sym} 1540 3760 0 0 {name=l3083 lab=WL19}
N 1640 3840 1660 3840 {}
C {lab_pin.sym} 1660 3840 0 0 {name=l3084 lab=VDD}
N 1640 3760 1660 3760 {}
C {lab_pin.sym} 1660 3760 0 0 {name=l3085 lab=VSS}
C {bitcell_6t.sym} 1800 3800 0 0 {name=Xr19c9}
N 1760 3840 1740 3840 {}
C {lab_pin.sym} 1740 3840 0 0 {name=l3086 lab=BL9}
N 1760 3800 1740 3800 {}
C {lab_pin.sym} 1740 3800 0 0 {name=l3087 lab=BLB9}
N 1760 3760 1740 3760 {}
C {lab_pin.sym} 1740 3760 0 0 {name=l3088 lab=WL19}
N 1840 3840 1860 3840 {}
C {lab_pin.sym} 1860 3840 0 0 {name=l3089 lab=VDD}
N 1840 3760 1860 3760 {}
C {lab_pin.sym} 1860 3760 0 0 {name=l3090 lab=VSS}
C {bitcell_6t.sym} 2000 3800 0 0 {name=Xr19c10}
N 1960 3840 1940 3840 {}
C {lab_pin.sym} 1940 3840 0 0 {name=l3091 lab=BL10}
N 1960 3800 1940 3800 {}
C {lab_pin.sym} 1940 3800 0 0 {name=l3092 lab=BLB10}
N 1960 3760 1940 3760 {}
C {lab_pin.sym} 1940 3760 0 0 {name=l3093 lab=WL19}
N 2040 3840 2060 3840 {}
C {lab_pin.sym} 2060 3840 0 0 {name=l3094 lab=VDD}
N 2040 3760 2060 3760 {}
C {lab_pin.sym} 2060 3760 0 0 {name=l3095 lab=VSS}
C {bitcell_6t.sym} 2200 3800 0 0 {name=Xr19c11}
N 2160 3840 2140 3840 {}
C {lab_pin.sym} 2140 3840 0 0 {name=l3096 lab=BL11}
N 2160 3800 2140 3800 {}
C {lab_pin.sym} 2140 3800 0 0 {name=l3097 lab=BLB11}
N 2160 3760 2140 3760 {}
C {lab_pin.sym} 2140 3760 0 0 {name=l3098 lab=WL19}
N 2240 3840 2260 3840 {}
C {lab_pin.sym} 2260 3840 0 0 {name=l3099 lab=VDD}
N 2240 3760 2260 3760 {}
C {lab_pin.sym} 2260 3760 0 0 {name=l3100 lab=VSS}
C {bitcell_6t.sym} 2400 3800 0 0 {name=Xr19c12}
N 2360 3840 2340 3840 {}
C {lab_pin.sym} 2340 3840 0 0 {name=l3101 lab=BL12}
N 2360 3800 2340 3800 {}
C {lab_pin.sym} 2340 3800 0 0 {name=l3102 lab=BLB12}
N 2360 3760 2340 3760 {}
C {lab_pin.sym} 2340 3760 0 0 {name=l3103 lab=WL19}
N 2440 3840 2460 3840 {}
C {lab_pin.sym} 2460 3840 0 0 {name=l3104 lab=VDD}
N 2440 3760 2460 3760 {}
C {lab_pin.sym} 2460 3760 0 0 {name=l3105 lab=VSS}
C {bitcell_6t.sym} 2600 3800 0 0 {name=Xr19c13}
N 2560 3840 2540 3840 {}
C {lab_pin.sym} 2540 3840 0 0 {name=l3106 lab=BL13}
N 2560 3800 2540 3800 {}
C {lab_pin.sym} 2540 3800 0 0 {name=l3107 lab=BLB13}
N 2560 3760 2540 3760 {}
C {lab_pin.sym} 2540 3760 0 0 {name=l3108 lab=WL19}
N 2640 3840 2660 3840 {}
C {lab_pin.sym} 2660 3840 0 0 {name=l3109 lab=VDD}
N 2640 3760 2660 3760 {}
C {lab_pin.sym} 2660 3760 0 0 {name=l3110 lab=VSS}
C {bitcell_6t.sym} 2800 3800 0 0 {name=Xr19c14}
N 2760 3840 2740 3840 {}
C {lab_pin.sym} 2740 3840 0 0 {name=l3111 lab=BL14}
N 2760 3800 2740 3800 {}
C {lab_pin.sym} 2740 3800 0 0 {name=l3112 lab=BLB14}
N 2760 3760 2740 3760 {}
C {lab_pin.sym} 2740 3760 0 0 {name=l3113 lab=WL19}
N 2840 3840 2860 3840 {}
C {lab_pin.sym} 2860 3840 0 0 {name=l3114 lab=VDD}
N 2840 3760 2860 3760 {}
C {lab_pin.sym} 2860 3760 0 0 {name=l3115 lab=VSS}
C {bitcell_6t.sym} 3000 3800 0 0 {name=Xr19c15}
N 2960 3840 2940 3840 {}
C {lab_pin.sym} 2940 3840 0 0 {name=l3116 lab=BL15}
N 2960 3800 2940 3800 {}
C {lab_pin.sym} 2940 3800 0 0 {name=l3117 lab=BLB15}
N 2960 3760 2940 3760 {}
C {lab_pin.sym} 2940 3760 0 0 {name=l3118 lab=WL19}
N 3040 3840 3060 3840 {}
C {lab_pin.sym} 3060 3840 0 0 {name=l3119 lab=VDD}
N 3040 3760 3060 3760 {}
C {lab_pin.sym} 3060 3760 0 0 {name=l3120 lab=VSS}
C {bitcell_6t.sym} 3200 3800 0 0 {name=Xr19c16}
N 3160 3840 3140 3840 {}
C {lab_pin.sym} 3140 3840 0 0 {name=l3121 lab=BL16}
N 3160 3800 3140 3800 {}
C {lab_pin.sym} 3140 3800 0 0 {name=l3122 lab=BLB16}
N 3160 3760 3140 3760 {}
C {lab_pin.sym} 3140 3760 0 0 {name=l3123 lab=WL19}
N 3240 3840 3260 3840 {}
C {lab_pin.sym} 3260 3840 0 0 {name=l3124 lab=VDD}
N 3240 3760 3260 3760 {}
C {lab_pin.sym} 3260 3760 0 0 {name=l3125 lab=VSS}
C {bitcell_6t.sym} 3400 3800 0 0 {name=Xr19c17}
N 3360 3840 3340 3840 {}
C {lab_pin.sym} 3340 3840 0 0 {name=l3126 lab=BL17}
N 3360 3800 3340 3800 {}
C {lab_pin.sym} 3340 3800 0 0 {name=l3127 lab=BLB17}
N 3360 3760 3340 3760 {}
C {lab_pin.sym} 3340 3760 0 0 {name=l3128 lab=WL19}
N 3440 3840 3460 3840 {}
C {lab_pin.sym} 3460 3840 0 0 {name=l3129 lab=VDD}
N 3440 3760 3460 3760 {}
C {lab_pin.sym} 3460 3760 0 0 {name=l3130 lab=VSS}
C {bitcell_6t.sym} 3600 3800 0 0 {name=Xr19c18}
N 3560 3840 3540 3840 {}
C {lab_pin.sym} 3540 3840 0 0 {name=l3131 lab=BL18}
N 3560 3800 3540 3800 {}
C {lab_pin.sym} 3540 3800 0 0 {name=l3132 lab=BLB18}
N 3560 3760 3540 3760 {}
C {lab_pin.sym} 3540 3760 0 0 {name=l3133 lab=WL19}
N 3640 3840 3660 3840 {}
C {lab_pin.sym} 3660 3840 0 0 {name=l3134 lab=VDD}
N 3640 3760 3660 3760 {}
C {lab_pin.sym} 3660 3760 0 0 {name=l3135 lab=VSS}
C {bitcell_6t.sym} 3800 3800 0 0 {name=Xr19c19}
N 3760 3840 3740 3840 {}
C {lab_pin.sym} 3740 3840 0 0 {name=l3136 lab=BL19}
N 3760 3800 3740 3800 {}
C {lab_pin.sym} 3740 3800 0 0 {name=l3137 lab=BLB19}
N 3760 3760 3740 3760 {}
C {lab_pin.sym} 3740 3760 0 0 {name=l3138 lab=WL19}
N 3840 3840 3860 3840 {}
C {lab_pin.sym} 3860 3840 0 0 {name=l3139 lab=VDD}
N 3840 3760 3860 3760 {}
C {lab_pin.sym} 3860 3760 0 0 {name=l3140 lab=VSS}
C {bitcell_6t.sym} 4000 3800 0 0 {name=Xr19c20}
N 3960 3840 3940 3840 {}
C {lab_pin.sym} 3940 3840 0 0 {name=l3141 lab=BL20}
N 3960 3800 3940 3800 {}
C {lab_pin.sym} 3940 3800 0 0 {name=l3142 lab=BLB20}
N 3960 3760 3940 3760 {}
C {lab_pin.sym} 3940 3760 0 0 {name=l3143 lab=WL19}
N 4040 3840 4060 3840 {}
C {lab_pin.sym} 4060 3840 0 0 {name=l3144 lab=VDD}
N 4040 3760 4060 3760 {}
C {lab_pin.sym} 4060 3760 0 0 {name=l3145 lab=VSS}
C {bitcell_6t.sym} 4200 3800 0 0 {name=Xr19c21}
N 4160 3840 4140 3840 {}
C {lab_pin.sym} 4140 3840 0 0 {name=l3146 lab=BL21}
N 4160 3800 4140 3800 {}
C {lab_pin.sym} 4140 3800 0 0 {name=l3147 lab=BLB21}
N 4160 3760 4140 3760 {}
C {lab_pin.sym} 4140 3760 0 0 {name=l3148 lab=WL19}
N 4240 3840 4260 3840 {}
C {lab_pin.sym} 4260 3840 0 0 {name=l3149 lab=VDD}
N 4240 3760 4260 3760 {}
C {lab_pin.sym} 4260 3760 0 0 {name=l3150 lab=VSS}
C {bitcell_6t.sym} 4400 3800 0 0 {name=Xr19c22}
N 4360 3840 4340 3840 {}
C {lab_pin.sym} 4340 3840 0 0 {name=l3151 lab=BL22}
N 4360 3800 4340 3800 {}
C {lab_pin.sym} 4340 3800 0 0 {name=l3152 lab=BLB22}
N 4360 3760 4340 3760 {}
C {lab_pin.sym} 4340 3760 0 0 {name=l3153 lab=WL19}
N 4440 3840 4460 3840 {}
C {lab_pin.sym} 4460 3840 0 0 {name=l3154 lab=VDD}
N 4440 3760 4460 3760 {}
C {lab_pin.sym} 4460 3760 0 0 {name=l3155 lab=VSS}
C {bitcell_6t.sym} 4600 3800 0 0 {name=Xr19c23}
N 4560 3840 4540 3840 {}
C {lab_pin.sym} 4540 3840 0 0 {name=l3156 lab=BL23}
N 4560 3800 4540 3800 {}
C {lab_pin.sym} 4540 3800 0 0 {name=l3157 lab=BLB23}
N 4560 3760 4540 3760 {}
C {lab_pin.sym} 4540 3760 0 0 {name=l3158 lab=WL19}
N 4640 3840 4660 3840 {}
C {lab_pin.sym} 4660 3840 0 0 {name=l3159 lab=VDD}
N 4640 3760 4660 3760 {}
C {lab_pin.sym} 4660 3760 0 0 {name=l3160 lab=VSS}
C {bitcell_6t.sym} 4800 3800 0 0 {name=Xr19c24}
N 4760 3840 4740 3840 {}
C {lab_pin.sym} 4740 3840 0 0 {name=l3161 lab=BL24}
N 4760 3800 4740 3800 {}
C {lab_pin.sym} 4740 3800 0 0 {name=l3162 lab=BLB24}
N 4760 3760 4740 3760 {}
C {lab_pin.sym} 4740 3760 0 0 {name=l3163 lab=WL19}
N 4840 3840 4860 3840 {}
C {lab_pin.sym} 4860 3840 0 0 {name=l3164 lab=VDD}
N 4840 3760 4860 3760 {}
C {lab_pin.sym} 4860 3760 0 0 {name=l3165 lab=VSS}
C {bitcell_6t.sym} 5000 3800 0 0 {name=Xr19c25}
N 4960 3840 4940 3840 {}
C {lab_pin.sym} 4940 3840 0 0 {name=l3166 lab=BL25}
N 4960 3800 4940 3800 {}
C {lab_pin.sym} 4940 3800 0 0 {name=l3167 lab=BLB25}
N 4960 3760 4940 3760 {}
C {lab_pin.sym} 4940 3760 0 0 {name=l3168 lab=WL19}
N 5040 3840 5060 3840 {}
C {lab_pin.sym} 5060 3840 0 0 {name=l3169 lab=VDD}
N 5040 3760 5060 3760 {}
C {lab_pin.sym} 5060 3760 0 0 {name=l3170 lab=VSS}
C {bitcell_6t.sym} 5200 3800 0 0 {name=Xr19c26}
N 5160 3840 5140 3840 {}
C {lab_pin.sym} 5140 3840 0 0 {name=l3171 lab=BL26}
N 5160 3800 5140 3800 {}
C {lab_pin.sym} 5140 3800 0 0 {name=l3172 lab=BLB26}
N 5160 3760 5140 3760 {}
C {lab_pin.sym} 5140 3760 0 0 {name=l3173 lab=WL19}
N 5240 3840 5260 3840 {}
C {lab_pin.sym} 5260 3840 0 0 {name=l3174 lab=VDD}
N 5240 3760 5260 3760 {}
C {lab_pin.sym} 5260 3760 0 0 {name=l3175 lab=VSS}
C {bitcell_6t.sym} 5400 3800 0 0 {name=Xr19c27}
N 5360 3840 5340 3840 {}
C {lab_pin.sym} 5340 3840 0 0 {name=l3176 lab=BL27}
N 5360 3800 5340 3800 {}
C {lab_pin.sym} 5340 3800 0 0 {name=l3177 lab=BLB27}
N 5360 3760 5340 3760 {}
C {lab_pin.sym} 5340 3760 0 0 {name=l3178 lab=WL19}
N 5440 3840 5460 3840 {}
C {lab_pin.sym} 5460 3840 0 0 {name=l3179 lab=VDD}
N 5440 3760 5460 3760 {}
C {lab_pin.sym} 5460 3760 0 0 {name=l3180 lab=VSS}
C {bitcell_6t.sym} 5600 3800 0 0 {name=Xr19c28}
N 5560 3840 5540 3840 {}
C {lab_pin.sym} 5540 3840 0 0 {name=l3181 lab=BL28}
N 5560 3800 5540 3800 {}
C {lab_pin.sym} 5540 3800 0 0 {name=l3182 lab=BLB28}
N 5560 3760 5540 3760 {}
C {lab_pin.sym} 5540 3760 0 0 {name=l3183 lab=WL19}
N 5640 3840 5660 3840 {}
C {lab_pin.sym} 5660 3840 0 0 {name=l3184 lab=VDD}
N 5640 3760 5660 3760 {}
C {lab_pin.sym} 5660 3760 0 0 {name=l3185 lab=VSS}
C {bitcell_6t.sym} 5800 3800 0 0 {name=Xr19c29}
N 5760 3840 5740 3840 {}
C {lab_pin.sym} 5740 3840 0 0 {name=l3186 lab=BL29}
N 5760 3800 5740 3800 {}
C {lab_pin.sym} 5740 3800 0 0 {name=l3187 lab=BLB29}
N 5760 3760 5740 3760 {}
C {lab_pin.sym} 5740 3760 0 0 {name=l3188 lab=WL19}
N 5840 3840 5860 3840 {}
C {lab_pin.sym} 5860 3840 0 0 {name=l3189 lab=VDD}
N 5840 3760 5860 3760 {}
C {lab_pin.sym} 5860 3760 0 0 {name=l3190 lab=VSS}
C {bitcell_6t.sym} 6000 3800 0 0 {name=Xr19c30}
N 5960 3840 5940 3840 {}
C {lab_pin.sym} 5940 3840 0 0 {name=l3191 lab=BL30}
N 5960 3800 5940 3800 {}
C {lab_pin.sym} 5940 3800 0 0 {name=l3192 lab=BLB30}
N 5960 3760 5940 3760 {}
C {lab_pin.sym} 5940 3760 0 0 {name=l3193 lab=WL19}
N 6040 3840 6060 3840 {}
C {lab_pin.sym} 6060 3840 0 0 {name=l3194 lab=VDD}
N 6040 3760 6060 3760 {}
C {lab_pin.sym} 6060 3760 0 0 {name=l3195 lab=VSS}
C {bitcell_6t.sym} 6200 3800 0 0 {name=Xr19c31}
N 6160 3840 6140 3840 {}
C {lab_pin.sym} 6140 3840 0 0 {name=l3196 lab=BL31}
N 6160 3800 6140 3800 {}
C {lab_pin.sym} 6140 3800 0 0 {name=l3197 lab=BLB31}
N 6160 3760 6140 3760 {}
C {lab_pin.sym} 6140 3760 0 0 {name=l3198 lab=WL19}
N 6240 3840 6260 3840 {}
C {lab_pin.sym} 6260 3840 0 0 {name=l3199 lab=VDD}
N 6240 3760 6260 3760 {}
C {lab_pin.sym} 6260 3760 0 0 {name=l3200 lab=VSS}
C {bitcell_6t.sym} 0 4000 0 0 {name=Xr20c0}
N -40 4040 -60 4040 {}
C {lab_pin.sym} -60 4040 0 0 {name=l3201 lab=BL0}
N -40 4000 -60 4000 {}
C {lab_pin.sym} -60 4000 0 0 {name=l3202 lab=BLB0}
N -40 3960 -60 3960 {}
C {lab_pin.sym} -60 3960 0 0 {name=l3203 lab=WL20}
N 40 4040 60 4040 {}
C {lab_pin.sym} 60 4040 0 0 {name=l3204 lab=VDD}
N 40 3960 60 3960 {}
C {lab_pin.sym} 60 3960 0 0 {name=l3205 lab=VSS}
C {bitcell_6t.sym} 200 4000 0 0 {name=Xr20c1}
N 160 4040 140 4040 {}
C {lab_pin.sym} 140 4040 0 0 {name=l3206 lab=BL1}
N 160 4000 140 4000 {}
C {lab_pin.sym} 140 4000 0 0 {name=l3207 lab=BLB1}
N 160 3960 140 3960 {}
C {lab_pin.sym} 140 3960 0 0 {name=l3208 lab=WL20}
N 240 4040 260 4040 {}
C {lab_pin.sym} 260 4040 0 0 {name=l3209 lab=VDD}
N 240 3960 260 3960 {}
C {lab_pin.sym} 260 3960 0 0 {name=l3210 lab=VSS}
C {bitcell_6t.sym} 400 4000 0 0 {name=Xr20c2}
N 360 4040 340 4040 {}
C {lab_pin.sym} 340 4040 0 0 {name=l3211 lab=BL2}
N 360 4000 340 4000 {}
C {lab_pin.sym} 340 4000 0 0 {name=l3212 lab=BLB2}
N 360 3960 340 3960 {}
C {lab_pin.sym} 340 3960 0 0 {name=l3213 lab=WL20}
N 440 4040 460 4040 {}
C {lab_pin.sym} 460 4040 0 0 {name=l3214 lab=VDD}
N 440 3960 460 3960 {}
C {lab_pin.sym} 460 3960 0 0 {name=l3215 lab=VSS}
C {bitcell_6t.sym} 600 4000 0 0 {name=Xr20c3}
N 560 4040 540 4040 {}
C {lab_pin.sym} 540 4040 0 0 {name=l3216 lab=BL3}
N 560 4000 540 4000 {}
C {lab_pin.sym} 540 4000 0 0 {name=l3217 lab=BLB3}
N 560 3960 540 3960 {}
C {lab_pin.sym} 540 3960 0 0 {name=l3218 lab=WL20}
N 640 4040 660 4040 {}
C {lab_pin.sym} 660 4040 0 0 {name=l3219 lab=VDD}
N 640 3960 660 3960 {}
C {lab_pin.sym} 660 3960 0 0 {name=l3220 lab=VSS}
C {bitcell_6t.sym} 800 4000 0 0 {name=Xr20c4}
N 760 4040 740 4040 {}
C {lab_pin.sym} 740 4040 0 0 {name=l3221 lab=BL4}
N 760 4000 740 4000 {}
C {lab_pin.sym} 740 4000 0 0 {name=l3222 lab=BLB4}
N 760 3960 740 3960 {}
C {lab_pin.sym} 740 3960 0 0 {name=l3223 lab=WL20}
N 840 4040 860 4040 {}
C {lab_pin.sym} 860 4040 0 0 {name=l3224 lab=VDD}
N 840 3960 860 3960 {}
C {lab_pin.sym} 860 3960 0 0 {name=l3225 lab=VSS}
C {bitcell_6t.sym} 1000 4000 0 0 {name=Xr20c5}
N 960 4040 940 4040 {}
C {lab_pin.sym} 940 4040 0 0 {name=l3226 lab=BL5}
N 960 4000 940 4000 {}
C {lab_pin.sym} 940 4000 0 0 {name=l3227 lab=BLB5}
N 960 3960 940 3960 {}
C {lab_pin.sym} 940 3960 0 0 {name=l3228 lab=WL20}
N 1040 4040 1060 4040 {}
C {lab_pin.sym} 1060 4040 0 0 {name=l3229 lab=VDD}
N 1040 3960 1060 3960 {}
C {lab_pin.sym} 1060 3960 0 0 {name=l3230 lab=VSS}
C {bitcell_6t.sym} 1200 4000 0 0 {name=Xr20c6}
N 1160 4040 1140 4040 {}
C {lab_pin.sym} 1140 4040 0 0 {name=l3231 lab=BL6}
N 1160 4000 1140 4000 {}
C {lab_pin.sym} 1140 4000 0 0 {name=l3232 lab=BLB6}
N 1160 3960 1140 3960 {}
C {lab_pin.sym} 1140 3960 0 0 {name=l3233 lab=WL20}
N 1240 4040 1260 4040 {}
C {lab_pin.sym} 1260 4040 0 0 {name=l3234 lab=VDD}
N 1240 3960 1260 3960 {}
C {lab_pin.sym} 1260 3960 0 0 {name=l3235 lab=VSS}
C {bitcell_6t.sym} 1400 4000 0 0 {name=Xr20c7}
N 1360 4040 1340 4040 {}
C {lab_pin.sym} 1340 4040 0 0 {name=l3236 lab=BL7}
N 1360 4000 1340 4000 {}
C {lab_pin.sym} 1340 4000 0 0 {name=l3237 lab=BLB7}
N 1360 3960 1340 3960 {}
C {lab_pin.sym} 1340 3960 0 0 {name=l3238 lab=WL20}
N 1440 4040 1460 4040 {}
C {lab_pin.sym} 1460 4040 0 0 {name=l3239 lab=VDD}
N 1440 3960 1460 3960 {}
C {lab_pin.sym} 1460 3960 0 0 {name=l3240 lab=VSS}
C {bitcell_6t.sym} 1600 4000 0 0 {name=Xr20c8}
N 1560 4040 1540 4040 {}
C {lab_pin.sym} 1540 4040 0 0 {name=l3241 lab=BL8}
N 1560 4000 1540 4000 {}
C {lab_pin.sym} 1540 4000 0 0 {name=l3242 lab=BLB8}
N 1560 3960 1540 3960 {}
C {lab_pin.sym} 1540 3960 0 0 {name=l3243 lab=WL20}
N 1640 4040 1660 4040 {}
C {lab_pin.sym} 1660 4040 0 0 {name=l3244 lab=VDD}
N 1640 3960 1660 3960 {}
C {lab_pin.sym} 1660 3960 0 0 {name=l3245 lab=VSS}
C {bitcell_6t.sym} 1800 4000 0 0 {name=Xr20c9}
N 1760 4040 1740 4040 {}
C {lab_pin.sym} 1740 4040 0 0 {name=l3246 lab=BL9}
N 1760 4000 1740 4000 {}
C {lab_pin.sym} 1740 4000 0 0 {name=l3247 lab=BLB9}
N 1760 3960 1740 3960 {}
C {lab_pin.sym} 1740 3960 0 0 {name=l3248 lab=WL20}
N 1840 4040 1860 4040 {}
C {lab_pin.sym} 1860 4040 0 0 {name=l3249 lab=VDD}
N 1840 3960 1860 3960 {}
C {lab_pin.sym} 1860 3960 0 0 {name=l3250 lab=VSS}
C {bitcell_6t.sym} 2000 4000 0 0 {name=Xr20c10}
N 1960 4040 1940 4040 {}
C {lab_pin.sym} 1940 4040 0 0 {name=l3251 lab=BL10}
N 1960 4000 1940 4000 {}
C {lab_pin.sym} 1940 4000 0 0 {name=l3252 lab=BLB10}
N 1960 3960 1940 3960 {}
C {lab_pin.sym} 1940 3960 0 0 {name=l3253 lab=WL20}
N 2040 4040 2060 4040 {}
C {lab_pin.sym} 2060 4040 0 0 {name=l3254 lab=VDD}
N 2040 3960 2060 3960 {}
C {lab_pin.sym} 2060 3960 0 0 {name=l3255 lab=VSS}
C {bitcell_6t.sym} 2200 4000 0 0 {name=Xr20c11}
N 2160 4040 2140 4040 {}
C {lab_pin.sym} 2140 4040 0 0 {name=l3256 lab=BL11}
N 2160 4000 2140 4000 {}
C {lab_pin.sym} 2140 4000 0 0 {name=l3257 lab=BLB11}
N 2160 3960 2140 3960 {}
C {lab_pin.sym} 2140 3960 0 0 {name=l3258 lab=WL20}
N 2240 4040 2260 4040 {}
C {lab_pin.sym} 2260 4040 0 0 {name=l3259 lab=VDD}
N 2240 3960 2260 3960 {}
C {lab_pin.sym} 2260 3960 0 0 {name=l3260 lab=VSS}
C {bitcell_6t.sym} 2400 4000 0 0 {name=Xr20c12}
N 2360 4040 2340 4040 {}
C {lab_pin.sym} 2340 4040 0 0 {name=l3261 lab=BL12}
N 2360 4000 2340 4000 {}
C {lab_pin.sym} 2340 4000 0 0 {name=l3262 lab=BLB12}
N 2360 3960 2340 3960 {}
C {lab_pin.sym} 2340 3960 0 0 {name=l3263 lab=WL20}
N 2440 4040 2460 4040 {}
C {lab_pin.sym} 2460 4040 0 0 {name=l3264 lab=VDD}
N 2440 3960 2460 3960 {}
C {lab_pin.sym} 2460 3960 0 0 {name=l3265 lab=VSS}
C {bitcell_6t.sym} 2600 4000 0 0 {name=Xr20c13}
N 2560 4040 2540 4040 {}
C {lab_pin.sym} 2540 4040 0 0 {name=l3266 lab=BL13}
N 2560 4000 2540 4000 {}
C {lab_pin.sym} 2540 4000 0 0 {name=l3267 lab=BLB13}
N 2560 3960 2540 3960 {}
C {lab_pin.sym} 2540 3960 0 0 {name=l3268 lab=WL20}
N 2640 4040 2660 4040 {}
C {lab_pin.sym} 2660 4040 0 0 {name=l3269 lab=VDD}
N 2640 3960 2660 3960 {}
C {lab_pin.sym} 2660 3960 0 0 {name=l3270 lab=VSS}
C {bitcell_6t.sym} 2800 4000 0 0 {name=Xr20c14}
N 2760 4040 2740 4040 {}
C {lab_pin.sym} 2740 4040 0 0 {name=l3271 lab=BL14}
N 2760 4000 2740 4000 {}
C {lab_pin.sym} 2740 4000 0 0 {name=l3272 lab=BLB14}
N 2760 3960 2740 3960 {}
C {lab_pin.sym} 2740 3960 0 0 {name=l3273 lab=WL20}
N 2840 4040 2860 4040 {}
C {lab_pin.sym} 2860 4040 0 0 {name=l3274 lab=VDD}
N 2840 3960 2860 3960 {}
C {lab_pin.sym} 2860 3960 0 0 {name=l3275 lab=VSS}
C {bitcell_6t.sym} 3000 4000 0 0 {name=Xr20c15}
N 2960 4040 2940 4040 {}
C {lab_pin.sym} 2940 4040 0 0 {name=l3276 lab=BL15}
N 2960 4000 2940 4000 {}
C {lab_pin.sym} 2940 4000 0 0 {name=l3277 lab=BLB15}
N 2960 3960 2940 3960 {}
C {lab_pin.sym} 2940 3960 0 0 {name=l3278 lab=WL20}
N 3040 4040 3060 4040 {}
C {lab_pin.sym} 3060 4040 0 0 {name=l3279 lab=VDD}
N 3040 3960 3060 3960 {}
C {lab_pin.sym} 3060 3960 0 0 {name=l3280 lab=VSS}
C {bitcell_6t.sym} 3200 4000 0 0 {name=Xr20c16}
N 3160 4040 3140 4040 {}
C {lab_pin.sym} 3140 4040 0 0 {name=l3281 lab=BL16}
N 3160 4000 3140 4000 {}
C {lab_pin.sym} 3140 4000 0 0 {name=l3282 lab=BLB16}
N 3160 3960 3140 3960 {}
C {lab_pin.sym} 3140 3960 0 0 {name=l3283 lab=WL20}
N 3240 4040 3260 4040 {}
C {lab_pin.sym} 3260 4040 0 0 {name=l3284 lab=VDD}
N 3240 3960 3260 3960 {}
C {lab_pin.sym} 3260 3960 0 0 {name=l3285 lab=VSS}
C {bitcell_6t.sym} 3400 4000 0 0 {name=Xr20c17}
N 3360 4040 3340 4040 {}
C {lab_pin.sym} 3340 4040 0 0 {name=l3286 lab=BL17}
N 3360 4000 3340 4000 {}
C {lab_pin.sym} 3340 4000 0 0 {name=l3287 lab=BLB17}
N 3360 3960 3340 3960 {}
C {lab_pin.sym} 3340 3960 0 0 {name=l3288 lab=WL20}
N 3440 4040 3460 4040 {}
C {lab_pin.sym} 3460 4040 0 0 {name=l3289 lab=VDD}
N 3440 3960 3460 3960 {}
C {lab_pin.sym} 3460 3960 0 0 {name=l3290 lab=VSS}
C {bitcell_6t.sym} 3600 4000 0 0 {name=Xr20c18}
N 3560 4040 3540 4040 {}
C {lab_pin.sym} 3540 4040 0 0 {name=l3291 lab=BL18}
N 3560 4000 3540 4000 {}
C {lab_pin.sym} 3540 4000 0 0 {name=l3292 lab=BLB18}
N 3560 3960 3540 3960 {}
C {lab_pin.sym} 3540 3960 0 0 {name=l3293 lab=WL20}
N 3640 4040 3660 4040 {}
C {lab_pin.sym} 3660 4040 0 0 {name=l3294 lab=VDD}
N 3640 3960 3660 3960 {}
C {lab_pin.sym} 3660 3960 0 0 {name=l3295 lab=VSS}
C {bitcell_6t.sym} 3800 4000 0 0 {name=Xr20c19}
N 3760 4040 3740 4040 {}
C {lab_pin.sym} 3740 4040 0 0 {name=l3296 lab=BL19}
N 3760 4000 3740 4000 {}
C {lab_pin.sym} 3740 4000 0 0 {name=l3297 lab=BLB19}
N 3760 3960 3740 3960 {}
C {lab_pin.sym} 3740 3960 0 0 {name=l3298 lab=WL20}
N 3840 4040 3860 4040 {}
C {lab_pin.sym} 3860 4040 0 0 {name=l3299 lab=VDD}
N 3840 3960 3860 3960 {}
C {lab_pin.sym} 3860 3960 0 0 {name=l3300 lab=VSS}
C {bitcell_6t.sym} 4000 4000 0 0 {name=Xr20c20}
N 3960 4040 3940 4040 {}
C {lab_pin.sym} 3940 4040 0 0 {name=l3301 lab=BL20}
N 3960 4000 3940 4000 {}
C {lab_pin.sym} 3940 4000 0 0 {name=l3302 lab=BLB20}
N 3960 3960 3940 3960 {}
C {lab_pin.sym} 3940 3960 0 0 {name=l3303 lab=WL20}
N 4040 4040 4060 4040 {}
C {lab_pin.sym} 4060 4040 0 0 {name=l3304 lab=VDD}
N 4040 3960 4060 3960 {}
C {lab_pin.sym} 4060 3960 0 0 {name=l3305 lab=VSS}
C {bitcell_6t.sym} 4200 4000 0 0 {name=Xr20c21}
N 4160 4040 4140 4040 {}
C {lab_pin.sym} 4140 4040 0 0 {name=l3306 lab=BL21}
N 4160 4000 4140 4000 {}
C {lab_pin.sym} 4140 4000 0 0 {name=l3307 lab=BLB21}
N 4160 3960 4140 3960 {}
C {lab_pin.sym} 4140 3960 0 0 {name=l3308 lab=WL20}
N 4240 4040 4260 4040 {}
C {lab_pin.sym} 4260 4040 0 0 {name=l3309 lab=VDD}
N 4240 3960 4260 3960 {}
C {lab_pin.sym} 4260 3960 0 0 {name=l3310 lab=VSS}
C {bitcell_6t.sym} 4400 4000 0 0 {name=Xr20c22}
N 4360 4040 4340 4040 {}
C {lab_pin.sym} 4340 4040 0 0 {name=l3311 lab=BL22}
N 4360 4000 4340 4000 {}
C {lab_pin.sym} 4340 4000 0 0 {name=l3312 lab=BLB22}
N 4360 3960 4340 3960 {}
C {lab_pin.sym} 4340 3960 0 0 {name=l3313 lab=WL20}
N 4440 4040 4460 4040 {}
C {lab_pin.sym} 4460 4040 0 0 {name=l3314 lab=VDD}
N 4440 3960 4460 3960 {}
C {lab_pin.sym} 4460 3960 0 0 {name=l3315 lab=VSS}
C {bitcell_6t.sym} 4600 4000 0 0 {name=Xr20c23}
N 4560 4040 4540 4040 {}
C {lab_pin.sym} 4540 4040 0 0 {name=l3316 lab=BL23}
N 4560 4000 4540 4000 {}
C {lab_pin.sym} 4540 4000 0 0 {name=l3317 lab=BLB23}
N 4560 3960 4540 3960 {}
C {lab_pin.sym} 4540 3960 0 0 {name=l3318 lab=WL20}
N 4640 4040 4660 4040 {}
C {lab_pin.sym} 4660 4040 0 0 {name=l3319 lab=VDD}
N 4640 3960 4660 3960 {}
C {lab_pin.sym} 4660 3960 0 0 {name=l3320 lab=VSS}
C {bitcell_6t.sym} 4800 4000 0 0 {name=Xr20c24}
N 4760 4040 4740 4040 {}
C {lab_pin.sym} 4740 4040 0 0 {name=l3321 lab=BL24}
N 4760 4000 4740 4000 {}
C {lab_pin.sym} 4740 4000 0 0 {name=l3322 lab=BLB24}
N 4760 3960 4740 3960 {}
C {lab_pin.sym} 4740 3960 0 0 {name=l3323 lab=WL20}
N 4840 4040 4860 4040 {}
C {lab_pin.sym} 4860 4040 0 0 {name=l3324 lab=VDD}
N 4840 3960 4860 3960 {}
C {lab_pin.sym} 4860 3960 0 0 {name=l3325 lab=VSS}
C {bitcell_6t.sym} 5000 4000 0 0 {name=Xr20c25}
N 4960 4040 4940 4040 {}
C {lab_pin.sym} 4940 4040 0 0 {name=l3326 lab=BL25}
N 4960 4000 4940 4000 {}
C {lab_pin.sym} 4940 4000 0 0 {name=l3327 lab=BLB25}
N 4960 3960 4940 3960 {}
C {lab_pin.sym} 4940 3960 0 0 {name=l3328 lab=WL20}
N 5040 4040 5060 4040 {}
C {lab_pin.sym} 5060 4040 0 0 {name=l3329 lab=VDD}
N 5040 3960 5060 3960 {}
C {lab_pin.sym} 5060 3960 0 0 {name=l3330 lab=VSS}
C {bitcell_6t.sym} 5200 4000 0 0 {name=Xr20c26}
N 5160 4040 5140 4040 {}
C {lab_pin.sym} 5140 4040 0 0 {name=l3331 lab=BL26}
N 5160 4000 5140 4000 {}
C {lab_pin.sym} 5140 4000 0 0 {name=l3332 lab=BLB26}
N 5160 3960 5140 3960 {}
C {lab_pin.sym} 5140 3960 0 0 {name=l3333 lab=WL20}
N 5240 4040 5260 4040 {}
C {lab_pin.sym} 5260 4040 0 0 {name=l3334 lab=VDD}
N 5240 3960 5260 3960 {}
C {lab_pin.sym} 5260 3960 0 0 {name=l3335 lab=VSS}
C {bitcell_6t.sym} 5400 4000 0 0 {name=Xr20c27}
N 5360 4040 5340 4040 {}
C {lab_pin.sym} 5340 4040 0 0 {name=l3336 lab=BL27}
N 5360 4000 5340 4000 {}
C {lab_pin.sym} 5340 4000 0 0 {name=l3337 lab=BLB27}
N 5360 3960 5340 3960 {}
C {lab_pin.sym} 5340 3960 0 0 {name=l3338 lab=WL20}
N 5440 4040 5460 4040 {}
C {lab_pin.sym} 5460 4040 0 0 {name=l3339 lab=VDD}
N 5440 3960 5460 3960 {}
C {lab_pin.sym} 5460 3960 0 0 {name=l3340 lab=VSS}
C {bitcell_6t.sym} 5600 4000 0 0 {name=Xr20c28}
N 5560 4040 5540 4040 {}
C {lab_pin.sym} 5540 4040 0 0 {name=l3341 lab=BL28}
N 5560 4000 5540 4000 {}
C {lab_pin.sym} 5540 4000 0 0 {name=l3342 lab=BLB28}
N 5560 3960 5540 3960 {}
C {lab_pin.sym} 5540 3960 0 0 {name=l3343 lab=WL20}
N 5640 4040 5660 4040 {}
C {lab_pin.sym} 5660 4040 0 0 {name=l3344 lab=VDD}
N 5640 3960 5660 3960 {}
C {lab_pin.sym} 5660 3960 0 0 {name=l3345 lab=VSS}
C {bitcell_6t.sym} 5800 4000 0 0 {name=Xr20c29}
N 5760 4040 5740 4040 {}
C {lab_pin.sym} 5740 4040 0 0 {name=l3346 lab=BL29}
N 5760 4000 5740 4000 {}
C {lab_pin.sym} 5740 4000 0 0 {name=l3347 lab=BLB29}
N 5760 3960 5740 3960 {}
C {lab_pin.sym} 5740 3960 0 0 {name=l3348 lab=WL20}
N 5840 4040 5860 4040 {}
C {lab_pin.sym} 5860 4040 0 0 {name=l3349 lab=VDD}
N 5840 3960 5860 3960 {}
C {lab_pin.sym} 5860 3960 0 0 {name=l3350 lab=VSS}
C {bitcell_6t.sym} 6000 4000 0 0 {name=Xr20c30}
N 5960 4040 5940 4040 {}
C {lab_pin.sym} 5940 4040 0 0 {name=l3351 lab=BL30}
N 5960 4000 5940 4000 {}
C {lab_pin.sym} 5940 4000 0 0 {name=l3352 lab=BLB30}
N 5960 3960 5940 3960 {}
C {lab_pin.sym} 5940 3960 0 0 {name=l3353 lab=WL20}
N 6040 4040 6060 4040 {}
C {lab_pin.sym} 6060 4040 0 0 {name=l3354 lab=VDD}
N 6040 3960 6060 3960 {}
C {lab_pin.sym} 6060 3960 0 0 {name=l3355 lab=VSS}
C {bitcell_6t.sym} 6200 4000 0 0 {name=Xr20c31}
N 6160 4040 6140 4040 {}
C {lab_pin.sym} 6140 4040 0 0 {name=l3356 lab=BL31}
N 6160 4000 6140 4000 {}
C {lab_pin.sym} 6140 4000 0 0 {name=l3357 lab=BLB31}
N 6160 3960 6140 3960 {}
C {lab_pin.sym} 6140 3960 0 0 {name=l3358 lab=WL20}
N 6240 4040 6260 4040 {}
C {lab_pin.sym} 6260 4040 0 0 {name=l3359 lab=VDD}
N 6240 3960 6260 3960 {}
C {lab_pin.sym} 6260 3960 0 0 {name=l3360 lab=VSS}
C {bitcell_6t.sym} 0 4200 0 0 {name=Xr21c0}
N -40 4240 -60 4240 {}
C {lab_pin.sym} -60 4240 0 0 {name=l3361 lab=BL0}
N -40 4200 -60 4200 {}
C {lab_pin.sym} -60 4200 0 0 {name=l3362 lab=BLB0}
N -40 4160 -60 4160 {}
C {lab_pin.sym} -60 4160 0 0 {name=l3363 lab=WL21}
N 40 4240 60 4240 {}
C {lab_pin.sym} 60 4240 0 0 {name=l3364 lab=VDD}
N 40 4160 60 4160 {}
C {lab_pin.sym} 60 4160 0 0 {name=l3365 lab=VSS}
C {bitcell_6t.sym} 200 4200 0 0 {name=Xr21c1}
N 160 4240 140 4240 {}
C {lab_pin.sym} 140 4240 0 0 {name=l3366 lab=BL1}
N 160 4200 140 4200 {}
C {lab_pin.sym} 140 4200 0 0 {name=l3367 lab=BLB1}
N 160 4160 140 4160 {}
C {lab_pin.sym} 140 4160 0 0 {name=l3368 lab=WL21}
N 240 4240 260 4240 {}
C {lab_pin.sym} 260 4240 0 0 {name=l3369 lab=VDD}
N 240 4160 260 4160 {}
C {lab_pin.sym} 260 4160 0 0 {name=l3370 lab=VSS}
C {bitcell_6t.sym} 400 4200 0 0 {name=Xr21c2}
N 360 4240 340 4240 {}
C {lab_pin.sym} 340 4240 0 0 {name=l3371 lab=BL2}
N 360 4200 340 4200 {}
C {lab_pin.sym} 340 4200 0 0 {name=l3372 lab=BLB2}
N 360 4160 340 4160 {}
C {lab_pin.sym} 340 4160 0 0 {name=l3373 lab=WL21}
N 440 4240 460 4240 {}
C {lab_pin.sym} 460 4240 0 0 {name=l3374 lab=VDD}
N 440 4160 460 4160 {}
C {lab_pin.sym} 460 4160 0 0 {name=l3375 lab=VSS}
C {bitcell_6t.sym} 600 4200 0 0 {name=Xr21c3}
N 560 4240 540 4240 {}
C {lab_pin.sym} 540 4240 0 0 {name=l3376 lab=BL3}
N 560 4200 540 4200 {}
C {lab_pin.sym} 540 4200 0 0 {name=l3377 lab=BLB3}
N 560 4160 540 4160 {}
C {lab_pin.sym} 540 4160 0 0 {name=l3378 lab=WL21}
N 640 4240 660 4240 {}
C {lab_pin.sym} 660 4240 0 0 {name=l3379 lab=VDD}
N 640 4160 660 4160 {}
C {lab_pin.sym} 660 4160 0 0 {name=l3380 lab=VSS}
C {bitcell_6t.sym} 800 4200 0 0 {name=Xr21c4}
N 760 4240 740 4240 {}
C {lab_pin.sym} 740 4240 0 0 {name=l3381 lab=BL4}
N 760 4200 740 4200 {}
C {lab_pin.sym} 740 4200 0 0 {name=l3382 lab=BLB4}
N 760 4160 740 4160 {}
C {lab_pin.sym} 740 4160 0 0 {name=l3383 lab=WL21}
N 840 4240 860 4240 {}
C {lab_pin.sym} 860 4240 0 0 {name=l3384 lab=VDD}
N 840 4160 860 4160 {}
C {lab_pin.sym} 860 4160 0 0 {name=l3385 lab=VSS}
C {bitcell_6t.sym} 1000 4200 0 0 {name=Xr21c5}
N 960 4240 940 4240 {}
C {lab_pin.sym} 940 4240 0 0 {name=l3386 lab=BL5}
N 960 4200 940 4200 {}
C {lab_pin.sym} 940 4200 0 0 {name=l3387 lab=BLB5}
N 960 4160 940 4160 {}
C {lab_pin.sym} 940 4160 0 0 {name=l3388 lab=WL21}
N 1040 4240 1060 4240 {}
C {lab_pin.sym} 1060 4240 0 0 {name=l3389 lab=VDD}
N 1040 4160 1060 4160 {}
C {lab_pin.sym} 1060 4160 0 0 {name=l3390 lab=VSS}
C {bitcell_6t.sym} 1200 4200 0 0 {name=Xr21c6}
N 1160 4240 1140 4240 {}
C {lab_pin.sym} 1140 4240 0 0 {name=l3391 lab=BL6}
N 1160 4200 1140 4200 {}
C {lab_pin.sym} 1140 4200 0 0 {name=l3392 lab=BLB6}
N 1160 4160 1140 4160 {}
C {lab_pin.sym} 1140 4160 0 0 {name=l3393 lab=WL21}
N 1240 4240 1260 4240 {}
C {lab_pin.sym} 1260 4240 0 0 {name=l3394 lab=VDD}
N 1240 4160 1260 4160 {}
C {lab_pin.sym} 1260 4160 0 0 {name=l3395 lab=VSS}
C {bitcell_6t.sym} 1400 4200 0 0 {name=Xr21c7}
N 1360 4240 1340 4240 {}
C {lab_pin.sym} 1340 4240 0 0 {name=l3396 lab=BL7}
N 1360 4200 1340 4200 {}
C {lab_pin.sym} 1340 4200 0 0 {name=l3397 lab=BLB7}
N 1360 4160 1340 4160 {}
C {lab_pin.sym} 1340 4160 0 0 {name=l3398 lab=WL21}
N 1440 4240 1460 4240 {}
C {lab_pin.sym} 1460 4240 0 0 {name=l3399 lab=VDD}
N 1440 4160 1460 4160 {}
C {lab_pin.sym} 1460 4160 0 0 {name=l3400 lab=VSS}
C {bitcell_6t.sym} 1600 4200 0 0 {name=Xr21c8}
N 1560 4240 1540 4240 {}
C {lab_pin.sym} 1540 4240 0 0 {name=l3401 lab=BL8}
N 1560 4200 1540 4200 {}
C {lab_pin.sym} 1540 4200 0 0 {name=l3402 lab=BLB8}
N 1560 4160 1540 4160 {}
C {lab_pin.sym} 1540 4160 0 0 {name=l3403 lab=WL21}
N 1640 4240 1660 4240 {}
C {lab_pin.sym} 1660 4240 0 0 {name=l3404 lab=VDD}
N 1640 4160 1660 4160 {}
C {lab_pin.sym} 1660 4160 0 0 {name=l3405 lab=VSS}
C {bitcell_6t.sym} 1800 4200 0 0 {name=Xr21c9}
N 1760 4240 1740 4240 {}
C {lab_pin.sym} 1740 4240 0 0 {name=l3406 lab=BL9}
N 1760 4200 1740 4200 {}
C {lab_pin.sym} 1740 4200 0 0 {name=l3407 lab=BLB9}
N 1760 4160 1740 4160 {}
C {lab_pin.sym} 1740 4160 0 0 {name=l3408 lab=WL21}
N 1840 4240 1860 4240 {}
C {lab_pin.sym} 1860 4240 0 0 {name=l3409 lab=VDD}
N 1840 4160 1860 4160 {}
C {lab_pin.sym} 1860 4160 0 0 {name=l3410 lab=VSS}
C {bitcell_6t.sym} 2000 4200 0 0 {name=Xr21c10}
N 1960 4240 1940 4240 {}
C {lab_pin.sym} 1940 4240 0 0 {name=l3411 lab=BL10}
N 1960 4200 1940 4200 {}
C {lab_pin.sym} 1940 4200 0 0 {name=l3412 lab=BLB10}
N 1960 4160 1940 4160 {}
C {lab_pin.sym} 1940 4160 0 0 {name=l3413 lab=WL21}
N 2040 4240 2060 4240 {}
C {lab_pin.sym} 2060 4240 0 0 {name=l3414 lab=VDD}
N 2040 4160 2060 4160 {}
C {lab_pin.sym} 2060 4160 0 0 {name=l3415 lab=VSS}
C {bitcell_6t.sym} 2200 4200 0 0 {name=Xr21c11}
N 2160 4240 2140 4240 {}
C {lab_pin.sym} 2140 4240 0 0 {name=l3416 lab=BL11}
N 2160 4200 2140 4200 {}
C {lab_pin.sym} 2140 4200 0 0 {name=l3417 lab=BLB11}
N 2160 4160 2140 4160 {}
C {lab_pin.sym} 2140 4160 0 0 {name=l3418 lab=WL21}
N 2240 4240 2260 4240 {}
C {lab_pin.sym} 2260 4240 0 0 {name=l3419 lab=VDD}
N 2240 4160 2260 4160 {}
C {lab_pin.sym} 2260 4160 0 0 {name=l3420 lab=VSS}
C {bitcell_6t.sym} 2400 4200 0 0 {name=Xr21c12}
N 2360 4240 2340 4240 {}
C {lab_pin.sym} 2340 4240 0 0 {name=l3421 lab=BL12}
N 2360 4200 2340 4200 {}
C {lab_pin.sym} 2340 4200 0 0 {name=l3422 lab=BLB12}
N 2360 4160 2340 4160 {}
C {lab_pin.sym} 2340 4160 0 0 {name=l3423 lab=WL21}
N 2440 4240 2460 4240 {}
C {lab_pin.sym} 2460 4240 0 0 {name=l3424 lab=VDD}
N 2440 4160 2460 4160 {}
C {lab_pin.sym} 2460 4160 0 0 {name=l3425 lab=VSS}
C {bitcell_6t.sym} 2600 4200 0 0 {name=Xr21c13}
N 2560 4240 2540 4240 {}
C {lab_pin.sym} 2540 4240 0 0 {name=l3426 lab=BL13}
N 2560 4200 2540 4200 {}
C {lab_pin.sym} 2540 4200 0 0 {name=l3427 lab=BLB13}
N 2560 4160 2540 4160 {}
C {lab_pin.sym} 2540 4160 0 0 {name=l3428 lab=WL21}
N 2640 4240 2660 4240 {}
C {lab_pin.sym} 2660 4240 0 0 {name=l3429 lab=VDD}
N 2640 4160 2660 4160 {}
C {lab_pin.sym} 2660 4160 0 0 {name=l3430 lab=VSS}
C {bitcell_6t.sym} 2800 4200 0 0 {name=Xr21c14}
N 2760 4240 2740 4240 {}
C {lab_pin.sym} 2740 4240 0 0 {name=l3431 lab=BL14}
N 2760 4200 2740 4200 {}
C {lab_pin.sym} 2740 4200 0 0 {name=l3432 lab=BLB14}
N 2760 4160 2740 4160 {}
C {lab_pin.sym} 2740 4160 0 0 {name=l3433 lab=WL21}
N 2840 4240 2860 4240 {}
C {lab_pin.sym} 2860 4240 0 0 {name=l3434 lab=VDD}
N 2840 4160 2860 4160 {}
C {lab_pin.sym} 2860 4160 0 0 {name=l3435 lab=VSS}
C {bitcell_6t.sym} 3000 4200 0 0 {name=Xr21c15}
N 2960 4240 2940 4240 {}
C {lab_pin.sym} 2940 4240 0 0 {name=l3436 lab=BL15}
N 2960 4200 2940 4200 {}
C {lab_pin.sym} 2940 4200 0 0 {name=l3437 lab=BLB15}
N 2960 4160 2940 4160 {}
C {lab_pin.sym} 2940 4160 0 0 {name=l3438 lab=WL21}
N 3040 4240 3060 4240 {}
C {lab_pin.sym} 3060 4240 0 0 {name=l3439 lab=VDD}
N 3040 4160 3060 4160 {}
C {lab_pin.sym} 3060 4160 0 0 {name=l3440 lab=VSS}
C {bitcell_6t.sym} 3200 4200 0 0 {name=Xr21c16}
N 3160 4240 3140 4240 {}
C {lab_pin.sym} 3140 4240 0 0 {name=l3441 lab=BL16}
N 3160 4200 3140 4200 {}
C {lab_pin.sym} 3140 4200 0 0 {name=l3442 lab=BLB16}
N 3160 4160 3140 4160 {}
C {lab_pin.sym} 3140 4160 0 0 {name=l3443 lab=WL21}
N 3240 4240 3260 4240 {}
C {lab_pin.sym} 3260 4240 0 0 {name=l3444 lab=VDD}
N 3240 4160 3260 4160 {}
C {lab_pin.sym} 3260 4160 0 0 {name=l3445 lab=VSS}
C {bitcell_6t.sym} 3400 4200 0 0 {name=Xr21c17}
N 3360 4240 3340 4240 {}
C {lab_pin.sym} 3340 4240 0 0 {name=l3446 lab=BL17}
N 3360 4200 3340 4200 {}
C {lab_pin.sym} 3340 4200 0 0 {name=l3447 lab=BLB17}
N 3360 4160 3340 4160 {}
C {lab_pin.sym} 3340 4160 0 0 {name=l3448 lab=WL21}
N 3440 4240 3460 4240 {}
C {lab_pin.sym} 3460 4240 0 0 {name=l3449 lab=VDD}
N 3440 4160 3460 4160 {}
C {lab_pin.sym} 3460 4160 0 0 {name=l3450 lab=VSS}
C {bitcell_6t.sym} 3600 4200 0 0 {name=Xr21c18}
N 3560 4240 3540 4240 {}
C {lab_pin.sym} 3540 4240 0 0 {name=l3451 lab=BL18}
N 3560 4200 3540 4200 {}
C {lab_pin.sym} 3540 4200 0 0 {name=l3452 lab=BLB18}
N 3560 4160 3540 4160 {}
C {lab_pin.sym} 3540 4160 0 0 {name=l3453 lab=WL21}
N 3640 4240 3660 4240 {}
C {lab_pin.sym} 3660 4240 0 0 {name=l3454 lab=VDD}
N 3640 4160 3660 4160 {}
C {lab_pin.sym} 3660 4160 0 0 {name=l3455 lab=VSS}
C {bitcell_6t.sym} 3800 4200 0 0 {name=Xr21c19}
N 3760 4240 3740 4240 {}
C {lab_pin.sym} 3740 4240 0 0 {name=l3456 lab=BL19}
N 3760 4200 3740 4200 {}
C {lab_pin.sym} 3740 4200 0 0 {name=l3457 lab=BLB19}
N 3760 4160 3740 4160 {}
C {lab_pin.sym} 3740 4160 0 0 {name=l3458 lab=WL21}
N 3840 4240 3860 4240 {}
C {lab_pin.sym} 3860 4240 0 0 {name=l3459 lab=VDD}
N 3840 4160 3860 4160 {}
C {lab_pin.sym} 3860 4160 0 0 {name=l3460 lab=VSS}
C {bitcell_6t.sym} 4000 4200 0 0 {name=Xr21c20}
N 3960 4240 3940 4240 {}
C {lab_pin.sym} 3940 4240 0 0 {name=l3461 lab=BL20}
N 3960 4200 3940 4200 {}
C {lab_pin.sym} 3940 4200 0 0 {name=l3462 lab=BLB20}
N 3960 4160 3940 4160 {}
C {lab_pin.sym} 3940 4160 0 0 {name=l3463 lab=WL21}
N 4040 4240 4060 4240 {}
C {lab_pin.sym} 4060 4240 0 0 {name=l3464 lab=VDD}
N 4040 4160 4060 4160 {}
C {lab_pin.sym} 4060 4160 0 0 {name=l3465 lab=VSS}
C {bitcell_6t.sym} 4200 4200 0 0 {name=Xr21c21}
N 4160 4240 4140 4240 {}
C {lab_pin.sym} 4140 4240 0 0 {name=l3466 lab=BL21}
N 4160 4200 4140 4200 {}
C {lab_pin.sym} 4140 4200 0 0 {name=l3467 lab=BLB21}
N 4160 4160 4140 4160 {}
C {lab_pin.sym} 4140 4160 0 0 {name=l3468 lab=WL21}
N 4240 4240 4260 4240 {}
C {lab_pin.sym} 4260 4240 0 0 {name=l3469 lab=VDD}
N 4240 4160 4260 4160 {}
C {lab_pin.sym} 4260 4160 0 0 {name=l3470 lab=VSS}
C {bitcell_6t.sym} 4400 4200 0 0 {name=Xr21c22}
N 4360 4240 4340 4240 {}
C {lab_pin.sym} 4340 4240 0 0 {name=l3471 lab=BL22}
N 4360 4200 4340 4200 {}
C {lab_pin.sym} 4340 4200 0 0 {name=l3472 lab=BLB22}
N 4360 4160 4340 4160 {}
C {lab_pin.sym} 4340 4160 0 0 {name=l3473 lab=WL21}
N 4440 4240 4460 4240 {}
C {lab_pin.sym} 4460 4240 0 0 {name=l3474 lab=VDD}
N 4440 4160 4460 4160 {}
C {lab_pin.sym} 4460 4160 0 0 {name=l3475 lab=VSS}
C {bitcell_6t.sym} 4600 4200 0 0 {name=Xr21c23}
N 4560 4240 4540 4240 {}
C {lab_pin.sym} 4540 4240 0 0 {name=l3476 lab=BL23}
N 4560 4200 4540 4200 {}
C {lab_pin.sym} 4540 4200 0 0 {name=l3477 lab=BLB23}
N 4560 4160 4540 4160 {}
C {lab_pin.sym} 4540 4160 0 0 {name=l3478 lab=WL21}
N 4640 4240 4660 4240 {}
C {lab_pin.sym} 4660 4240 0 0 {name=l3479 lab=VDD}
N 4640 4160 4660 4160 {}
C {lab_pin.sym} 4660 4160 0 0 {name=l3480 lab=VSS}
C {bitcell_6t.sym} 4800 4200 0 0 {name=Xr21c24}
N 4760 4240 4740 4240 {}
C {lab_pin.sym} 4740 4240 0 0 {name=l3481 lab=BL24}
N 4760 4200 4740 4200 {}
C {lab_pin.sym} 4740 4200 0 0 {name=l3482 lab=BLB24}
N 4760 4160 4740 4160 {}
C {lab_pin.sym} 4740 4160 0 0 {name=l3483 lab=WL21}
N 4840 4240 4860 4240 {}
C {lab_pin.sym} 4860 4240 0 0 {name=l3484 lab=VDD}
N 4840 4160 4860 4160 {}
C {lab_pin.sym} 4860 4160 0 0 {name=l3485 lab=VSS}
C {bitcell_6t.sym} 5000 4200 0 0 {name=Xr21c25}
N 4960 4240 4940 4240 {}
C {lab_pin.sym} 4940 4240 0 0 {name=l3486 lab=BL25}
N 4960 4200 4940 4200 {}
C {lab_pin.sym} 4940 4200 0 0 {name=l3487 lab=BLB25}
N 4960 4160 4940 4160 {}
C {lab_pin.sym} 4940 4160 0 0 {name=l3488 lab=WL21}
N 5040 4240 5060 4240 {}
C {lab_pin.sym} 5060 4240 0 0 {name=l3489 lab=VDD}
N 5040 4160 5060 4160 {}
C {lab_pin.sym} 5060 4160 0 0 {name=l3490 lab=VSS}
C {bitcell_6t.sym} 5200 4200 0 0 {name=Xr21c26}
N 5160 4240 5140 4240 {}
C {lab_pin.sym} 5140 4240 0 0 {name=l3491 lab=BL26}
N 5160 4200 5140 4200 {}
C {lab_pin.sym} 5140 4200 0 0 {name=l3492 lab=BLB26}
N 5160 4160 5140 4160 {}
C {lab_pin.sym} 5140 4160 0 0 {name=l3493 lab=WL21}
N 5240 4240 5260 4240 {}
C {lab_pin.sym} 5260 4240 0 0 {name=l3494 lab=VDD}
N 5240 4160 5260 4160 {}
C {lab_pin.sym} 5260 4160 0 0 {name=l3495 lab=VSS}
C {bitcell_6t.sym} 5400 4200 0 0 {name=Xr21c27}
N 5360 4240 5340 4240 {}
C {lab_pin.sym} 5340 4240 0 0 {name=l3496 lab=BL27}
N 5360 4200 5340 4200 {}
C {lab_pin.sym} 5340 4200 0 0 {name=l3497 lab=BLB27}
N 5360 4160 5340 4160 {}
C {lab_pin.sym} 5340 4160 0 0 {name=l3498 lab=WL21}
N 5440 4240 5460 4240 {}
C {lab_pin.sym} 5460 4240 0 0 {name=l3499 lab=VDD}
N 5440 4160 5460 4160 {}
C {lab_pin.sym} 5460 4160 0 0 {name=l3500 lab=VSS}
C {bitcell_6t.sym} 5600 4200 0 0 {name=Xr21c28}
N 5560 4240 5540 4240 {}
C {lab_pin.sym} 5540 4240 0 0 {name=l3501 lab=BL28}
N 5560 4200 5540 4200 {}
C {lab_pin.sym} 5540 4200 0 0 {name=l3502 lab=BLB28}
N 5560 4160 5540 4160 {}
C {lab_pin.sym} 5540 4160 0 0 {name=l3503 lab=WL21}
N 5640 4240 5660 4240 {}
C {lab_pin.sym} 5660 4240 0 0 {name=l3504 lab=VDD}
N 5640 4160 5660 4160 {}
C {lab_pin.sym} 5660 4160 0 0 {name=l3505 lab=VSS}
C {bitcell_6t.sym} 5800 4200 0 0 {name=Xr21c29}
N 5760 4240 5740 4240 {}
C {lab_pin.sym} 5740 4240 0 0 {name=l3506 lab=BL29}
N 5760 4200 5740 4200 {}
C {lab_pin.sym} 5740 4200 0 0 {name=l3507 lab=BLB29}
N 5760 4160 5740 4160 {}
C {lab_pin.sym} 5740 4160 0 0 {name=l3508 lab=WL21}
N 5840 4240 5860 4240 {}
C {lab_pin.sym} 5860 4240 0 0 {name=l3509 lab=VDD}
N 5840 4160 5860 4160 {}
C {lab_pin.sym} 5860 4160 0 0 {name=l3510 lab=VSS}
C {bitcell_6t.sym} 6000 4200 0 0 {name=Xr21c30}
N 5960 4240 5940 4240 {}
C {lab_pin.sym} 5940 4240 0 0 {name=l3511 lab=BL30}
N 5960 4200 5940 4200 {}
C {lab_pin.sym} 5940 4200 0 0 {name=l3512 lab=BLB30}
N 5960 4160 5940 4160 {}
C {lab_pin.sym} 5940 4160 0 0 {name=l3513 lab=WL21}
N 6040 4240 6060 4240 {}
C {lab_pin.sym} 6060 4240 0 0 {name=l3514 lab=VDD}
N 6040 4160 6060 4160 {}
C {lab_pin.sym} 6060 4160 0 0 {name=l3515 lab=VSS}
C {bitcell_6t.sym} 6200 4200 0 0 {name=Xr21c31}
N 6160 4240 6140 4240 {}
C {lab_pin.sym} 6140 4240 0 0 {name=l3516 lab=BL31}
N 6160 4200 6140 4200 {}
C {lab_pin.sym} 6140 4200 0 0 {name=l3517 lab=BLB31}
N 6160 4160 6140 4160 {}
C {lab_pin.sym} 6140 4160 0 0 {name=l3518 lab=WL21}
N 6240 4240 6260 4240 {}
C {lab_pin.sym} 6260 4240 0 0 {name=l3519 lab=VDD}
N 6240 4160 6260 4160 {}
C {lab_pin.sym} 6260 4160 0 0 {name=l3520 lab=VSS}
C {bitcell_6t.sym} 0 4400 0 0 {name=Xr22c0}
N -40 4440 -60 4440 {}
C {lab_pin.sym} -60 4440 0 0 {name=l3521 lab=BL0}
N -40 4400 -60 4400 {}
C {lab_pin.sym} -60 4400 0 0 {name=l3522 lab=BLB0}
N -40 4360 -60 4360 {}
C {lab_pin.sym} -60 4360 0 0 {name=l3523 lab=WL22}
N 40 4440 60 4440 {}
C {lab_pin.sym} 60 4440 0 0 {name=l3524 lab=VDD}
N 40 4360 60 4360 {}
C {lab_pin.sym} 60 4360 0 0 {name=l3525 lab=VSS}
C {bitcell_6t.sym} 200 4400 0 0 {name=Xr22c1}
N 160 4440 140 4440 {}
C {lab_pin.sym} 140 4440 0 0 {name=l3526 lab=BL1}
N 160 4400 140 4400 {}
C {lab_pin.sym} 140 4400 0 0 {name=l3527 lab=BLB1}
N 160 4360 140 4360 {}
C {lab_pin.sym} 140 4360 0 0 {name=l3528 lab=WL22}
N 240 4440 260 4440 {}
C {lab_pin.sym} 260 4440 0 0 {name=l3529 lab=VDD}
N 240 4360 260 4360 {}
C {lab_pin.sym} 260 4360 0 0 {name=l3530 lab=VSS}
C {bitcell_6t.sym} 400 4400 0 0 {name=Xr22c2}
N 360 4440 340 4440 {}
C {lab_pin.sym} 340 4440 0 0 {name=l3531 lab=BL2}
N 360 4400 340 4400 {}
C {lab_pin.sym} 340 4400 0 0 {name=l3532 lab=BLB2}
N 360 4360 340 4360 {}
C {lab_pin.sym} 340 4360 0 0 {name=l3533 lab=WL22}
N 440 4440 460 4440 {}
C {lab_pin.sym} 460 4440 0 0 {name=l3534 lab=VDD}
N 440 4360 460 4360 {}
C {lab_pin.sym} 460 4360 0 0 {name=l3535 lab=VSS}
C {bitcell_6t.sym} 600 4400 0 0 {name=Xr22c3}
N 560 4440 540 4440 {}
C {lab_pin.sym} 540 4440 0 0 {name=l3536 lab=BL3}
N 560 4400 540 4400 {}
C {lab_pin.sym} 540 4400 0 0 {name=l3537 lab=BLB3}
N 560 4360 540 4360 {}
C {lab_pin.sym} 540 4360 0 0 {name=l3538 lab=WL22}
N 640 4440 660 4440 {}
C {lab_pin.sym} 660 4440 0 0 {name=l3539 lab=VDD}
N 640 4360 660 4360 {}
C {lab_pin.sym} 660 4360 0 0 {name=l3540 lab=VSS}
C {bitcell_6t.sym} 800 4400 0 0 {name=Xr22c4}
N 760 4440 740 4440 {}
C {lab_pin.sym} 740 4440 0 0 {name=l3541 lab=BL4}
N 760 4400 740 4400 {}
C {lab_pin.sym} 740 4400 0 0 {name=l3542 lab=BLB4}
N 760 4360 740 4360 {}
C {lab_pin.sym} 740 4360 0 0 {name=l3543 lab=WL22}
N 840 4440 860 4440 {}
C {lab_pin.sym} 860 4440 0 0 {name=l3544 lab=VDD}
N 840 4360 860 4360 {}
C {lab_pin.sym} 860 4360 0 0 {name=l3545 lab=VSS}
C {bitcell_6t.sym} 1000 4400 0 0 {name=Xr22c5}
N 960 4440 940 4440 {}
C {lab_pin.sym} 940 4440 0 0 {name=l3546 lab=BL5}
N 960 4400 940 4400 {}
C {lab_pin.sym} 940 4400 0 0 {name=l3547 lab=BLB5}
N 960 4360 940 4360 {}
C {lab_pin.sym} 940 4360 0 0 {name=l3548 lab=WL22}
N 1040 4440 1060 4440 {}
C {lab_pin.sym} 1060 4440 0 0 {name=l3549 lab=VDD}
N 1040 4360 1060 4360 {}
C {lab_pin.sym} 1060 4360 0 0 {name=l3550 lab=VSS}
C {bitcell_6t.sym} 1200 4400 0 0 {name=Xr22c6}
N 1160 4440 1140 4440 {}
C {lab_pin.sym} 1140 4440 0 0 {name=l3551 lab=BL6}
N 1160 4400 1140 4400 {}
C {lab_pin.sym} 1140 4400 0 0 {name=l3552 lab=BLB6}
N 1160 4360 1140 4360 {}
C {lab_pin.sym} 1140 4360 0 0 {name=l3553 lab=WL22}
N 1240 4440 1260 4440 {}
C {lab_pin.sym} 1260 4440 0 0 {name=l3554 lab=VDD}
N 1240 4360 1260 4360 {}
C {lab_pin.sym} 1260 4360 0 0 {name=l3555 lab=VSS}
C {bitcell_6t.sym} 1400 4400 0 0 {name=Xr22c7}
N 1360 4440 1340 4440 {}
C {lab_pin.sym} 1340 4440 0 0 {name=l3556 lab=BL7}
N 1360 4400 1340 4400 {}
C {lab_pin.sym} 1340 4400 0 0 {name=l3557 lab=BLB7}
N 1360 4360 1340 4360 {}
C {lab_pin.sym} 1340 4360 0 0 {name=l3558 lab=WL22}
N 1440 4440 1460 4440 {}
C {lab_pin.sym} 1460 4440 0 0 {name=l3559 lab=VDD}
N 1440 4360 1460 4360 {}
C {lab_pin.sym} 1460 4360 0 0 {name=l3560 lab=VSS}
C {bitcell_6t.sym} 1600 4400 0 0 {name=Xr22c8}
N 1560 4440 1540 4440 {}
C {lab_pin.sym} 1540 4440 0 0 {name=l3561 lab=BL8}
N 1560 4400 1540 4400 {}
C {lab_pin.sym} 1540 4400 0 0 {name=l3562 lab=BLB8}
N 1560 4360 1540 4360 {}
C {lab_pin.sym} 1540 4360 0 0 {name=l3563 lab=WL22}
N 1640 4440 1660 4440 {}
C {lab_pin.sym} 1660 4440 0 0 {name=l3564 lab=VDD}
N 1640 4360 1660 4360 {}
C {lab_pin.sym} 1660 4360 0 0 {name=l3565 lab=VSS}
C {bitcell_6t.sym} 1800 4400 0 0 {name=Xr22c9}
N 1760 4440 1740 4440 {}
C {lab_pin.sym} 1740 4440 0 0 {name=l3566 lab=BL9}
N 1760 4400 1740 4400 {}
C {lab_pin.sym} 1740 4400 0 0 {name=l3567 lab=BLB9}
N 1760 4360 1740 4360 {}
C {lab_pin.sym} 1740 4360 0 0 {name=l3568 lab=WL22}
N 1840 4440 1860 4440 {}
C {lab_pin.sym} 1860 4440 0 0 {name=l3569 lab=VDD}
N 1840 4360 1860 4360 {}
C {lab_pin.sym} 1860 4360 0 0 {name=l3570 lab=VSS}
C {bitcell_6t.sym} 2000 4400 0 0 {name=Xr22c10}
N 1960 4440 1940 4440 {}
C {lab_pin.sym} 1940 4440 0 0 {name=l3571 lab=BL10}
N 1960 4400 1940 4400 {}
C {lab_pin.sym} 1940 4400 0 0 {name=l3572 lab=BLB10}
N 1960 4360 1940 4360 {}
C {lab_pin.sym} 1940 4360 0 0 {name=l3573 lab=WL22}
N 2040 4440 2060 4440 {}
C {lab_pin.sym} 2060 4440 0 0 {name=l3574 lab=VDD}
N 2040 4360 2060 4360 {}
C {lab_pin.sym} 2060 4360 0 0 {name=l3575 lab=VSS}
C {bitcell_6t.sym} 2200 4400 0 0 {name=Xr22c11}
N 2160 4440 2140 4440 {}
C {lab_pin.sym} 2140 4440 0 0 {name=l3576 lab=BL11}
N 2160 4400 2140 4400 {}
C {lab_pin.sym} 2140 4400 0 0 {name=l3577 lab=BLB11}
N 2160 4360 2140 4360 {}
C {lab_pin.sym} 2140 4360 0 0 {name=l3578 lab=WL22}
N 2240 4440 2260 4440 {}
C {lab_pin.sym} 2260 4440 0 0 {name=l3579 lab=VDD}
N 2240 4360 2260 4360 {}
C {lab_pin.sym} 2260 4360 0 0 {name=l3580 lab=VSS}
C {bitcell_6t.sym} 2400 4400 0 0 {name=Xr22c12}
N 2360 4440 2340 4440 {}
C {lab_pin.sym} 2340 4440 0 0 {name=l3581 lab=BL12}
N 2360 4400 2340 4400 {}
C {lab_pin.sym} 2340 4400 0 0 {name=l3582 lab=BLB12}
N 2360 4360 2340 4360 {}
C {lab_pin.sym} 2340 4360 0 0 {name=l3583 lab=WL22}
N 2440 4440 2460 4440 {}
C {lab_pin.sym} 2460 4440 0 0 {name=l3584 lab=VDD}
N 2440 4360 2460 4360 {}
C {lab_pin.sym} 2460 4360 0 0 {name=l3585 lab=VSS}
C {bitcell_6t.sym} 2600 4400 0 0 {name=Xr22c13}
N 2560 4440 2540 4440 {}
C {lab_pin.sym} 2540 4440 0 0 {name=l3586 lab=BL13}
N 2560 4400 2540 4400 {}
C {lab_pin.sym} 2540 4400 0 0 {name=l3587 lab=BLB13}
N 2560 4360 2540 4360 {}
C {lab_pin.sym} 2540 4360 0 0 {name=l3588 lab=WL22}
N 2640 4440 2660 4440 {}
C {lab_pin.sym} 2660 4440 0 0 {name=l3589 lab=VDD}
N 2640 4360 2660 4360 {}
C {lab_pin.sym} 2660 4360 0 0 {name=l3590 lab=VSS}
C {bitcell_6t.sym} 2800 4400 0 0 {name=Xr22c14}
N 2760 4440 2740 4440 {}
C {lab_pin.sym} 2740 4440 0 0 {name=l3591 lab=BL14}
N 2760 4400 2740 4400 {}
C {lab_pin.sym} 2740 4400 0 0 {name=l3592 lab=BLB14}
N 2760 4360 2740 4360 {}
C {lab_pin.sym} 2740 4360 0 0 {name=l3593 lab=WL22}
N 2840 4440 2860 4440 {}
C {lab_pin.sym} 2860 4440 0 0 {name=l3594 lab=VDD}
N 2840 4360 2860 4360 {}
C {lab_pin.sym} 2860 4360 0 0 {name=l3595 lab=VSS}
C {bitcell_6t.sym} 3000 4400 0 0 {name=Xr22c15}
N 2960 4440 2940 4440 {}
C {lab_pin.sym} 2940 4440 0 0 {name=l3596 lab=BL15}
N 2960 4400 2940 4400 {}
C {lab_pin.sym} 2940 4400 0 0 {name=l3597 lab=BLB15}
N 2960 4360 2940 4360 {}
C {lab_pin.sym} 2940 4360 0 0 {name=l3598 lab=WL22}
N 3040 4440 3060 4440 {}
C {lab_pin.sym} 3060 4440 0 0 {name=l3599 lab=VDD}
N 3040 4360 3060 4360 {}
C {lab_pin.sym} 3060 4360 0 0 {name=l3600 lab=VSS}
C {bitcell_6t.sym} 3200 4400 0 0 {name=Xr22c16}
N 3160 4440 3140 4440 {}
C {lab_pin.sym} 3140 4440 0 0 {name=l3601 lab=BL16}
N 3160 4400 3140 4400 {}
C {lab_pin.sym} 3140 4400 0 0 {name=l3602 lab=BLB16}
N 3160 4360 3140 4360 {}
C {lab_pin.sym} 3140 4360 0 0 {name=l3603 lab=WL22}
N 3240 4440 3260 4440 {}
C {lab_pin.sym} 3260 4440 0 0 {name=l3604 lab=VDD}
N 3240 4360 3260 4360 {}
C {lab_pin.sym} 3260 4360 0 0 {name=l3605 lab=VSS}
C {bitcell_6t.sym} 3400 4400 0 0 {name=Xr22c17}
N 3360 4440 3340 4440 {}
C {lab_pin.sym} 3340 4440 0 0 {name=l3606 lab=BL17}
N 3360 4400 3340 4400 {}
C {lab_pin.sym} 3340 4400 0 0 {name=l3607 lab=BLB17}
N 3360 4360 3340 4360 {}
C {lab_pin.sym} 3340 4360 0 0 {name=l3608 lab=WL22}
N 3440 4440 3460 4440 {}
C {lab_pin.sym} 3460 4440 0 0 {name=l3609 lab=VDD}
N 3440 4360 3460 4360 {}
C {lab_pin.sym} 3460 4360 0 0 {name=l3610 lab=VSS}
C {bitcell_6t.sym} 3600 4400 0 0 {name=Xr22c18}
N 3560 4440 3540 4440 {}
C {lab_pin.sym} 3540 4440 0 0 {name=l3611 lab=BL18}
N 3560 4400 3540 4400 {}
C {lab_pin.sym} 3540 4400 0 0 {name=l3612 lab=BLB18}
N 3560 4360 3540 4360 {}
C {lab_pin.sym} 3540 4360 0 0 {name=l3613 lab=WL22}
N 3640 4440 3660 4440 {}
C {lab_pin.sym} 3660 4440 0 0 {name=l3614 lab=VDD}
N 3640 4360 3660 4360 {}
C {lab_pin.sym} 3660 4360 0 0 {name=l3615 lab=VSS}
C {bitcell_6t.sym} 3800 4400 0 0 {name=Xr22c19}
N 3760 4440 3740 4440 {}
C {lab_pin.sym} 3740 4440 0 0 {name=l3616 lab=BL19}
N 3760 4400 3740 4400 {}
C {lab_pin.sym} 3740 4400 0 0 {name=l3617 lab=BLB19}
N 3760 4360 3740 4360 {}
C {lab_pin.sym} 3740 4360 0 0 {name=l3618 lab=WL22}
N 3840 4440 3860 4440 {}
C {lab_pin.sym} 3860 4440 0 0 {name=l3619 lab=VDD}
N 3840 4360 3860 4360 {}
C {lab_pin.sym} 3860 4360 0 0 {name=l3620 lab=VSS}
C {bitcell_6t.sym} 4000 4400 0 0 {name=Xr22c20}
N 3960 4440 3940 4440 {}
C {lab_pin.sym} 3940 4440 0 0 {name=l3621 lab=BL20}
N 3960 4400 3940 4400 {}
C {lab_pin.sym} 3940 4400 0 0 {name=l3622 lab=BLB20}
N 3960 4360 3940 4360 {}
C {lab_pin.sym} 3940 4360 0 0 {name=l3623 lab=WL22}
N 4040 4440 4060 4440 {}
C {lab_pin.sym} 4060 4440 0 0 {name=l3624 lab=VDD}
N 4040 4360 4060 4360 {}
C {lab_pin.sym} 4060 4360 0 0 {name=l3625 lab=VSS}
C {bitcell_6t.sym} 4200 4400 0 0 {name=Xr22c21}
N 4160 4440 4140 4440 {}
C {lab_pin.sym} 4140 4440 0 0 {name=l3626 lab=BL21}
N 4160 4400 4140 4400 {}
C {lab_pin.sym} 4140 4400 0 0 {name=l3627 lab=BLB21}
N 4160 4360 4140 4360 {}
C {lab_pin.sym} 4140 4360 0 0 {name=l3628 lab=WL22}
N 4240 4440 4260 4440 {}
C {lab_pin.sym} 4260 4440 0 0 {name=l3629 lab=VDD}
N 4240 4360 4260 4360 {}
C {lab_pin.sym} 4260 4360 0 0 {name=l3630 lab=VSS}
C {bitcell_6t.sym} 4400 4400 0 0 {name=Xr22c22}
N 4360 4440 4340 4440 {}
C {lab_pin.sym} 4340 4440 0 0 {name=l3631 lab=BL22}
N 4360 4400 4340 4400 {}
C {lab_pin.sym} 4340 4400 0 0 {name=l3632 lab=BLB22}
N 4360 4360 4340 4360 {}
C {lab_pin.sym} 4340 4360 0 0 {name=l3633 lab=WL22}
N 4440 4440 4460 4440 {}
C {lab_pin.sym} 4460 4440 0 0 {name=l3634 lab=VDD}
N 4440 4360 4460 4360 {}
C {lab_pin.sym} 4460 4360 0 0 {name=l3635 lab=VSS}
C {bitcell_6t.sym} 4600 4400 0 0 {name=Xr22c23}
N 4560 4440 4540 4440 {}
C {lab_pin.sym} 4540 4440 0 0 {name=l3636 lab=BL23}
N 4560 4400 4540 4400 {}
C {lab_pin.sym} 4540 4400 0 0 {name=l3637 lab=BLB23}
N 4560 4360 4540 4360 {}
C {lab_pin.sym} 4540 4360 0 0 {name=l3638 lab=WL22}
N 4640 4440 4660 4440 {}
C {lab_pin.sym} 4660 4440 0 0 {name=l3639 lab=VDD}
N 4640 4360 4660 4360 {}
C {lab_pin.sym} 4660 4360 0 0 {name=l3640 lab=VSS}
C {bitcell_6t.sym} 4800 4400 0 0 {name=Xr22c24}
N 4760 4440 4740 4440 {}
C {lab_pin.sym} 4740 4440 0 0 {name=l3641 lab=BL24}
N 4760 4400 4740 4400 {}
C {lab_pin.sym} 4740 4400 0 0 {name=l3642 lab=BLB24}
N 4760 4360 4740 4360 {}
C {lab_pin.sym} 4740 4360 0 0 {name=l3643 lab=WL22}
N 4840 4440 4860 4440 {}
C {lab_pin.sym} 4860 4440 0 0 {name=l3644 lab=VDD}
N 4840 4360 4860 4360 {}
C {lab_pin.sym} 4860 4360 0 0 {name=l3645 lab=VSS}
C {bitcell_6t.sym} 5000 4400 0 0 {name=Xr22c25}
N 4960 4440 4940 4440 {}
C {lab_pin.sym} 4940 4440 0 0 {name=l3646 lab=BL25}
N 4960 4400 4940 4400 {}
C {lab_pin.sym} 4940 4400 0 0 {name=l3647 lab=BLB25}
N 4960 4360 4940 4360 {}
C {lab_pin.sym} 4940 4360 0 0 {name=l3648 lab=WL22}
N 5040 4440 5060 4440 {}
C {lab_pin.sym} 5060 4440 0 0 {name=l3649 lab=VDD}
N 5040 4360 5060 4360 {}
C {lab_pin.sym} 5060 4360 0 0 {name=l3650 lab=VSS}
C {bitcell_6t.sym} 5200 4400 0 0 {name=Xr22c26}
N 5160 4440 5140 4440 {}
C {lab_pin.sym} 5140 4440 0 0 {name=l3651 lab=BL26}
N 5160 4400 5140 4400 {}
C {lab_pin.sym} 5140 4400 0 0 {name=l3652 lab=BLB26}
N 5160 4360 5140 4360 {}
C {lab_pin.sym} 5140 4360 0 0 {name=l3653 lab=WL22}
N 5240 4440 5260 4440 {}
C {lab_pin.sym} 5260 4440 0 0 {name=l3654 lab=VDD}
N 5240 4360 5260 4360 {}
C {lab_pin.sym} 5260 4360 0 0 {name=l3655 lab=VSS}
C {bitcell_6t.sym} 5400 4400 0 0 {name=Xr22c27}
N 5360 4440 5340 4440 {}
C {lab_pin.sym} 5340 4440 0 0 {name=l3656 lab=BL27}
N 5360 4400 5340 4400 {}
C {lab_pin.sym} 5340 4400 0 0 {name=l3657 lab=BLB27}
N 5360 4360 5340 4360 {}
C {lab_pin.sym} 5340 4360 0 0 {name=l3658 lab=WL22}
N 5440 4440 5460 4440 {}
C {lab_pin.sym} 5460 4440 0 0 {name=l3659 lab=VDD}
N 5440 4360 5460 4360 {}
C {lab_pin.sym} 5460 4360 0 0 {name=l3660 lab=VSS}
C {bitcell_6t.sym} 5600 4400 0 0 {name=Xr22c28}
N 5560 4440 5540 4440 {}
C {lab_pin.sym} 5540 4440 0 0 {name=l3661 lab=BL28}
N 5560 4400 5540 4400 {}
C {lab_pin.sym} 5540 4400 0 0 {name=l3662 lab=BLB28}
N 5560 4360 5540 4360 {}
C {lab_pin.sym} 5540 4360 0 0 {name=l3663 lab=WL22}
N 5640 4440 5660 4440 {}
C {lab_pin.sym} 5660 4440 0 0 {name=l3664 lab=VDD}
N 5640 4360 5660 4360 {}
C {lab_pin.sym} 5660 4360 0 0 {name=l3665 lab=VSS}
C {bitcell_6t.sym} 5800 4400 0 0 {name=Xr22c29}
N 5760 4440 5740 4440 {}
C {lab_pin.sym} 5740 4440 0 0 {name=l3666 lab=BL29}
N 5760 4400 5740 4400 {}
C {lab_pin.sym} 5740 4400 0 0 {name=l3667 lab=BLB29}
N 5760 4360 5740 4360 {}
C {lab_pin.sym} 5740 4360 0 0 {name=l3668 lab=WL22}
N 5840 4440 5860 4440 {}
C {lab_pin.sym} 5860 4440 0 0 {name=l3669 lab=VDD}
N 5840 4360 5860 4360 {}
C {lab_pin.sym} 5860 4360 0 0 {name=l3670 lab=VSS}
C {bitcell_6t.sym} 6000 4400 0 0 {name=Xr22c30}
N 5960 4440 5940 4440 {}
C {lab_pin.sym} 5940 4440 0 0 {name=l3671 lab=BL30}
N 5960 4400 5940 4400 {}
C {lab_pin.sym} 5940 4400 0 0 {name=l3672 lab=BLB30}
N 5960 4360 5940 4360 {}
C {lab_pin.sym} 5940 4360 0 0 {name=l3673 lab=WL22}
N 6040 4440 6060 4440 {}
C {lab_pin.sym} 6060 4440 0 0 {name=l3674 lab=VDD}
N 6040 4360 6060 4360 {}
C {lab_pin.sym} 6060 4360 0 0 {name=l3675 lab=VSS}
C {bitcell_6t.sym} 6200 4400 0 0 {name=Xr22c31}
N 6160 4440 6140 4440 {}
C {lab_pin.sym} 6140 4440 0 0 {name=l3676 lab=BL31}
N 6160 4400 6140 4400 {}
C {lab_pin.sym} 6140 4400 0 0 {name=l3677 lab=BLB31}
N 6160 4360 6140 4360 {}
C {lab_pin.sym} 6140 4360 0 0 {name=l3678 lab=WL22}
N 6240 4440 6260 4440 {}
C {lab_pin.sym} 6260 4440 0 0 {name=l3679 lab=VDD}
N 6240 4360 6260 4360 {}
C {lab_pin.sym} 6260 4360 0 0 {name=l3680 lab=VSS}
C {bitcell_6t.sym} 0 4600 0 0 {name=Xr23c0}
N -40 4640 -60 4640 {}
C {lab_pin.sym} -60 4640 0 0 {name=l3681 lab=BL0}
N -40 4600 -60 4600 {}
C {lab_pin.sym} -60 4600 0 0 {name=l3682 lab=BLB0}
N -40 4560 -60 4560 {}
C {lab_pin.sym} -60 4560 0 0 {name=l3683 lab=WL23}
N 40 4640 60 4640 {}
C {lab_pin.sym} 60 4640 0 0 {name=l3684 lab=VDD}
N 40 4560 60 4560 {}
C {lab_pin.sym} 60 4560 0 0 {name=l3685 lab=VSS}
C {bitcell_6t.sym} 200 4600 0 0 {name=Xr23c1}
N 160 4640 140 4640 {}
C {lab_pin.sym} 140 4640 0 0 {name=l3686 lab=BL1}
N 160 4600 140 4600 {}
C {lab_pin.sym} 140 4600 0 0 {name=l3687 lab=BLB1}
N 160 4560 140 4560 {}
C {lab_pin.sym} 140 4560 0 0 {name=l3688 lab=WL23}
N 240 4640 260 4640 {}
C {lab_pin.sym} 260 4640 0 0 {name=l3689 lab=VDD}
N 240 4560 260 4560 {}
C {lab_pin.sym} 260 4560 0 0 {name=l3690 lab=VSS}
C {bitcell_6t.sym} 400 4600 0 0 {name=Xr23c2}
N 360 4640 340 4640 {}
C {lab_pin.sym} 340 4640 0 0 {name=l3691 lab=BL2}
N 360 4600 340 4600 {}
C {lab_pin.sym} 340 4600 0 0 {name=l3692 lab=BLB2}
N 360 4560 340 4560 {}
C {lab_pin.sym} 340 4560 0 0 {name=l3693 lab=WL23}
N 440 4640 460 4640 {}
C {lab_pin.sym} 460 4640 0 0 {name=l3694 lab=VDD}
N 440 4560 460 4560 {}
C {lab_pin.sym} 460 4560 0 0 {name=l3695 lab=VSS}
C {bitcell_6t.sym} 600 4600 0 0 {name=Xr23c3}
N 560 4640 540 4640 {}
C {lab_pin.sym} 540 4640 0 0 {name=l3696 lab=BL3}
N 560 4600 540 4600 {}
C {lab_pin.sym} 540 4600 0 0 {name=l3697 lab=BLB3}
N 560 4560 540 4560 {}
C {lab_pin.sym} 540 4560 0 0 {name=l3698 lab=WL23}
N 640 4640 660 4640 {}
C {lab_pin.sym} 660 4640 0 0 {name=l3699 lab=VDD}
N 640 4560 660 4560 {}
C {lab_pin.sym} 660 4560 0 0 {name=l3700 lab=VSS}
C {bitcell_6t.sym} 800 4600 0 0 {name=Xr23c4}
N 760 4640 740 4640 {}
C {lab_pin.sym} 740 4640 0 0 {name=l3701 lab=BL4}
N 760 4600 740 4600 {}
C {lab_pin.sym} 740 4600 0 0 {name=l3702 lab=BLB4}
N 760 4560 740 4560 {}
C {lab_pin.sym} 740 4560 0 0 {name=l3703 lab=WL23}
N 840 4640 860 4640 {}
C {lab_pin.sym} 860 4640 0 0 {name=l3704 lab=VDD}
N 840 4560 860 4560 {}
C {lab_pin.sym} 860 4560 0 0 {name=l3705 lab=VSS}
C {bitcell_6t.sym} 1000 4600 0 0 {name=Xr23c5}
N 960 4640 940 4640 {}
C {lab_pin.sym} 940 4640 0 0 {name=l3706 lab=BL5}
N 960 4600 940 4600 {}
C {lab_pin.sym} 940 4600 0 0 {name=l3707 lab=BLB5}
N 960 4560 940 4560 {}
C {lab_pin.sym} 940 4560 0 0 {name=l3708 lab=WL23}
N 1040 4640 1060 4640 {}
C {lab_pin.sym} 1060 4640 0 0 {name=l3709 lab=VDD}
N 1040 4560 1060 4560 {}
C {lab_pin.sym} 1060 4560 0 0 {name=l3710 lab=VSS}
C {bitcell_6t.sym} 1200 4600 0 0 {name=Xr23c6}
N 1160 4640 1140 4640 {}
C {lab_pin.sym} 1140 4640 0 0 {name=l3711 lab=BL6}
N 1160 4600 1140 4600 {}
C {lab_pin.sym} 1140 4600 0 0 {name=l3712 lab=BLB6}
N 1160 4560 1140 4560 {}
C {lab_pin.sym} 1140 4560 0 0 {name=l3713 lab=WL23}
N 1240 4640 1260 4640 {}
C {lab_pin.sym} 1260 4640 0 0 {name=l3714 lab=VDD}
N 1240 4560 1260 4560 {}
C {lab_pin.sym} 1260 4560 0 0 {name=l3715 lab=VSS}
C {bitcell_6t.sym} 1400 4600 0 0 {name=Xr23c7}
N 1360 4640 1340 4640 {}
C {lab_pin.sym} 1340 4640 0 0 {name=l3716 lab=BL7}
N 1360 4600 1340 4600 {}
C {lab_pin.sym} 1340 4600 0 0 {name=l3717 lab=BLB7}
N 1360 4560 1340 4560 {}
C {lab_pin.sym} 1340 4560 0 0 {name=l3718 lab=WL23}
N 1440 4640 1460 4640 {}
C {lab_pin.sym} 1460 4640 0 0 {name=l3719 lab=VDD}
N 1440 4560 1460 4560 {}
C {lab_pin.sym} 1460 4560 0 0 {name=l3720 lab=VSS}
C {bitcell_6t.sym} 1600 4600 0 0 {name=Xr23c8}
N 1560 4640 1540 4640 {}
C {lab_pin.sym} 1540 4640 0 0 {name=l3721 lab=BL8}
N 1560 4600 1540 4600 {}
C {lab_pin.sym} 1540 4600 0 0 {name=l3722 lab=BLB8}
N 1560 4560 1540 4560 {}
C {lab_pin.sym} 1540 4560 0 0 {name=l3723 lab=WL23}
N 1640 4640 1660 4640 {}
C {lab_pin.sym} 1660 4640 0 0 {name=l3724 lab=VDD}
N 1640 4560 1660 4560 {}
C {lab_pin.sym} 1660 4560 0 0 {name=l3725 lab=VSS}
C {bitcell_6t.sym} 1800 4600 0 0 {name=Xr23c9}
N 1760 4640 1740 4640 {}
C {lab_pin.sym} 1740 4640 0 0 {name=l3726 lab=BL9}
N 1760 4600 1740 4600 {}
C {lab_pin.sym} 1740 4600 0 0 {name=l3727 lab=BLB9}
N 1760 4560 1740 4560 {}
C {lab_pin.sym} 1740 4560 0 0 {name=l3728 lab=WL23}
N 1840 4640 1860 4640 {}
C {lab_pin.sym} 1860 4640 0 0 {name=l3729 lab=VDD}
N 1840 4560 1860 4560 {}
C {lab_pin.sym} 1860 4560 0 0 {name=l3730 lab=VSS}
C {bitcell_6t.sym} 2000 4600 0 0 {name=Xr23c10}
N 1960 4640 1940 4640 {}
C {lab_pin.sym} 1940 4640 0 0 {name=l3731 lab=BL10}
N 1960 4600 1940 4600 {}
C {lab_pin.sym} 1940 4600 0 0 {name=l3732 lab=BLB10}
N 1960 4560 1940 4560 {}
C {lab_pin.sym} 1940 4560 0 0 {name=l3733 lab=WL23}
N 2040 4640 2060 4640 {}
C {lab_pin.sym} 2060 4640 0 0 {name=l3734 lab=VDD}
N 2040 4560 2060 4560 {}
C {lab_pin.sym} 2060 4560 0 0 {name=l3735 lab=VSS}
C {bitcell_6t.sym} 2200 4600 0 0 {name=Xr23c11}
N 2160 4640 2140 4640 {}
C {lab_pin.sym} 2140 4640 0 0 {name=l3736 lab=BL11}
N 2160 4600 2140 4600 {}
C {lab_pin.sym} 2140 4600 0 0 {name=l3737 lab=BLB11}
N 2160 4560 2140 4560 {}
C {lab_pin.sym} 2140 4560 0 0 {name=l3738 lab=WL23}
N 2240 4640 2260 4640 {}
C {lab_pin.sym} 2260 4640 0 0 {name=l3739 lab=VDD}
N 2240 4560 2260 4560 {}
C {lab_pin.sym} 2260 4560 0 0 {name=l3740 lab=VSS}
C {bitcell_6t.sym} 2400 4600 0 0 {name=Xr23c12}
N 2360 4640 2340 4640 {}
C {lab_pin.sym} 2340 4640 0 0 {name=l3741 lab=BL12}
N 2360 4600 2340 4600 {}
C {lab_pin.sym} 2340 4600 0 0 {name=l3742 lab=BLB12}
N 2360 4560 2340 4560 {}
C {lab_pin.sym} 2340 4560 0 0 {name=l3743 lab=WL23}
N 2440 4640 2460 4640 {}
C {lab_pin.sym} 2460 4640 0 0 {name=l3744 lab=VDD}
N 2440 4560 2460 4560 {}
C {lab_pin.sym} 2460 4560 0 0 {name=l3745 lab=VSS}
C {bitcell_6t.sym} 2600 4600 0 0 {name=Xr23c13}
N 2560 4640 2540 4640 {}
C {lab_pin.sym} 2540 4640 0 0 {name=l3746 lab=BL13}
N 2560 4600 2540 4600 {}
C {lab_pin.sym} 2540 4600 0 0 {name=l3747 lab=BLB13}
N 2560 4560 2540 4560 {}
C {lab_pin.sym} 2540 4560 0 0 {name=l3748 lab=WL23}
N 2640 4640 2660 4640 {}
C {lab_pin.sym} 2660 4640 0 0 {name=l3749 lab=VDD}
N 2640 4560 2660 4560 {}
C {lab_pin.sym} 2660 4560 0 0 {name=l3750 lab=VSS}
C {bitcell_6t.sym} 2800 4600 0 0 {name=Xr23c14}
N 2760 4640 2740 4640 {}
C {lab_pin.sym} 2740 4640 0 0 {name=l3751 lab=BL14}
N 2760 4600 2740 4600 {}
C {lab_pin.sym} 2740 4600 0 0 {name=l3752 lab=BLB14}
N 2760 4560 2740 4560 {}
C {lab_pin.sym} 2740 4560 0 0 {name=l3753 lab=WL23}
N 2840 4640 2860 4640 {}
C {lab_pin.sym} 2860 4640 0 0 {name=l3754 lab=VDD}
N 2840 4560 2860 4560 {}
C {lab_pin.sym} 2860 4560 0 0 {name=l3755 lab=VSS}
C {bitcell_6t.sym} 3000 4600 0 0 {name=Xr23c15}
N 2960 4640 2940 4640 {}
C {lab_pin.sym} 2940 4640 0 0 {name=l3756 lab=BL15}
N 2960 4600 2940 4600 {}
C {lab_pin.sym} 2940 4600 0 0 {name=l3757 lab=BLB15}
N 2960 4560 2940 4560 {}
C {lab_pin.sym} 2940 4560 0 0 {name=l3758 lab=WL23}
N 3040 4640 3060 4640 {}
C {lab_pin.sym} 3060 4640 0 0 {name=l3759 lab=VDD}
N 3040 4560 3060 4560 {}
C {lab_pin.sym} 3060 4560 0 0 {name=l3760 lab=VSS}
C {bitcell_6t.sym} 3200 4600 0 0 {name=Xr23c16}
N 3160 4640 3140 4640 {}
C {lab_pin.sym} 3140 4640 0 0 {name=l3761 lab=BL16}
N 3160 4600 3140 4600 {}
C {lab_pin.sym} 3140 4600 0 0 {name=l3762 lab=BLB16}
N 3160 4560 3140 4560 {}
C {lab_pin.sym} 3140 4560 0 0 {name=l3763 lab=WL23}
N 3240 4640 3260 4640 {}
C {lab_pin.sym} 3260 4640 0 0 {name=l3764 lab=VDD}
N 3240 4560 3260 4560 {}
C {lab_pin.sym} 3260 4560 0 0 {name=l3765 lab=VSS}
C {bitcell_6t.sym} 3400 4600 0 0 {name=Xr23c17}
N 3360 4640 3340 4640 {}
C {lab_pin.sym} 3340 4640 0 0 {name=l3766 lab=BL17}
N 3360 4600 3340 4600 {}
C {lab_pin.sym} 3340 4600 0 0 {name=l3767 lab=BLB17}
N 3360 4560 3340 4560 {}
C {lab_pin.sym} 3340 4560 0 0 {name=l3768 lab=WL23}
N 3440 4640 3460 4640 {}
C {lab_pin.sym} 3460 4640 0 0 {name=l3769 lab=VDD}
N 3440 4560 3460 4560 {}
C {lab_pin.sym} 3460 4560 0 0 {name=l3770 lab=VSS}
C {bitcell_6t.sym} 3600 4600 0 0 {name=Xr23c18}
N 3560 4640 3540 4640 {}
C {lab_pin.sym} 3540 4640 0 0 {name=l3771 lab=BL18}
N 3560 4600 3540 4600 {}
C {lab_pin.sym} 3540 4600 0 0 {name=l3772 lab=BLB18}
N 3560 4560 3540 4560 {}
C {lab_pin.sym} 3540 4560 0 0 {name=l3773 lab=WL23}
N 3640 4640 3660 4640 {}
C {lab_pin.sym} 3660 4640 0 0 {name=l3774 lab=VDD}
N 3640 4560 3660 4560 {}
C {lab_pin.sym} 3660 4560 0 0 {name=l3775 lab=VSS}
C {bitcell_6t.sym} 3800 4600 0 0 {name=Xr23c19}
N 3760 4640 3740 4640 {}
C {lab_pin.sym} 3740 4640 0 0 {name=l3776 lab=BL19}
N 3760 4600 3740 4600 {}
C {lab_pin.sym} 3740 4600 0 0 {name=l3777 lab=BLB19}
N 3760 4560 3740 4560 {}
C {lab_pin.sym} 3740 4560 0 0 {name=l3778 lab=WL23}
N 3840 4640 3860 4640 {}
C {lab_pin.sym} 3860 4640 0 0 {name=l3779 lab=VDD}
N 3840 4560 3860 4560 {}
C {lab_pin.sym} 3860 4560 0 0 {name=l3780 lab=VSS}
C {bitcell_6t.sym} 4000 4600 0 0 {name=Xr23c20}
N 3960 4640 3940 4640 {}
C {lab_pin.sym} 3940 4640 0 0 {name=l3781 lab=BL20}
N 3960 4600 3940 4600 {}
C {lab_pin.sym} 3940 4600 0 0 {name=l3782 lab=BLB20}
N 3960 4560 3940 4560 {}
C {lab_pin.sym} 3940 4560 0 0 {name=l3783 lab=WL23}
N 4040 4640 4060 4640 {}
C {lab_pin.sym} 4060 4640 0 0 {name=l3784 lab=VDD}
N 4040 4560 4060 4560 {}
C {lab_pin.sym} 4060 4560 0 0 {name=l3785 lab=VSS}
C {bitcell_6t.sym} 4200 4600 0 0 {name=Xr23c21}
N 4160 4640 4140 4640 {}
C {lab_pin.sym} 4140 4640 0 0 {name=l3786 lab=BL21}
N 4160 4600 4140 4600 {}
C {lab_pin.sym} 4140 4600 0 0 {name=l3787 lab=BLB21}
N 4160 4560 4140 4560 {}
C {lab_pin.sym} 4140 4560 0 0 {name=l3788 lab=WL23}
N 4240 4640 4260 4640 {}
C {lab_pin.sym} 4260 4640 0 0 {name=l3789 lab=VDD}
N 4240 4560 4260 4560 {}
C {lab_pin.sym} 4260 4560 0 0 {name=l3790 lab=VSS}
C {bitcell_6t.sym} 4400 4600 0 0 {name=Xr23c22}
N 4360 4640 4340 4640 {}
C {lab_pin.sym} 4340 4640 0 0 {name=l3791 lab=BL22}
N 4360 4600 4340 4600 {}
C {lab_pin.sym} 4340 4600 0 0 {name=l3792 lab=BLB22}
N 4360 4560 4340 4560 {}
C {lab_pin.sym} 4340 4560 0 0 {name=l3793 lab=WL23}
N 4440 4640 4460 4640 {}
C {lab_pin.sym} 4460 4640 0 0 {name=l3794 lab=VDD}
N 4440 4560 4460 4560 {}
C {lab_pin.sym} 4460 4560 0 0 {name=l3795 lab=VSS}
C {bitcell_6t.sym} 4600 4600 0 0 {name=Xr23c23}
N 4560 4640 4540 4640 {}
C {lab_pin.sym} 4540 4640 0 0 {name=l3796 lab=BL23}
N 4560 4600 4540 4600 {}
C {lab_pin.sym} 4540 4600 0 0 {name=l3797 lab=BLB23}
N 4560 4560 4540 4560 {}
C {lab_pin.sym} 4540 4560 0 0 {name=l3798 lab=WL23}
N 4640 4640 4660 4640 {}
C {lab_pin.sym} 4660 4640 0 0 {name=l3799 lab=VDD}
N 4640 4560 4660 4560 {}
C {lab_pin.sym} 4660 4560 0 0 {name=l3800 lab=VSS}
C {bitcell_6t.sym} 4800 4600 0 0 {name=Xr23c24}
N 4760 4640 4740 4640 {}
C {lab_pin.sym} 4740 4640 0 0 {name=l3801 lab=BL24}
N 4760 4600 4740 4600 {}
C {lab_pin.sym} 4740 4600 0 0 {name=l3802 lab=BLB24}
N 4760 4560 4740 4560 {}
C {lab_pin.sym} 4740 4560 0 0 {name=l3803 lab=WL23}
N 4840 4640 4860 4640 {}
C {lab_pin.sym} 4860 4640 0 0 {name=l3804 lab=VDD}
N 4840 4560 4860 4560 {}
C {lab_pin.sym} 4860 4560 0 0 {name=l3805 lab=VSS}
C {bitcell_6t.sym} 5000 4600 0 0 {name=Xr23c25}
N 4960 4640 4940 4640 {}
C {lab_pin.sym} 4940 4640 0 0 {name=l3806 lab=BL25}
N 4960 4600 4940 4600 {}
C {lab_pin.sym} 4940 4600 0 0 {name=l3807 lab=BLB25}
N 4960 4560 4940 4560 {}
C {lab_pin.sym} 4940 4560 0 0 {name=l3808 lab=WL23}
N 5040 4640 5060 4640 {}
C {lab_pin.sym} 5060 4640 0 0 {name=l3809 lab=VDD}
N 5040 4560 5060 4560 {}
C {lab_pin.sym} 5060 4560 0 0 {name=l3810 lab=VSS}
C {bitcell_6t.sym} 5200 4600 0 0 {name=Xr23c26}
N 5160 4640 5140 4640 {}
C {lab_pin.sym} 5140 4640 0 0 {name=l3811 lab=BL26}
N 5160 4600 5140 4600 {}
C {lab_pin.sym} 5140 4600 0 0 {name=l3812 lab=BLB26}
N 5160 4560 5140 4560 {}
C {lab_pin.sym} 5140 4560 0 0 {name=l3813 lab=WL23}
N 5240 4640 5260 4640 {}
C {lab_pin.sym} 5260 4640 0 0 {name=l3814 lab=VDD}
N 5240 4560 5260 4560 {}
C {lab_pin.sym} 5260 4560 0 0 {name=l3815 lab=VSS}
C {bitcell_6t.sym} 5400 4600 0 0 {name=Xr23c27}
N 5360 4640 5340 4640 {}
C {lab_pin.sym} 5340 4640 0 0 {name=l3816 lab=BL27}
N 5360 4600 5340 4600 {}
C {lab_pin.sym} 5340 4600 0 0 {name=l3817 lab=BLB27}
N 5360 4560 5340 4560 {}
C {lab_pin.sym} 5340 4560 0 0 {name=l3818 lab=WL23}
N 5440 4640 5460 4640 {}
C {lab_pin.sym} 5460 4640 0 0 {name=l3819 lab=VDD}
N 5440 4560 5460 4560 {}
C {lab_pin.sym} 5460 4560 0 0 {name=l3820 lab=VSS}
C {bitcell_6t.sym} 5600 4600 0 0 {name=Xr23c28}
N 5560 4640 5540 4640 {}
C {lab_pin.sym} 5540 4640 0 0 {name=l3821 lab=BL28}
N 5560 4600 5540 4600 {}
C {lab_pin.sym} 5540 4600 0 0 {name=l3822 lab=BLB28}
N 5560 4560 5540 4560 {}
C {lab_pin.sym} 5540 4560 0 0 {name=l3823 lab=WL23}
N 5640 4640 5660 4640 {}
C {lab_pin.sym} 5660 4640 0 0 {name=l3824 lab=VDD}
N 5640 4560 5660 4560 {}
C {lab_pin.sym} 5660 4560 0 0 {name=l3825 lab=VSS}
C {bitcell_6t.sym} 5800 4600 0 0 {name=Xr23c29}
N 5760 4640 5740 4640 {}
C {lab_pin.sym} 5740 4640 0 0 {name=l3826 lab=BL29}
N 5760 4600 5740 4600 {}
C {lab_pin.sym} 5740 4600 0 0 {name=l3827 lab=BLB29}
N 5760 4560 5740 4560 {}
C {lab_pin.sym} 5740 4560 0 0 {name=l3828 lab=WL23}
N 5840 4640 5860 4640 {}
C {lab_pin.sym} 5860 4640 0 0 {name=l3829 lab=VDD}
N 5840 4560 5860 4560 {}
C {lab_pin.sym} 5860 4560 0 0 {name=l3830 lab=VSS}
C {bitcell_6t.sym} 6000 4600 0 0 {name=Xr23c30}
N 5960 4640 5940 4640 {}
C {lab_pin.sym} 5940 4640 0 0 {name=l3831 lab=BL30}
N 5960 4600 5940 4600 {}
C {lab_pin.sym} 5940 4600 0 0 {name=l3832 lab=BLB30}
N 5960 4560 5940 4560 {}
C {lab_pin.sym} 5940 4560 0 0 {name=l3833 lab=WL23}
N 6040 4640 6060 4640 {}
C {lab_pin.sym} 6060 4640 0 0 {name=l3834 lab=VDD}
N 6040 4560 6060 4560 {}
C {lab_pin.sym} 6060 4560 0 0 {name=l3835 lab=VSS}
C {bitcell_6t.sym} 6200 4600 0 0 {name=Xr23c31}
N 6160 4640 6140 4640 {}
C {lab_pin.sym} 6140 4640 0 0 {name=l3836 lab=BL31}
N 6160 4600 6140 4600 {}
C {lab_pin.sym} 6140 4600 0 0 {name=l3837 lab=BLB31}
N 6160 4560 6140 4560 {}
C {lab_pin.sym} 6140 4560 0 0 {name=l3838 lab=WL23}
N 6240 4640 6260 4640 {}
C {lab_pin.sym} 6260 4640 0 0 {name=l3839 lab=VDD}
N 6240 4560 6260 4560 {}
C {lab_pin.sym} 6260 4560 0 0 {name=l3840 lab=VSS}
C {bitcell_6t.sym} 0 4800 0 0 {name=Xr24c0}
N -40 4840 -60 4840 {}
C {lab_pin.sym} -60 4840 0 0 {name=l3841 lab=BL0}
N -40 4800 -60 4800 {}
C {lab_pin.sym} -60 4800 0 0 {name=l3842 lab=BLB0}
N -40 4760 -60 4760 {}
C {lab_pin.sym} -60 4760 0 0 {name=l3843 lab=WL24}
N 40 4840 60 4840 {}
C {lab_pin.sym} 60 4840 0 0 {name=l3844 lab=VDD}
N 40 4760 60 4760 {}
C {lab_pin.sym} 60 4760 0 0 {name=l3845 lab=VSS}
C {bitcell_6t.sym} 200 4800 0 0 {name=Xr24c1}
N 160 4840 140 4840 {}
C {lab_pin.sym} 140 4840 0 0 {name=l3846 lab=BL1}
N 160 4800 140 4800 {}
C {lab_pin.sym} 140 4800 0 0 {name=l3847 lab=BLB1}
N 160 4760 140 4760 {}
C {lab_pin.sym} 140 4760 0 0 {name=l3848 lab=WL24}
N 240 4840 260 4840 {}
C {lab_pin.sym} 260 4840 0 0 {name=l3849 lab=VDD}
N 240 4760 260 4760 {}
C {lab_pin.sym} 260 4760 0 0 {name=l3850 lab=VSS}
C {bitcell_6t.sym} 400 4800 0 0 {name=Xr24c2}
N 360 4840 340 4840 {}
C {lab_pin.sym} 340 4840 0 0 {name=l3851 lab=BL2}
N 360 4800 340 4800 {}
C {lab_pin.sym} 340 4800 0 0 {name=l3852 lab=BLB2}
N 360 4760 340 4760 {}
C {lab_pin.sym} 340 4760 0 0 {name=l3853 lab=WL24}
N 440 4840 460 4840 {}
C {lab_pin.sym} 460 4840 0 0 {name=l3854 lab=VDD}
N 440 4760 460 4760 {}
C {lab_pin.sym} 460 4760 0 0 {name=l3855 lab=VSS}
C {bitcell_6t.sym} 600 4800 0 0 {name=Xr24c3}
N 560 4840 540 4840 {}
C {lab_pin.sym} 540 4840 0 0 {name=l3856 lab=BL3}
N 560 4800 540 4800 {}
C {lab_pin.sym} 540 4800 0 0 {name=l3857 lab=BLB3}
N 560 4760 540 4760 {}
C {lab_pin.sym} 540 4760 0 0 {name=l3858 lab=WL24}
N 640 4840 660 4840 {}
C {lab_pin.sym} 660 4840 0 0 {name=l3859 lab=VDD}
N 640 4760 660 4760 {}
C {lab_pin.sym} 660 4760 0 0 {name=l3860 lab=VSS}
C {bitcell_6t.sym} 800 4800 0 0 {name=Xr24c4}
N 760 4840 740 4840 {}
C {lab_pin.sym} 740 4840 0 0 {name=l3861 lab=BL4}
N 760 4800 740 4800 {}
C {lab_pin.sym} 740 4800 0 0 {name=l3862 lab=BLB4}
N 760 4760 740 4760 {}
C {lab_pin.sym} 740 4760 0 0 {name=l3863 lab=WL24}
N 840 4840 860 4840 {}
C {lab_pin.sym} 860 4840 0 0 {name=l3864 lab=VDD}
N 840 4760 860 4760 {}
C {lab_pin.sym} 860 4760 0 0 {name=l3865 lab=VSS}
C {bitcell_6t.sym} 1000 4800 0 0 {name=Xr24c5}
N 960 4840 940 4840 {}
C {lab_pin.sym} 940 4840 0 0 {name=l3866 lab=BL5}
N 960 4800 940 4800 {}
C {lab_pin.sym} 940 4800 0 0 {name=l3867 lab=BLB5}
N 960 4760 940 4760 {}
C {lab_pin.sym} 940 4760 0 0 {name=l3868 lab=WL24}
N 1040 4840 1060 4840 {}
C {lab_pin.sym} 1060 4840 0 0 {name=l3869 lab=VDD}
N 1040 4760 1060 4760 {}
C {lab_pin.sym} 1060 4760 0 0 {name=l3870 lab=VSS}
C {bitcell_6t.sym} 1200 4800 0 0 {name=Xr24c6}
N 1160 4840 1140 4840 {}
C {lab_pin.sym} 1140 4840 0 0 {name=l3871 lab=BL6}
N 1160 4800 1140 4800 {}
C {lab_pin.sym} 1140 4800 0 0 {name=l3872 lab=BLB6}
N 1160 4760 1140 4760 {}
C {lab_pin.sym} 1140 4760 0 0 {name=l3873 lab=WL24}
N 1240 4840 1260 4840 {}
C {lab_pin.sym} 1260 4840 0 0 {name=l3874 lab=VDD}
N 1240 4760 1260 4760 {}
C {lab_pin.sym} 1260 4760 0 0 {name=l3875 lab=VSS}
C {bitcell_6t.sym} 1400 4800 0 0 {name=Xr24c7}
N 1360 4840 1340 4840 {}
C {lab_pin.sym} 1340 4840 0 0 {name=l3876 lab=BL7}
N 1360 4800 1340 4800 {}
C {lab_pin.sym} 1340 4800 0 0 {name=l3877 lab=BLB7}
N 1360 4760 1340 4760 {}
C {lab_pin.sym} 1340 4760 0 0 {name=l3878 lab=WL24}
N 1440 4840 1460 4840 {}
C {lab_pin.sym} 1460 4840 0 0 {name=l3879 lab=VDD}
N 1440 4760 1460 4760 {}
C {lab_pin.sym} 1460 4760 0 0 {name=l3880 lab=VSS}
C {bitcell_6t.sym} 1600 4800 0 0 {name=Xr24c8}
N 1560 4840 1540 4840 {}
C {lab_pin.sym} 1540 4840 0 0 {name=l3881 lab=BL8}
N 1560 4800 1540 4800 {}
C {lab_pin.sym} 1540 4800 0 0 {name=l3882 lab=BLB8}
N 1560 4760 1540 4760 {}
C {lab_pin.sym} 1540 4760 0 0 {name=l3883 lab=WL24}
N 1640 4840 1660 4840 {}
C {lab_pin.sym} 1660 4840 0 0 {name=l3884 lab=VDD}
N 1640 4760 1660 4760 {}
C {lab_pin.sym} 1660 4760 0 0 {name=l3885 lab=VSS}
C {bitcell_6t.sym} 1800 4800 0 0 {name=Xr24c9}
N 1760 4840 1740 4840 {}
C {lab_pin.sym} 1740 4840 0 0 {name=l3886 lab=BL9}
N 1760 4800 1740 4800 {}
C {lab_pin.sym} 1740 4800 0 0 {name=l3887 lab=BLB9}
N 1760 4760 1740 4760 {}
C {lab_pin.sym} 1740 4760 0 0 {name=l3888 lab=WL24}
N 1840 4840 1860 4840 {}
C {lab_pin.sym} 1860 4840 0 0 {name=l3889 lab=VDD}
N 1840 4760 1860 4760 {}
C {lab_pin.sym} 1860 4760 0 0 {name=l3890 lab=VSS}
C {bitcell_6t.sym} 2000 4800 0 0 {name=Xr24c10}
N 1960 4840 1940 4840 {}
C {lab_pin.sym} 1940 4840 0 0 {name=l3891 lab=BL10}
N 1960 4800 1940 4800 {}
C {lab_pin.sym} 1940 4800 0 0 {name=l3892 lab=BLB10}
N 1960 4760 1940 4760 {}
C {lab_pin.sym} 1940 4760 0 0 {name=l3893 lab=WL24}
N 2040 4840 2060 4840 {}
C {lab_pin.sym} 2060 4840 0 0 {name=l3894 lab=VDD}
N 2040 4760 2060 4760 {}
C {lab_pin.sym} 2060 4760 0 0 {name=l3895 lab=VSS}
C {bitcell_6t.sym} 2200 4800 0 0 {name=Xr24c11}
N 2160 4840 2140 4840 {}
C {lab_pin.sym} 2140 4840 0 0 {name=l3896 lab=BL11}
N 2160 4800 2140 4800 {}
C {lab_pin.sym} 2140 4800 0 0 {name=l3897 lab=BLB11}
N 2160 4760 2140 4760 {}
C {lab_pin.sym} 2140 4760 0 0 {name=l3898 lab=WL24}
N 2240 4840 2260 4840 {}
C {lab_pin.sym} 2260 4840 0 0 {name=l3899 lab=VDD}
N 2240 4760 2260 4760 {}
C {lab_pin.sym} 2260 4760 0 0 {name=l3900 lab=VSS}
C {bitcell_6t.sym} 2400 4800 0 0 {name=Xr24c12}
N 2360 4840 2340 4840 {}
C {lab_pin.sym} 2340 4840 0 0 {name=l3901 lab=BL12}
N 2360 4800 2340 4800 {}
C {lab_pin.sym} 2340 4800 0 0 {name=l3902 lab=BLB12}
N 2360 4760 2340 4760 {}
C {lab_pin.sym} 2340 4760 0 0 {name=l3903 lab=WL24}
N 2440 4840 2460 4840 {}
C {lab_pin.sym} 2460 4840 0 0 {name=l3904 lab=VDD}
N 2440 4760 2460 4760 {}
C {lab_pin.sym} 2460 4760 0 0 {name=l3905 lab=VSS}
C {bitcell_6t.sym} 2600 4800 0 0 {name=Xr24c13}
N 2560 4840 2540 4840 {}
C {lab_pin.sym} 2540 4840 0 0 {name=l3906 lab=BL13}
N 2560 4800 2540 4800 {}
C {lab_pin.sym} 2540 4800 0 0 {name=l3907 lab=BLB13}
N 2560 4760 2540 4760 {}
C {lab_pin.sym} 2540 4760 0 0 {name=l3908 lab=WL24}
N 2640 4840 2660 4840 {}
C {lab_pin.sym} 2660 4840 0 0 {name=l3909 lab=VDD}
N 2640 4760 2660 4760 {}
C {lab_pin.sym} 2660 4760 0 0 {name=l3910 lab=VSS}
C {bitcell_6t.sym} 2800 4800 0 0 {name=Xr24c14}
N 2760 4840 2740 4840 {}
C {lab_pin.sym} 2740 4840 0 0 {name=l3911 lab=BL14}
N 2760 4800 2740 4800 {}
C {lab_pin.sym} 2740 4800 0 0 {name=l3912 lab=BLB14}
N 2760 4760 2740 4760 {}
C {lab_pin.sym} 2740 4760 0 0 {name=l3913 lab=WL24}
N 2840 4840 2860 4840 {}
C {lab_pin.sym} 2860 4840 0 0 {name=l3914 lab=VDD}
N 2840 4760 2860 4760 {}
C {lab_pin.sym} 2860 4760 0 0 {name=l3915 lab=VSS}
C {bitcell_6t.sym} 3000 4800 0 0 {name=Xr24c15}
N 2960 4840 2940 4840 {}
C {lab_pin.sym} 2940 4840 0 0 {name=l3916 lab=BL15}
N 2960 4800 2940 4800 {}
C {lab_pin.sym} 2940 4800 0 0 {name=l3917 lab=BLB15}
N 2960 4760 2940 4760 {}
C {lab_pin.sym} 2940 4760 0 0 {name=l3918 lab=WL24}
N 3040 4840 3060 4840 {}
C {lab_pin.sym} 3060 4840 0 0 {name=l3919 lab=VDD}
N 3040 4760 3060 4760 {}
C {lab_pin.sym} 3060 4760 0 0 {name=l3920 lab=VSS}
C {bitcell_6t.sym} 3200 4800 0 0 {name=Xr24c16}
N 3160 4840 3140 4840 {}
C {lab_pin.sym} 3140 4840 0 0 {name=l3921 lab=BL16}
N 3160 4800 3140 4800 {}
C {lab_pin.sym} 3140 4800 0 0 {name=l3922 lab=BLB16}
N 3160 4760 3140 4760 {}
C {lab_pin.sym} 3140 4760 0 0 {name=l3923 lab=WL24}
N 3240 4840 3260 4840 {}
C {lab_pin.sym} 3260 4840 0 0 {name=l3924 lab=VDD}
N 3240 4760 3260 4760 {}
C {lab_pin.sym} 3260 4760 0 0 {name=l3925 lab=VSS}
C {bitcell_6t.sym} 3400 4800 0 0 {name=Xr24c17}
N 3360 4840 3340 4840 {}
C {lab_pin.sym} 3340 4840 0 0 {name=l3926 lab=BL17}
N 3360 4800 3340 4800 {}
C {lab_pin.sym} 3340 4800 0 0 {name=l3927 lab=BLB17}
N 3360 4760 3340 4760 {}
C {lab_pin.sym} 3340 4760 0 0 {name=l3928 lab=WL24}
N 3440 4840 3460 4840 {}
C {lab_pin.sym} 3460 4840 0 0 {name=l3929 lab=VDD}
N 3440 4760 3460 4760 {}
C {lab_pin.sym} 3460 4760 0 0 {name=l3930 lab=VSS}
C {bitcell_6t.sym} 3600 4800 0 0 {name=Xr24c18}
N 3560 4840 3540 4840 {}
C {lab_pin.sym} 3540 4840 0 0 {name=l3931 lab=BL18}
N 3560 4800 3540 4800 {}
C {lab_pin.sym} 3540 4800 0 0 {name=l3932 lab=BLB18}
N 3560 4760 3540 4760 {}
C {lab_pin.sym} 3540 4760 0 0 {name=l3933 lab=WL24}
N 3640 4840 3660 4840 {}
C {lab_pin.sym} 3660 4840 0 0 {name=l3934 lab=VDD}
N 3640 4760 3660 4760 {}
C {lab_pin.sym} 3660 4760 0 0 {name=l3935 lab=VSS}
C {bitcell_6t.sym} 3800 4800 0 0 {name=Xr24c19}
N 3760 4840 3740 4840 {}
C {lab_pin.sym} 3740 4840 0 0 {name=l3936 lab=BL19}
N 3760 4800 3740 4800 {}
C {lab_pin.sym} 3740 4800 0 0 {name=l3937 lab=BLB19}
N 3760 4760 3740 4760 {}
C {lab_pin.sym} 3740 4760 0 0 {name=l3938 lab=WL24}
N 3840 4840 3860 4840 {}
C {lab_pin.sym} 3860 4840 0 0 {name=l3939 lab=VDD}
N 3840 4760 3860 4760 {}
C {lab_pin.sym} 3860 4760 0 0 {name=l3940 lab=VSS}
C {bitcell_6t.sym} 4000 4800 0 0 {name=Xr24c20}
N 3960 4840 3940 4840 {}
C {lab_pin.sym} 3940 4840 0 0 {name=l3941 lab=BL20}
N 3960 4800 3940 4800 {}
C {lab_pin.sym} 3940 4800 0 0 {name=l3942 lab=BLB20}
N 3960 4760 3940 4760 {}
C {lab_pin.sym} 3940 4760 0 0 {name=l3943 lab=WL24}
N 4040 4840 4060 4840 {}
C {lab_pin.sym} 4060 4840 0 0 {name=l3944 lab=VDD}
N 4040 4760 4060 4760 {}
C {lab_pin.sym} 4060 4760 0 0 {name=l3945 lab=VSS}
C {bitcell_6t.sym} 4200 4800 0 0 {name=Xr24c21}
N 4160 4840 4140 4840 {}
C {lab_pin.sym} 4140 4840 0 0 {name=l3946 lab=BL21}
N 4160 4800 4140 4800 {}
C {lab_pin.sym} 4140 4800 0 0 {name=l3947 lab=BLB21}
N 4160 4760 4140 4760 {}
C {lab_pin.sym} 4140 4760 0 0 {name=l3948 lab=WL24}
N 4240 4840 4260 4840 {}
C {lab_pin.sym} 4260 4840 0 0 {name=l3949 lab=VDD}
N 4240 4760 4260 4760 {}
C {lab_pin.sym} 4260 4760 0 0 {name=l3950 lab=VSS}
C {bitcell_6t.sym} 4400 4800 0 0 {name=Xr24c22}
N 4360 4840 4340 4840 {}
C {lab_pin.sym} 4340 4840 0 0 {name=l3951 lab=BL22}
N 4360 4800 4340 4800 {}
C {lab_pin.sym} 4340 4800 0 0 {name=l3952 lab=BLB22}
N 4360 4760 4340 4760 {}
C {lab_pin.sym} 4340 4760 0 0 {name=l3953 lab=WL24}
N 4440 4840 4460 4840 {}
C {lab_pin.sym} 4460 4840 0 0 {name=l3954 lab=VDD}
N 4440 4760 4460 4760 {}
C {lab_pin.sym} 4460 4760 0 0 {name=l3955 lab=VSS}
C {bitcell_6t.sym} 4600 4800 0 0 {name=Xr24c23}
N 4560 4840 4540 4840 {}
C {lab_pin.sym} 4540 4840 0 0 {name=l3956 lab=BL23}
N 4560 4800 4540 4800 {}
C {lab_pin.sym} 4540 4800 0 0 {name=l3957 lab=BLB23}
N 4560 4760 4540 4760 {}
C {lab_pin.sym} 4540 4760 0 0 {name=l3958 lab=WL24}
N 4640 4840 4660 4840 {}
C {lab_pin.sym} 4660 4840 0 0 {name=l3959 lab=VDD}
N 4640 4760 4660 4760 {}
C {lab_pin.sym} 4660 4760 0 0 {name=l3960 lab=VSS}
C {bitcell_6t.sym} 4800 4800 0 0 {name=Xr24c24}
N 4760 4840 4740 4840 {}
C {lab_pin.sym} 4740 4840 0 0 {name=l3961 lab=BL24}
N 4760 4800 4740 4800 {}
C {lab_pin.sym} 4740 4800 0 0 {name=l3962 lab=BLB24}
N 4760 4760 4740 4760 {}
C {lab_pin.sym} 4740 4760 0 0 {name=l3963 lab=WL24}
N 4840 4840 4860 4840 {}
C {lab_pin.sym} 4860 4840 0 0 {name=l3964 lab=VDD}
N 4840 4760 4860 4760 {}
C {lab_pin.sym} 4860 4760 0 0 {name=l3965 lab=VSS}
C {bitcell_6t.sym} 5000 4800 0 0 {name=Xr24c25}
N 4960 4840 4940 4840 {}
C {lab_pin.sym} 4940 4840 0 0 {name=l3966 lab=BL25}
N 4960 4800 4940 4800 {}
C {lab_pin.sym} 4940 4800 0 0 {name=l3967 lab=BLB25}
N 4960 4760 4940 4760 {}
C {lab_pin.sym} 4940 4760 0 0 {name=l3968 lab=WL24}
N 5040 4840 5060 4840 {}
C {lab_pin.sym} 5060 4840 0 0 {name=l3969 lab=VDD}
N 5040 4760 5060 4760 {}
C {lab_pin.sym} 5060 4760 0 0 {name=l3970 lab=VSS}
C {bitcell_6t.sym} 5200 4800 0 0 {name=Xr24c26}
N 5160 4840 5140 4840 {}
C {lab_pin.sym} 5140 4840 0 0 {name=l3971 lab=BL26}
N 5160 4800 5140 4800 {}
C {lab_pin.sym} 5140 4800 0 0 {name=l3972 lab=BLB26}
N 5160 4760 5140 4760 {}
C {lab_pin.sym} 5140 4760 0 0 {name=l3973 lab=WL24}
N 5240 4840 5260 4840 {}
C {lab_pin.sym} 5260 4840 0 0 {name=l3974 lab=VDD}
N 5240 4760 5260 4760 {}
C {lab_pin.sym} 5260 4760 0 0 {name=l3975 lab=VSS}
C {bitcell_6t.sym} 5400 4800 0 0 {name=Xr24c27}
N 5360 4840 5340 4840 {}
C {lab_pin.sym} 5340 4840 0 0 {name=l3976 lab=BL27}
N 5360 4800 5340 4800 {}
C {lab_pin.sym} 5340 4800 0 0 {name=l3977 lab=BLB27}
N 5360 4760 5340 4760 {}
C {lab_pin.sym} 5340 4760 0 0 {name=l3978 lab=WL24}
N 5440 4840 5460 4840 {}
C {lab_pin.sym} 5460 4840 0 0 {name=l3979 lab=VDD}
N 5440 4760 5460 4760 {}
C {lab_pin.sym} 5460 4760 0 0 {name=l3980 lab=VSS}
C {bitcell_6t.sym} 5600 4800 0 0 {name=Xr24c28}
N 5560 4840 5540 4840 {}
C {lab_pin.sym} 5540 4840 0 0 {name=l3981 lab=BL28}
N 5560 4800 5540 4800 {}
C {lab_pin.sym} 5540 4800 0 0 {name=l3982 lab=BLB28}
N 5560 4760 5540 4760 {}
C {lab_pin.sym} 5540 4760 0 0 {name=l3983 lab=WL24}
N 5640 4840 5660 4840 {}
C {lab_pin.sym} 5660 4840 0 0 {name=l3984 lab=VDD}
N 5640 4760 5660 4760 {}
C {lab_pin.sym} 5660 4760 0 0 {name=l3985 lab=VSS}
C {bitcell_6t.sym} 5800 4800 0 0 {name=Xr24c29}
N 5760 4840 5740 4840 {}
C {lab_pin.sym} 5740 4840 0 0 {name=l3986 lab=BL29}
N 5760 4800 5740 4800 {}
C {lab_pin.sym} 5740 4800 0 0 {name=l3987 lab=BLB29}
N 5760 4760 5740 4760 {}
C {lab_pin.sym} 5740 4760 0 0 {name=l3988 lab=WL24}
N 5840 4840 5860 4840 {}
C {lab_pin.sym} 5860 4840 0 0 {name=l3989 lab=VDD}
N 5840 4760 5860 4760 {}
C {lab_pin.sym} 5860 4760 0 0 {name=l3990 lab=VSS}
C {bitcell_6t.sym} 6000 4800 0 0 {name=Xr24c30}
N 5960 4840 5940 4840 {}
C {lab_pin.sym} 5940 4840 0 0 {name=l3991 lab=BL30}
N 5960 4800 5940 4800 {}
C {lab_pin.sym} 5940 4800 0 0 {name=l3992 lab=BLB30}
N 5960 4760 5940 4760 {}
C {lab_pin.sym} 5940 4760 0 0 {name=l3993 lab=WL24}
N 6040 4840 6060 4840 {}
C {lab_pin.sym} 6060 4840 0 0 {name=l3994 lab=VDD}
N 6040 4760 6060 4760 {}
C {lab_pin.sym} 6060 4760 0 0 {name=l3995 lab=VSS}
C {bitcell_6t.sym} 6200 4800 0 0 {name=Xr24c31}
N 6160 4840 6140 4840 {}
C {lab_pin.sym} 6140 4840 0 0 {name=l3996 lab=BL31}
N 6160 4800 6140 4800 {}
C {lab_pin.sym} 6140 4800 0 0 {name=l3997 lab=BLB31}
N 6160 4760 6140 4760 {}
C {lab_pin.sym} 6140 4760 0 0 {name=l3998 lab=WL24}
N 6240 4840 6260 4840 {}
C {lab_pin.sym} 6260 4840 0 0 {name=l3999 lab=VDD}
N 6240 4760 6260 4760 {}
C {lab_pin.sym} 6260 4760 0 0 {name=l4000 lab=VSS}
C {bitcell_6t.sym} 0 5000 0 0 {name=Xr25c0}
N -40 5040 -60 5040 {}
C {lab_pin.sym} -60 5040 0 0 {name=l4001 lab=BL0}
N -40 5000 -60 5000 {}
C {lab_pin.sym} -60 5000 0 0 {name=l4002 lab=BLB0}
N -40 4960 -60 4960 {}
C {lab_pin.sym} -60 4960 0 0 {name=l4003 lab=WL25}
N 40 5040 60 5040 {}
C {lab_pin.sym} 60 5040 0 0 {name=l4004 lab=VDD}
N 40 4960 60 4960 {}
C {lab_pin.sym} 60 4960 0 0 {name=l4005 lab=VSS}
C {bitcell_6t.sym} 200 5000 0 0 {name=Xr25c1}
N 160 5040 140 5040 {}
C {lab_pin.sym} 140 5040 0 0 {name=l4006 lab=BL1}
N 160 5000 140 5000 {}
C {lab_pin.sym} 140 5000 0 0 {name=l4007 lab=BLB1}
N 160 4960 140 4960 {}
C {lab_pin.sym} 140 4960 0 0 {name=l4008 lab=WL25}
N 240 5040 260 5040 {}
C {lab_pin.sym} 260 5040 0 0 {name=l4009 lab=VDD}
N 240 4960 260 4960 {}
C {lab_pin.sym} 260 4960 0 0 {name=l4010 lab=VSS}
C {bitcell_6t.sym} 400 5000 0 0 {name=Xr25c2}
N 360 5040 340 5040 {}
C {lab_pin.sym} 340 5040 0 0 {name=l4011 lab=BL2}
N 360 5000 340 5000 {}
C {lab_pin.sym} 340 5000 0 0 {name=l4012 lab=BLB2}
N 360 4960 340 4960 {}
C {lab_pin.sym} 340 4960 0 0 {name=l4013 lab=WL25}
N 440 5040 460 5040 {}
C {lab_pin.sym} 460 5040 0 0 {name=l4014 lab=VDD}
N 440 4960 460 4960 {}
C {lab_pin.sym} 460 4960 0 0 {name=l4015 lab=VSS}
C {bitcell_6t.sym} 600 5000 0 0 {name=Xr25c3}
N 560 5040 540 5040 {}
C {lab_pin.sym} 540 5040 0 0 {name=l4016 lab=BL3}
N 560 5000 540 5000 {}
C {lab_pin.sym} 540 5000 0 0 {name=l4017 lab=BLB3}
N 560 4960 540 4960 {}
C {lab_pin.sym} 540 4960 0 0 {name=l4018 lab=WL25}
N 640 5040 660 5040 {}
C {lab_pin.sym} 660 5040 0 0 {name=l4019 lab=VDD}
N 640 4960 660 4960 {}
C {lab_pin.sym} 660 4960 0 0 {name=l4020 lab=VSS}
C {bitcell_6t.sym} 800 5000 0 0 {name=Xr25c4}
N 760 5040 740 5040 {}
C {lab_pin.sym} 740 5040 0 0 {name=l4021 lab=BL4}
N 760 5000 740 5000 {}
C {lab_pin.sym} 740 5000 0 0 {name=l4022 lab=BLB4}
N 760 4960 740 4960 {}
C {lab_pin.sym} 740 4960 0 0 {name=l4023 lab=WL25}
N 840 5040 860 5040 {}
C {lab_pin.sym} 860 5040 0 0 {name=l4024 lab=VDD}
N 840 4960 860 4960 {}
C {lab_pin.sym} 860 4960 0 0 {name=l4025 lab=VSS}
C {bitcell_6t.sym} 1000 5000 0 0 {name=Xr25c5}
N 960 5040 940 5040 {}
C {lab_pin.sym} 940 5040 0 0 {name=l4026 lab=BL5}
N 960 5000 940 5000 {}
C {lab_pin.sym} 940 5000 0 0 {name=l4027 lab=BLB5}
N 960 4960 940 4960 {}
C {lab_pin.sym} 940 4960 0 0 {name=l4028 lab=WL25}
N 1040 5040 1060 5040 {}
C {lab_pin.sym} 1060 5040 0 0 {name=l4029 lab=VDD}
N 1040 4960 1060 4960 {}
C {lab_pin.sym} 1060 4960 0 0 {name=l4030 lab=VSS}
C {bitcell_6t.sym} 1200 5000 0 0 {name=Xr25c6}
N 1160 5040 1140 5040 {}
C {lab_pin.sym} 1140 5040 0 0 {name=l4031 lab=BL6}
N 1160 5000 1140 5000 {}
C {lab_pin.sym} 1140 5000 0 0 {name=l4032 lab=BLB6}
N 1160 4960 1140 4960 {}
C {lab_pin.sym} 1140 4960 0 0 {name=l4033 lab=WL25}
N 1240 5040 1260 5040 {}
C {lab_pin.sym} 1260 5040 0 0 {name=l4034 lab=VDD}
N 1240 4960 1260 4960 {}
C {lab_pin.sym} 1260 4960 0 0 {name=l4035 lab=VSS}
C {bitcell_6t.sym} 1400 5000 0 0 {name=Xr25c7}
N 1360 5040 1340 5040 {}
C {lab_pin.sym} 1340 5040 0 0 {name=l4036 lab=BL7}
N 1360 5000 1340 5000 {}
C {lab_pin.sym} 1340 5000 0 0 {name=l4037 lab=BLB7}
N 1360 4960 1340 4960 {}
C {lab_pin.sym} 1340 4960 0 0 {name=l4038 lab=WL25}
N 1440 5040 1460 5040 {}
C {lab_pin.sym} 1460 5040 0 0 {name=l4039 lab=VDD}
N 1440 4960 1460 4960 {}
C {lab_pin.sym} 1460 4960 0 0 {name=l4040 lab=VSS}
C {bitcell_6t.sym} 1600 5000 0 0 {name=Xr25c8}
N 1560 5040 1540 5040 {}
C {lab_pin.sym} 1540 5040 0 0 {name=l4041 lab=BL8}
N 1560 5000 1540 5000 {}
C {lab_pin.sym} 1540 5000 0 0 {name=l4042 lab=BLB8}
N 1560 4960 1540 4960 {}
C {lab_pin.sym} 1540 4960 0 0 {name=l4043 lab=WL25}
N 1640 5040 1660 5040 {}
C {lab_pin.sym} 1660 5040 0 0 {name=l4044 lab=VDD}
N 1640 4960 1660 4960 {}
C {lab_pin.sym} 1660 4960 0 0 {name=l4045 lab=VSS}
C {bitcell_6t.sym} 1800 5000 0 0 {name=Xr25c9}
N 1760 5040 1740 5040 {}
C {lab_pin.sym} 1740 5040 0 0 {name=l4046 lab=BL9}
N 1760 5000 1740 5000 {}
C {lab_pin.sym} 1740 5000 0 0 {name=l4047 lab=BLB9}
N 1760 4960 1740 4960 {}
C {lab_pin.sym} 1740 4960 0 0 {name=l4048 lab=WL25}
N 1840 5040 1860 5040 {}
C {lab_pin.sym} 1860 5040 0 0 {name=l4049 lab=VDD}
N 1840 4960 1860 4960 {}
C {lab_pin.sym} 1860 4960 0 0 {name=l4050 lab=VSS}
C {bitcell_6t.sym} 2000 5000 0 0 {name=Xr25c10}
N 1960 5040 1940 5040 {}
C {lab_pin.sym} 1940 5040 0 0 {name=l4051 lab=BL10}
N 1960 5000 1940 5000 {}
C {lab_pin.sym} 1940 5000 0 0 {name=l4052 lab=BLB10}
N 1960 4960 1940 4960 {}
C {lab_pin.sym} 1940 4960 0 0 {name=l4053 lab=WL25}
N 2040 5040 2060 5040 {}
C {lab_pin.sym} 2060 5040 0 0 {name=l4054 lab=VDD}
N 2040 4960 2060 4960 {}
C {lab_pin.sym} 2060 4960 0 0 {name=l4055 lab=VSS}
C {bitcell_6t.sym} 2200 5000 0 0 {name=Xr25c11}
N 2160 5040 2140 5040 {}
C {lab_pin.sym} 2140 5040 0 0 {name=l4056 lab=BL11}
N 2160 5000 2140 5000 {}
C {lab_pin.sym} 2140 5000 0 0 {name=l4057 lab=BLB11}
N 2160 4960 2140 4960 {}
C {lab_pin.sym} 2140 4960 0 0 {name=l4058 lab=WL25}
N 2240 5040 2260 5040 {}
C {lab_pin.sym} 2260 5040 0 0 {name=l4059 lab=VDD}
N 2240 4960 2260 4960 {}
C {lab_pin.sym} 2260 4960 0 0 {name=l4060 lab=VSS}
C {bitcell_6t.sym} 2400 5000 0 0 {name=Xr25c12}
N 2360 5040 2340 5040 {}
C {lab_pin.sym} 2340 5040 0 0 {name=l4061 lab=BL12}
N 2360 5000 2340 5000 {}
C {lab_pin.sym} 2340 5000 0 0 {name=l4062 lab=BLB12}
N 2360 4960 2340 4960 {}
C {lab_pin.sym} 2340 4960 0 0 {name=l4063 lab=WL25}
N 2440 5040 2460 5040 {}
C {lab_pin.sym} 2460 5040 0 0 {name=l4064 lab=VDD}
N 2440 4960 2460 4960 {}
C {lab_pin.sym} 2460 4960 0 0 {name=l4065 lab=VSS}
C {bitcell_6t.sym} 2600 5000 0 0 {name=Xr25c13}
N 2560 5040 2540 5040 {}
C {lab_pin.sym} 2540 5040 0 0 {name=l4066 lab=BL13}
N 2560 5000 2540 5000 {}
C {lab_pin.sym} 2540 5000 0 0 {name=l4067 lab=BLB13}
N 2560 4960 2540 4960 {}
C {lab_pin.sym} 2540 4960 0 0 {name=l4068 lab=WL25}
N 2640 5040 2660 5040 {}
C {lab_pin.sym} 2660 5040 0 0 {name=l4069 lab=VDD}
N 2640 4960 2660 4960 {}
C {lab_pin.sym} 2660 4960 0 0 {name=l4070 lab=VSS}
C {bitcell_6t.sym} 2800 5000 0 0 {name=Xr25c14}
N 2760 5040 2740 5040 {}
C {lab_pin.sym} 2740 5040 0 0 {name=l4071 lab=BL14}
N 2760 5000 2740 5000 {}
C {lab_pin.sym} 2740 5000 0 0 {name=l4072 lab=BLB14}
N 2760 4960 2740 4960 {}
C {lab_pin.sym} 2740 4960 0 0 {name=l4073 lab=WL25}
N 2840 5040 2860 5040 {}
C {lab_pin.sym} 2860 5040 0 0 {name=l4074 lab=VDD}
N 2840 4960 2860 4960 {}
C {lab_pin.sym} 2860 4960 0 0 {name=l4075 lab=VSS}
C {bitcell_6t.sym} 3000 5000 0 0 {name=Xr25c15}
N 2960 5040 2940 5040 {}
C {lab_pin.sym} 2940 5040 0 0 {name=l4076 lab=BL15}
N 2960 5000 2940 5000 {}
C {lab_pin.sym} 2940 5000 0 0 {name=l4077 lab=BLB15}
N 2960 4960 2940 4960 {}
C {lab_pin.sym} 2940 4960 0 0 {name=l4078 lab=WL25}
N 3040 5040 3060 5040 {}
C {lab_pin.sym} 3060 5040 0 0 {name=l4079 lab=VDD}
N 3040 4960 3060 4960 {}
C {lab_pin.sym} 3060 4960 0 0 {name=l4080 lab=VSS}
C {bitcell_6t.sym} 3200 5000 0 0 {name=Xr25c16}
N 3160 5040 3140 5040 {}
C {lab_pin.sym} 3140 5040 0 0 {name=l4081 lab=BL16}
N 3160 5000 3140 5000 {}
C {lab_pin.sym} 3140 5000 0 0 {name=l4082 lab=BLB16}
N 3160 4960 3140 4960 {}
C {lab_pin.sym} 3140 4960 0 0 {name=l4083 lab=WL25}
N 3240 5040 3260 5040 {}
C {lab_pin.sym} 3260 5040 0 0 {name=l4084 lab=VDD}
N 3240 4960 3260 4960 {}
C {lab_pin.sym} 3260 4960 0 0 {name=l4085 lab=VSS}
C {bitcell_6t.sym} 3400 5000 0 0 {name=Xr25c17}
N 3360 5040 3340 5040 {}
C {lab_pin.sym} 3340 5040 0 0 {name=l4086 lab=BL17}
N 3360 5000 3340 5000 {}
C {lab_pin.sym} 3340 5000 0 0 {name=l4087 lab=BLB17}
N 3360 4960 3340 4960 {}
C {lab_pin.sym} 3340 4960 0 0 {name=l4088 lab=WL25}
N 3440 5040 3460 5040 {}
C {lab_pin.sym} 3460 5040 0 0 {name=l4089 lab=VDD}
N 3440 4960 3460 4960 {}
C {lab_pin.sym} 3460 4960 0 0 {name=l4090 lab=VSS}
C {bitcell_6t.sym} 3600 5000 0 0 {name=Xr25c18}
N 3560 5040 3540 5040 {}
C {lab_pin.sym} 3540 5040 0 0 {name=l4091 lab=BL18}
N 3560 5000 3540 5000 {}
C {lab_pin.sym} 3540 5000 0 0 {name=l4092 lab=BLB18}
N 3560 4960 3540 4960 {}
C {lab_pin.sym} 3540 4960 0 0 {name=l4093 lab=WL25}
N 3640 5040 3660 5040 {}
C {lab_pin.sym} 3660 5040 0 0 {name=l4094 lab=VDD}
N 3640 4960 3660 4960 {}
C {lab_pin.sym} 3660 4960 0 0 {name=l4095 lab=VSS}
C {bitcell_6t.sym} 3800 5000 0 0 {name=Xr25c19}
N 3760 5040 3740 5040 {}
C {lab_pin.sym} 3740 5040 0 0 {name=l4096 lab=BL19}
N 3760 5000 3740 5000 {}
C {lab_pin.sym} 3740 5000 0 0 {name=l4097 lab=BLB19}
N 3760 4960 3740 4960 {}
C {lab_pin.sym} 3740 4960 0 0 {name=l4098 lab=WL25}
N 3840 5040 3860 5040 {}
C {lab_pin.sym} 3860 5040 0 0 {name=l4099 lab=VDD}
N 3840 4960 3860 4960 {}
C {lab_pin.sym} 3860 4960 0 0 {name=l4100 lab=VSS}
C {bitcell_6t.sym} 4000 5000 0 0 {name=Xr25c20}
N 3960 5040 3940 5040 {}
C {lab_pin.sym} 3940 5040 0 0 {name=l4101 lab=BL20}
N 3960 5000 3940 5000 {}
C {lab_pin.sym} 3940 5000 0 0 {name=l4102 lab=BLB20}
N 3960 4960 3940 4960 {}
C {lab_pin.sym} 3940 4960 0 0 {name=l4103 lab=WL25}
N 4040 5040 4060 5040 {}
C {lab_pin.sym} 4060 5040 0 0 {name=l4104 lab=VDD}
N 4040 4960 4060 4960 {}
C {lab_pin.sym} 4060 4960 0 0 {name=l4105 lab=VSS}
C {bitcell_6t.sym} 4200 5000 0 0 {name=Xr25c21}
N 4160 5040 4140 5040 {}
C {lab_pin.sym} 4140 5040 0 0 {name=l4106 lab=BL21}
N 4160 5000 4140 5000 {}
C {lab_pin.sym} 4140 5000 0 0 {name=l4107 lab=BLB21}
N 4160 4960 4140 4960 {}
C {lab_pin.sym} 4140 4960 0 0 {name=l4108 lab=WL25}
N 4240 5040 4260 5040 {}
C {lab_pin.sym} 4260 5040 0 0 {name=l4109 lab=VDD}
N 4240 4960 4260 4960 {}
C {lab_pin.sym} 4260 4960 0 0 {name=l4110 lab=VSS}
C {bitcell_6t.sym} 4400 5000 0 0 {name=Xr25c22}
N 4360 5040 4340 5040 {}
C {lab_pin.sym} 4340 5040 0 0 {name=l4111 lab=BL22}
N 4360 5000 4340 5000 {}
C {lab_pin.sym} 4340 5000 0 0 {name=l4112 lab=BLB22}
N 4360 4960 4340 4960 {}
C {lab_pin.sym} 4340 4960 0 0 {name=l4113 lab=WL25}
N 4440 5040 4460 5040 {}
C {lab_pin.sym} 4460 5040 0 0 {name=l4114 lab=VDD}
N 4440 4960 4460 4960 {}
C {lab_pin.sym} 4460 4960 0 0 {name=l4115 lab=VSS}
C {bitcell_6t.sym} 4600 5000 0 0 {name=Xr25c23}
N 4560 5040 4540 5040 {}
C {lab_pin.sym} 4540 5040 0 0 {name=l4116 lab=BL23}
N 4560 5000 4540 5000 {}
C {lab_pin.sym} 4540 5000 0 0 {name=l4117 lab=BLB23}
N 4560 4960 4540 4960 {}
C {lab_pin.sym} 4540 4960 0 0 {name=l4118 lab=WL25}
N 4640 5040 4660 5040 {}
C {lab_pin.sym} 4660 5040 0 0 {name=l4119 lab=VDD}
N 4640 4960 4660 4960 {}
C {lab_pin.sym} 4660 4960 0 0 {name=l4120 lab=VSS}
C {bitcell_6t.sym} 4800 5000 0 0 {name=Xr25c24}
N 4760 5040 4740 5040 {}
C {lab_pin.sym} 4740 5040 0 0 {name=l4121 lab=BL24}
N 4760 5000 4740 5000 {}
C {lab_pin.sym} 4740 5000 0 0 {name=l4122 lab=BLB24}
N 4760 4960 4740 4960 {}
C {lab_pin.sym} 4740 4960 0 0 {name=l4123 lab=WL25}
N 4840 5040 4860 5040 {}
C {lab_pin.sym} 4860 5040 0 0 {name=l4124 lab=VDD}
N 4840 4960 4860 4960 {}
C {lab_pin.sym} 4860 4960 0 0 {name=l4125 lab=VSS}
C {bitcell_6t.sym} 5000 5000 0 0 {name=Xr25c25}
N 4960 5040 4940 5040 {}
C {lab_pin.sym} 4940 5040 0 0 {name=l4126 lab=BL25}
N 4960 5000 4940 5000 {}
C {lab_pin.sym} 4940 5000 0 0 {name=l4127 lab=BLB25}
N 4960 4960 4940 4960 {}
C {lab_pin.sym} 4940 4960 0 0 {name=l4128 lab=WL25}
N 5040 5040 5060 5040 {}
C {lab_pin.sym} 5060 5040 0 0 {name=l4129 lab=VDD}
N 5040 4960 5060 4960 {}
C {lab_pin.sym} 5060 4960 0 0 {name=l4130 lab=VSS}
C {bitcell_6t.sym} 5200 5000 0 0 {name=Xr25c26}
N 5160 5040 5140 5040 {}
C {lab_pin.sym} 5140 5040 0 0 {name=l4131 lab=BL26}
N 5160 5000 5140 5000 {}
C {lab_pin.sym} 5140 5000 0 0 {name=l4132 lab=BLB26}
N 5160 4960 5140 4960 {}
C {lab_pin.sym} 5140 4960 0 0 {name=l4133 lab=WL25}
N 5240 5040 5260 5040 {}
C {lab_pin.sym} 5260 5040 0 0 {name=l4134 lab=VDD}
N 5240 4960 5260 4960 {}
C {lab_pin.sym} 5260 4960 0 0 {name=l4135 lab=VSS}
C {bitcell_6t.sym} 5400 5000 0 0 {name=Xr25c27}
N 5360 5040 5340 5040 {}
C {lab_pin.sym} 5340 5040 0 0 {name=l4136 lab=BL27}
N 5360 5000 5340 5000 {}
C {lab_pin.sym} 5340 5000 0 0 {name=l4137 lab=BLB27}
N 5360 4960 5340 4960 {}
C {lab_pin.sym} 5340 4960 0 0 {name=l4138 lab=WL25}
N 5440 5040 5460 5040 {}
C {lab_pin.sym} 5460 5040 0 0 {name=l4139 lab=VDD}
N 5440 4960 5460 4960 {}
C {lab_pin.sym} 5460 4960 0 0 {name=l4140 lab=VSS}
C {bitcell_6t.sym} 5600 5000 0 0 {name=Xr25c28}
N 5560 5040 5540 5040 {}
C {lab_pin.sym} 5540 5040 0 0 {name=l4141 lab=BL28}
N 5560 5000 5540 5000 {}
C {lab_pin.sym} 5540 5000 0 0 {name=l4142 lab=BLB28}
N 5560 4960 5540 4960 {}
C {lab_pin.sym} 5540 4960 0 0 {name=l4143 lab=WL25}
N 5640 5040 5660 5040 {}
C {lab_pin.sym} 5660 5040 0 0 {name=l4144 lab=VDD}
N 5640 4960 5660 4960 {}
C {lab_pin.sym} 5660 4960 0 0 {name=l4145 lab=VSS}
C {bitcell_6t.sym} 5800 5000 0 0 {name=Xr25c29}
N 5760 5040 5740 5040 {}
C {lab_pin.sym} 5740 5040 0 0 {name=l4146 lab=BL29}
N 5760 5000 5740 5000 {}
C {lab_pin.sym} 5740 5000 0 0 {name=l4147 lab=BLB29}
N 5760 4960 5740 4960 {}
C {lab_pin.sym} 5740 4960 0 0 {name=l4148 lab=WL25}
N 5840 5040 5860 5040 {}
C {lab_pin.sym} 5860 5040 0 0 {name=l4149 lab=VDD}
N 5840 4960 5860 4960 {}
C {lab_pin.sym} 5860 4960 0 0 {name=l4150 lab=VSS}
C {bitcell_6t.sym} 6000 5000 0 0 {name=Xr25c30}
N 5960 5040 5940 5040 {}
C {lab_pin.sym} 5940 5040 0 0 {name=l4151 lab=BL30}
N 5960 5000 5940 5000 {}
C {lab_pin.sym} 5940 5000 0 0 {name=l4152 lab=BLB30}
N 5960 4960 5940 4960 {}
C {lab_pin.sym} 5940 4960 0 0 {name=l4153 lab=WL25}
N 6040 5040 6060 5040 {}
C {lab_pin.sym} 6060 5040 0 0 {name=l4154 lab=VDD}
N 6040 4960 6060 4960 {}
C {lab_pin.sym} 6060 4960 0 0 {name=l4155 lab=VSS}
C {bitcell_6t.sym} 6200 5000 0 0 {name=Xr25c31}
N 6160 5040 6140 5040 {}
C {lab_pin.sym} 6140 5040 0 0 {name=l4156 lab=BL31}
N 6160 5000 6140 5000 {}
C {lab_pin.sym} 6140 5000 0 0 {name=l4157 lab=BLB31}
N 6160 4960 6140 4960 {}
C {lab_pin.sym} 6140 4960 0 0 {name=l4158 lab=WL25}
N 6240 5040 6260 5040 {}
C {lab_pin.sym} 6260 5040 0 0 {name=l4159 lab=VDD}
N 6240 4960 6260 4960 {}
C {lab_pin.sym} 6260 4960 0 0 {name=l4160 lab=VSS}
C {bitcell_6t.sym} 0 5200 0 0 {name=Xr26c0}
N -40 5240 -60 5240 {}
C {lab_pin.sym} -60 5240 0 0 {name=l4161 lab=BL0}
N -40 5200 -60 5200 {}
C {lab_pin.sym} -60 5200 0 0 {name=l4162 lab=BLB0}
N -40 5160 -60 5160 {}
C {lab_pin.sym} -60 5160 0 0 {name=l4163 lab=WL26}
N 40 5240 60 5240 {}
C {lab_pin.sym} 60 5240 0 0 {name=l4164 lab=VDD}
N 40 5160 60 5160 {}
C {lab_pin.sym} 60 5160 0 0 {name=l4165 lab=VSS}
C {bitcell_6t.sym} 200 5200 0 0 {name=Xr26c1}
N 160 5240 140 5240 {}
C {lab_pin.sym} 140 5240 0 0 {name=l4166 lab=BL1}
N 160 5200 140 5200 {}
C {lab_pin.sym} 140 5200 0 0 {name=l4167 lab=BLB1}
N 160 5160 140 5160 {}
C {lab_pin.sym} 140 5160 0 0 {name=l4168 lab=WL26}
N 240 5240 260 5240 {}
C {lab_pin.sym} 260 5240 0 0 {name=l4169 lab=VDD}
N 240 5160 260 5160 {}
C {lab_pin.sym} 260 5160 0 0 {name=l4170 lab=VSS}
C {bitcell_6t.sym} 400 5200 0 0 {name=Xr26c2}
N 360 5240 340 5240 {}
C {lab_pin.sym} 340 5240 0 0 {name=l4171 lab=BL2}
N 360 5200 340 5200 {}
C {lab_pin.sym} 340 5200 0 0 {name=l4172 lab=BLB2}
N 360 5160 340 5160 {}
C {lab_pin.sym} 340 5160 0 0 {name=l4173 lab=WL26}
N 440 5240 460 5240 {}
C {lab_pin.sym} 460 5240 0 0 {name=l4174 lab=VDD}
N 440 5160 460 5160 {}
C {lab_pin.sym} 460 5160 0 0 {name=l4175 lab=VSS}
C {bitcell_6t.sym} 600 5200 0 0 {name=Xr26c3}
N 560 5240 540 5240 {}
C {lab_pin.sym} 540 5240 0 0 {name=l4176 lab=BL3}
N 560 5200 540 5200 {}
C {lab_pin.sym} 540 5200 0 0 {name=l4177 lab=BLB3}
N 560 5160 540 5160 {}
C {lab_pin.sym} 540 5160 0 0 {name=l4178 lab=WL26}
N 640 5240 660 5240 {}
C {lab_pin.sym} 660 5240 0 0 {name=l4179 lab=VDD}
N 640 5160 660 5160 {}
C {lab_pin.sym} 660 5160 0 0 {name=l4180 lab=VSS}
C {bitcell_6t.sym} 800 5200 0 0 {name=Xr26c4}
N 760 5240 740 5240 {}
C {lab_pin.sym} 740 5240 0 0 {name=l4181 lab=BL4}
N 760 5200 740 5200 {}
C {lab_pin.sym} 740 5200 0 0 {name=l4182 lab=BLB4}
N 760 5160 740 5160 {}
C {lab_pin.sym} 740 5160 0 0 {name=l4183 lab=WL26}
N 840 5240 860 5240 {}
C {lab_pin.sym} 860 5240 0 0 {name=l4184 lab=VDD}
N 840 5160 860 5160 {}
C {lab_pin.sym} 860 5160 0 0 {name=l4185 lab=VSS}
C {bitcell_6t.sym} 1000 5200 0 0 {name=Xr26c5}
N 960 5240 940 5240 {}
C {lab_pin.sym} 940 5240 0 0 {name=l4186 lab=BL5}
N 960 5200 940 5200 {}
C {lab_pin.sym} 940 5200 0 0 {name=l4187 lab=BLB5}
N 960 5160 940 5160 {}
C {lab_pin.sym} 940 5160 0 0 {name=l4188 lab=WL26}
N 1040 5240 1060 5240 {}
C {lab_pin.sym} 1060 5240 0 0 {name=l4189 lab=VDD}
N 1040 5160 1060 5160 {}
C {lab_pin.sym} 1060 5160 0 0 {name=l4190 lab=VSS}
C {bitcell_6t.sym} 1200 5200 0 0 {name=Xr26c6}
N 1160 5240 1140 5240 {}
C {lab_pin.sym} 1140 5240 0 0 {name=l4191 lab=BL6}
N 1160 5200 1140 5200 {}
C {lab_pin.sym} 1140 5200 0 0 {name=l4192 lab=BLB6}
N 1160 5160 1140 5160 {}
C {lab_pin.sym} 1140 5160 0 0 {name=l4193 lab=WL26}
N 1240 5240 1260 5240 {}
C {lab_pin.sym} 1260 5240 0 0 {name=l4194 lab=VDD}
N 1240 5160 1260 5160 {}
C {lab_pin.sym} 1260 5160 0 0 {name=l4195 lab=VSS}
C {bitcell_6t.sym} 1400 5200 0 0 {name=Xr26c7}
N 1360 5240 1340 5240 {}
C {lab_pin.sym} 1340 5240 0 0 {name=l4196 lab=BL7}
N 1360 5200 1340 5200 {}
C {lab_pin.sym} 1340 5200 0 0 {name=l4197 lab=BLB7}
N 1360 5160 1340 5160 {}
C {lab_pin.sym} 1340 5160 0 0 {name=l4198 lab=WL26}
N 1440 5240 1460 5240 {}
C {lab_pin.sym} 1460 5240 0 0 {name=l4199 lab=VDD}
N 1440 5160 1460 5160 {}
C {lab_pin.sym} 1460 5160 0 0 {name=l4200 lab=VSS}
C {bitcell_6t.sym} 1600 5200 0 0 {name=Xr26c8}
N 1560 5240 1540 5240 {}
C {lab_pin.sym} 1540 5240 0 0 {name=l4201 lab=BL8}
N 1560 5200 1540 5200 {}
C {lab_pin.sym} 1540 5200 0 0 {name=l4202 lab=BLB8}
N 1560 5160 1540 5160 {}
C {lab_pin.sym} 1540 5160 0 0 {name=l4203 lab=WL26}
N 1640 5240 1660 5240 {}
C {lab_pin.sym} 1660 5240 0 0 {name=l4204 lab=VDD}
N 1640 5160 1660 5160 {}
C {lab_pin.sym} 1660 5160 0 0 {name=l4205 lab=VSS}
C {bitcell_6t.sym} 1800 5200 0 0 {name=Xr26c9}
N 1760 5240 1740 5240 {}
C {lab_pin.sym} 1740 5240 0 0 {name=l4206 lab=BL9}
N 1760 5200 1740 5200 {}
C {lab_pin.sym} 1740 5200 0 0 {name=l4207 lab=BLB9}
N 1760 5160 1740 5160 {}
C {lab_pin.sym} 1740 5160 0 0 {name=l4208 lab=WL26}
N 1840 5240 1860 5240 {}
C {lab_pin.sym} 1860 5240 0 0 {name=l4209 lab=VDD}
N 1840 5160 1860 5160 {}
C {lab_pin.sym} 1860 5160 0 0 {name=l4210 lab=VSS}
C {bitcell_6t.sym} 2000 5200 0 0 {name=Xr26c10}
N 1960 5240 1940 5240 {}
C {lab_pin.sym} 1940 5240 0 0 {name=l4211 lab=BL10}
N 1960 5200 1940 5200 {}
C {lab_pin.sym} 1940 5200 0 0 {name=l4212 lab=BLB10}
N 1960 5160 1940 5160 {}
C {lab_pin.sym} 1940 5160 0 0 {name=l4213 lab=WL26}
N 2040 5240 2060 5240 {}
C {lab_pin.sym} 2060 5240 0 0 {name=l4214 lab=VDD}
N 2040 5160 2060 5160 {}
C {lab_pin.sym} 2060 5160 0 0 {name=l4215 lab=VSS}
C {bitcell_6t.sym} 2200 5200 0 0 {name=Xr26c11}
N 2160 5240 2140 5240 {}
C {lab_pin.sym} 2140 5240 0 0 {name=l4216 lab=BL11}
N 2160 5200 2140 5200 {}
C {lab_pin.sym} 2140 5200 0 0 {name=l4217 lab=BLB11}
N 2160 5160 2140 5160 {}
C {lab_pin.sym} 2140 5160 0 0 {name=l4218 lab=WL26}
N 2240 5240 2260 5240 {}
C {lab_pin.sym} 2260 5240 0 0 {name=l4219 lab=VDD}
N 2240 5160 2260 5160 {}
C {lab_pin.sym} 2260 5160 0 0 {name=l4220 lab=VSS}
C {bitcell_6t.sym} 2400 5200 0 0 {name=Xr26c12}
N 2360 5240 2340 5240 {}
C {lab_pin.sym} 2340 5240 0 0 {name=l4221 lab=BL12}
N 2360 5200 2340 5200 {}
C {lab_pin.sym} 2340 5200 0 0 {name=l4222 lab=BLB12}
N 2360 5160 2340 5160 {}
C {lab_pin.sym} 2340 5160 0 0 {name=l4223 lab=WL26}
N 2440 5240 2460 5240 {}
C {lab_pin.sym} 2460 5240 0 0 {name=l4224 lab=VDD}
N 2440 5160 2460 5160 {}
C {lab_pin.sym} 2460 5160 0 0 {name=l4225 lab=VSS}
C {bitcell_6t.sym} 2600 5200 0 0 {name=Xr26c13}
N 2560 5240 2540 5240 {}
C {lab_pin.sym} 2540 5240 0 0 {name=l4226 lab=BL13}
N 2560 5200 2540 5200 {}
C {lab_pin.sym} 2540 5200 0 0 {name=l4227 lab=BLB13}
N 2560 5160 2540 5160 {}
C {lab_pin.sym} 2540 5160 0 0 {name=l4228 lab=WL26}
N 2640 5240 2660 5240 {}
C {lab_pin.sym} 2660 5240 0 0 {name=l4229 lab=VDD}
N 2640 5160 2660 5160 {}
C {lab_pin.sym} 2660 5160 0 0 {name=l4230 lab=VSS}
C {bitcell_6t.sym} 2800 5200 0 0 {name=Xr26c14}
N 2760 5240 2740 5240 {}
C {lab_pin.sym} 2740 5240 0 0 {name=l4231 lab=BL14}
N 2760 5200 2740 5200 {}
C {lab_pin.sym} 2740 5200 0 0 {name=l4232 lab=BLB14}
N 2760 5160 2740 5160 {}
C {lab_pin.sym} 2740 5160 0 0 {name=l4233 lab=WL26}
N 2840 5240 2860 5240 {}
C {lab_pin.sym} 2860 5240 0 0 {name=l4234 lab=VDD}
N 2840 5160 2860 5160 {}
C {lab_pin.sym} 2860 5160 0 0 {name=l4235 lab=VSS}
C {bitcell_6t.sym} 3000 5200 0 0 {name=Xr26c15}
N 2960 5240 2940 5240 {}
C {lab_pin.sym} 2940 5240 0 0 {name=l4236 lab=BL15}
N 2960 5200 2940 5200 {}
C {lab_pin.sym} 2940 5200 0 0 {name=l4237 lab=BLB15}
N 2960 5160 2940 5160 {}
C {lab_pin.sym} 2940 5160 0 0 {name=l4238 lab=WL26}
N 3040 5240 3060 5240 {}
C {lab_pin.sym} 3060 5240 0 0 {name=l4239 lab=VDD}
N 3040 5160 3060 5160 {}
C {lab_pin.sym} 3060 5160 0 0 {name=l4240 lab=VSS}
C {bitcell_6t.sym} 3200 5200 0 0 {name=Xr26c16}
N 3160 5240 3140 5240 {}
C {lab_pin.sym} 3140 5240 0 0 {name=l4241 lab=BL16}
N 3160 5200 3140 5200 {}
C {lab_pin.sym} 3140 5200 0 0 {name=l4242 lab=BLB16}
N 3160 5160 3140 5160 {}
C {lab_pin.sym} 3140 5160 0 0 {name=l4243 lab=WL26}
N 3240 5240 3260 5240 {}
C {lab_pin.sym} 3260 5240 0 0 {name=l4244 lab=VDD}
N 3240 5160 3260 5160 {}
C {lab_pin.sym} 3260 5160 0 0 {name=l4245 lab=VSS}
C {bitcell_6t.sym} 3400 5200 0 0 {name=Xr26c17}
N 3360 5240 3340 5240 {}
C {lab_pin.sym} 3340 5240 0 0 {name=l4246 lab=BL17}
N 3360 5200 3340 5200 {}
C {lab_pin.sym} 3340 5200 0 0 {name=l4247 lab=BLB17}
N 3360 5160 3340 5160 {}
C {lab_pin.sym} 3340 5160 0 0 {name=l4248 lab=WL26}
N 3440 5240 3460 5240 {}
C {lab_pin.sym} 3460 5240 0 0 {name=l4249 lab=VDD}
N 3440 5160 3460 5160 {}
C {lab_pin.sym} 3460 5160 0 0 {name=l4250 lab=VSS}
C {bitcell_6t.sym} 3600 5200 0 0 {name=Xr26c18}
N 3560 5240 3540 5240 {}
C {lab_pin.sym} 3540 5240 0 0 {name=l4251 lab=BL18}
N 3560 5200 3540 5200 {}
C {lab_pin.sym} 3540 5200 0 0 {name=l4252 lab=BLB18}
N 3560 5160 3540 5160 {}
C {lab_pin.sym} 3540 5160 0 0 {name=l4253 lab=WL26}
N 3640 5240 3660 5240 {}
C {lab_pin.sym} 3660 5240 0 0 {name=l4254 lab=VDD}
N 3640 5160 3660 5160 {}
C {lab_pin.sym} 3660 5160 0 0 {name=l4255 lab=VSS}
C {bitcell_6t.sym} 3800 5200 0 0 {name=Xr26c19}
N 3760 5240 3740 5240 {}
C {lab_pin.sym} 3740 5240 0 0 {name=l4256 lab=BL19}
N 3760 5200 3740 5200 {}
C {lab_pin.sym} 3740 5200 0 0 {name=l4257 lab=BLB19}
N 3760 5160 3740 5160 {}
C {lab_pin.sym} 3740 5160 0 0 {name=l4258 lab=WL26}
N 3840 5240 3860 5240 {}
C {lab_pin.sym} 3860 5240 0 0 {name=l4259 lab=VDD}
N 3840 5160 3860 5160 {}
C {lab_pin.sym} 3860 5160 0 0 {name=l4260 lab=VSS}
C {bitcell_6t.sym} 4000 5200 0 0 {name=Xr26c20}
N 3960 5240 3940 5240 {}
C {lab_pin.sym} 3940 5240 0 0 {name=l4261 lab=BL20}
N 3960 5200 3940 5200 {}
C {lab_pin.sym} 3940 5200 0 0 {name=l4262 lab=BLB20}
N 3960 5160 3940 5160 {}
C {lab_pin.sym} 3940 5160 0 0 {name=l4263 lab=WL26}
N 4040 5240 4060 5240 {}
C {lab_pin.sym} 4060 5240 0 0 {name=l4264 lab=VDD}
N 4040 5160 4060 5160 {}
C {lab_pin.sym} 4060 5160 0 0 {name=l4265 lab=VSS}
C {bitcell_6t.sym} 4200 5200 0 0 {name=Xr26c21}
N 4160 5240 4140 5240 {}
C {lab_pin.sym} 4140 5240 0 0 {name=l4266 lab=BL21}
N 4160 5200 4140 5200 {}
C {lab_pin.sym} 4140 5200 0 0 {name=l4267 lab=BLB21}
N 4160 5160 4140 5160 {}
C {lab_pin.sym} 4140 5160 0 0 {name=l4268 lab=WL26}
N 4240 5240 4260 5240 {}
C {lab_pin.sym} 4260 5240 0 0 {name=l4269 lab=VDD}
N 4240 5160 4260 5160 {}
C {lab_pin.sym} 4260 5160 0 0 {name=l4270 lab=VSS}
C {bitcell_6t.sym} 4400 5200 0 0 {name=Xr26c22}
N 4360 5240 4340 5240 {}
C {lab_pin.sym} 4340 5240 0 0 {name=l4271 lab=BL22}
N 4360 5200 4340 5200 {}
C {lab_pin.sym} 4340 5200 0 0 {name=l4272 lab=BLB22}
N 4360 5160 4340 5160 {}
C {lab_pin.sym} 4340 5160 0 0 {name=l4273 lab=WL26}
N 4440 5240 4460 5240 {}
C {lab_pin.sym} 4460 5240 0 0 {name=l4274 lab=VDD}
N 4440 5160 4460 5160 {}
C {lab_pin.sym} 4460 5160 0 0 {name=l4275 lab=VSS}
C {bitcell_6t.sym} 4600 5200 0 0 {name=Xr26c23}
N 4560 5240 4540 5240 {}
C {lab_pin.sym} 4540 5240 0 0 {name=l4276 lab=BL23}
N 4560 5200 4540 5200 {}
C {lab_pin.sym} 4540 5200 0 0 {name=l4277 lab=BLB23}
N 4560 5160 4540 5160 {}
C {lab_pin.sym} 4540 5160 0 0 {name=l4278 lab=WL26}
N 4640 5240 4660 5240 {}
C {lab_pin.sym} 4660 5240 0 0 {name=l4279 lab=VDD}
N 4640 5160 4660 5160 {}
C {lab_pin.sym} 4660 5160 0 0 {name=l4280 lab=VSS}
C {bitcell_6t.sym} 4800 5200 0 0 {name=Xr26c24}
N 4760 5240 4740 5240 {}
C {lab_pin.sym} 4740 5240 0 0 {name=l4281 lab=BL24}
N 4760 5200 4740 5200 {}
C {lab_pin.sym} 4740 5200 0 0 {name=l4282 lab=BLB24}
N 4760 5160 4740 5160 {}
C {lab_pin.sym} 4740 5160 0 0 {name=l4283 lab=WL26}
N 4840 5240 4860 5240 {}
C {lab_pin.sym} 4860 5240 0 0 {name=l4284 lab=VDD}
N 4840 5160 4860 5160 {}
C {lab_pin.sym} 4860 5160 0 0 {name=l4285 lab=VSS}
C {bitcell_6t.sym} 5000 5200 0 0 {name=Xr26c25}
N 4960 5240 4940 5240 {}
C {lab_pin.sym} 4940 5240 0 0 {name=l4286 lab=BL25}
N 4960 5200 4940 5200 {}
C {lab_pin.sym} 4940 5200 0 0 {name=l4287 lab=BLB25}
N 4960 5160 4940 5160 {}
C {lab_pin.sym} 4940 5160 0 0 {name=l4288 lab=WL26}
N 5040 5240 5060 5240 {}
C {lab_pin.sym} 5060 5240 0 0 {name=l4289 lab=VDD}
N 5040 5160 5060 5160 {}
C {lab_pin.sym} 5060 5160 0 0 {name=l4290 lab=VSS}
C {bitcell_6t.sym} 5200 5200 0 0 {name=Xr26c26}
N 5160 5240 5140 5240 {}
C {lab_pin.sym} 5140 5240 0 0 {name=l4291 lab=BL26}
N 5160 5200 5140 5200 {}
C {lab_pin.sym} 5140 5200 0 0 {name=l4292 lab=BLB26}
N 5160 5160 5140 5160 {}
C {lab_pin.sym} 5140 5160 0 0 {name=l4293 lab=WL26}
N 5240 5240 5260 5240 {}
C {lab_pin.sym} 5260 5240 0 0 {name=l4294 lab=VDD}
N 5240 5160 5260 5160 {}
C {lab_pin.sym} 5260 5160 0 0 {name=l4295 lab=VSS}
C {bitcell_6t.sym} 5400 5200 0 0 {name=Xr26c27}
N 5360 5240 5340 5240 {}
C {lab_pin.sym} 5340 5240 0 0 {name=l4296 lab=BL27}
N 5360 5200 5340 5200 {}
C {lab_pin.sym} 5340 5200 0 0 {name=l4297 lab=BLB27}
N 5360 5160 5340 5160 {}
C {lab_pin.sym} 5340 5160 0 0 {name=l4298 lab=WL26}
N 5440 5240 5460 5240 {}
C {lab_pin.sym} 5460 5240 0 0 {name=l4299 lab=VDD}
N 5440 5160 5460 5160 {}
C {lab_pin.sym} 5460 5160 0 0 {name=l4300 lab=VSS}
C {bitcell_6t.sym} 5600 5200 0 0 {name=Xr26c28}
N 5560 5240 5540 5240 {}
C {lab_pin.sym} 5540 5240 0 0 {name=l4301 lab=BL28}
N 5560 5200 5540 5200 {}
C {lab_pin.sym} 5540 5200 0 0 {name=l4302 lab=BLB28}
N 5560 5160 5540 5160 {}
C {lab_pin.sym} 5540 5160 0 0 {name=l4303 lab=WL26}
N 5640 5240 5660 5240 {}
C {lab_pin.sym} 5660 5240 0 0 {name=l4304 lab=VDD}
N 5640 5160 5660 5160 {}
C {lab_pin.sym} 5660 5160 0 0 {name=l4305 lab=VSS}
C {bitcell_6t.sym} 5800 5200 0 0 {name=Xr26c29}
N 5760 5240 5740 5240 {}
C {lab_pin.sym} 5740 5240 0 0 {name=l4306 lab=BL29}
N 5760 5200 5740 5200 {}
C {lab_pin.sym} 5740 5200 0 0 {name=l4307 lab=BLB29}
N 5760 5160 5740 5160 {}
C {lab_pin.sym} 5740 5160 0 0 {name=l4308 lab=WL26}
N 5840 5240 5860 5240 {}
C {lab_pin.sym} 5860 5240 0 0 {name=l4309 lab=VDD}
N 5840 5160 5860 5160 {}
C {lab_pin.sym} 5860 5160 0 0 {name=l4310 lab=VSS}
C {bitcell_6t.sym} 6000 5200 0 0 {name=Xr26c30}
N 5960 5240 5940 5240 {}
C {lab_pin.sym} 5940 5240 0 0 {name=l4311 lab=BL30}
N 5960 5200 5940 5200 {}
C {lab_pin.sym} 5940 5200 0 0 {name=l4312 lab=BLB30}
N 5960 5160 5940 5160 {}
C {lab_pin.sym} 5940 5160 0 0 {name=l4313 lab=WL26}
N 6040 5240 6060 5240 {}
C {lab_pin.sym} 6060 5240 0 0 {name=l4314 lab=VDD}
N 6040 5160 6060 5160 {}
C {lab_pin.sym} 6060 5160 0 0 {name=l4315 lab=VSS}
C {bitcell_6t.sym} 6200 5200 0 0 {name=Xr26c31}
N 6160 5240 6140 5240 {}
C {lab_pin.sym} 6140 5240 0 0 {name=l4316 lab=BL31}
N 6160 5200 6140 5200 {}
C {lab_pin.sym} 6140 5200 0 0 {name=l4317 lab=BLB31}
N 6160 5160 6140 5160 {}
C {lab_pin.sym} 6140 5160 0 0 {name=l4318 lab=WL26}
N 6240 5240 6260 5240 {}
C {lab_pin.sym} 6260 5240 0 0 {name=l4319 lab=VDD}
N 6240 5160 6260 5160 {}
C {lab_pin.sym} 6260 5160 0 0 {name=l4320 lab=VSS}
C {bitcell_6t.sym} 0 5400 0 0 {name=Xr27c0}
N -40 5440 -60 5440 {}
C {lab_pin.sym} -60 5440 0 0 {name=l4321 lab=BL0}
N -40 5400 -60 5400 {}
C {lab_pin.sym} -60 5400 0 0 {name=l4322 lab=BLB0}
N -40 5360 -60 5360 {}
C {lab_pin.sym} -60 5360 0 0 {name=l4323 lab=WL27}
N 40 5440 60 5440 {}
C {lab_pin.sym} 60 5440 0 0 {name=l4324 lab=VDD}
N 40 5360 60 5360 {}
C {lab_pin.sym} 60 5360 0 0 {name=l4325 lab=VSS}
C {bitcell_6t.sym} 200 5400 0 0 {name=Xr27c1}
N 160 5440 140 5440 {}
C {lab_pin.sym} 140 5440 0 0 {name=l4326 lab=BL1}
N 160 5400 140 5400 {}
C {lab_pin.sym} 140 5400 0 0 {name=l4327 lab=BLB1}
N 160 5360 140 5360 {}
C {lab_pin.sym} 140 5360 0 0 {name=l4328 lab=WL27}
N 240 5440 260 5440 {}
C {lab_pin.sym} 260 5440 0 0 {name=l4329 lab=VDD}
N 240 5360 260 5360 {}
C {lab_pin.sym} 260 5360 0 0 {name=l4330 lab=VSS}
C {bitcell_6t.sym} 400 5400 0 0 {name=Xr27c2}
N 360 5440 340 5440 {}
C {lab_pin.sym} 340 5440 0 0 {name=l4331 lab=BL2}
N 360 5400 340 5400 {}
C {lab_pin.sym} 340 5400 0 0 {name=l4332 lab=BLB2}
N 360 5360 340 5360 {}
C {lab_pin.sym} 340 5360 0 0 {name=l4333 lab=WL27}
N 440 5440 460 5440 {}
C {lab_pin.sym} 460 5440 0 0 {name=l4334 lab=VDD}
N 440 5360 460 5360 {}
C {lab_pin.sym} 460 5360 0 0 {name=l4335 lab=VSS}
C {bitcell_6t.sym} 600 5400 0 0 {name=Xr27c3}
N 560 5440 540 5440 {}
C {lab_pin.sym} 540 5440 0 0 {name=l4336 lab=BL3}
N 560 5400 540 5400 {}
C {lab_pin.sym} 540 5400 0 0 {name=l4337 lab=BLB3}
N 560 5360 540 5360 {}
C {lab_pin.sym} 540 5360 0 0 {name=l4338 lab=WL27}
N 640 5440 660 5440 {}
C {lab_pin.sym} 660 5440 0 0 {name=l4339 lab=VDD}
N 640 5360 660 5360 {}
C {lab_pin.sym} 660 5360 0 0 {name=l4340 lab=VSS}
C {bitcell_6t.sym} 800 5400 0 0 {name=Xr27c4}
N 760 5440 740 5440 {}
C {lab_pin.sym} 740 5440 0 0 {name=l4341 lab=BL4}
N 760 5400 740 5400 {}
C {lab_pin.sym} 740 5400 0 0 {name=l4342 lab=BLB4}
N 760 5360 740 5360 {}
C {lab_pin.sym} 740 5360 0 0 {name=l4343 lab=WL27}
N 840 5440 860 5440 {}
C {lab_pin.sym} 860 5440 0 0 {name=l4344 lab=VDD}
N 840 5360 860 5360 {}
C {lab_pin.sym} 860 5360 0 0 {name=l4345 lab=VSS}
C {bitcell_6t.sym} 1000 5400 0 0 {name=Xr27c5}
N 960 5440 940 5440 {}
C {lab_pin.sym} 940 5440 0 0 {name=l4346 lab=BL5}
N 960 5400 940 5400 {}
C {lab_pin.sym} 940 5400 0 0 {name=l4347 lab=BLB5}
N 960 5360 940 5360 {}
C {lab_pin.sym} 940 5360 0 0 {name=l4348 lab=WL27}
N 1040 5440 1060 5440 {}
C {lab_pin.sym} 1060 5440 0 0 {name=l4349 lab=VDD}
N 1040 5360 1060 5360 {}
C {lab_pin.sym} 1060 5360 0 0 {name=l4350 lab=VSS}
C {bitcell_6t.sym} 1200 5400 0 0 {name=Xr27c6}
N 1160 5440 1140 5440 {}
C {lab_pin.sym} 1140 5440 0 0 {name=l4351 lab=BL6}
N 1160 5400 1140 5400 {}
C {lab_pin.sym} 1140 5400 0 0 {name=l4352 lab=BLB6}
N 1160 5360 1140 5360 {}
C {lab_pin.sym} 1140 5360 0 0 {name=l4353 lab=WL27}
N 1240 5440 1260 5440 {}
C {lab_pin.sym} 1260 5440 0 0 {name=l4354 lab=VDD}
N 1240 5360 1260 5360 {}
C {lab_pin.sym} 1260 5360 0 0 {name=l4355 lab=VSS}
C {bitcell_6t.sym} 1400 5400 0 0 {name=Xr27c7}
N 1360 5440 1340 5440 {}
C {lab_pin.sym} 1340 5440 0 0 {name=l4356 lab=BL7}
N 1360 5400 1340 5400 {}
C {lab_pin.sym} 1340 5400 0 0 {name=l4357 lab=BLB7}
N 1360 5360 1340 5360 {}
C {lab_pin.sym} 1340 5360 0 0 {name=l4358 lab=WL27}
N 1440 5440 1460 5440 {}
C {lab_pin.sym} 1460 5440 0 0 {name=l4359 lab=VDD}
N 1440 5360 1460 5360 {}
C {lab_pin.sym} 1460 5360 0 0 {name=l4360 lab=VSS}
C {bitcell_6t.sym} 1600 5400 0 0 {name=Xr27c8}
N 1560 5440 1540 5440 {}
C {lab_pin.sym} 1540 5440 0 0 {name=l4361 lab=BL8}
N 1560 5400 1540 5400 {}
C {lab_pin.sym} 1540 5400 0 0 {name=l4362 lab=BLB8}
N 1560 5360 1540 5360 {}
C {lab_pin.sym} 1540 5360 0 0 {name=l4363 lab=WL27}
N 1640 5440 1660 5440 {}
C {lab_pin.sym} 1660 5440 0 0 {name=l4364 lab=VDD}
N 1640 5360 1660 5360 {}
C {lab_pin.sym} 1660 5360 0 0 {name=l4365 lab=VSS}
C {bitcell_6t.sym} 1800 5400 0 0 {name=Xr27c9}
N 1760 5440 1740 5440 {}
C {lab_pin.sym} 1740 5440 0 0 {name=l4366 lab=BL9}
N 1760 5400 1740 5400 {}
C {lab_pin.sym} 1740 5400 0 0 {name=l4367 lab=BLB9}
N 1760 5360 1740 5360 {}
C {lab_pin.sym} 1740 5360 0 0 {name=l4368 lab=WL27}
N 1840 5440 1860 5440 {}
C {lab_pin.sym} 1860 5440 0 0 {name=l4369 lab=VDD}
N 1840 5360 1860 5360 {}
C {lab_pin.sym} 1860 5360 0 0 {name=l4370 lab=VSS}
C {bitcell_6t.sym} 2000 5400 0 0 {name=Xr27c10}
N 1960 5440 1940 5440 {}
C {lab_pin.sym} 1940 5440 0 0 {name=l4371 lab=BL10}
N 1960 5400 1940 5400 {}
C {lab_pin.sym} 1940 5400 0 0 {name=l4372 lab=BLB10}
N 1960 5360 1940 5360 {}
C {lab_pin.sym} 1940 5360 0 0 {name=l4373 lab=WL27}
N 2040 5440 2060 5440 {}
C {lab_pin.sym} 2060 5440 0 0 {name=l4374 lab=VDD}
N 2040 5360 2060 5360 {}
C {lab_pin.sym} 2060 5360 0 0 {name=l4375 lab=VSS}
C {bitcell_6t.sym} 2200 5400 0 0 {name=Xr27c11}
N 2160 5440 2140 5440 {}
C {lab_pin.sym} 2140 5440 0 0 {name=l4376 lab=BL11}
N 2160 5400 2140 5400 {}
C {lab_pin.sym} 2140 5400 0 0 {name=l4377 lab=BLB11}
N 2160 5360 2140 5360 {}
C {lab_pin.sym} 2140 5360 0 0 {name=l4378 lab=WL27}
N 2240 5440 2260 5440 {}
C {lab_pin.sym} 2260 5440 0 0 {name=l4379 lab=VDD}
N 2240 5360 2260 5360 {}
C {lab_pin.sym} 2260 5360 0 0 {name=l4380 lab=VSS}
C {bitcell_6t.sym} 2400 5400 0 0 {name=Xr27c12}
N 2360 5440 2340 5440 {}
C {lab_pin.sym} 2340 5440 0 0 {name=l4381 lab=BL12}
N 2360 5400 2340 5400 {}
C {lab_pin.sym} 2340 5400 0 0 {name=l4382 lab=BLB12}
N 2360 5360 2340 5360 {}
C {lab_pin.sym} 2340 5360 0 0 {name=l4383 lab=WL27}
N 2440 5440 2460 5440 {}
C {lab_pin.sym} 2460 5440 0 0 {name=l4384 lab=VDD}
N 2440 5360 2460 5360 {}
C {lab_pin.sym} 2460 5360 0 0 {name=l4385 lab=VSS}
C {bitcell_6t.sym} 2600 5400 0 0 {name=Xr27c13}
N 2560 5440 2540 5440 {}
C {lab_pin.sym} 2540 5440 0 0 {name=l4386 lab=BL13}
N 2560 5400 2540 5400 {}
C {lab_pin.sym} 2540 5400 0 0 {name=l4387 lab=BLB13}
N 2560 5360 2540 5360 {}
C {lab_pin.sym} 2540 5360 0 0 {name=l4388 lab=WL27}
N 2640 5440 2660 5440 {}
C {lab_pin.sym} 2660 5440 0 0 {name=l4389 lab=VDD}
N 2640 5360 2660 5360 {}
C {lab_pin.sym} 2660 5360 0 0 {name=l4390 lab=VSS}
C {bitcell_6t.sym} 2800 5400 0 0 {name=Xr27c14}
N 2760 5440 2740 5440 {}
C {lab_pin.sym} 2740 5440 0 0 {name=l4391 lab=BL14}
N 2760 5400 2740 5400 {}
C {lab_pin.sym} 2740 5400 0 0 {name=l4392 lab=BLB14}
N 2760 5360 2740 5360 {}
C {lab_pin.sym} 2740 5360 0 0 {name=l4393 lab=WL27}
N 2840 5440 2860 5440 {}
C {lab_pin.sym} 2860 5440 0 0 {name=l4394 lab=VDD}
N 2840 5360 2860 5360 {}
C {lab_pin.sym} 2860 5360 0 0 {name=l4395 lab=VSS}
C {bitcell_6t.sym} 3000 5400 0 0 {name=Xr27c15}
N 2960 5440 2940 5440 {}
C {lab_pin.sym} 2940 5440 0 0 {name=l4396 lab=BL15}
N 2960 5400 2940 5400 {}
C {lab_pin.sym} 2940 5400 0 0 {name=l4397 lab=BLB15}
N 2960 5360 2940 5360 {}
C {lab_pin.sym} 2940 5360 0 0 {name=l4398 lab=WL27}
N 3040 5440 3060 5440 {}
C {lab_pin.sym} 3060 5440 0 0 {name=l4399 lab=VDD}
N 3040 5360 3060 5360 {}
C {lab_pin.sym} 3060 5360 0 0 {name=l4400 lab=VSS}
C {bitcell_6t.sym} 3200 5400 0 0 {name=Xr27c16}
N 3160 5440 3140 5440 {}
C {lab_pin.sym} 3140 5440 0 0 {name=l4401 lab=BL16}
N 3160 5400 3140 5400 {}
C {lab_pin.sym} 3140 5400 0 0 {name=l4402 lab=BLB16}
N 3160 5360 3140 5360 {}
C {lab_pin.sym} 3140 5360 0 0 {name=l4403 lab=WL27}
N 3240 5440 3260 5440 {}
C {lab_pin.sym} 3260 5440 0 0 {name=l4404 lab=VDD}
N 3240 5360 3260 5360 {}
C {lab_pin.sym} 3260 5360 0 0 {name=l4405 lab=VSS}
C {bitcell_6t.sym} 3400 5400 0 0 {name=Xr27c17}
N 3360 5440 3340 5440 {}
C {lab_pin.sym} 3340 5440 0 0 {name=l4406 lab=BL17}
N 3360 5400 3340 5400 {}
C {lab_pin.sym} 3340 5400 0 0 {name=l4407 lab=BLB17}
N 3360 5360 3340 5360 {}
C {lab_pin.sym} 3340 5360 0 0 {name=l4408 lab=WL27}
N 3440 5440 3460 5440 {}
C {lab_pin.sym} 3460 5440 0 0 {name=l4409 lab=VDD}
N 3440 5360 3460 5360 {}
C {lab_pin.sym} 3460 5360 0 0 {name=l4410 lab=VSS}
C {bitcell_6t.sym} 3600 5400 0 0 {name=Xr27c18}
N 3560 5440 3540 5440 {}
C {lab_pin.sym} 3540 5440 0 0 {name=l4411 lab=BL18}
N 3560 5400 3540 5400 {}
C {lab_pin.sym} 3540 5400 0 0 {name=l4412 lab=BLB18}
N 3560 5360 3540 5360 {}
C {lab_pin.sym} 3540 5360 0 0 {name=l4413 lab=WL27}
N 3640 5440 3660 5440 {}
C {lab_pin.sym} 3660 5440 0 0 {name=l4414 lab=VDD}
N 3640 5360 3660 5360 {}
C {lab_pin.sym} 3660 5360 0 0 {name=l4415 lab=VSS}
C {bitcell_6t.sym} 3800 5400 0 0 {name=Xr27c19}
N 3760 5440 3740 5440 {}
C {lab_pin.sym} 3740 5440 0 0 {name=l4416 lab=BL19}
N 3760 5400 3740 5400 {}
C {lab_pin.sym} 3740 5400 0 0 {name=l4417 lab=BLB19}
N 3760 5360 3740 5360 {}
C {lab_pin.sym} 3740 5360 0 0 {name=l4418 lab=WL27}
N 3840 5440 3860 5440 {}
C {lab_pin.sym} 3860 5440 0 0 {name=l4419 lab=VDD}
N 3840 5360 3860 5360 {}
C {lab_pin.sym} 3860 5360 0 0 {name=l4420 lab=VSS}
C {bitcell_6t.sym} 4000 5400 0 0 {name=Xr27c20}
N 3960 5440 3940 5440 {}
C {lab_pin.sym} 3940 5440 0 0 {name=l4421 lab=BL20}
N 3960 5400 3940 5400 {}
C {lab_pin.sym} 3940 5400 0 0 {name=l4422 lab=BLB20}
N 3960 5360 3940 5360 {}
C {lab_pin.sym} 3940 5360 0 0 {name=l4423 lab=WL27}
N 4040 5440 4060 5440 {}
C {lab_pin.sym} 4060 5440 0 0 {name=l4424 lab=VDD}
N 4040 5360 4060 5360 {}
C {lab_pin.sym} 4060 5360 0 0 {name=l4425 lab=VSS}
C {bitcell_6t.sym} 4200 5400 0 0 {name=Xr27c21}
N 4160 5440 4140 5440 {}
C {lab_pin.sym} 4140 5440 0 0 {name=l4426 lab=BL21}
N 4160 5400 4140 5400 {}
C {lab_pin.sym} 4140 5400 0 0 {name=l4427 lab=BLB21}
N 4160 5360 4140 5360 {}
C {lab_pin.sym} 4140 5360 0 0 {name=l4428 lab=WL27}
N 4240 5440 4260 5440 {}
C {lab_pin.sym} 4260 5440 0 0 {name=l4429 lab=VDD}
N 4240 5360 4260 5360 {}
C {lab_pin.sym} 4260 5360 0 0 {name=l4430 lab=VSS}
C {bitcell_6t.sym} 4400 5400 0 0 {name=Xr27c22}
N 4360 5440 4340 5440 {}
C {lab_pin.sym} 4340 5440 0 0 {name=l4431 lab=BL22}
N 4360 5400 4340 5400 {}
C {lab_pin.sym} 4340 5400 0 0 {name=l4432 lab=BLB22}
N 4360 5360 4340 5360 {}
C {lab_pin.sym} 4340 5360 0 0 {name=l4433 lab=WL27}
N 4440 5440 4460 5440 {}
C {lab_pin.sym} 4460 5440 0 0 {name=l4434 lab=VDD}
N 4440 5360 4460 5360 {}
C {lab_pin.sym} 4460 5360 0 0 {name=l4435 lab=VSS}
C {bitcell_6t.sym} 4600 5400 0 0 {name=Xr27c23}
N 4560 5440 4540 5440 {}
C {lab_pin.sym} 4540 5440 0 0 {name=l4436 lab=BL23}
N 4560 5400 4540 5400 {}
C {lab_pin.sym} 4540 5400 0 0 {name=l4437 lab=BLB23}
N 4560 5360 4540 5360 {}
C {lab_pin.sym} 4540 5360 0 0 {name=l4438 lab=WL27}
N 4640 5440 4660 5440 {}
C {lab_pin.sym} 4660 5440 0 0 {name=l4439 lab=VDD}
N 4640 5360 4660 5360 {}
C {lab_pin.sym} 4660 5360 0 0 {name=l4440 lab=VSS}
C {bitcell_6t.sym} 4800 5400 0 0 {name=Xr27c24}
N 4760 5440 4740 5440 {}
C {lab_pin.sym} 4740 5440 0 0 {name=l4441 lab=BL24}
N 4760 5400 4740 5400 {}
C {lab_pin.sym} 4740 5400 0 0 {name=l4442 lab=BLB24}
N 4760 5360 4740 5360 {}
C {lab_pin.sym} 4740 5360 0 0 {name=l4443 lab=WL27}
N 4840 5440 4860 5440 {}
C {lab_pin.sym} 4860 5440 0 0 {name=l4444 lab=VDD}
N 4840 5360 4860 5360 {}
C {lab_pin.sym} 4860 5360 0 0 {name=l4445 lab=VSS}
C {bitcell_6t.sym} 5000 5400 0 0 {name=Xr27c25}
N 4960 5440 4940 5440 {}
C {lab_pin.sym} 4940 5440 0 0 {name=l4446 lab=BL25}
N 4960 5400 4940 5400 {}
C {lab_pin.sym} 4940 5400 0 0 {name=l4447 lab=BLB25}
N 4960 5360 4940 5360 {}
C {lab_pin.sym} 4940 5360 0 0 {name=l4448 lab=WL27}
N 5040 5440 5060 5440 {}
C {lab_pin.sym} 5060 5440 0 0 {name=l4449 lab=VDD}
N 5040 5360 5060 5360 {}
C {lab_pin.sym} 5060 5360 0 0 {name=l4450 lab=VSS}
C {bitcell_6t.sym} 5200 5400 0 0 {name=Xr27c26}
N 5160 5440 5140 5440 {}
C {lab_pin.sym} 5140 5440 0 0 {name=l4451 lab=BL26}
N 5160 5400 5140 5400 {}
C {lab_pin.sym} 5140 5400 0 0 {name=l4452 lab=BLB26}
N 5160 5360 5140 5360 {}
C {lab_pin.sym} 5140 5360 0 0 {name=l4453 lab=WL27}
N 5240 5440 5260 5440 {}
C {lab_pin.sym} 5260 5440 0 0 {name=l4454 lab=VDD}
N 5240 5360 5260 5360 {}
C {lab_pin.sym} 5260 5360 0 0 {name=l4455 lab=VSS}
C {bitcell_6t.sym} 5400 5400 0 0 {name=Xr27c27}
N 5360 5440 5340 5440 {}
C {lab_pin.sym} 5340 5440 0 0 {name=l4456 lab=BL27}
N 5360 5400 5340 5400 {}
C {lab_pin.sym} 5340 5400 0 0 {name=l4457 lab=BLB27}
N 5360 5360 5340 5360 {}
C {lab_pin.sym} 5340 5360 0 0 {name=l4458 lab=WL27}
N 5440 5440 5460 5440 {}
C {lab_pin.sym} 5460 5440 0 0 {name=l4459 lab=VDD}
N 5440 5360 5460 5360 {}
C {lab_pin.sym} 5460 5360 0 0 {name=l4460 lab=VSS}
C {bitcell_6t.sym} 5600 5400 0 0 {name=Xr27c28}
N 5560 5440 5540 5440 {}
C {lab_pin.sym} 5540 5440 0 0 {name=l4461 lab=BL28}
N 5560 5400 5540 5400 {}
C {lab_pin.sym} 5540 5400 0 0 {name=l4462 lab=BLB28}
N 5560 5360 5540 5360 {}
C {lab_pin.sym} 5540 5360 0 0 {name=l4463 lab=WL27}
N 5640 5440 5660 5440 {}
C {lab_pin.sym} 5660 5440 0 0 {name=l4464 lab=VDD}
N 5640 5360 5660 5360 {}
C {lab_pin.sym} 5660 5360 0 0 {name=l4465 lab=VSS}
C {bitcell_6t.sym} 5800 5400 0 0 {name=Xr27c29}
N 5760 5440 5740 5440 {}
C {lab_pin.sym} 5740 5440 0 0 {name=l4466 lab=BL29}
N 5760 5400 5740 5400 {}
C {lab_pin.sym} 5740 5400 0 0 {name=l4467 lab=BLB29}
N 5760 5360 5740 5360 {}
C {lab_pin.sym} 5740 5360 0 0 {name=l4468 lab=WL27}
N 5840 5440 5860 5440 {}
C {lab_pin.sym} 5860 5440 0 0 {name=l4469 lab=VDD}
N 5840 5360 5860 5360 {}
C {lab_pin.sym} 5860 5360 0 0 {name=l4470 lab=VSS}
C {bitcell_6t.sym} 6000 5400 0 0 {name=Xr27c30}
N 5960 5440 5940 5440 {}
C {lab_pin.sym} 5940 5440 0 0 {name=l4471 lab=BL30}
N 5960 5400 5940 5400 {}
C {lab_pin.sym} 5940 5400 0 0 {name=l4472 lab=BLB30}
N 5960 5360 5940 5360 {}
C {lab_pin.sym} 5940 5360 0 0 {name=l4473 lab=WL27}
N 6040 5440 6060 5440 {}
C {lab_pin.sym} 6060 5440 0 0 {name=l4474 lab=VDD}
N 6040 5360 6060 5360 {}
C {lab_pin.sym} 6060 5360 0 0 {name=l4475 lab=VSS}
C {bitcell_6t.sym} 6200 5400 0 0 {name=Xr27c31}
N 6160 5440 6140 5440 {}
C {lab_pin.sym} 6140 5440 0 0 {name=l4476 lab=BL31}
N 6160 5400 6140 5400 {}
C {lab_pin.sym} 6140 5400 0 0 {name=l4477 lab=BLB31}
N 6160 5360 6140 5360 {}
C {lab_pin.sym} 6140 5360 0 0 {name=l4478 lab=WL27}
N 6240 5440 6260 5440 {}
C {lab_pin.sym} 6260 5440 0 0 {name=l4479 lab=VDD}
N 6240 5360 6260 5360 {}
C {lab_pin.sym} 6260 5360 0 0 {name=l4480 lab=VSS}
C {bitcell_6t.sym} 0 5600 0 0 {name=Xr28c0}
N -40 5640 -60 5640 {}
C {lab_pin.sym} -60 5640 0 0 {name=l4481 lab=BL0}
N -40 5600 -60 5600 {}
C {lab_pin.sym} -60 5600 0 0 {name=l4482 lab=BLB0}
N -40 5560 -60 5560 {}
C {lab_pin.sym} -60 5560 0 0 {name=l4483 lab=WL28}
N 40 5640 60 5640 {}
C {lab_pin.sym} 60 5640 0 0 {name=l4484 lab=VDD}
N 40 5560 60 5560 {}
C {lab_pin.sym} 60 5560 0 0 {name=l4485 lab=VSS}
C {bitcell_6t.sym} 200 5600 0 0 {name=Xr28c1}
N 160 5640 140 5640 {}
C {lab_pin.sym} 140 5640 0 0 {name=l4486 lab=BL1}
N 160 5600 140 5600 {}
C {lab_pin.sym} 140 5600 0 0 {name=l4487 lab=BLB1}
N 160 5560 140 5560 {}
C {lab_pin.sym} 140 5560 0 0 {name=l4488 lab=WL28}
N 240 5640 260 5640 {}
C {lab_pin.sym} 260 5640 0 0 {name=l4489 lab=VDD}
N 240 5560 260 5560 {}
C {lab_pin.sym} 260 5560 0 0 {name=l4490 lab=VSS}
C {bitcell_6t.sym} 400 5600 0 0 {name=Xr28c2}
N 360 5640 340 5640 {}
C {lab_pin.sym} 340 5640 0 0 {name=l4491 lab=BL2}
N 360 5600 340 5600 {}
C {lab_pin.sym} 340 5600 0 0 {name=l4492 lab=BLB2}
N 360 5560 340 5560 {}
C {lab_pin.sym} 340 5560 0 0 {name=l4493 lab=WL28}
N 440 5640 460 5640 {}
C {lab_pin.sym} 460 5640 0 0 {name=l4494 lab=VDD}
N 440 5560 460 5560 {}
C {lab_pin.sym} 460 5560 0 0 {name=l4495 lab=VSS}
C {bitcell_6t.sym} 600 5600 0 0 {name=Xr28c3}
N 560 5640 540 5640 {}
C {lab_pin.sym} 540 5640 0 0 {name=l4496 lab=BL3}
N 560 5600 540 5600 {}
C {lab_pin.sym} 540 5600 0 0 {name=l4497 lab=BLB3}
N 560 5560 540 5560 {}
C {lab_pin.sym} 540 5560 0 0 {name=l4498 lab=WL28}
N 640 5640 660 5640 {}
C {lab_pin.sym} 660 5640 0 0 {name=l4499 lab=VDD}
N 640 5560 660 5560 {}
C {lab_pin.sym} 660 5560 0 0 {name=l4500 lab=VSS}
C {bitcell_6t.sym} 800 5600 0 0 {name=Xr28c4}
N 760 5640 740 5640 {}
C {lab_pin.sym} 740 5640 0 0 {name=l4501 lab=BL4}
N 760 5600 740 5600 {}
C {lab_pin.sym} 740 5600 0 0 {name=l4502 lab=BLB4}
N 760 5560 740 5560 {}
C {lab_pin.sym} 740 5560 0 0 {name=l4503 lab=WL28}
N 840 5640 860 5640 {}
C {lab_pin.sym} 860 5640 0 0 {name=l4504 lab=VDD}
N 840 5560 860 5560 {}
C {lab_pin.sym} 860 5560 0 0 {name=l4505 lab=VSS}
C {bitcell_6t.sym} 1000 5600 0 0 {name=Xr28c5}
N 960 5640 940 5640 {}
C {lab_pin.sym} 940 5640 0 0 {name=l4506 lab=BL5}
N 960 5600 940 5600 {}
C {lab_pin.sym} 940 5600 0 0 {name=l4507 lab=BLB5}
N 960 5560 940 5560 {}
C {lab_pin.sym} 940 5560 0 0 {name=l4508 lab=WL28}
N 1040 5640 1060 5640 {}
C {lab_pin.sym} 1060 5640 0 0 {name=l4509 lab=VDD}
N 1040 5560 1060 5560 {}
C {lab_pin.sym} 1060 5560 0 0 {name=l4510 lab=VSS}
C {bitcell_6t.sym} 1200 5600 0 0 {name=Xr28c6}
N 1160 5640 1140 5640 {}
C {lab_pin.sym} 1140 5640 0 0 {name=l4511 lab=BL6}
N 1160 5600 1140 5600 {}
C {lab_pin.sym} 1140 5600 0 0 {name=l4512 lab=BLB6}
N 1160 5560 1140 5560 {}
C {lab_pin.sym} 1140 5560 0 0 {name=l4513 lab=WL28}
N 1240 5640 1260 5640 {}
C {lab_pin.sym} 1260 5640 0 0 {name=l4514 lab=VDD}
N 1240 5560 1260 5560 {}
C {lab_pin.sym} 1260 5560 0 0 {name=l4515 lab=VSS}
C {bitcell_6t.sym} 1400 5600 0 0 {name=Xr28c7}
N 1360 5640 1340 5640 {}
C {lab_pin.sym} 1340 5640 0 0 {name=l4516 lab=BL7}
N 1360 5600 1340 5600 {}
C {lab_pin.sym} 1340 5600 0 0 {name=l4517 lab=BLB7}
N 1360 5560 1340 5560 {}
C {lab_pin.sym} 1340 5560 0 0 {name=l4518 lab=WL28}
N 1440 5640 1460 5640 {}
C {lab_pin.sym} 1460 5640 0 0 {name=l4519 lab=VDD}
N 1440 5560 1460 5560 {}
C {lab_pin.sym} 1460 5560 0 0 {name=l4520 lab=VSS}
C {bitcell_6t.sym} 1600 5600 0 0 {name=Xr28c8}
N 1560 5640 1540 5640 {}
C {lab_pin.sym} 1540 5640 0 0 {name=l4521 lab=BL8}
N 1560 5600 1540 5600 {}
C {lab_pin.sym} 1540 5600 0 0 {name=l4522 lab=BLB8}
N 1560 5560 1540 5560 {}
C {lab_pin.sym} 1540 5560 0 0 {name=l4523 lab=WL28}
N 1640 5640 1660 5640 {}
C {lab_pin.sym} 1660 5640 0 0 {name=l4524 lab=VDD}
N 1640 5560 1660 5560 {}
C {lab_pin.sym} 1660 5560 0 0 {name=l4525 lab=VSS}
C {bitcell_6t.sym} 1800 5600 0 0 {name=Xr28c9}
N 1760 5640 1740 5640 {}
C {lab_pin.sym} 1740 5640 0 0 {name=l4526 lab=BL9}
N 1760 5600 1740 5600 {}
C {lab_pin.sym} 1740 5600 0 0 {name=l4527 lab=BLB9}
N 1760 5560 1740 5560 {}
C {lab_pin.sym} 1740 5560 0 0 {name=l4528 lab=WL28}
N 1840 5640 1860 5640 {}
C {lab_pin.sym} 1860 5640 0 0 {name=l4529 lab=VDD}
N 1840 5560 1860 5560 {}
C {lab_pin.sym} 1860 5560 0 0 {name=l4530 lab=VSS}
C {bitcell_6t.sym} 2000 5600 0 0 {name=Xr28c10}
N 1960 5640 1940 5640 {}
C {lab_pin.sym} 1940 5640 0 0 {name=l4531 lab=BL10}
N 1960 5600 1940 5600 {}
C {lab_pin.sym} 1940 5600 0 0 {name=l4532 lab=BLB10}
N 1960 5560 1940 5560 {}
C {lab_pin.sym} 1940 5560 0 0 {name=l4533 lab=WL28}
N 2040 5640 2060 5640 {}
C {lab_pin.sym} 2060 5640 0 0 {name=l4534 lab=VDD}
N 2040 5560 2060 5560 {}
C {lab_pin.sym} 2060 5560 0 0 {name=l4535 lab=VSS}
C {bitcell_6t.sym} 2200 5600 0 0 {name=Xr28c11}
N 2160 5640 2140 5640 {}
C {lab_pin.sym} 2140 5640 0 0 {name=l4536 lab=BL11}
N 2160 5600 2140 5600 {}
C {lab_pin.sym} 2140 5600 0 0 {name=l4537 lab=BLB11}
N 2160 5560 2140 5560 {}
C {lab_pin.sym} 2140 5560 0 0 {name=l4538 lab=WL28}
N 2240 5640 2260 5640 {}
C {lab_pin.sym} 2260 5640 0 0 {name=l4539 lab=VDD}
N 2240 5560 2260 5560 {}
C {lab_pin.sym} 2260 5560 0 0 {name=l4540 lab=VSS}
C {bitcell_6t.sym} 2400 5600 0 0 {name=Xr28c12}
N 2360 5640 2340 5640 {}
C {lab_pin.sym} 2340 5640 0 0 {name=l4541 lab=BL12}
N 2360 5600 2340 5600 {}
C {lab_pin.sym} 2340 5600 0 0 {name=l4542 lab=BLB12}
N 2360 5560 2340 5560 {}
C {lab_pin.sym} 2340 5560 0 0 {name=l4543 lab=WL28}
N 2440 5640 2460 5640 {}
C {lab_pin.sym} 2460 5640 0 0 {name=l4544 lab=VDD}
N 2440 5560 2460 5560 {}
C {lab_pin.sym} 2460 5560 0 0 {name=l4545 lab=VSS}
C {bitcell_6t.sym} 2600 5600 0 0 {name=Xr28c13}
N 2560 5640 2540 5640 {}
C {lab_pin.sym} 2540 5640 0 0 {name=l4546 lab=BL13}
N 2560 5600 2540 5600 {}
C {lab_pin.sym} 2540 5600 0 0 {name=l4547 lab=BLB13}
N 2560 5560 2540 5560 {}
C {lab_pin.sym} 2540 5560 0 0 {name=l4548 lab=WL28}
N 2640 5640 2660 5640 {}
C {lab_pin.sym} 2660 5640 0 0 {name=l4549 lab=VDD}
N 2640 5560 2660 5560 {}
C {lab_pin.sym} 2660 5560 0 0 {name=l4550 lab=VSS}
C {bitcell_6t.sym} 2800 5600 0 0 {name=Xr28c14}
N 2760 5640 2740 5640 {}
C {lab_pin.sym} 2740 5640 0 0 {name=l4551 lab=BL14}
N 2760 5600 2740 5600 {}
C {lab_pin.sym} 2740 5600 0 0 {name=l4552 lab=BLB14}
N 2760 5560 2740 5560 {}
C {lab_pin.sym} 2740 5560 0 0 {name=l4553 lab=WL28}
N 2840 5640 2860 5640 {}
C {lab_pin.sym} 2860 5640 0 0 {name=l4554 lab=VDD}
N 2840 5560 2860 5560 {}
C {lab_pin.sym} 2860 5560 0 0 {name=l4555 lab=VSS}
C {bitcell_6t.sym} 3000 5600 0 0 {name=Xr28c15}
N 2960 5640 2940 5640 {}
C {lab_pin.sym} 2940 5640 0 0 {name=l4556 lab=BL15}
N 2960 5600 2940 5600 {}
C {lab_pin.sym} 2940 5600 0 0 {name=l4557 lab=BLB15}
N 2960 5560 2940 5560 {}
C {lab_pin.sym} 2940 5560 0 0 {name=l4558 lab=WL28}
N 3040 5640 3060 5640 {}
C {lab_pin.sym} 3060 5640 0 0 {name=l4559 lab=VDD}
N 3040 5560 3060 5560 {}
C {lab_pin.sym} 3060 5560 0 0 {name=l4560 lab=VSS}
C {bitcell_6t.sym} 3200 5600 0 0 {name=Xr28c16}
N 3160 5640 3140 5640 {}
C {lab_pin.sym} 3140 5640 0 0 {name=l4561 lab=BL16}
N 3160 5600 3140 5600 {}
C {lab_pin.sym} 3140 5600 0 0 {name=l4562 lab=BLB16}
N 3160 5560 3140 5560 {}
C {lab_pin.sym} 3140 5560 0 0 {name=l4563 lab=WL28}
N 3240 5640 3260 5640 {}
C {lab_pin.sym} 3260 5640 0 0 {name=l4564 lab=VDD}
N 3240 5560 3260 5560 {}
C {lab_pin.sym} 3260 5560 0 0 {name=l4565 lab=VSS}
C {bitcell_6t.sym} 3400 5600 0 0 {name=Xr28c17}
N 3360 5640 3340 5640 {}
C {lab_pin.sym} 3340 5640 0 0 {name=l4566 lab=BL17}
N 3360 5600 3340 5600 {}
C {lab_pin.sym} 3340 5600 0 0 {name=l4567 lab=BLB17}
N 3360 5560 3340 5560 {}
C {lab_pin.sym} 3340 5560 0 0 {name=l4568 lab=WL28}
N 3440 5640 3460 5640 {}
C {lab_pin.sym} 3460 5640 0 0 {name=l4569 lab=VDD}
N 3440 5560 3460 5560 {}
C {lab_pin.sym} 3460 5560 0 0 {name=l4570 lab=VSS}
C {bitcell_6t.sym} 3600 5600 0 0 {name=Xr28c18}
N 3560 5640 3540 5640 {}
C {lab_pin.sym} 3540 5640 0 0 {name=l4571 lab=BL18}
N 3560 5600 3540 5600 {}
C {lab_pin.sym} 3540 5600 0 0 {name=l4572 lab=BLB18}
N 3560 5560 3540 5560 {}
C {lab_pin.sym} 3540 5560 0 0 {name=l4573 lab=WL28}
N 3640 5640 3660 5640 {}
C {lab_pin.sym} 3660 5640 0 0 {name=l4574 lab=VDD}
N 3640 5560 3660 5560 {}
C {lab_pin.sym} 3660 5560 0 0 {name=l4575 lab=VSS}
C {bitcell_6t.sym} 3800 5600 0 0 {name=Xr28c19}
N 3760 5640 3740 5640 {}
C {lab_pin.sym} 3740 5640 0 0 {name=l4576 lab=BL19}
N 3760 5600 3740 5600 {}
C {lab_pin.sym} 3740 5600 0 0 {name=l4577 lab=BLB19}
N 3760 5560 3740 5560 {}
C {lab_pin.sym} 3740 5560 0 0 {name=l4578 lab=WL28}
N 3840 5640 3860 5640 {}
C {lab_pin.sym} 3860 5640 0 0 {name=l4579 lab=VDD}
N 3840 5560 3860 5560 {}
C {lab_pin.sym} 3860 5560 0 0 {name=l4580 lab=VSS}
C {bitcell_6t.sym} 4000 5600 0 0 {name=Xr28c20}
N 3960 5640 3940 5640 {}
C {lab_pin.sym} 3940 5640 0 0 {name=l4581 lab=BL20}
N 3960 5600 3940 5600 {}
C {lab_pin.sym} 3940 5600 0 0 {name=l4582 lab=BLB20}
N 3960 5560 3940 5560 {}
C {lab_pin.sym} 3940 5560 0 0 {name=l4583 lab=WL28}
N 4040 5640 4060 5640 {}
C {lab_pin.sym} 4060 5640 0 0 {name=l4584 lab=VDD}
N 4040 5560 4060 5560 {}
C {lab_pin.sym} 4060 5560 0 0 {name=l4585 lab=VSS}
C {bitcell_6t.sym} 4200 5600 0 0 {name=Xr28c21}
N 4160 5640 4140 5640 {}
C {lab_pin.sym} 4140 5640 0 0 {name=l4586 lab=BL21}
N 4160 5600 4140 5600 {}
C {lab_pin.sym} 4140 5600 0 0 {name=l4587 lab=BLB21}
N 4160 5560 4140 5560 {}
C {lab_pin.sym} 4140 5560 0 0 {name=l4588 lab=WL28}
N 4240 5640 4260 5640 {}
C {lab_pin.sym} 4260 5640 0 0 {name=l4589 lab=VDD}
N 4240 5560 4260 5560 {}
C {lab_pin.sym} 4260 5560 0 0 {name=l4590 lab=VSS}
C {bitcell_6t.sym} 4400 5600 0 0 {name=Xr28c22}
N 4360 5640 4340 5640 {}
C {lab_pin.sym} 4340 5640 0 0 {name=l4591 lab=BL22}
N 4360 5600 4340 5600 {}
C {lab_pin.sym} 4340 5600 0 0 {name=l4592 lab=BLB22}
N 4360 5560 4340 5560 {}
C {lab_pin.sym} 4340 5560 0 0 {name=l4593 lab=WL28}
N 4440 5640 4460 5640 {}
C {lab_pin.sym} 4460 5640 0 0 {name=l4594 lab=VDD}
N 4440 5560 4460 5560 {}
C {lab_pin.sym} 4460 5560 0 0 {name=l4595 lab=VSS}
C {bitcell_6t.sym} 4600 5600 0 0 {name=Xr28c23}
N 4560 5640 4540 5640 {}
C {lab_pin.sym} 4540 5640 0 0 {name=l4596 lab=BL23}
N 4560 5600 4540 5600 {}
C {lab_pin.sym} 4540 5600 0 0 {name=l4597 lab=BLB23}
N 4560 5560 4540 5560 {}
C {lab_pin.sym} 4540 5560 0 0 {name=l4598 lab=WL28}
N 4640 5640 4660 5640 {}
C {lab_pin.sym} 4660 5640 0 0 {name=l4599 lab=VDD}
N 4640 5560 4660 5560 {}
C {lab_pin.sym} 4660 5560 0 0 {name=l4600 lab=VSS}
C {bitcell_6t.sym} 4800 5600 0 0 {name=Xr28c24}
N 4760 5640 4740 5640 {}
C {lab_pin.sym} 4740 5640 0 0 {name=l4601 lab=BL24}
N 4760 5600 4740 5600 {}
C {lab_pin.sym} 4740 5600 0 0 {name=l4602 lab=BLB24}
N 4760 5560 4740 5560 {}
C {lab_pin.sym} 4740 5560 0 0 {name=l4603 lab=WL28}
N 4840 5640 4860 5640 {}
C {lab_pin.sym} 4860 5640 0 0 {name=l4604 lab=VDD}
N 4840 5560 4860 5560 {}
C {lab_pin.sym} 4860 5560 0 0 {name=l4605 lab=VSS}
C {bitcell_6t.sym} 5000 5600 0 0 {name=Xr28c25}
N 4960 5640 4940 5640 {}
C {lab_pin.sym} 4940 5640 0 0 {name=l4606 lab=BL25}
N 4960 5600 4940 5600 {}
C {lab_pin.sym} 4940 5600 0 0 {name=l4607 lab=BLB25}
N 4960 5560 4940 5560 {}
C {lab_pin.sym} 4940 5560 0 0 {name=l4608 lab=WL28}
N 5040 5640 5060 5640 {}
C {lab_pin.sym} 5060 5640 0 0 {name=l4609 lab=VDD}
N 5040 5560 5060 5560 {}
C {lab_pin.sym} 5060 5560 0 0 {name=l4610 lab=VSS}
C {bitcell_6t.sym} 5200 5600 0 0 {name=Xr28c26}
N 5160 5640 5140 5640 {}
C {lab_pin.sym} 5140 5640 0 0 {name=l4611 lab=BL26}
N 5160 5600 5140 5600 {}
C {lab_pin.sym} 5140 5600 0 0 {name=l4612 lab=BLB26}
N 5160 5560 5140 5560 {}
C {lab_pin.sym} 5140 5560 0 0 {name=l4613 lab=WL28}
N 5240 5640 5260 5640 {}
C {lab_pin.sym} 5260 5640 0 0 {name=l4614 lab=VDD}
N 5240 5560 5260 5560 {}
C {lab_pin.sym} 5260 5560 0 0 {name=l4615 lab=VSS}
C {bitcell_6t.sym} 5400 5600 0 0 {name=Xr28c27}
N 5360 5640 5340 5640 {}
C {lab_pin.sym} 5340 5640 0 0 {name=l4616 lab=BL27}
N 5360 5600 5340 5600 {}
C {lab_pin.sym} 5340 5600 0 0 {name=l4617 lab=BLB27}
N 5360 5560 5340 5560 {}
C {lab_pin.sym} 5340 5560 0 0 {name=l4618 lab=WL28}
N 5440 5640 5460 5640 {}
C {lab_pin.sym} 5460 5640 0 0 {name=l4619 lab=VDD}
N 5440 5560 5460 5560 {}
C {lab_pin.sym} 5460 5560 0 0 {name=l4620 lab=VSS}
C {bitcell_6t.sym} 5600 5600 0 0 {name=Xr28c28}
N 5560 5640 5540 5640 {}
C {lab_pin.sym} 5540 5640 0 0 {name=l4621 lab=BL28}
N 5560 5600 5540 5600 {}
C {lab_pin.sym} 5540 5600 0 0 {name=l4622 lab=BLB28}
N 5560 5560 5540 5560 {}
C {lab_pin.sym} 5540 5560 0 0 {name=l4623 lab=WL28}
N 5640 5640 5660 5640 {}
C {lab_pin.sym} 5660 5640 0 0 {name=l4624 lab=VDD}
N 5640 5560 5660 5560 {}
C {lab_pin.sym} 5660 5560 0 0 {name=l4625 lab=VSS}
C {bitcell_6t.sym} 5800 5600 0 0 {name=Xr28c29}
N 5760 5640 5740 5640 {}
C {lab_pin.sym} 5740 5640 0 0 {name=l4626 lab=BL29}
N 5760 5600 5740 5600 {}
C {lab_pin.sym} 5740 5600 0 0 {name=l4627 lab=BLB29}
N 5760 5560 5740 5560 {}
C {lab_pin.sym} 5740 5560 0 0 {name=l4628 lab=WL28}
N 5840 5640 5860 5640 {}
C {lab_pin.sym} 5860 5640 0 0 {name=l4629 lab=VDD}
N 5840 5560 5860 5560 {}
C {lab_pin.sym} 5860 5560 0 0 {name=l4630 lab=VSS}
C {bitcell_6t.sym} 6000 5600 0 0 {name=Xr28c30}
N 5960 5640 5940 5640 {}
C {lab_pin.sym} 5940 5640 0 0 {name=l4631 lab=BL30}
N 5960 5600 5940 5600 {}
C {lab_pin.sym} 5940 5600 0 0 {name=l4632 lab=BLB30}
N 5960 5560 5940 5560 {}
C {lab_pin.sym} 5940 5560 0 0 {name=l4633 lab=WL28}
N 6040 5640 6060 5640 {}
C {lab_pin.sym} 6060 5640 0 0 {name=l4634 lab=VDD}
N 6040 5560 6060 5560 {}
C {lab_pin.sym} 6060 5560 0 0 {name=l4635 lab=VSS}
C {bitcell_6t.sym} 6200 5600 0 0 {name=Xr28c31}
N 6160 5640 6140 5640 {}
C {lab_pin.sym} 6140 5640 0 0 {name=l4636 lab=BL31}
N 6160 5600 6140 5600 {}
C {lab_pin.sym} 6140 5600 0 0 {name=l4637 lab=BLB31}
N 6160 5560 6140 5560 {}
C {lab_pin.sym} 6140 5560 0 0 {name=l4638 lab=WL28}
N 6240 5640 6260 5640 {}
C {lab_pin.sym} 6260 5640 0 0 {name=l4639 lab=VDD}
N 6240 5560 6260 5560 {}
C {lab_pin.sym} 6260 5560 0 0 {name=l4640 lab=VSS}
C {bitcell_6t.sym} 0 5800 0 0 {name=Xr29c0}
N -40 5840 -60 5840 {}
C {lab_pin.sym} -60 5840 0 0 {name=l4641 lab=BL0}
N -40 5800 -60 5800 {}
C {lab_pin.sym} -60 5800 0 0 {name=l4642 lab=BLB0}
N -40 5760 -60 5760 {}
C {lab_pin.sym} -60 5760 0 0 {name=l4643 lab=WL29}
N 40 5840 60 5840 {}
C {lab_pin.sym} 60 5840 0 0 {name=l4644 lab=VDD}
N 40 5760 60 5760 {}
C {lab_pin.sym} 60 5760 0 0 {name=l4645 lab=VSS}
C {bitcell_6t.sym} 200 5800 0 0 {name=Xr29c1}
N 160 5840 140 5840 {}
C {lab_pin.sym} 140 5840 0 0 {name=l4646 lab=BL1}
N 160 5800 140 5800 {}
C {lab_pin.sym} 140 5800 0 0 {name=l4647 lab=BLB1}
N 160 5760 140 5760 {}
C {lab_pin.sym} 140 5760 0 0 {name=l4648 lab=WL29}
N 240 5840 260 5840 {}
C {lab_pin.sym} 260 5840 0 0 {name=l4649 lab=VDD}
N 240 5760 260 5760 {}
C {lab_pin.sym} 260 5760 0 0 {name=l4650 lab=VSS}
C {bitcell_6t.sym} 400 5800 0 0 {name=Xr29c2}
N 360 5840 340 5840 {}
C {lab_pin.sym} 340 5840 0 0 {name=l4651 lab=BL2}
N 360 5800 340 5800 {}
C {lab_pin.sym} 340 5800 0 0 {name=l4652 lab=BLB2}
N 360 5760 340 5760 {}
C {lab_pin.sym} 340 5760 0 0 {name=l4653 lab=WL29}
N 440 5840 460 5840 {}
C {lab_pin.sym} 460 5840 0 0 {name=l4654 lab=VDD}
N 440 5760 460 5760 {}
C {lab_pin.sym} 460 5760 0 0 {name=l4655 lab=VSS}
C {bitcell_6t.sym} 600 5800 0 0 {name=Xr29c3}
N 560 5840 540 5840 {}
C {lab_pin.sym} 540 5840 0 0 {name=l4656 lab=BL3}
N 560 5800 540 5800 {}
C {lab_pin.sym} 540 5800 0 0 {name=l4657 lab=BLB3}
N 560 5760 540 5760 {}
C {lab_pin.sym} 540 5760 0 0 {name=l4658 lab=WL29}
N 640 5840 660 5840 {}
C {lab_pin.sym} 660 5840 0 0 {name=l4659 lab=VDD}
N 640 5760 660 5760 {}
C {lab_pin.sym} 660 5760 0 0 {name=l4660 lab=VSS}
C {bitcell_6t.sym} 800 5800 0 0 {name=Xr29c4}
N 760 5840 740 5840 {}
C {lab_pin.sym} 740 5840 0 0 {name=l4661 lab=BL4}
N 760 5800 740 5800 {}
C {lab_pin.sym} 740 5800 0 0 {name=l4662 lab=BLB4}
N 760 5760 740 5760 {}
C {lab_pin.sym} 740 5760 0 0 {name=l4663 lab=WL29}
N 840 5840 860 5840 {}
C {lab_pin.sym} 860 5840 0 0 {name=l4664 lab=VDD}
N 840 5760 860 5760 {}
C {lab_pin.sym} 860 5760 0 0 {name=l4665 lab=VSS}
C {bitcell_6t.sym} 1000 5800 0 0 {name=Xr29c5}
N 960 5840 940 5840 {}
C {lab_pin.sym} 940 5840 0 0 {name=l4666 lab=BL5}
N 960 5800 940 5800 {}
C {lab_pin.sym} 940 5800 0 0 {name=l4667 lab=BLB5}
N 960 5760 940 5760 {}
C {lab_pin.sym} 940 5760 0 0 {name=l4668 lab=WL29}
N 1040 5840 1060 5840 {}
C {lab_pin.sym} 1060 5840 0 0 {name=l4669 lab=VDD}
N 1040 5760 1060 5760 {}
C {lab_pin.sym} 1060 5760 0 0 {name=l4670 lab=VSS}
C {bitcell_6t.sym} 1200 5800 0 0 {name=Xr29c6}
N 1160 5840 1140 5840 {}
C {lab_pin.sym} 1140 5840 0 0 {name=l4671 lab=BL6}
N 1160 5800 1140 5800 {}
C {lab_pin.sym} 1140 5800 0 0 {name=l4672 lab=BLB6}
N 1160 5760 1140 5760 {}
C {lab_pin.sym} 1140 5760 0 0 {name=l4673 lab=WL29}
N 1240 5840 1260 5840 {}
C {lab_pin.sym} 1260 5840 0 0 {name=l4674 lab=VDD}
N 1240 5760 1260 5760 {}
C {lab_pin.sym} 1260 5760 0 0 {name=l4675 lab=VSS}
C {bitcell_6t.sym} 1400 5800 0 0 {name=Xr29c7}
N 1360 5840 1340 5840 {}
C {lab_pin.sym} 1340 5840 0 0 {name=l4676 lab=BL7}
N 1360 5800 1340 5800 {}
C {lab_pin.sym} 1340 5800 0 0 {name=l4677 lab=BLB7}
N 1360 5760 1340 5760 {}
C {lab_pin.sym} 1340 5760 0 0 {name=l4678 lab=WL29}
N 1440 5840 1460 5840 {}
C {lab_pin.sym} 1460 5840 0 0 {name=l4679 lab=VDD}
N 1440 5760 1460 5760 {}
C {lab_pin.sym} 1460 5760 0 0 {name=l4680 lab=VSS}
C {bitcell_6t.sym} 1600 5800 0 0 {name=Xr29c8}
N 1560 5840 1540 5840 {}
C {lab_pin.sym} 1540 5840 0 0 {name=l4681 lab=BL8}
N 1560 5800 1540 5800 {}
C {lab_pin.sym} 1540 5800 0 0 {name=l4682 lab=BLB8}
N 1560 5760 1540 5760 {}
C {lab_pin.sym} 1540 5760 0 0 {name=l4683 lab=WL29}
N 1640 5840 1660 5840 {}
C {lab_pin.sym} 1660 5840 0 0 {name=l4684 lab=VDD}
N 1640 5760 1660 5760 {}
C {lab_pin.sym} 1660 5760 0 0 {name=l4685 lab=VSS}
C {bitcell_6t.sym} 1800 5800 0 0 {name=Xr29c9}
N 1760 5840 1740 5840 {}
C {lab_pin.sym} 1740 5840 0 0 {name=l4686 lab=BL9}
N 1760 5800 1740 5800 {}
C {lab_pin.sym} 1740 5800 0 0 {name=l4687 lab=BLB9}
N 1760 5760 1740 5760 {}
C {lab_pin.sym} 1740 5760 0 0 {name=l4688 lab=WL29}
N 1840 5840 1860 5840 {}
C {lab_pin.sym} 1860 5840 0 0 {name=l4689 lab=VDD}
N 1840 5760 1860 5760 {}
C {lab_pin.sym} 1860 5760 0 0 {name=l4690 lab=VSS}
C {bitcell_6t.sym} 2000 5800 0 0 {name=Xr29c10}
N 1960 5840 1940 5840 {}
C {lab_pin.sym} 1940 5840 0 0 {name=l4691 lab=BL10}
N 1960 5800 1940 5800 {}
C {lab_pin.sym} 1940 5800 0 0 {name=l4692 lab=BLB10}
N 1960 5760 1940 5760 {}
C {lab_pin.sym} 1940 5760 0 0 {name=l4693 lab=WL29}
N 2040 5840 2060 5840 {}
C {lab_pin.sym} 2060 5840 0 0 {name=l4694 lab=VDD}
N 2040 5760 2060 5760 {}
C {lab_pin.sym} 2060 5760 0 0 {name=l4695 lab=VSS}
C {bitcell_6t.sym} 2200 5800 0 0 {name=Xr29c11}
N 2160 5840 2140 5840 {}
C {lab_pin.sym} 2140 5840 0 0 {name=l4696 lab=BL11}
N 2160 5800 2140 5800 {}
C {lab_pin.sym} 2140 5800 0 0 {name=l4697 lab=BLB11}
N 2160 5760 2140 5760 {}
C {lab_pin.sym} 2140 5760 0 0 {name=l4698 lab=WL29}
N 2240 5840 2260 5840 {}
C {lab_pin.sym} 2260 5840 0 0 {name=l4699 lab=VDD}
N 2240 5760 2260 5760 {}
C {lab_pin.sym} 2260 5760 0 0 {name=l4700 lab=VSS}
C {bitcell_6t.sym} 2400 5800 0 0 {name=Xr29c12}
N 2360 5840 2340 5840 {}
C {lab_pin.sym} 2340 5840 0 0 {name=l4701 lab=BL12}
N 2360 5800 2340 5800 {}
C {lab_pin.sym} 2340 5800 0 0 {name=l4702 lab=BLB12}
N 2360 5760 2340 5760 {}
C {lab_pin.sym} 2340 5760 0 0 {name=l4703 lab=WL29}
N 2440 5840 2460 5840 {}
C {lab_pin.sym} 2460 5840 0 0 {name=l4704 lab=VDD}
N 2440 5760 2460 5760 {}
C {lab_pin.sym} 2460 5760 0 0 {name=l4705 lab=VSS}
C {bitcell_6t.sym} 2600 5800 0 0 {name=Xr29c13}
N 2560 5840 2540 5840 {}
C {lab_pin.sym} 2540 5840 0 0 {name=l4706 lab=BL13}
N 2560 5800 2540 5800 {}
C {lab_pin.sym} 2540 5800 0 0 {name=l4707 lab=BLB13}
N 2560 5760 2540 5760 {}
C {lab_pin.sym} 2540 5760 0 0 {name=l4708 lab=WL29}
N 2640 5840 2660 5840 {}
C {lab_pin.sym} 2660 5840 0 0 {name=l4709 lab=VDD}
N 2640 5760 2660 5760 {}
C {lab_pin.sym} 2660 5760 0 0 {name=l4710 lab=VSS}
C {bitcell_6t.sym} 2800 5800 0 0 {name=Xr29c14}
N 2760 5840 2740 5840 {}
C {lab_pin.sym} 2740 5840 0 0 {name=l4711 lab=BL14}
N 2760 5800 2740 5800 {}
C {lab_pin.sym} 2740 5800 0 0 {name=l4712 lab=BLB14}
N 2760 5760 2740 5760 {}
C {lab_pin.sym} 2740 5760 0 0 {name=l4713 lab=WL29}
N 2840 5840 2860 5840 {}
