C {lab_pin.sym} 1460 17160 0 0 {name=l13800 lab=VSS}
C {bitcell_6t.sym} 1600 17200 0 0 {name=Xr86c8}
N 1560 17240 1540 17240 {}
C {lab_pin.sym} 1540 17240 0 0 {name=l13801 lab=BL8}
N 1560 17200 1540 17200 {}
C {lab_pin.sym} 1540 17200 0 0 {name=l13802 lab=BLB8}
N 1560 17160 1540 17160 {}
C {lab_pin.sym} 1540 17160 0 0 {name=l13803 lab=WL86}
N 1640 17240 1660 17240 {}
C {lab_pin.sym} 1660 17240 0 0 {name=l13804 lab=VDD}
N 1640 17160 1660 17160 {}
C {lab_pin.sym} 1660 17160 0 0 {name=l13805 lab=VSS}
C {bitcell_6t.sym} 1800 17200 0 0 {name=Xr86c9}
N 1760 17240 1740 17240 {}
C {lab_pin.sym} 1740 17240 0 0 {name=l13806 lab=BL9}
N 1760 17200 1740 17200 {}
C {lab_pin.sym} 1740 17200 0 0 {name=l13807 lab=BLB9}
N 1760 17160 1740 17160 {}
C {lab_pin.sym} 1740 17160 0 0 {name=l13808 lab=WL86}
N 1840 17240 1860 17240 {}
C {lab_pin.sym} 1860 17240 0 0 {name=l13809 lab=VDD}
N 1840 17160 1860 17160 {}
C {lab_pin.sym} 1860 17160 0 0 {name=l13810 lab=VSS}
C {bitcell_6t.sym} 2000 17200 0 0 {name=Xr86c10}
N 1960 17240 1940 17240 {}
C {lab_pin.sym} 1940 17240 0 0 {name=l13811 lab=BL10}
N 1960 17200 1940 17200 {}
C {lab_pin.sym} 1940 17200 0 0 {name=l13812 lab=BLB10}
N 1960 17160 1940 17160 {}
C {lab_pin.sym} 1940 17160 0 0 {name=l13813 lab=WL86}
N 2040 17240 2060 17240 {}
C {lab_pin.sym} 2060 17240 0 0 {name=l13814 lab=VDD}
N 2040 17160 2060 17160 {}
C {lab_pin.sym} 2060 17160 0 0 {name=l13815 lab=VSS}
C {bitcell_6t.sym} 2200 17200 0 0 {name=Xr86c11}
N 2160 17240 2140 17240 {}
C {lab_pin.sym} 2140 17240 0 0 {name=l13816 lab=BL11}
N 2160 17200 2140 17200 {}
C {lab_pin.sym} 2140 17200 0 0 {name=l13817 lab=BLB11}
N 2160 17160 2140 17160 {}
C {lab_pin.sym} 2140 17160 0 0 {name=l13818 lab=WL86}
N 2240 17240 2260 17240 {}
C {lab_pin.sym} 2260 17240 0 0 {name=l13819 lab=VDD}
N 2240 17160 2260 17160 {}
C {lab_pin.sym} 2260 17160 0 0 {name=l13820 lab=VSS}
C {bitcell_6t.sym} 2400 17200 0 0 {name=Xr86c12}
N 2360 17240 2340 17240 {}
C {lab_pin.sym} 2340 17240 0 0 {name=l13821 lab=BL12}
N 2360 17200 2340 17200 {}
C {lab_pin.sym} 2340 17200 0 0 {name=l13822 lab=BLB12}
N 2360 17160 2340 17160 {}
C {lab_pin.sym} 2340 17160 0 0 {name=l13823 lab=WL86}
N 2440 17240 2460 17240 {}
C {lab_pin.sym} 2460 17240 0 0 {name=l13824 lab=VDD}
N 2440 17160 2460 17160 {}
C {lab_pin.sym} 2460 17160 0 0 {name=l13825 lab=VSS}
C {bitcell_6t.sym} 2600 17200 0 0 {name=Xr86c13}
N 2560 17240 2540 17240 {}
C {lab_pin.sym} 2540 17240 0 0 {name=l13826 lab=BL13}
N 2560 17200 2540 17200 {}
C {lab_pin.sym} 2540 17200 0 0 {name=l13827 lab=BLB13}
N 2560 17160 2540 17160 {}
C {lab_pin.sym} 2540 17160 0 0 {name=l13828 lab=WL86}
N 2640 17240 2660 17240 {}
C {lab_pin.sym} 2660 17240 0 0 {name=l13829 lab=VDD}
N 2640 17160 2660 17160 {}
C {lab_pin.sym} 2660 17160 0 0 {name=l13830 lab=VSS}
C {bitcell_6t.sym} 2800 17200 0 0 {name=Xr86c14}
N 2760 17240 2740 17240 {}
C {lab_pin.sym} 2740 17240 0 0 {name=l13831 lab=BL14}
N 2760 17200 2740 17200 {}
C {lab_pin.sym} 2740 17200 0 0 {name=l13832 lab=BLB14}
N 2760 17160 2740 17160 {}
C {lab_pin.sym} 2740 17160 0 0 {name=l13833 lab=WL86}
N 2840 17240 2860 17240 {}
C {lab_pin.sym} 2860 17240 0 0 {name=l13834 lab=VDD}
N 2840 17160 2860 17160 {}
C {lab_pin.sym} 2860 17160 0 0 {name=l13835 lab=VSS}
C {bitcell_6t.sym} 3000 17200 0 0 {name=Xr86c15}
N 2960 17240 2940 17240 {}
C {lab_pin.sym} 2940 17240 0 0 {name=l13836 lab=BL15}
N 2960 17200 2940 17200 {}
C {lab_pin.sym} 2940 17200 0 0 {name=l13837 lab=BLB15}
N 2960 17160 2940 17160 {}
C {lab_pin.sym} 2940 17160 0 0 {name=l13838 lab=WL86}
N 3040 17240 3060 17240 {}
C {lab_pin.sym} 3060 17240 0 0 {name=l13839 lab=VDD}
N 3040 17160 3060 17160 {}
C {lab_pin.sym} 3060 17160 0 0 {name=l13840 lab=VSS}
C {bitcell_6t.sym} 3200 17200 0 0 {name=Xr86c16}
N 3160 17240 3140 17240 {}
C {lab_pin.sym} 3140 17240 0 0 {name=l13841 lab=BL16}
N 3160 17200 3140 17200 {}
C {lab_pin.sym} 3140 17200 0 0 {name=l13842 lab=BLB16}
N 3160 17160 3140 17160 {}
C {lab_pin.sym} 3140 17160 0 0 {name=l13843 lab=WL86}
N 3240 17240 3260 17240 {}
C {lab_pin.sym} 3260 17240 0 0 {name=l13844 lab=VDD}
N 3240 17160 3260 17160 {}
C {lab_pin.sym} 3260 17160 0 0 {name=l13845 lab=VSS}
C {bitcell_6t.sym} 3400 17200 0 0 {name=Xr86c17}
N 3360 17240 3340 17240 {}
C {lab_pin.sym} 3340 17240 0 0 {name=l13846 lab=BL17}
N 3360 17200 3340 17200 {}
C {lab_pin.sym} 3340 17200 0 0 {name=l13847 lab=BLB17}
N 3360 17160 3340 17160 {}
C {lab_pin.sym} 3340 17160 0 0 {name=l13848 lab=WL86}
N 3440 17240 3460 17240 {}
C {lab_pin.sym} 3460 17240 0 0 {name=l13849 lab=VDD}
N 3440 17160 3460 17160 {}
C {lab_pin.sym} 3460 17160 0 0 {name=l13850 lab=VSS}
C {bitcell_6t.sym} 3600 17200 0 0 {name=Xr86c18}
N 3560 17240 3540 17240 {}
C {lab_pin.sym} 3540 17240 0 0 {name=l13851 lab=BL18}
N 3560 17200 3540 17200 {}
C {lab_pin.sym} 3540 17200 0 0 {name=l13852 lab=BLB18}
N 3560 17160 3540 17160 {}
C {lab_pin.sym} 3540 17160 0 0 {name=l13853 lab=WL86}
N 3640 17240 3660 17240 {}
C {lab_pin.sym} 3660 17240 0 0 {name=l13854 lab=VDD}
N 3640 17160 3660 17160 {}
C {lab_pin.sym} 3660 17160 0 0 {name=l13855 lab=VSS}
C {bitcell_6t.sym} 3800 17200 0 0 {name=Xr86c19}
N 3760 17240 3740 17240 {}
C {lab_pin.sym} 3740 17240 0 0 {name=l13856 lab=BL19}
N 3760 17200 3740 17200 {}
C {lab_pin.sym} 3740 17200 0 0 {name=l13857 lab=BLB19}
N 3760 17160 3740 17160 {}
C {lab_pin.sym} 3740 17160 0 0 {name=l13858 lab=WL86}
N 3840 17240 3860 17240 {}
C {lab_pin.sym} 3860 17240 0 0 {name=l13859 lab=VDD}
N 3840 17160 3860 17160 {}
C {lab_pin.sym} 3860 17160 0 0 {name=l13860 lab=VSS}
C {bitcell_6t.sym} 4000 17200 0 0 {name=Xr86c20}
N 3960 17240 3940 17240 {}
C {lab_pin.sym} 3940 17240 0 0 {name=l13861 lab=BL20}
N 3960 17200 3940 17200 {}
C {lab_pin.sym} 3940 17200 0 0 {name=l13862 lab=BLB20}
N 3960 17160 3940 17160 {}
C {lab_pin.sym} 3940 17160 0 0 {name=l13863 lab=WL86}
N 4040 17240 4060 17240 {}
C {lab_pin.sym} 4060 17240 0 0 {name=l13864 lab=VDD}
N 4040 17160 4060 17160 {}
C {lab_pin.sym} 4060 17160 0 0 {name=l13865 lab=VSS}
C {bitcell_6t.sym} 4200 17200 0 0 {name=Xr86c21}
N 4160 17240 4140 17240 {}
C {lab_pin.sym} 4140 17240 0 0 {name=l13866 lab=BL21}
N 4160 17200 4140 17200 {}
C {lab_pin.sym} 4140 17200 0 0 {name=l13867 lab=BLB21}
N 4160 17160 4140 17160 {}
C {lab_pin.sym} 4140 17160 0 0 {name=l13868 lab=WL86}
N 4240 17240 4260 17240 {}
C {lab_pin.sym} 4260 17240 0 0 {name=l13869 lab=VDD}
N 4240 17160 4260 17160 {}
C {lab_pin.sym} 4260 17160 0 0 {name=l13870 lab=VSS}
C {bitcell_6t.sym} 4400 17200 0 0 {name=Xr86c22}
N 4360 17240 4340 17240 {}
C {lab_pin.sym} 4340 17240 0 0 {name=l13871 lab=BL22}
N 4360 17200 4340 17200 {}
C {lab_pin.sym} 4340 17200 0 0 {name=l13872 lab=BLB22}
N 4360 17160 4340 17160 {}
C {lab_pin.sym} 4340 17160 0 0 {name=l13873 lab=WL86}
N 4440 17240 4460 17240 {}
C {lab_pin.sym} 4460 17240 0 0 {name=l13874 lab=VDD}
N 4440 17160 4460 17160 {}
C {lab_pin.sym} 4460 17160 0 0 {name=l13875 lab=VSS}
C {bitcell_6t.sym} 4600 17200 0 0 {name=Xr86c23}
N 4560 17240 4540 17240 {}
C {lab_pin.sym} 4540 17240 0 0 {name=l13876 lab=BL23}
N 4560 17200 4540 17200 {}
C {lab_pin.sym} 4540 17200 0 0 {name=l13877 lab=BLB23}
N 4560 17160 4540 17160 {}
C {lab_pin.sym} 4540 17160 0 0 {name=l13878 lab=WL86}
N 4640 17240 4660 17240 {}
C {lab_pin.sym} 4660 17240 0 0 {name=l13879 lab=VDD}
N 4640 17160 4660 17160 {}
C {lab_pin.sym} 4660 17160 0 0 {name=l13880 lab=VSS}
C {bitcell_6t.sym} 4800 17200 0 0 {name=Xr86c24}
N 4760 17240 4740 17240 {}
C {lab_pin.sym} 4740 17240 0 0 {name=l13881 lab=BL24}
N 4760 17200 4740 17200 {}
C {lab_pin.sym} 4740 17200 0 0 {name=l13882 lab=BLB24}
N 4760 17160 4740 17160 {}
C {lab_pin.sym} 4740 17160 0 0 {name=l13883 lab=WL86}
N 4840 17240 4860 17240 {}
C {lab_pin.sym} 4860 17240 0 0 {name=l13884 lab=VDD}
N 4840 17160 4860 17160 {}
C {lab_pin.sym} 4860 17160 0 0 {name=l13885 lab=VSS}
C {bitcell_6t.sym} 5000 17200 0 0 {name=Xr86c25}
N 4960 17240 4940 17240 {}
C {lab_pin.sym} 4940 17240 0 0 {name=l13886 lab=BL25}
N 4960 17200 4940 17200 {}
C {lab_pin.sym} 4940 17200 0 0 {name=l13887 lab=BLB25}
N 4960 17160 4940 17160 {}
C {lab_pin.sym} 4940 17160 0 0 {name=l13888 lab=WL86}
N 5040 17240 5060 17240 {}
C {lab_pin.sym} 5060 17240 0 0 {name=l13889 lab=VDD}
N 5040 17160 5060 17160 {}
C {lab_pin.sym} 5060 17160 0 0 {name=l13890 lab=VSS}
C {bitcell_6t.sym} 5200 17200 0 0 {name=Xr86c26}
N 5160 17240 5140 17240 {}
C {lab_pin.sym} 5140 17240 0 0 {name=l13891 lab=BL26}
N 5160 17200 5140 17200 {}
C {lab_pin.sym} 5140 17200 0 0 {name=l13892 lab=BLB26}
N 5160 17160 5140 17160 {}
C {lab_pin.sym} 5140 17160 0 0 {name=l13893 lab=WL86}
N 5240 17240 5260 17240 {}
C {lab_pin.sym} 5260 17240 0 0 {name=l13894 lab=VDD}
N 5240 17160 5260 17160 {}
C {lab_pin.sym} 5260 17160 0 0 {name=l13895 lab=VSS}
C {bitcell_6t.sym} 5400 17200 0 0 {name=Xr86c27}
N 5360 17240 5340 17240 {}
C {lab_pin.sym} 5340 17240 0 0 {name=l13896 lab=BL27}
N 5360 17200 5340 17200 {}
C {lab_pin.sym} 5340 17200 0 0 {name=l13897 lab=BLB27}
N 5360 17160 5340 17160 {}
C {lab_pin.sym} 5340 17160 0 0 {name=l13898 lab=WL86}
N 5440 17240 5460 17240 {}
C {lab_pin.sym} 5460 17240 0 0 {name=l13899 lab=VDD}
N 5440 17160 5460 17160 {}
C {lab_pin.sym} 5460 17160 0 0 {name=l13900 lab=VSS}
C {bitcell_6t.sym} 5600 17200 0 0 {name=Xr86c28}
N 5560 17240 5540 17240 {}
C {lab_pin.sym} 5540 17240 0 0 {name=l13901 lab=BL28}
N 5560 17200 5540 17200 {}
C {lab_pin.sym} 5540 17200 0 0 {name=l13902 lab=BLB28}
N 5560 17160 5540 17160 {}
C {lab_pin.sym} 5540 17160 0 0 {name=l13903 lab=WL86}
N 5640 17240 5660 17240 {}
C {lab_pin.sym} 5660 17240 0 0 {name=l13904 lab=VDD}
N 5640 17160 5660 17160 {}
C {lab_pin.sym} 5660 17160 0 0 {name=l13905 lab=VSS}
C {bitcell_6t.sym} 5800 17200 0 0 {name=Xr86c29}
N 5760 17240 5740 17240 {}
C {lab_pin.sym} 5740 17240 0 0 {name=l13906 lab=BL29}
N 5760 17200 5740 17200 {}
C {lab_pin.sym} 5740 17200 0 0 {name=l13907 lab=BLB29}
N 5760 17160 5740 17160 {}
C {lab_pin.sym} 5740 17160 0 0 {name=l13908 lab=WL86}
N 5840 17240 5860 17240 {}
C {lab_pin.sym} 5860 17240 0 0 {name=l13909 lab=VDD}
N 5840 17160 5860 17160 {}
C {lab_pin.sym} 5860 17160 0 0 {name=l13910 lab=VSS}
C {bitcell_6t.sym} 6000 17200 0 0 {name=Xr86c30}
N 5960 17240 5940 17240 {}
C {lab_pin.sym} 5940 17240 0 0 {name=l13911 lab=BL30}
N 5960 17200 5940 17200 {}
C {lab_pin.sym} 5940 17200 0 0 {name=l13912 lab=BLB30}
N 5960 17160 5940 17160 {}
C {lab_pin.sym} 5940 17160 0 0 {name=l13913 lab=WL86}
N 6040 17240 6060 17240 {}
C {lab_pin.sym} 6060 17240 0 0 {name=l13914 lab=VDD}
N 6040 17160 6060 17160 {}
C {lab_pin.sym} 6060 17160 0 0 {name=l13915 lab=VSS}
C {bitcell_6t.sym} 6200 17200 0 0 {name=Xr86c31}
N 6160 17240 6140 17240 {}
C {lab_pin.sym} 6140 17240 0 0 {name=l13916 lab=BL31}
N 6160 17200 6140 17200 {}
C {lab_pin.sym} 6140 17200 0 0 {name=l13917 lab=BLB31}
N 6160 17160 6140 17160 {}
C {lab_pin.sym} 6140 17160 0 0 {name=l13918 lab=WL86}
N 6240 17240 6260 17240 {}
C {lab_pin.sym} 6260 17240 0 0 {name=l13919 lab=VDD}
N 6240 17160 6260 17160 {}
C {lab_pin.sym} 6260 17160 0 0 {name=l13920 lab=VSS}
C {bitcell_6t.sym} 0 17400 0 0 {name=Xr87c0}
N -40 17440 -60 17440 {}
C {lab_pin.sym} -60 17440 0 0 {name=l13921 lab=BL0}
N -40 17400 -60 17400 {}
C {lab_pin.sym} -60 17400 0 0 {name=l13922 lab=BLB0}
N -40 17360 -60 17360 {}
C {lab_pin.sym} -60 17360 0 0 {name=l13923 lab=WL87}
N 40 17440 60 17440 {}
C {lab_pin.sym} 60 17440 0 0 {name=l13924 lab=VDD}
N 40 17360 60 17360 {}
C {lab_pin.sym} 60 17360 0 0 {name=l13925 lab=VSS}
C {bitcell_6t.sym} 200 17400 0 0 {name=Xr87c1}
N 160 17440 140 17440 {}
C {lab_pin.sym} 140 17440 0 0 {name=l13926 lab=BL1}
N 160 17400 140 17400 {}
C {lab_pin.sym} 140 17400 0 0 {name=l13927 lab=BLB1}
N 160 17360 140 17360 {}
C {lab_pin.sym} 140 17360 0 0 {name=l13928 lab=WL87}
N 240 17440 260 17440 {}
C {lab_pin.sym} 260 17440 0 0 {name=l13929 lab=VDD}
N 240 17360 260 17360 {}
C {lab_pin.sym} 260 17360 0 0 {name=l13930 lab=VSS}
C {bitcell_6t.sym} 400 17400 0 0 {name=Xr87c2}
N 360 17440 340 17440 {}
C {lab_pin.sym} 340 17440 0 0 {name=l13931 lab=BL2}
N 360 17400 340 17400 {}
C {lab_pin.sym} 340 17400 0 0 {name=l13932 lab=BLB2}
N 360 17360 340 17360 {}
C {lab_pin.sym} 340 17360 0 0 {name=l13933 lab=WL87}
N 440 17440 460 17440 {}
C {lab_pin.sym} 460 17440 0 0 {name=l13934 lab=VDD}
N 440 17360 460 17360 {}
C {lab_pin.sym} 460 17360 0 0 {name=l13935 lab=VSS}
C {bitcell_6t.sym} 600 17400 0 0 {name=Xr87c3}
N 560 17440 540 17440 {}
C {lab_pin.sym} 540 17440 0 0 {name=l13936 lab=BL3}
N 560 17400 540 17400 {}
C {lab_pin.sym} 540 17400 0 0 {name=l13937 lab=BLB3}
N 560 17360 540 17360 {}
C {lab_pin.sym} 540 17360 0 0 {name=l13938 lab=WL87}
N 640 17440 660 17440 {}
C {lab_pin.sym} 660 17440 0 0 {name=l13939 lab=VDD}
N 640 17360 660 17360 {}
C {lab_pin.sym} 660 17360 0 0 {name=l13940 lab=VSS}
C {bitcell_6t.sym} 800 17400 0 0 {name=Xr87c4}
N 760 17440 740 17440 {}
C {lab_pin.sym} 740 17440 0 0 {name=l13941 lab=BL4}
N 760 17400 740 17400 {}
C {lab_pin.sym} 740 17400 0 0 {name=l13942 lab=BLB4}
N 760 17360 740 17360 {}
C {lab_pin.sym} 740 17360 0 0 {name=l13943 lab=WL87}
N 840 17440 860 17440 {}
C {lab_pin.sym} 860 17440 0 0 {name=l13944 lab=VDD}
N 840 17360 860 17360 {}
C {lab_pin.sym} 860 17360 0 0 {name=l13945 lab=VSS}
C {bitcell_6t.sym} 1000 17400 0 0 {name=Xr87c5}
N 960 17440 940 17440 {}
C {lab_pin.sym} 940 17440 0 0 {name=l13946 lab=BL5}
N 960 17400 940 17400 {}
C {lab_pin.sym} 940 17400 0 0 {name=l13947 lab=BLB5}
N 960 17360 940 17360 {}
C {lab_pin.sym} 940 17360 0 0 {name=l13948 lab=WL87}
N 1040 17440 1060 17440 {}
C {lab_pin.sym} 1060 17440 0 0 {name=l13949 lab=VDD}
N 1040 17360 1060 17360 {}
C {lab_pin.sym} 1060 17360 0 0 {name=l13950 lab=VSS}
C {bitcell_6t.sym} 1200 17400 0 0 {name=Xr87c6}
N 1160 17440 1140 17440 {}
C {lab_pin.sym} 1140 17440 0 0 {name=l13951 lab=BL6}
N 1160 17400 1140 17400 {}
C {lab_pin.sym} 1140 17400 0 0 {name=l13952 lab=BLB6}
N 1160 17360 1140 17360 {}
C {lab_pin.sym} 1140 17360 0 0 {name=l13953 lab=WL87}
N 1240 17440 1260 17440 {}
C {lab_pin.sym} 1260 17440 0 0 {name=l13954 lab=VDD}
N 1240 17360 1260 17360 {}
C {lab_pin.sym} 1260 17360 0 0 {name=l13955 lab=VSS}
C {bitcell_6t.sym} 1400 17400 0 0 {name=Xr87c7}
N 1360 17440 1340 17440 {}
C {lab_pin.sym} 1340 17440 0 0 {name=l13956 lab=BL7}
N 1360 17400 1340 17400 {}
C {lab_pin.sym} 1340 17400 0 0 {name=l13957 lab=BLB7}
N 1360 17360 1340 17360 {}
C {lab_pin.sym} 1340 17360 0 0 {name=l13958 lab=WL87}
N 1440 17440 1460 17440 {}
C {lab_pin.sym} 1460 17440 0 0 {name=l13959 lab=VDD}
N 1440 17360 1460 17360 {}
C {lab_pin.sym} 1460 17360 0 0 {name=l13960 lab=VSS}
C {bitcell_6t.sym} 1600 17400 0 0 {name=Xr87c8}
N 1560 17440 1540 17440 {}
C {lab_pin.sym} 1540 17440 0 0 {name=l13961 lab=BL8}
N 1560 17400 1540 17400 {}
C {lab_pin.sym} 1540 17400 0 0 {name=l13962 lab=BLB8}
N 1560 17360 1540 17360 {}
C {lab_pin.sym} 1540 17360 0 0 {name=l13963 lab=WL87}
N 1640 17440 1660 17440 {}
C {lab_pin.sym} 1660 17440 0 0 {name=l13964 lab=VDD}
N 1640 17360 1660 17360 {}
C {lab_pin.sym} 1660 17360 0 0 {name=l13965 lab=VSS}
C {bitcell_6t.sym} 1800 17400 0 0 {name=Xr87c9}
N 1760 17440 1740 17440 {}
C {lab_pin.sym} 1740 17440 0 0 {name=l13966 lab=BL9}
N 1760 17400 1740 17400 {}
C {lab_pin.sym} 1740 17400 0 0 {name=l13967 lab=BLB9}
N 1760 17360 1740 17360 {}
C {lab_pin.sym} 1740 17360 0 0 {name=l13968 lab=WL87}
N 1840 17440 1860 17440 {}
C {lab_pin.sym} 1860 17440 0 0 {name=l13969 lab=VDD}
N 1840 17360 1860 17360 {}
C {lab_pin.sym} 1860 17360 0 0 {name=l13970 lab=VSS}
C {bitcell_6t.sym} 2000 17400 0 0 {name=Xr87c10}
N 1960 17440 1940 17440 {}
C {lab_pin.sym} 1940 17440 0 0 {name=l13971 lab=BL10}
N 1960 17400 1940 17400 {}
C {lab_pin.sym} 1940 17400 0 0 {name=l13972 lab=BLB10}
N 1960 17360 1940 17360 {}
C {lab_pin.sym} 1940 17360 0 0 {name=l13973 lab=WL87}
N 2040 17440 2060 17440 {}
C {lab_pin.sym} 2060 17440 0 0 {name=l13974 lab=VDD}
N 2040 17360 2060 17360 {}
C {lab_pin.sym} 2060 17360 0 0 {name=l13975 lab=VSS}
C {bitcell_6t.sym} 2200 17400 0 0 {name=Xr87c11}
N 2160 17440 2140 17440 {}
C {lab_pin.sym} 2140 17440 0 0 {name=l13976 lab=BL11}
N 2160 17400 2140 17400 {}
C {lab_pin.sym} 2140 17400 0 0 {name=l13977 lab=BLB11}
N 2160 17360 2140 17360 {}
C {lab_pin.sym} 2140 17360 0 0 {name=l13978 lab=WL87}
N 2240 17440 2260 17440 {}
C {lab_pin.sym} 2260 17440 0 0 {name=l13979 lab=VDD}
N 2240 17360 2260 17360 {}
C {lab_pin.sym} 2260 17360 0 0 {name=l13980 lab=VSS}
C {bitcell_6t.sym} 2400 17400 0 0 {name=Xr87c12}
N 2360 17440 2340 17440 {}
C {lab_pin.sym} 2340 17440 0 0 {name=l13981 lab=BL12}
N 2360 17400 2340 17400 {}
C {lab_pin.sym} 2340 17400 0 0 {name=l13982 lab=BLB12}
N 2360 17360 2340 17360 {}
C {lab_pin.sym} 2340 17360 0 0 {name=l13983 lab=WL87}
N 2440 17440 2460 17440 {}
C {lab_pin.sym} 2460 17440 0 0 {name=l13984 lab=VDD}
N 2440 17360 2460 17360 {}
C {lab_pin.sym} 2460 17360 0 0 {name=l13985 lab=VSS}
C {bitcell_6t.sym} 2600 17400 0 0 {name=Xr87c13}
N 2560 17440 2540 17440 {}
C {lab_pin.sym} 2540 17440 0 0 {name=l13986 lab=BL13}
N 2560 17400 2540 17400 {}
C {lab_pin.sym} 2540 17400 0 0 {name=l13987 lab=BLB13}
N 2560 17360 2540 17360 {}
C {lab_pin.sym} 2540 17360 0 0 {name=l13988 lab=WL87}
N 2640 17440 2660 17440 {}
C {lab_pin.sym} 2660 17440 0 0 {name=l13989 lab=VDD}
N 2640 17360 2660 17360 {}
C {lab_pin.sym} 2660 17360 0 0 {name=l13990 lab=VSS}
C {bitcell_6t.sym} 2800 17400 0 0 {name=Xr87c14}
N 2760 17440 2740 17440 {}
C {lab_pin.sym} 2740 17440 0 0 {name=l13991 lab=BL14}
N 2760 17400 2740 17400 {}
C {lab_pin.sym} 2740 17400 0 0 {name=l13992 lab=BLB14}
N 2760 17360 2740 17360 {}
C {lab_pin.sym} 2740 17360 0 0 {name=l13993 lab=WL87}
N 2840 17440 2860 17440 {}
C {lab_pin.sym} 2860 17440 0 0 {name=l13994 lab=VDD}
N 2840 17360 2860 17360 {}
C {lab_pin.sym} 2860 17360 0 0 {name=l13995 lab=VSS}
C {bitcell_6t.sym} 3000 17400 0 0 {name=Xr87c15}
N 2960 17440 2940 17440 {}
C {lab_pin.sym} 2940 17440 0 0 {name=l13996 lab=BL15}
N 2960 17400 2940 17400 {}
C {lab_pin.sym} 2940 17400 0 0 {name=l13997 lab=BLB15}
N 2960 17360 2940 17360 {}
C {lab_pin.sym} 2940 17360 0 0 {name=l13998 lab=WL87}
N 3040 17440 3060 17440 {}
C {lab_pin.sym} 3060 17440 0 0 {name=l13999 lab=VDD}
N 3040 17360 3060 17360 {}
C {lab_pin.sym} 3060 17360 0 0 {name=l14000 lab=VSS}
C {bitcell_6t.sym} 3200 17400 0 0 {name=Xr87c16}
N 3160 17440 3140 17440 {}
C {lab_pin.sym} 3140 17440 0 0 {name=l14001 lab=BL16}
N 3160 17400 3140 17400 {}
C {lab_pin.sym} 3140 17400 0 0 {name=l14002 lab=BLB16}
N 3160 17360 3140 17360 {}
C {lab_pin.sym} 3140 17360 0 0 {name=l14003 lab=WL87}
N 3240 17440 3260 17440 {}
C {lab_pin.sym} 3260 17440 0 0 {name=l14004 lab=VDD}
N 3240 17360 3260 17360 {}
C {lab_pin.sym} 3260 17360 0 0 {name=l14005 lab=VSS}
C {bitcell_6t.sym} 3400 17400 0 0 {name=Xr87c17}
N 3360 17440 3340 17440 {}
C {lab_pin.sym} 3340 17440 0 0 {name=l14006 lab=BL17}
N 3360 17400 3340 17400 {}
C {lab_pin.sym} 3340 17400 0 0 {name=l14007 lab=BLB17}
N 3360 17360 3340 17360 {}
C {lab_pin.sym} 3340 17360 0 0 {name=l14008 lab=WL87}
N 3440 17440 3460 17440 {}
C {lab_pin.sym} 3460 17440 0 0 {name=l14009 lab=VDD}
N 3440 17360 3460 17360 {}
C {lab_pin.sym} 3460 17360 0 0 {name=l14010 lab=VSS}
C {bitcell_6t.sym} 3600 17400 0 0 {name=Xr87c18}
N 3560 17440 3540 17440 {}
C {lab_pin.sym} 3540 17440 0 0 {name=l14011 lab=BL18}
N 3560 17400 3540 17400 {}
C {lab_pin.sym} 3540 17400 0 0 {name=l14012 lab=BLB18}
N 3560 17360 3540 17360 {}
C {lab_pin.sym} 3540 17360 0 0 {name=l14013 lab=WL87}
N 3640 17440 3660 17440 {}
C {lab_pin.sym} 3660 17440 0 0 {name=l14014 lab=VDD}
N 3640 17360 3660 17360 {}
C {lab_pin.sym} 3660 17360 0 0 {name=l14015 lab=VSS}
C {bitcell_6t.sym} 3800 17400 0 0 {name=Xr87c19}
N 3760 17440 3740 17440 {}
C {lab_pin.sym} 3740 17440 0 0 {name=l14016 lab=BL19}
N 3760 17400 3740 17400 {}
C {lab_pin.sym} 3740 17400 0 0 {name=l14017 lab=BLB19}
N 3760 17360 3740 17360 {}
C {lab_pin.sym} 3740 17360 0 0 {name=l14018 lab=WL87}
N 3840 17440 3860 17440 {}
C {lab_pin.sym} 3860 17440 0 0 {name=l14019 lab=VDD}
N 3840 17360 3860 17360 {}
C {lab_pin.sym} 3860 17360 0 0 {name=l14020 lab=VSS}
C {bitcell_6t.sym} 4000 17400 0 0 {name=Xr87c20}
N 3960 17440 3940 17440 {}
C {lab_pin.sym} 3940 17440 0 0 {name=l14021 lab=BL20}
N 3960 17400 3940 17400 {}
C {lab_pin.sym} 3940 17400 0 0 {name=l14022 lab=BLB20}
N 3960 17360 3940 17360 {}
C {lab_pin.sym} 3940 17360 0 0 {name=l14023 lab=WL87}
N 4040 17440 4060 17440 {}
C {lab_pin.sym} 4060 17440 0 0 {name=l14024 lab=VDD}
N 4040 17360 4060 17360 {}
C {lab_pin.sym} 4060 17360 0 0 {name=l14025 lab=VSS}
C {bitcell_6t.sym} 4200 17400 0 0 {name=Xr87c21}
N 4160 17440 4140 17440 {}
C {lab_pin.sym} 4140 17440 0 0 {name=l14026 lab=BL21}
N 4160 17400 4140 17400 {}
C {lab_pin.sym} 4140 17400 0 0 {name=l14027 lab=BLB21}
N 4160 17360 4140 17360 {}
C {lab_pin.sym} 4140 17360 0 0 {name=l14028 lab=WL87}
N 4240 17440 4260 17440 {}
C {lab_pin.sym} 4260 17440 0 0 {name=l14029 lab=VDD}
N 4240 17360 4260 17360 {}
C {lab_pin.sym} 4260 17360 0 0 {name=l14030 lab=VSS}
C {bitcell_6t.sym} 4400 17400 0 0 {name=Xr87c22}
N 4360 17440 4340 17440 {}
C {lab_pin.sym} 4340 17440 0 0 {name=l14031 lab=BL22}
N 4360 17400 4340 17400 {}
C {lab_pin.sym} 4340 17400 0 0 {name=l14032 lab=BLB22}
N 4360 17360 4340 17360 {}
C {lab_pin.sym} 4340 17360 0 0 {name=l14033 lab=WL87}
N 4440 17440 4460 17440 {}
C {lab_pin.sym} 4460 17440 0 0 {name=l14034 lab=VDD}
N 4440 17360 4460 17360 {}
C {lab_pin.sym} 4460 17360 0 0 {name=l14035 lab=VSS}
C {bitcell_6t.sym} 4600 17400 0 0 {name=Xr87c23}
N 4560 17440 4540 17440 {}
C {lab_pin.sym} 4540 17440 0 0 {name=l14036 lab=BL23}
N 4560 17400 4540 17400 {}
C {lab_pin.sym} 4540 17400 0 0 {name=l14037 lab=BLB23}
N 4560 17360 4540 17360 {}
C {lab_pin.sym} 4540 17360 0 0 {name=l14038 lab=WL87}
N 4640 17440 4660 17440 {}
C {lab_pin.sym} 4660 17440 0 0 {name=l14039 lab=VDD}
N 4640 17360 4660 17360 {}
C {lab_pin.sym} 4660 17360 0 0 {name=l14040 lab=VSS}
C {bitcell_6t.sym} 4800 17400 0 0 {name=Xr87c24}
N 4760 17440 4740 17440 {}
C {lab_pin.sym} 4740 17440 0 0 {name=l14041 lab=BL24}
N 4760 17400 4740 17400 {}
C {lab_pin.sym} 4740 17400 0 0 {name=l14042 lab=BLB24}
N 4760 17360 4740 17360 {}
C {lab_pin.sym} 4740 17360 0 0 {name=l14043 lab=WL87}
N 4840 17440 4860 17440 {}
C {lab_pin.sym} 4860 17440 0 0 {name=l14044 lab=VDD}
N 4840 17360 4860 17360 {}
C {lab_pin.sym} 4860 17360 0 0 {name=l14045 lab=VSS}
C {bitcell_6t.sym} 5000 17400 0 0 {name=Xr87c25}
N 4960 17440 4940 17440 {}
C {lab_pin.sym} 4940 17440 0 0 {name=l14046 lab=BL25}
N 4960 17400 4940 17400 {}
C {lab_pin.sym} 4940 17400 0 0 {name=l14047 lab=BLB25}
N 4960 17360 4940 17360 {}
C {lab_pin.sym} 4940 17360 0 0 {name=l14048 lab=WL87}
N 5040 17440 5060 17440 {}
C {lab_pin.sym} 5060 17440 0 0 {name=l14049 lab=VDD}
N 5040 17360 5060 17360 {}
C {lab_pin.sym} 5060 17360 0 0 {name=l14050 lab=VSS}
C {bitcell_6t.sym} 5200 17400 0 0 {name=Xr87c26}
N 5160 17440 5140 17440 {}
C {lab_pin.sym} 5140 17440 0 0 {name=l14051 lab=BL26}
N 5160 17400 5140 17400 {}
C {lab_pin.sym} 5140 17400 0 0 {name=l14052 lab=BLB26}
N 5160 17360 5140 17360 {}
C {lab_pin.sym} 5140 17360 0 0 {name=l14053 lab=WL87}
N 5240 17440 5260 17440 {}
C {lab_pin.sym} 5260 17440 0 0 {name=l14054 lab=VDD}
N 5240 17360 5260 17360 {}
C {lab_pin.sym} 5260 17360 0 0 {name=l14055 lab=VSS}
C {bitcell_6t.sym} 5400 17400 0 0 {name=Xr87c27}
N 5360 17440 5340 17440 {}
C {lab_pin.sym} 5340 17440 0 0 {name=l14056 lab=BL27}
N 5360 17400 5340 17400 {}
C {lab_pin.sym} 5340 17400 0 0 {name=l14057 lab=BLB27}
N 5360 17360 5340 17360 {}
C {lab_pin.sym} 5340 17360 0 0 {name=l14058 lab=WL87}
N 5440 17440 5460 17440 {}
C {lab_pin.sym} 5460 17440 0 0 {name=l14059 lab=VDD}
N 5440 17360 5460 17360 {}
C {lab_pin.sym} 5460 17360 0 0 {name=l14060 lab=VSS}
C {bitcell_6t.sym} 5600 17400 0 0 {name=Xr87c28}
N 5560 17440 5540 17440 {}
C {lab_pin.sym} 5540 17440 0 0 {name=l14061 lab=BL28}
N 5560 17400 5540 17400 {}
C {lab_pin.sym} 5540 17400 0 0 {name=l14062 lab=BLB28}
N 5560 17360 5540 17360 {}
C {lab_pin.sym} 5540 17360 0 0 {name=l14063 lab=WL87}
N 5640 17440 5660 17440 {}
C {lab_pin.sym} 5660 17440 0 0 {name=l14064 lab=VDD}
N 5640 17360 5660 17360 {}
C {lab_pin.sym} 5660 17360 0 0 {name=l14065 lab=VSS}
C {bitcell_6t.sym} 5800 17400 0 0 {name=Xr87c29}
N 5760 17440 5740 17440 {}
C {lab_pin.sym} 5740 17440 0 0 {name=l14066 lab=BL29}
N 5760 17400 5740 17400 {}
C {lab_pin.sym} 5740 17400 0 0 {name=l14067 lab=BLB29}
N 5760 17360 5740 17360 {}
C {lab_pin.sym} 5740 17360 0 0 {name=l14068 lab=WL87}
N 5840 17440 5860 17440 {}
C {lab_pin.sym} 5860 17440 0 0 {name=l14069 lab=VDD}
N 5840 17360 5860 17360 {}
C {lab_pin.sym} 5860 17360 0 0 {name=l14070 lab=VSS}
C {bitcell_6t.sym} 6000 17400 0 0 {name=Xr87c30}
N 5960 17440 5940 17440 {}
C {lab_pin.sym} 5940 17440 0 0 {name=l14071 lab=BL30}
N 5960 17400 5940 17400 {}
C {lab_pin.sym} 5940 17400 0 0 {name=l14072 lab=BLB30}
N 5960 17360 5940 17360 {}
C {lab_pin.sym} 5940 17360 0 0 {name=l14073 lab=WL87}
N 6040 17440 6060 17440 {}
C {lab_pin.sym} 6060 17440 0 0 {name=l14074 lab=VDD}
N 6040 17360 6060 17360 {}
C {lab_pin.sym} 6060 17360 0 0 {name=l14075 lab=VSS}
C {bitcell_6t.sym} 6200 17400 0 0 {name=Xr87c31}
N 6160 17440 6140 17440 {}
C {lab_pin.sym} 6140 17440 0 0 {name=l14076 lab=BL31}
N 6160 17400 6140 17400 {}
C {lab_pin.sym} 6140 17400 0 0 {name=l14077 lab=BLB31}
N 6160 17360 6140 17360 {}
C {lab_pin.sym} 6140 17360 0 0 {name=l14078 lab=WL87}
N 6240 17440 6260 17440 {}
C {lab_pin.sym} 6260 17440 0 0 {name=l14079 lab=VDD}
N 6240 17360 6260 17360 {}
C {lab_pin.sym} 6260 17360 0 0 {name=l14080 lab=VSS}
C {bitcell_6t.sym} 0 17600 0 0 {name=Xr88c0}
N -40 17640 -60 17640 {}
C {lab_pin.sym} -60 17640 0 0 {name=l14081 lab=BL0}
N -40 17600 -60 17600 {}
C {lab_pin.sym} -60 17600 0 0 {name=l14082 lab=BLB0}
N -40 17560 -60 17560 {}
C {lab_pin.sym} -60 17560 0 0 {name=l14083 lab=WL88}
N 40 17640 60 17640 {}
C {lab_pin.sym} 60 17640 0 0 {name=l14084 lab=VDD}
N 40 17560 60 17560 {}
C {lab_pin.sym} 60 17560 0 0 {name=l14085 lab=VSS}
C {bitcell_6t.sym} 200 17600 0 0 {name=Xr88c1}
N 160 17640 140 17640 {}
C {lab_pin.sym} 140 17640 0 0 {name=l14086 lab=BL1}
N 160 17600 140 17600 {}
C {lab_pin.sym} 140 17600 0 0 {name=l14087 lab=BLB1}
N 160 17560 140 17560 {}
C {lab_pin.sym} 140 17560 0 0 {name=l14088 lab=WL88}
N 240 17640 260 17640 {}
C {lab_pin.sym} 260 17640 0 0 {name=l14089 lab=VDD}
N 240 17560 260 17560 {}
C {lab_pin.sym} 260 17560 0 0 {name=l14090 lab=VSS}
C {bitcell_6t.sym} 400 17600 0 0 {name=Xr88c2}
N 360 17640 340 17640 {}
C {lab_pin.sym} 340 17640 0 0 {name=l14091 lab=BL2}
N 360 17600 340 17600 {}
C {lab_pin.sym} 340 17600 0 0 {name=l14092 lab=BLB2}
N 360 17560 340 17560 {}
C {lab_pin.sym} 340 17560 0 0 {name=l14093 lab=WL88}
N 440 17640 460 17640 {}
C {lab_pin.sym} 460 17640 0 0 {name=l14094 lab=VDD}
N 440 17560 460 17560 {}
C {lab_pin.sym} 460 17560 0 0 {name=l14095 lab=VSS}
C {bitcell_6t.sym} 600 17600 0 0 {name=Xr88c3}
N 560 17640 540 17640 {}
C {lab_pin.sym} 540 17640 0 0 {name=l14096 lab=BL3}
N 560 17600 540 17600 {}
C {lab_pin.sym} 540 17600 0 0 {name=l14097 lab=BLB3}
N 560 17560 540 17560 {}
C {lab_pin.sym} 540 17560 0 0 {name=l14098 lab=WL88}
N 640 17640 660 17640 {}
C {lab_pin.sym} 660 17640 0 0 {name=l14099 lab=VDD}
N 640 17560 660 17560 {}
C {lab_pin.sym} 660 17560 0 0 {name=l14100 lab=VSS}
C {bitcell_6t.sym} 800 17600 0 0 {name=Xr88c4}
N 760 17640 740 17640 {}
C {lab_pin.sym} 740 17640 0 0 {name=l14101 lab=BL4}
N 760 17600 740 17600 {}
C {lab_pin.sym} 740 17600 0 0 {name=l14102 lab=BLB4}
N 760 17560 740 17560 {}
C {lab_pin.sym} 740 17560 0 0 {name=l14103 lab=WL88}
N 840 17640 860 17640 {}
C {lab_pin.sym} 860 17640 0 0 {name=l14104 lab=VDD}
N 840 17560 860 17560 {}
C {lab_pin.sym} 860 17560 0 0 {name=l14105 lab=VSS}
C {bitcell_6t.sym} 1000 17600 0 0 {name=Xr88c5}
N 960 17640 940 17640 {}
C {lab_pin.sym} 940 17640 0 0 {name=l14106 lab=BL5}
N 960 17600 940 17600 {}
C {lab_pin.sym} 940 17600 0 0 {name=l14107 lab=BLB5}
N 960 17560 940 17560 {}
C {lab_pin.sym} 940 17560 0 0 {name=l14108 lab=WL88}
N 1040 17640 1060 17640 {}
C {lab_pin.sym} 1060 17640 0 0 {name=l14109 lab=VDD}
N 1040 17560 1060 17560 {}
C {lab_pin.sym} 1060 17560 0 0 {name=l14110 lab=VSS}
C {bitcell_6t.sym} 1200 17600 0 0 {name=Xr88c6}
N 1160 17640 1140 17640 {}
C {lab_pin.sym} 1140 17640 0 0 {name=l14111 lab=BL6}
N 1160 17600 1140 17600 {}
C {lab_pin.sym} 1140 17600 0 0 {name=l14112 lab=BLB6}
N 1160 17560 1140 17560 {}
C {lab_pin.sym} 1140 17560 0 0 {name=l14113 lab=WL88}
N 1240 17640 1260 17640 {}
C {lab_pin.sym} 1260 17640 0 0 {name=l14114 lab=VDD}
N 1240 17560 1260 17560 {}
C {lab_pin.sym} 1260 17560 0 0 {name=l14115 lab=VSS}
C {bitcell_6t.sym} 1400 17600 0 0 {name=Xr88c7}
N 1360 17640 1340 17640 {}
C {lab_pin.sym} 1340 17640 0 0 {name=l14116 lab=BL7}
N 1360 17600 1340 17600 {}
C {lab_pin.sym} 1340 17600 0 0 {name=l14117 lab=BLB7}
N 1360 17560 1340 17560 {}
C {lab_pin.sym} 1340 17560 0 0 {name=l14118 lab=WL88}
N 1440 17640 1460 17640 {}
C {lab_pin.sym} 1460 17640 0 0 {name=l14119 lab=VDD}
N 1440 17560 1460 17560 {}
C {lab_pin.sym} 1460 17560 0 0 {name=l14120 lab=VSS}
C {bitcell_6t.sym} 1600 17600 0 0 {name=Xr88c8}
N 1560 17640 1540 17640 {}
C {lab_pin.sym} 1540 17640 0 0 {name=l14121 lab=BL8}
N 1560 17600 1540 17600 {}
C {lab_pin.sym} 1540 17600 0 0 {name=l14122 lab=BLB8}
N 1560 17560 1540 17560 {}
C {lab_pin.sym} 1540 17560 0 0 {name=l14123 lab=WL88}
N 1640 17640 1660 17640 {}
C {lab_pin.sym} 1660 17640 0 0 {name=l14124 lab=VDD}
N 1640 17560 1660 17560 {}
C {lab_pin.sym} 1660 17560 0 0 {name=l14125 lab=VSS}
C {bitcell_6t.sym} 1800 17600 0 0 {name=Xr88c9}
N 1760 17640 1740 17640 {}
C {lab_pin.sym} 1740 17640 0 0 {name=l14126 lab=BL9}
N 1760 17600 1740 17600 {}
C {lab_pin.sym} 1740 17600 0 0 {name=l14127 lab=BLB9}
N 1760 17560 1740 17560 {}
C {lab_pin.sym} 1740 17560 0 0 {name=l14128 lab=WL88}
N 1840 17640 1860 17640 {}
C {lab_pin.sym} 1860 17640 0 0 {name=l14129 lab=VDD}
N 1840 17560 1860 17560 {}
C {lab_pin.sym} 1860 17560 0 0 {name=l14130 lab=VSS}
C {bitcell_6t.sym} 2000 17600 0 0 {name=Xr88c10}
N 1960 17640 1940 17640 {}
C {lab_pin.sym} 1940 17640 0 0 {name=l14131 lab=BL10}
N 1960 17600 1940 17600 {}
C {lab_pin.sym} 1940 17600 0 0 {name=l14132 lab=BLB10}
N 1960 17560 1940 17560 {}
C {lab_pin.sym} 1940 17560 0 0 {name=l14133 lab=WL88}
N 2040 17640 2060 17640 {}
C {lab_pin.sym} 2060 17640 0 0 {name=l14134 lab=VDD}
N 2040 17560 2060 17560 {}
C {lab_pin.sym} 2060 17560 0 0 {name=l14135 lab=VSS}
C {bitcell_6t.sym} 2200 17600 0 0 {name=Xr88c11}
N 2160 17640 2140 17640 {}
C {lab_pin.sym} 2140 17640 0 0 {name=l14136 lab=BL11}
N 2160 17600 2140 17600 {}
C {lab_pin.sym} 2140 17600 0 0 {name=l14137 lab=BLB11}
N 2160 17560 2140 17560 {}
C {lab_pin.sym} 2140 17560 0 0 {name=l14138 lab=WL88}
N 2240 17640 2260 17640 {}
C {lab_pin.sym} 2260 17640 0 0 {name=l14139 lab=VDD}
N 2240 17560 2260 17560 {}
C {lab_pin.sym} 2260 17560 0 0 {name=l14140 lab=VSS}
C {bitcell_6t.sym} 2400 17600 0 0 {name=Xr88c12}
N 2360 17640 2340 17640 {}
C {lab_pin.sym} 2340 17640 0 0 {name=l14141 lab=BL12}
N 2360 17600 2340 17600 {}
C {lab_pin.sym} 2340 17600 0 0 {name=l14142 lab=BLB12}
N 2360 17560 2340 17560 {}
C {lab_pin.sym} 2340 17560 0 0 {name=l14143 lab=WL88}
N 2440 17640 2460 17640 {}
C {lab_pin.sym} 2460 17640 0 0 {name=l14144 lab=VDD}
N 2440 17560 2460 17560 {}
C {lab_pin.sym} 2460 17560 0 0 {name=l14145 lab=VSS}
C {bitcell_6t.sym} 2600 17600 0 0 {name=Xr88c13}
N 2560 17640 2540 17640 {}
C {lab_pin.sym} 2540 17640 0 0 {name=l14146 lab=BL13}
N 2560 17600 2540 17600 {}
C {lab_pin.sym} 2540 17600 0 0 {name=l14147 lab=BLB13}
N 2560 17560 2540 17560 {}
C {lab_pin.sym} 2540 17560 0 0 {name=l14148 lab=WL88}
N 2640 17640 2660 17640 {}
C {lab_pin.sym} 2660 17640 0 0 {name=l14149 lab=VDD}
N 2640 17560 2660 17560 {}
C {lab_pin.sym} 2660 17560 0 0 {name=l14150 lab=VSS}
C {bitcell_6t.sym} 2800 17600 0 0 {name=Xr88c14}
N 2760 17640 2740 17640 {}
C {lab_pin.sym} 2740 17640 0 0 {name=l14151 lab=BL14}
N 2760 17600 2740 17600 {}
C {lab_pin.sym} 2740 17600 0 0 {name=l14152 lab=BLB14}
N 2760 17560 2740 17560 {}
C {lab_pin.sym} 2740 17560 0 0 {name=l14153 lab=WL88}
N 2840 17640 2860 17640 {}
C {lab_pin.sym} 2860 17640 0 0 {name=l14154 lab=VDD}
N 2840 17560 2860 17560 {}
C {lab_pin.sym} 2860 17560 0 0 {name=l14155 lab=VSS}
C {bitcell_6t.sym} 3000 17600 0 0 {name=Xr88c15}
N 2960 17640 2940 17640 {}
C {lab_pin.sym} 2940 17640 0 0 {name=l14156 lab=BL15}
N 2960 17600 2940 17600 {}
C {lab_pin.sym} 2940 17600 0 0 {name=l14157 lab=BLB15}
N 2960 17560 2940 17560 {}
C {lab_pin.sym} 2940 17560 0 0 {name=l14158 lab=WL88}
N 3040 17640 3060 17640 {}
C {lab_pin.sym} 3060 17640 0 0 {name=l14159 lab=VDD}
N 3040 17560 3060 17560 {}
C {lab_pin.sym} 3060 17560 0 0 {name=l14160 lab=VSS}
C {bitcell_6t.sym} 3200 17600 0 0 {name=Xr88c16}
N 3160 17640 3140 17640 {}
C {lab_pin.sym} 3140 17640 0 0 {name=l14161 lab=BL16}
N 3160 17600 3140 17600 {}
C {lab_pin.sym} 3140 17600 0 0 {name=l14162 lab=BLB16}
N 3160 17560 3140 17560 {}
C {lab_pin.sym} 3140 17560 0 0 {name=l14163 lab=WL88}
N 3240 17640 3260 17640 {}
C {lab_pin.sym} 3260 17640 0 0 {name=l14164 lab=VDD}
N 3240 17560 3260 17560 {}
C {lab_pin.sym} 3260 17560 0 0 {name=l14165 lab=VSS}
C {bitcell_6t.sym} 3400 17600 0 0 {name=Xr88c17}
N 3360 17640 3340 17640 {}
C {lab_pin.sym} 3340 17640 0 0 {name=l14166 lab=BL17}
N 3360 17600 3340 17600 {}
C {lab_pin.sym} 3340 17600 0 0 {name=l14167 lab=BLB17}
N 3360 17560 3340 17560 {}
C {lab_pin.sym} 3340 17560 0 0 {name=l14168 lab=WL88}
N 3440 17640 3460 17640 {}
C {lab_pin.sym} 3460 17640 0 0 {name=l14169 lab=VDD}
N 3440 17560 3460 17560 {}
C {lab_pin.sym} 3460 17560 0 0 {name=l14170 lab=VSS}
C {bitcell_6t.sym} 3600 17600 0 0 {name=Xr88c18}
N 3560 17640 3540 17640 {}
C {lab_pin.sym} 3540 17640 0 0 {name=l14171 lab=BL18}
N 3560 17600 3540 17600 {}
C {lab_pin.sym} 3540 17600 0 0 {name=l14172 lab=BLB18}
N 3560 17560 3540 17560 {}
C {lab_pin.sym} 3540 17560 0 0 {name=l14173 lab=WL88}
N 3640 17640 3660 17640 {}
C {lab_pin.sym} 3660 17640 0 0 {name=l14174 lab=VDD}
N 3640 17560 3660 17560 {}
C {lab_pin.sym} 3660 17560 0 0 {name=l14175 lab=VSS}
C {bitcell_6t.sym} 3800 17600 0 0 {name=Xr88c19}
N 3760 17640 3740 17640 {}
C {lab_pin.sym} 3740 17640 0 0 {name=l14176 lab=BL19}
N 3760 17600 3740 17600 {}
C {lab_pin.sym} 3740 17600 0 0 {name=l14177 lab=BLB19}
N 3760 17560 3740 17560 {}
C {lab_pin.sym} 3740 17560 0 0 {name=l14178 lab=WL88}
N 3840 17640 3860 17640 {}
C {lab_pin.sym} 3860 17640 0 0 {name=l14179 lab=VDD}
N 3840 17560 3860 17560 {}
C {lab_pin.sym} 3860 17560 0 0 {name=l14180 lab=VSS}
C {bitcell_6t.sym} 4000 17600 0 0 {name=Xr88c20}
N 3960 17640 3940 17640 {}
C {lab_pin.sym} 3940 17640 0 0 {name=l14181 lab=BL20}
N 3960 17600 3940 17600 {}
C {lab_pin.sym} 3940 17600 0 0 {name=l14182 lab=BLB20}
N 3960 17560 3940 17560 {}
C {lab_pin.sym} 3940 17560 0 0 {name=l14183 lab=WL88}
N 4040 17640 4060 17640 {}
C {lab_pin.sym} 4060 17640 0 0 {name=l14184 lab=VDD}
N 4040 17560 4060 17560 {}
C {lab_pin.sym} 4060 17560 0 0 {name=l14185 lab=VSS}
C {bitcell_6t.sym} 4200 17600 0 0 {name=Xr88c21}
N 4160 17640 4140 17640 {}
C {lab_pin.sym} 4140 17640 0 0 {name=l14186 lab=BL21}
N 4160 17600 4140 17600 {}
C {lab_pin.sym} 4140 17600 0 0 {name=l14187 lab=BLB21}
N 4160 17560 4140 17560 {}
C {lab_pin.sym} 4140 17560 0 0 {name=l14188 lab=WL88}
N 4240 17640 4260 17640 {}
C {lab_pin.sym} 4260 17640 0 0 {name=l14189 lab=VDD}
N 4240 17560 4260 17560 {}
C {lab_pin.sym} 4260 17560 0 0 {name=l14190 lab=VSS}
C {bitcell_6t.sym} 4400 17600 0 0 {name=Xr88c22}
N 4360 17640 4340 17640 {}
C {lab_pin.sym} 4340 17640 0 0 {name=l14191 lab=BL22}
N 4360 17600 4340 17600 {}
C {lab_pin.sym} 4340 17600 0 0 {name=l14192 lab=BLB22}
N 4360 17560 4340 17560 {}
C {lab_pin.sym} 4340 17560 0 0 {name=l14193 lab=WL88}
N 4440 17640 4460 17640 {}
C {lab_pin.sym} 4460 17640 0 0 {name=l14194 lab=VDD}
N 4440 17560 4460 17560 {}
C {lab_pin.sym} 4460 17560 0 0 {name=l14195 lab=VSS}
C {bitcell_6t.sym} 4600 17600 0 0 {name=Xr88c23}
N 4560 17640 4540 17640 {}
C {lab_pin.sym} 4540 17640 0 0 {name=l14196 lab=BL23}
N 4560 17600 4540 17600 {}
C {lab_pin.sym} 4540 17600 0 0 {name=l14197 lab=BLB23}
N 4560 17560 4540 17560 {}
C {lab_pin.sym} 4540 17560 0 0 {name=l14198 lab=WL88}
N 4640 17640 4660 17640 {}
C {lab_pin.sym} 4660 17640 0 0 {name=l14199 lab=VDD}
N 4640 17560 4660 17560 {}
C {lab_pin.sym} 4660 17560 0 0 {name=l14200 lab=VSS}
C {bitcell_6t.sym} 4800 17600 0 0 {name=Xr88c24}
N 4760 17640 4740 17640 {}
C {lab_pin.sym} 4740 17640 0 0 {name=l14201 lab=BL24}
N 4760 17600 4740 17600 {}
C {lab_pin.sym} 4740 17600 0 0 {name=l14202 lab=BLB24}
N 4760 17560 4740 17560 {}
C {lab_pin.sym} 4740 17560 0 0 {name=l14203 lab=WL88}
N 4840 17640 4860 17640 {}
C {lab_pin.sym} 4860 17640 0 0 {name=l14204 lab=VDD}
N 4840 17560 4860 17560 {}
C {lab_pin.sym} 4860 17560 0 0 {name=l14205 lab=VSS}
C {bitcell_6t.sym} 5000 17600 0 0 {name=Xr88c25}
N 4960 17640 4940 17640 {}
C {lab_pin.sym} 4940 17640 0 0 {name=l14206 lab=BL25}
N 4960 17600 4940 17600 {}
C {lab_pin.sym} 4940 17600 0 0 {name=l14207 lab=BLB25}
N 4960 17560 4940 17560 {}
C {lab_pin.sym} 4940 17560 0 0 {name=l14208 lab=WL88}
N 5040 17640 5060 17640 {}
C {lab_pin.sym} 5060 17640 0 0 {name=l14209 lab=VDD}
N 5040 17560 5060 17560 {}
C {lab_pin.sym} 5060 17560 0 0 {name=l14210 lab=VSS}
C {bitcell_6t.sym} 5200 17600 0 0 {name=Xr88c26}
N 5160 17640 5140 17640 {}
C {lab_pin.sym} 5140 17640 0 0 {name=l14211 lab=BL26}
N 5160 17600 5140 17600 {}
C {lab_pin.sym} 5140 17600 0 0 {name=l14212 lab=BLB26}
N 5160 17560 5140 17560 {}
C {lab_pin.sym} 5140 17560 0 0 {name=l14213 lab=WL88}
N 5240 17640 5260 17640 {}
C {lab_pin.sym} 5260 17640 0 0 {name=l14214 lab=VDD}
N 5240 17560 5260 17560 {}
C {lab_pin.sym} 5260 17560 0 0 {name=l14215 lab=VSS}
C {bitcell_6t.sym} 5400 17600 0 0 {name=Xr88c27}
N 5360 17640 5340 17640 {}
C {lab_pin.sym} 5340 17640 0 0 {name=l14216 lab=BL27}
N 5360 17600 5340 17600 {}
C {lab_pin.sym} 5340 17600 0 0 {name=l14217 lab=BLB27}
N 5360 17560 5340 17560 {}
C {lab_pin.sym} 5340 17560 0 0 {name=l14218 lab=WL88}
N 5440 17640 5460 17640 {}
C {lab_pin.sym} 5460 17640 0 0 {name=l14219 lab=VDD}
N 5440 17560 5460 17560 {}
C {lab_pin.sym} 5460 17560 0 0 {name=l14220 lab=VSS}
C {bitcell_6t.sym} 5600 17600 0 0 {name=Xr88c28}
N 5560 17640 5540 17640 {}
C {lab_pin.sym} 5540 17640 0 0 {name=l14221 lab=BL28}
N 5560 17600 5540 17600 {}
C {lab_pin.sym} 5540 17600 0 0 {name=l14222 lab=BLB28}
N 5560 17560 5540 17560 {}
C {lab_pin.sym} 5540 17560 0 0 {name=l14223 lab=WL88}
N 5640 17640 5660 17640 {}
C {lab_pin.sym} 5660 17640 0 0 {name=l14224 lab=VDD}
N 5640 17560 5660 17560 {}
C {lab_pin.sym} 5660 17560 0 0 {name=l14225 lab=VSS}
C {bitcell_6t.sym} 5800 17600 0 0 {name=Xr88c29}
N 5760 17640 5740 17640 {}
C {lab_pin.sym} 5740 17640 0 0 {name=l14226 lab=BL29}
N 5760 17600 5740 17600 {}
C {lab_pin.sym} 5740 17600 0 0 {name=l14227 lab=BLB29}
N 5760 17560 5740 17560 {}
C {lab_pin.sym} 5740 17560 0 0 {name=l14228 lab=WL88}
N 5840 17640 5860 17640 {}
C {lab_pin.sym} 5860 17640 0 0 {name=l14229 lab=VDD}
N 5840 17560 5860 17560 {}
C {lab_pin.sym} 5860 17560 0 0 {name=l14230 lab=VSS}
C {bitcell_6t.sym} 6000 17600 0 0 {name=Xr88c30}
N 5960 17640 5940 17640 {}
C {lab_pin.sym} 5940 17640 0 0 {name=l14231 lab=BL30}
N 5960 17600 5940 17600 {}
C {lab_pin.sym} 5940 17600 0 0 {name=l14232 lab=BLB30}
N 5960 17560 5940 17560 {}
C {lab_pin.sym} 5940 17560 0 0 {name=l14233 lab=WL88}
N 6040 17640 6060 17640 {}
C {lab_pin.sym} 6060 17640 0 0 {name=l14234 lab=VDD}
N 6040 17560 6060 17560 {}
C {lab_pin.sym} 6060 17560 0 0 {name=l14235 lab=VSS}
C {bitcell_6t.sym} 6200 17600 0 0 {name=Xr88c31}
N 6160 17640 6140 17640 {}
C {lab_pin.sym} 6140 17640 0 0 {name=l14236 lab=BL31}
N 6160 17600 6140 17600 {}
C {lab_pin.sym} 6140 17600 0 0 {name=l14237 lab=BLB31}
N 6160 17560 6140 17560 {}
C {lab_pin.sym} 6140 17560 0 0 {name=l14238 lab=WL88}
N 6240 17640 6260 17640 {}
C {lab_pin.sym} 6260 17640 0 0 {name=l14239 lab=VDD}
N 6240 17560 6260 17560 {}
C {lab_pin.sym} 6260 17560 0 0 {name=l14240 lab=VSS}
C {bitcell_6t.sym} 0 17800 0 0 {name=Xr89c0}
N -40 17840 -60 17840 {}
C {lab_pin.sym} -60 17840 0 0 {name=l14241 lab=BL0}
N -40 17800 -60 17800 {}
C {lab_pin.sym} -60 17800 0 0 {name=l14242 lab=BLB0}
N -40 17760 -60 17760 {}
C {lab_pin.sym} -60 17760 0 0 {name=l14243 lab=WL89}
N 40 17840 60 17840 {}
C {lab_pin.sym} 60 17840 0 0 {name=l14244 lab=VDD}
N 40 17760 60 17760 {}
C {lab_pin.sym} 60 17760 0 0 {name=l14245 lab=VSS}
C {bitcell_6t.sym} 200 17800 0 0 {name=Xr89c1}
N 160 17840 140 17840 {}
C {lab_pin.sym} 140 17840 0 0 {name=l14246 lab=BL1}
N 160 17800 140 17800 {}
C {lab_pin.sym} 140 17800 0 0 {name=l14247 lab=BLB1}
N 160 17760 140 17760 {}
C {lab_pin.sym} 140 17760 0 0 {name=l14248 lab=WL89}
N 240 17840 260 17840 {}
C {lab_pin.sym} 260 17840 0 0 {name=l14249 lab=VDD}
N 240 17760 260 17760 {}
C {lab_pin.sym} 260 17760 0 0 {name=l14250 lab=VSS}
C {bitcell_6t.sym} 400 17800 0 0 {name=Xr89c2}
N 360 17840 340 17840 {}
C {lab_pin.sym} 340 17840 0 0 {name=l14251 lab=BL2}
N 360 17800 340 17800 {}
C {lab_pin.sym} 340 17800 0 0 {name=l14252 lab=BLB2}
N 360 17760 340 17760 {}
C {lab_pin.sym} 340 17760 0 0 {name=l14253 lab=WL89}
N 440 17840 460 17840 {}
C {lab_pin.sym} 460 17840 0 0 {name=l14254 lab=VDD}
N 440 17760 460 17760 {}
C {lab_pin.sym} 460 17760 0 0 {name=l14255 lab=VSS}
C {bitcell_6t.sym} 600 17800 0 0 {name=Xr89c3}
N 560 17840 540 17840 {}
C {lab_pin.sym} 540 17840 0 0 {name=l14256 lab=BL3}
N 560 17800 540 17800 {}
C {lab_pin.sym} 540 17800 0 0 {name=l14257 lab=BLB3}
N 560 17760 540 17760 {}
C {lab_pin.sym} 540 17760 0 0 {name=l14258 lab=WL89}
N 640 17840 660 17840 {}
C {lab_pin.sym} 660 17840 0 0 {name=l14259 lab=VDD}
N 640 17760 660 17760 {}
C {lab_pin.sym} 660 17760 0 0 {name=l14260 lab=VSS}
C {bitcell_6t.sym} 800 17800 0 0 {name=Xr89c4}
N 760 17840 740 17840 {}
C {lab_pin.sym} 740 17840 0 0 {name=l14261 lab=BL4}
N 760 17800 740 17800 {}
C {lab_pin.sym} 740 17800 0 0 {name=l14262 lab=BLB4}
N 760 17760 740 17760 {}
C {lab_pin.sym} 740 17760 0 0 {name=l14263 lab=WL89}
N 840 17840 860 17840 {}
C {lab_pin.sym} 860 17840 0 0 {name=l14264 lab=VDD}
N 840 17760 860 17760 {}
C {lab_pin.sym} 860 17760 0 0 {name=l14265 lab=VSS}
C {bitcell_6t.sym} 1000 17800 0 0 {name=Xr89c5}
N 960 17840 940 17840 {}
C {lab_pin.sym} 940 17840 0 0 {name=l14266 lab=BL5}
N 960 17800 940 17800 {}
C {lab_pin.sym} 940 17800 0 0 {name=l14267 lab=BLB5}
N 960 17760 940 17760 {}
C {lab_pin.sym} 940 17760 0 0 {name=l14268 lab=WL89}
N 1040 17840 1060 17840 {}
C {lab_pin.sym} 1060 17840 0 0 {name=l14269 lab=VDD}
N 1040 17760 1060 17760 {}
C {lab_pin.sym} 1060 17760 0 0 {name=l14270 lab=VSS}
C {bitcell_6t.sym} 1200 17800 0 0 {name=Xr89c6}
N 1160 17840 1140 17840 {}
C {lab_pin.sym} 1140 17840 0 0 {name=l14271 lab=BL6}
N 1160 17800 1140 17800 {}
C {lab_pin.sym} 1140 17800 0 0 {name=l14272 lab=BLB6}
N 1160 17760 1140 17760 {}
C {lab_pin.sym} 1140 17760 0 0 {name=l14273 lab=WL89}
N 1240 17840 1260 17840 {}
C {lab_pin.sym} 1260 17840 0 0 {name=l14274 lab=VDD}
N 1240 17760 1260 17760 {}
C {lab_pin.sym} 1260 17760 0 0 {name=l14275 lab=VSS}
C {bitcell_6t.sym} 1400 17800 0 0 {name=Xr89c7}
N 1360 17840 1340 17840 {}
C {lab_pin.sym} 1340 17840 0 0 {name=l14276 lab=BL7}
N 1360 17800 1340 17800 {}
C {lab_pin.sym} 1340 17800 0 0 {name=l14277 lab=BLB7}
N 1360 17760 1340 17760 {}
C {lab_pin.sym} 1340 17760 0 0 {name=l14278 lab=WL89}
N 1440 17840 1460 17840 {}
C {lab_pin.sym} 1460 17840 0 0 {name=l14279 lab=VDD}
N 1440 17760 1460 17760 {}
C {lab_pin.sym} 1460 17760 0 0 {name=l14280 lab=VSS}
C {bitcell_6t.sym} 1600 17800 0 0 {name=Xr89c8}
N 1560 17840 1540 17840 {}
C {lab_pin.sym} 1540 17840 0 0 {name=l14281 lab=BL8}
N 1560 17800 1540 17800 {}
C {lab_pin.sym} 1540 17800 0 0 {name=l14282 lab=BLB8}
N 1560 17760 1540 17760 {}
C {lab_pin.sym} 1540 17760 0 0 {name=l14283 lab=WL89}
N 1640 17840 1660 17840 {}
C {lab_pin.sym} 1660 17840 0 0 {name=l14284 lab=VDD}
N 1640 17760 1660 17760 {}
C {lab_pin.sym} 1660 17760 0 0 {name=l14285 lab=VSS}
C {bitcell_6t.sym} 1800 17800 0 0 {name=Xr89c9}
N 1760 17840 1740 17840 {}
C {lab_pin.sym} 1740 17840 0 0 {name=l14286 lab=BL9}
N 1760 17800 1740 17800 {}
C {lab_pin.sym} 1740 17800 0 0 {name=l14287 lab=BLB9}
N 1760 17760 1740 17760 {}
C {lab_pin.sym} 1740 17760 0 0 {name=l14288 lab=WL89}
N 1840 17840 1860 17840 {}
C {lab_pin.sym} 1860 17840 0 0 {name=l14289 lab=VDD}
N 1840 17760 1860 17760 {}
C {lab_pin.sym} 1860 17760 0 0 {name=l14290 lab=VSS}
C {bitcell_6t.sym} 2000 17800 0 0 {name=Xr89c10}
N 1960 17840 1940 17840 {}
C {lab_pin.sym} 1940 17840 0 0 {name=l14291 lab=BL10}
N 1960 17800 1940 17800 {}
C {lab_pin.sym} 1940 17800 0 0 {name=l14292 lab=BLB10}
N 1960 17760 1940 17760 {}
C {lab_pin.sym} 1940 17760 0 0 {name=l14293 lab=WL89}
N 2040 17840 2060 17840 {}
C {lab_pin.sym} 2060 17840 0 0 {name=l14294 lab=VDD}
N 2040 17760 2060 17760 {}
C {lab_pin.sym} 2060 17760 0 0 {name=l14295 lab=VSS}
C {bitcell_6t.sym} 2200 17800 0 0 {name=Xr89c11}
N 2160 17840 2140 17840 {}
C {lab_pin.sym} 2140 17840 0 0 {name=l14296 lab=BL11}
N 2160 17800 2140 17800 {}
C {lab_pin.sym} 2140 17800 0 0 {name=l14297 lab=BLB11}
N 2160 17760 2140 17760 {}
C {lab_pin.sym} 2140 17760 0 0 {name=l14298 lab=WL89}
N 2240 17840 2260 17840 {}
C {lab_pin.sym} 2260 17840 0 0 {name=l14299 lab=VDD}
N 2240 17760 2260 17760 {}
C {lab_pin.sym} 2260 17760 0 0 {name=l14300 lab=VSS}
C {bitcell_6t.sym} 2400 17800 0 0 {name=Xr89c12}
N 2360 17840 2340 17840 {}
C {lab_pin.sym} 2340 17840 0 0 {name=l14301 lab=BL12}
N 2360 17800 2340 17800 {}
C {lab_pin.sym} 2340 17800 0 0 {name=l14302 lab=BLB12}
N 2360 17760 2340 17760 {}
C {lab_pin.sym} 2340 17760 0 0 {name=l14303 lab=WL89}
N 2440 17840 2460 17840 {}
C {lab_pin.sym} 2460 17840 0 0 {name=l14304 lab=VDD}
N 2440 17760 2460 17760 {}
C {lab_pin.sym} 2460 17760 0 0 {name=l14305 lab=VSS}
C {bitcell_6t.sym} 2600 17800 0 0 {name=Xr89c13}
N 2560 17840 2540 17840 {}
C {lab_pin.sym} 2540 17840 0 0 {name=l14306 lab=BL13}
N 2560 17800 2540 17800 {}
C {lab_pin.sym} 2540 17800 0 0 {name=l14307 lab=BLB13}
N 2560 17760 2540 17760 {}
C {lab_pin.sym} 2540 17760 0 0 {name=l14308 lab=WL89}
N 2640 17840 2660 17840 {}
C {lab_pin.sym} 2660 17840 0 0 {name=l14309 lab=VDD}
N 2640 17760 2660 17760 {}
C {lab_pin.sym} 2660 17760 0 0 {name=l14310 lab=VSS}
C {bitcell_6t.sym} 2800 17800 0 0 {name=Xr89c14}
N 2760 17840 2740 17840 {}
C {lab_pin.sym} 2740 17840 0 0 {name=l14311 lab=BL14}
N 2760 17800 2740 17800 {}
C {lab_pin.sym} 2740 17800 0 0 {name=l14312 lab=BLB14}
N 2760 17760 2740 17760 {}
C {lab_pin.sym} 2740 17760 0 0 {name=l14313 lab=WL89}
N 2840 17840 2860 17840 {}
C {lab_pin.sym} 2860 17840 0 0 {name=l14314 lab=VDD}
N 2840 17760 2860 17760 {}
C {lab_pin.sym} 2860 17760 0 0 {name=l14315 lab=VSS}
C {bitcell_6t.sym} 3000 17800 0 0 {name=Xr89c15}
N 2960 17840 2940 17840 {}
C {lab_pin.sym} 2940 17840 0 0 {name=l14316 lab=BL15}
N 2960 17800 2940 17800 {}
C {lab_pin.sym} 2940 17800 0 0 {name=l14317 lab=BLB15}
N 2960 17760 2940 17760 {}
C {lab_pin.sym} 2940 17760 0 0 {name=l14318 lab=WL89}
N 3040 17840 3060 17840 {}
C {lab_pin.sym} 3060 17840 0 0 {name=l14319 lab=VDD}
N 3040 17760 3060 17760 {}
C {lab_pin.sym} 3060 17760 0 0 {name=l14320 lab=VSS}
C {bitcell_6t.sym} 3200 17800 0 0 {name=Xr89c16}
N 3160 17840 3140 17840 {}
C {lab_pin.sym} 3140 17840 0 0 {name=l14321 lab=BL16}
N 3160 17800 3140 17800 {}
C {lab_pin.sym} 3140 17800 0 0 {name=l14322 lab=BLB16}
N 3160 17760 3140 17760 {}
C {lab_pin.sym} 3140 17760 0 0 {name=l14323 lab=WL89}
N 3240 17840 3260 17840 {}
C {lab_pin.sym} 3260 17840 0 0 {name=l14324 lab=VDD}
N 3240 17760 3260 17760 {}
C {lab_pin.sym} 3260 17760 0 0 {name=l14325 lab=VSS}
C {bitcell_6t.sym} 3400 17800 0 0 {name=Xr89c17}
N 3360 17840 3340 17840 {}
C {lab_pin.sym} 3340 17840 0 0 {name=l14326 lab=BL17}
N 3360 17800 3340 17800 {}
C {lab_pin.sym} 3340 17800 0 0 {name=l14327 lab=BLB17}
N 3360 17760 3340 17760 {}
C {lab_pin.sym} 3340 17760 0 0 {name=l14328 lab=WL89}
N 3440 17840 3460 17840 {}
C {lab_pin.sym} 3460 17840 0 0 {name=l14329 lab=VDD}
N 3440 17760 3460 17760 {}
C {lab_pin.sym} 3460 17760 0 0 {name=l14330 lab=VSS}
C {bitcell_6t.sym} 3600 17800 0 0 {name=Xr89c18}
N 3560 17840 3540 17840 {}
C {lab_pin.sym} 3540 17840 0 0 {name=l14331 lab=BL18}
N 3560 17800 3540 17800 {}
C {lab_pin.sym} 3540 17800 0 0 {name=l14332 lab=BLB18}
N 3560 17760 3540 17760 {}
C {lab_pin.sym} 3540 17760 0 0 {name=l14333 lab=WL89}
N 3640 17840 3660 17840 {}
C {lab_pin.sym} 3660 17840 0 0 {name=l14334 lab=VDD}
N 3640 17760 3660 17760 {}
C {lab_pin.sym} 3660 17760 0 0 {name=l14335 lab=VSS}
C {bitcell_6t.sym} 3800 17800 0 0 {name=Xr89c19}
N 3760 17840 3740 17840 {}
C {lab_pin.sym} 3740 17840 0 0 {name=l14336 lab=BL19}
N 3760 17800 3740 17800 {}
C {lab_pin.sym} 3740 17800 0 0 {name=l14337 lab=BLB19}
N 3760 17760 3740 17760 {}
C {lab_pin.sym} 3740 17760 0 0 {name=l14338 lab=WL89}
N 3840 17840 3860 17840 {}
C {lab_pin.sym} 3860 17840 0 0 {name=l14339 lab=VDD}
N 3840 17760 3860 17760 {}
C {lab_pin.sym} 3860 17760 0 0 {name=l14340 lab=VSS}
C {bitcell_6t.sym} 4000 17800 0 0 {name=Xr89c20}
N 3960 17840 3940 17840 {}
C {lab_pin.sym} 3940 17840 0 0 {name=l14341 lab=BL20}
N 3960 17800 3940 17800 {}
C {lab_pin.sym} 3940 17800 0 0 {name=l14342 lab=BLB20}
N 3960 17760 3940 17760 {}
C {lab_pin.sym} 3940 17760 0 0 {name=l14343 lab=WL89}
N 4040 17840 4060 17840 {}
C {lab_pin.sym} 4060 17840 0 0 {name=l14344 lab=VDD}
N 4040 17760 4060 17760 {}
C {lab_pin.sym} 4060 17760 0 0 {name=l14345 lab=VSS}
C {bitcell_6t.sym} 4200 17800 0 0 {name=Xr89c21}
N 4160 17840 4140 17840 {}
C {lab_pin.sym} 4140 17840 0 0 {name=l14346 lab=BL21}
N 4160 17800 4140 17800 {}
C {lab_pin.sym} 4140 17800 0 0 {name=l14347 lab=BLB21}
N 4160 17760 4140 17760 {}
C {lab_pin.sym} 4140 17760 0 0 {name=l14348 lab=WL89}
N 4240 17840 4260 17840 {}
C {lab_pin.sym} 4260 17840 0 0 {name=l14349 lab=VDD}
N 4240 17760 4260 17760 {}
C {lab_pin.sym} 4260 17760 0 0 {name=l14350 lab=VSS}
C {bitcell_6t.sym} 4400 17800 0 0 {name=Xr89c22}
N 4360 17840 4340 17840 {}
C {lab_pin.sym} 4340 17840 0 0 {name=l14351 lab=BL22}
N 4360 17800 4340 17800 {}
C {lab_pin.sym} 4340 17800 0 0 {name=l14352 lab=BLB22}
N 4360 17760 4340 17760 {}
C {lab_pin.sym} 4340 17760 0 0 {name=l14353 lab=WL89}
N 4440 17840 4460 17840 {}
C {lab_pin.sym} 4460 17840 0 0 {name=l14354 lab=VDD}
N 4440 17760 4460 17760 {}
C {lab_pin.sym} 4460 17760 0 0 {name=l14355 lab=VSS}
C {bitcell_6t.sym} 4600 17800 0 0 {name=Xr89c23}
N 4560 17840 4540 17840 {}
C {lab_pin.sym} 4540 17840 0 0 {name=l14356 lab=BL23}
N 4560 17800 4540 17800 {}
C {lab_pin.sym} 4540 17800 0 0 {name=l14357 lab=BLB23}
N 4560 17760 4540 17760 {}
C {lab_pin.sym} 4540 17760 0 0 {name=l14358 lab=WL89}
N 4640 17840 4660 17840 {}
C {lab_pin.sym} 4660 17840 0 0 {name=l14359 lab=VDD}
N 4640 17760 4660 17760 {}
C {lab_pin.sym} 4660 17760 0 0 {name=l14360 lab=VSS}
C {bitcell_6t.sym} 4800 17800 0 0 {name=Xr89c24}
N 4760 17840 4740 17840 {}
C {lab_pin.sym} 4740 17840 0 0 {name=l14361 lab=BL24}
N 4760 17800 4740 17800 {}
C {lab_pin.sym} 4740 17800 0 0 {name=l14362 lab=BLB24}
N 4760 17760 4740 17760 {}
C {lab_pin.sym} 4740 17760 0 0 {name=l14363 lab=WL89}
N 4840 17840 4860 17840 {}
C {lab_pin.sym} 4860 17840 0 0 {name=l14364 lab=VDD}
N 4840 17760 4860 17760 {}
C {lab_pin.sym} 4860 17760 0 0 {name=l14365 lab=VSS}
C {bitcell_6t.sym} 5000 17800 0 0 {name=Xr89c25}
N 4960 17840 4940 17840 {}
C {lab_pin.sym} 4940 17840 0 0 {name=l14366 lab=BL25}
N 4960 17800 4940 17800 {}
C {lab_pin.sym} 4940 17800 0 0 {name=l14367 lab=BLB25}
N 4960 17760 4940 17760 {}
C {lab_pin.sym} 4940 17760 0 0 {name=l14368 lab=WL89}
N 5040 17840 5060 17840 {}
C {lab_pin.sym} 5060 17840 0 0 {name=l14369 lab=VDD}
N 5040 17760 5060 17760 {}
C {lab_pin.sym} 5060 17760 0 0 {name=l14370 lab=VSS}
C {bitcell_6t.sym} 5200 17800 0 0 {name=Xr89c26}
N 5160 17840 5140 17840 {}
C {lab_pin.sym} 5140 17840 0 0 {name=l14371 lab=BL26}
N 5160 17800 5140 17800 {}
C {lab_pin.sym} 5140 17800 0 0 {name=l14372 lab=BLB26}
N 5160 17760 5140 17760 {}
C {lab_pin.sym} 5140 17760 0 0 {name=l14373 lab=WL89}
N 5240 17840 5260 17840 {}
C {lab_pin.sym} 5260 17840 0 0 {name=l14374 lab=VDD}
N 5240 17760 5260 17760 {}
C {lab_pin.sym} 5260 17760 0 0 {name=l14375 lab=VSS}
C {bitcell_6t.sym} 5400 17800 0 0 {name=Xr89c27}
N 5360 17840 5340 17840 {}
C {lab_pin.sym} 5340 17840 0 0 {name=l14376 lab=BL27}
N 5360 17800 5340 17800 {}
C {lab_pin.sym} 5340 17800 0 0 {name=l14377 lab=BLB27}
N 5360 17760 5340 17760 {}
C {lab_pin.sym} 5340 17760 0 0 {name=l14378 lab=WL89}
N 5440 17840 5460 17840 {}
C {lab_pin.sym} 5460 17840 0 0 {name=l14379 lab=VDD}
N 5440 17760 5460 17760 {}
C {lab_pin.sym} 5460 17760 0 0 {name=l14380 lab=VSS}
C {bitcell_6t.sym} 5600 17800 0 0 {name=Xr89c28}
N 5560 17840 5540 17840 {}
C {lab_pin.sym} 5540 17840 0 0 {name=l14381 lab=BL28}
N 5560 17800 5540 17800 {}
C {lab_pin.sym} 5540 17800 0 0 {name=l14382 lab=BLB28}
N 5560 17760 5540 17760 {}
C {lab_pin.sym} 5540 17760 0 0 {name=l14383 lab=WL89}
N 5640 17840 5660 17840 {}
C {lab_pin.sym} 5660 17840 0 0 {name=l14384 lab=VDD}
N 5640 17760 5660 17760 {}
C {lab_pin.sym} 5660 17760 0 0 {name=l14385 lab=VSS}
C {bitcell_6t.sym} 5800 17800 0 0 {name=Xr89c29}
N 5760 17840 5740 17840 {}
C {lab_pin.sym} 5740 17840 0 0 {name=l14386 lab=BL29}
N 5760 17800 5740 17800 {}
C {lab_pin.sym} 5740 17800 0 0 {name=l14387 lab=BLB29}
N 5760 17760 5740 17760 {}
C {lab_pin.sym} 5740 17760 0 0 {name=l14388 lab=WL89}
N 5840 17840 5860 17840 {}
C {lab_pin.sym} 5860 17840 0 0 {name=l14389 lab=VDD}
N 5840 17760 5860 17760 {}
C {lab_pin.sym} 5860 17760 0 0 {name=l14390 lab=VSS}
C {bitcell_6t.sym} 6000 17800 0 0 {name=Xr89c30}
N 5960 17840 5940 17840 {}
C {lab_pin.sym} 5940 17840 0 0 {name=l14391 lab=BL30}
N 5960 17800 5940 17800 {}
C {lab_pin.sym} 5940 17800 0 0 {name=l14392 lab=BLB30}
N 5960 17760 5940 17760 {}
C {lab_pin.sym} 5940 17760 0 0 {name=l14393 lab=WL89}
N 6040 17840 6060 17840 {}
C {lab_pin.sym} 6060 17840 0 0 {name=l14394 lab=VDD}
N 6040 17760 6060 17760 {}
C {lab_pin.sym} 6060 17760 0 0 {name=l14395 lab=VSS}
C {bitcell_6t.sym} 6200 17800 0 0 {name=Xr89c31}
N 6160 17840 6140 17840 {}
C {lab_pin.sym} 6140 17840 0 0 {name=l14396 lab=BL31}
N 6160 17800 6140 17800 {}
C {lab_pin.sym} 6140 17800 0 0 {name=l14397 lab=BLB31}
N 6160 17760 6140 17760 {}
C {lab_pin.sym} 6140 17760 0 0 {name=l14398 lab=WL89}
N 6240 17840 6260 17840 {}
C {lab_pin.sym} 6260 17840 0 0 {name=l14399 lab=VDD}
N 6240 17760 6260 17760 {}
C {lab_pin.sym} 6260 17760 0 0 {name=l14400 lab=VSS}
C {bitcell_6t.sym} 0 18000 0 0 {name=Xr90c0}
N -40 18040 -60 18040 {}
C {lab_pin.sym} -60 18040 0 0 {name=l14401 lab=BL0}
N -40 18000 -60 18000 {}
C {lab_pin.sym} -60 18000 0 0 {name=l14402 lab=BLB0}
N -40 17960 -60 17960 {}
C {lab_pin.sym} -60 17960 0 0 {name=l14403 lab=WL90}
N 40 18040 60 18040 {}
C {lab_pin.sym} 60 18040 0 0 {name=l14404 lab=VDD}
N 40 17960 60 17960 {}
C {lab_pin.sym} 60 17960 0 0 {name=l14405 lab=VSS}
C {bitcell_6t.sym} 200 18000 0 0 {name=Xr90c1}
N 160 18040 140 18040 {}
C {lab_pin.sym} 140 18040 0 0 {name=l14406 lab=BL1}
N 160 18000 140 18000 {}
C {lab_pin.sym} 140 18000 0 0 {name=l14407 lab=BLB1}
N 160 17960 140 17960 {}
C {lab_pin.sym} 140 17960 0 0 {name=l14408 lab=WL90}
N 240 18040 260 18040 {}
C {lab_pin.sym} 260 18040 0 0 {name=l14409 lab=VDD}
N 240 17960 260 17960 {}
C {lab_pin.sym} 260 17960 0 0 {name=l14410 lab=VSS}
C {bitcell_6t.sym} 400 18000 0 0 {name=Xr90c2}
N 360 18040 340 18040 {}
C {lab_pin.sym} 340 18040 0 0 {name=l14411 lab=BL2}
N 360 18000 340 18000 {}
C {lab_pin.sym} 340 18000 0 0 {name=l14412 lab=BLB2}
N 360 17960 340 17960 {}
C {lab_pin.sym} 340 17960 0 0 {name=l14413 lab=WL90}
N 440 18040 460 18040 {}
C {lab_pin.sym} 460 18040 0 0 {name=l14414 lab=VDD}
N 440 17960 460 17960 {}
C {lab_pin.sym} 460 17960 0 0 {name=l14415 lab=VSS}
C {bitcell_6t.sym} 600 18000 0 0 {name=Xr90c3}
N 560 18040 540 18040 {}
C {lab_pin.sym} 540 18040 0 0 {name=l14416 lab=BL3}
N 560 18000 540 18000 {}
C {lab_pin.sym} 540 18000 0 0 {name=l14417 lab=BLB3}
N 560 17960 540 17960 {}
C {lab_pin.sym} 540 17960 0 0 {name=l14418 lab=WL90}
N 640 18040 660 18040 {}
C {lab_pin.sym} 660 18040 0 0 {name=l14419 lab=VDD}
N 640 17960 660 17960 {}
C {lab_pin.sym} 660 17960 0 0 {name=l14420 lab=VSS}
C {bitcell_6t.sym} 800 18000 0 0 {name=Xr90c4}
N 760 18040 740 18040 {}
C {lab_pin.sym} 740 18040 0 0 {name=l14421 lab=BL4}
N 760 18000 740 18000 {}
C {lab_pin.sym} 740 18000 0 0 {name=l14422 lab=BLB4}
N 760 17960 740 17960 {}
C {lab_pin.sym} 740 17960 0 0 {name=l14423 lab=WL90}
N 840 18040 860 18040 {}
C {lab_pin.sym} 860 18040 0 0 {name=l14424 lab=VDD}
N 840 17960 860 17960 {}
C {lab_pin.sym} 860 17960 0 0 {name=l14425 lab=VSS}
C {bitcell_6t.sym} 1000 18000 0 0 {name=Xr90c5}
N 960 18040 940 18040 {}
C {lab_pin.sym} 940 18040 0 0 {name=l14426 lab=BL5}
N 960 18000 940 18000 {}
C {lab_pin.sym} 940 18000 0 0 {name=l14427 lab=BLB5}
N 960 17960 940 17960 {}
C {lab_pin.sym} 940 17960 0 0 {name=l14428 lab=WL90}
N 1040 18040 1060 18040 {}
C {lab_pin.sym} 1060 18040 0 0 {name=l14429 lab=VDD}
N 1040 17960 1060 17960 {}
C {lab_pin.sym} 1060 17960 0 0 {name=l14430 lab=VSS}
C {bitcell_6t.sym} 1200 18000 0 0 {name=Xr90c6}
N 1160 18040 1140 18040 {}
C {lab_pin.sym} 1140 18040 0 0 {name=l14431 lab=BL6}
N 1160 18000 1140 18000 {}
C {lab_pin.sym} 1140 18000 0 0 {name=l14432 lab=BLB6}
N 1160 17960 1140 17960 {}
C {lab_pin.sym} 1140 17960 0 0 {name=l14433 lab=WL90}
N 1240 18040 1260 18040 {}
C {lab_pin.sym} 1260 18040 0 0 {name=l14434 lab=VDD}
N 1240 17960 1260 17960 {}
C {lab_pin.sym} 1260 17960 0 0 {name=l14435 lab=VSS}
C {bitcell_6t.sym} 1400 18000 0 0 {name=Xr90c7}
N 1360 18040 1340 18040 {}
C {lab_pin.sym} 1340 18040 0 0 {name=l14436 lab=BL7}
N 1360 18000 1340 18000 {}
C {lab_pin.sym} 1340 18000 0 0 {name=l14437 lab=BLB7}
N 1360 17960 1340 17960 {}
C {lab_pin.sym} 1340 17960 0 0 {name=l14438 lab=WL90}
N 1440 18040 1460 18040 {}
C {lab_pin.sym} 1460 18040 0 0 {name=l14439 lab=VDD}
N 1440 17960 1460 17960 {}
C {lab_pin.sym} 1460 17960 0 0 {name=l14440 lab=VSS}
C {bitcell_6t.sym} 1600 18000 0 0 {name=Xr90c8}
N 1560 18040 1540 18040 {}
C {lab_pin.sym} 1540 18040 0 0 {name=l14441 lab=BL8}
N 1560 18000 1540 18000 {}
C {lab_pin.sym} 1540 18000 0 0 {name=l14442 lab=BLB8}
N 1560 17960 1540 17960 {}
C {lab_pin.sym} 1540 17960 0 0 {name=l14443 lab=WL90}
N 1640 18040 1660 18040 {}
C {lab_pin.sym} 1660 18040 0 0 {name=l14444 lab=VDD}
N 1640 17960 1660 17960 {}
C {lab_pin.sym} 1660 17960 0 0 {name=l14445 lab=VSS}
C {bitcell_6t.sym} 1800 18000 0 0 {name=Xr90c9}
N 1760 18040 1740 18040 {}
C {lab_pin.sym} 1740 18040 0 0 {name=l14446 lab=BL9}
N 1760 18000 1740 18000 {}
C {lab_pin.sym} 1740 18000 0 0 {name=l14447 lab=BLB9}
N 1760 17960 1740 17960 {}
C {lab_pin.sym} 1740 17960 0 0 {name=l14448 lab=WL90}
N 1840 18040 1860 18040 {}
C {lab_pin.sym} 1860 18040 0 0 {name=l14449 lab=VDD}
N 1840 17960 1860 17960 {}
C {lab_pin.sym} 1860 17960 0 0 {name=l14450 lab=VSS}
C {bitcell_6t.sym} 2000 18000 0 0 {name=Xr90c10}
N 1960 18040 1940 18040 {}
C {lab_pin.sym} 1940 18040 0 0 {name=l14451 lab=BL10}
N 1960 18000 1940 18000 {}
C {lab_pin.sym} 1940 18000 0 0 {name=l14452 lab=BLB10}
N 1960 17960 1940 17960 {}
C {lab_pin.sym} 1940 17960 0 0 {name=l14453 lab=WL90}
N 2040 18040 2060 18040 {}
C {lab_pin.sym} 2060 18040 0 0 {name=l14454 lab=VDD}
N 2040 17960 2060 17960 {}
C {lab_pin.sym} 2060 17960 0 0 {name=l14455 lab=VSS}
C {bitcell_6t.sym} 2200 18000 0 0 {name=Xr90c11}
N 2160 18040 2140 18040 {}
C {lab_pin.sym} 2140 18040 0 0 {name=l14456 lab=BL11}
N 2160 18000 2140 18000 {}
C {lab_pin.sym} 2140 18000 0 0 {name=l14457 lab=BLB11}
N 2160 17960 2140 17960 {}
C {lab_pin.sym} 2140 17960 0 0 {name=l14458 lab=WL90}
N 2240 18040 2260 18040 {}
C {lab_pin.sym} 2260 18040 0 0 {name=l14459 lab=VDD}
N 2240 17960 2260 17960 {}
C {lab_pin.sym} 2260 17960 0 0 {name=l14460 lab=VSS}
C {bitcell_6t.sym} 2400 18000 0 0 {name=Xr90c12}
N 2360 18040 2340 18040 {}
C {lab_pin.sym} 2340 18040 0 0 {name=l14461 lab=BL12}
N 2360 18000 2340 18000 {}
C {lab_pin.sym} 2340 18000 0 0 {name=l14462 lab=BLB12}
N 2360 17960 2340 17960 {}
C {lab_pin.sym} 2340 17960 0 0 {name=l14463 lab=WL90}
N 2440 18040 2460 18040 {}
C {lab_pin.sym} 2460 18040 0 0 {name=l14464 lab=VDD}
N 2440 17960 2460 17960 {}
C {lab_pin.sym} 2460 17960 0 0 {name=l14465 lab=VSS}
C {bitcell_6t.sym} 2600 18000 0 0 {name=Xr90c13}
N 2560 18040 2540 18040 {}
C {lab_pin.sym} 2540 18040 0 0 {name=l14466 lab=BL13}
N 2560 18000 2540 18000 {}
C {lab_pin.sym} 2540 18000 0 0 {name=l14467 lab=BLB13}
N 2560 17960 2540 17960 {}
C {lab_pin.sym} 2540 17960 0 0 {name=l14468 lab=WL90}
N 2640 18040 2660 18040 {}
C {lab_pin.sym} 2660 18040 0 0 {name=l14469 lab=VDD}
N 2640 17960 2660 17960 {}
C {lab_pin.sym} 2660 17960 0 0 {name=l14470 lab=VSS}
C {bitcell_6t.sym} 2800 18000 0 0 {name=Xr90c14}
N 2760 18040 2740 18040 {}
C {lab_pin.sym} 2740 18040 0 0 {name=l14471 lab=BL14}
N 2760 18000 2740 18000 {}
C {lab_pin.sym} 2740 18000 0 0 {name=l14472 lab=BLB14}
N 2760 17960 2740 17960 {}
C {lab_pin.sym} 2740 17960 0 0 {name=l14473 lab=WL90}
N 2840 18040 2860 18040 {}
C {lab_pin.sym} 2860 18040 0 0 {name=l14474 lab=VDD}
N 2840 17960 2860 17960 {}
C {lab_pin.sym} 2860 17960 0 0 {name=l14475 lab=VSS}
C {bitcell_6t.sym} 3000 18000 0 0 {name=Xr90c15}
N 2960 18040 2940 18040 {}
C {lab_pin.sym} 2940 18040 0 0 {name=l14476 lab=BL15}
N 2960 18000 2940 18000 {}
C {lab_pin.sym} 2940 18000 0 0 {name=l14477 lab=BLB15}
N 2960 17960 2940 17960 {}
C {lab_pin.sym} 2940 17960 0 0 {name=l14478 lab=WL90}
N 3040 18040 3060 18040 {}
C {lab_pin.sym} 3060 18040 0 0 {name=l14479 lab=VDD}
N 3040 17960 3060 17960 {}
C {lab_pin.sym} 3060 17960 0 0 {name=l14480 lab=VSS}
C {bitcell_6t.sym} 3200 18000 0 0 {name=Xr90c16}
N 3160 18040 3140 18040 {}
C {lab_pin.sym} 3140 18040 0 0 {name=l14481 lab=BL16}
N 3160 18000 3140 18000 {}
C {lab_pin.sym} 3140 18000 0 0 {name=l14482 lab=BLB16}
N 3160 17960 3140 17960 {}
C {lab_pin.sym} 3140 17960 0 0 {name=l14483 lab=WL90}
N 3240 18040 3260 18040 {}
C {lab_pin.sym} 3260 18040 0 0 {name=l14484 lab=VDD}
N 3240 17960 3260 17960 {}
C {lab_pin.sym} 3260 17960 0 0 {name=l14485 lab=VSS}
C {bitcell_6t.sym} 3400 18000 0 0 {name=Xr90c17}
N 3360 18040 3340 18040 {}
C {lab_pin.sym} 3340 18040 0 0 {name=l14486 lab=BL17}
N 3360 18000 3340 18000 {}
C {lab_pin.sym} 3340 18000 0 0 {name=l14487 lab=BLB17}
N 3360 17960 3340 17960 {}
C {lab_pin.sym} 3340 17960 0 0 {name=l14488 lab=WL90}
N 3440 18040 3460 18040 {}
C {lab_pin.sym} 3460 18040 0 0 {name=l14489 lab=VDD}
N 3440 17960 3460 17960 {}
C {lab_pin.sym} 3460 17960 0 0 {name=l14490 lab=VSS}
C {bitcell_6t.sym} 3600 18000 0 0 {name=Xr90c18}
N 3560 18040 3540 18040 {}
C {lab_pin.sym} 3540 18040 0 0 {name=l14491 lab=BL18}
N 3560 18000 3540 18000 {}
C {lab_pin.sym} 3540 18000 0 0 {name=l14492 lab=BLB18}
N 3560 17960 3540 17960 {}
C {lab_pin.sym} 3540 17960 0 0 {name=l14493 lab=WL90}
N 3640 18040 3660 18040 {}
C {lab_pin.sym} 3660 18040 0 0 {name=l14494 lab=VDD}
N 3640 17960 3660 17960 {}
C {lab_pin.sym} 3660 17960 0 0 {name=l14495 lab=VSS}
C {bitcell_6t.sym} 3800 18000 0 0 {name=Xr90c19}
N 3760 18040 3740 18040 {}
C {lab_pin.sym} 3740 18040 0 0 {name=l14496 lab=BL19}
N 3760 18000 3740 18000 {}
C {lab_pin.sym} 3740 18000 0 0 {name=l14497 lab=BLB19}
N 3760 17960 3740 17960 {}
C {lab_pin.sym} 3740 17960 0 0 {name=l14498 lab=WL90}
N 3840 18040 3860 18040 {}
C {lab_pin.sym} 3860 18040 0 0 {name=l14499 lab=VDD}
N 3840 17960 3860 17960 {}
C {lab_pin.sym} 3860 17960 0 0 {name=l14500 lab=VSS}
C {bitcell_6t.sym} 4000 18000 0 0 {name=Xr90c20}
N 3960 18040 3940 18040 {}
C {lab_pin.sym} 3940 18040 0 0 {name=l14501 lab=BL20}
N 3960 18000 3940 18000 {}
C {lab_pin.sym} 3940 18000 0 0 {name=l14502 lab=BLB20}
N 3960 17960 3940 17960 {}
C {lab_pin.sym} 3940 17960 0 0 {name=l14503 lab=WL90}
N 4040 18040 4060 18040 {}
C {lab_pin.sym} 4060 18040 0 0 {name=l14504 lab=VDD}
N 4040 17960 4060 17960 {}
C {lab_pin.sym} 4060 17960 0 0 {name=l14505 lab=VSS}
C {bitcell_6t.sym} 4200 18000 0 0 {name=Xr90c21}
N 4160 18040 4140 18040 {}
C {lab_pin.sym} 4140 18040 0 0 {name=l14506 lab=BL21}
N 4160 18000 4140 18000 {}
C {lab_pin.sym} 4140 18000 0 0 {name=l14507 lab=BLB21}
N 4160 17960 4140 17960 {}
C {lab_pin.sym} 4140 17960 0 0 {name=l14508 lab=WL90}
N 4240 18040 4260 18040 {}
C {lab_pin.sym} 4260 18040 0 0 {name=l14509 lab=VDD}
N 4240 17960 4260 17960 {}
C {lab_pin.sym} 4260 17960 0 0 {name=l14510 lab=VSS}
C {bitcell_6t.sym} 4400 18000 0 0 {name=Xr90c22}
N 4360 18040 4340 18040 {}
C {lab_pin.sym} 4340 18040 0 0 {name=l14511 lab=BL22}
N 4360 18000 4340 18000 {}
C {lab_pin.sym} 4340 18000 0 0 {name=l14512 lab=BLB22}
N 4360 17960 4340 17960 {}
C {lab_pin.sym} 4340 17960 0 0 {name=l14513 lab=WL90}
N 4440 18040 4460 18040 {}
C {lab_pin.sym} 4460 18040 0 0 {name=l14514 lab=VDD}
N 4440 17960 4460 17960 {}
C {lab_pin.sym} 4460 17960 0 0 {name=l14515 lab=VSS}
C {bitcell_6t.sym} 4600 18000 0 0 {name=Xr90c23}
N 4560 18040 4540 18040 {}
C {lab_pin.sym} 4540 18040 0 0 {name=l14516 lab=BL23}
N 4560 18000 4540 18000 {}
C {lab_pin.sym} 4540 18000 0 0 {name=l14517 lab=BLB23}
N 4560 17960 4540 17960 {}
C {lab_pin.sym} 4540 17960 0 0 {name=l14518 lab=WL90}
N 4640 18040 4660 18040 {}
C {lab_pin.sym} 4660 18040 0 0 {name=l14519 lab=VDD}
N 4640 17960 4660 17960 {}
C {lab_pin.sym} 4660 17960 0 0 {name=l14520 lab=VSS}
C {bitcell_6t.sym} 4800 18000 0 0 {name=Xr90c24}
N 4760 18040 4740 18040 {}
C {lab_pin.sym} 4740 18040 0 0 {name=l14521 lab=BL24}
N 4760 18000 4740 18000 {}
C {lab_pin.sym} 4740 18000 0 0 {name=l14522 lab=BLB24}
N 4760 17960 4740 17960 {}
C {lab_pin.sym} 4740 17960 0 0 {name=l14523 lab=WL90}
N 4840 18040 4860 18040 {}
C {lab_pin.sym} 4860 18040 0 0 {name=l14524 lab=VDD}
N 4840 17960 4860 17960 {}
C {lab_pin.sym} 4860 17960 0 0 {name=l14525 lab=VSS}
C {bitcell_6t.sym} 5000 18000 0 0 {name=Xr90c25}
N 4960 18040 4940 18040 {}
C {lab_pin.sym} 4940 18040 0 0 {name=l14526 lab=BL25}
N 4960 18000 4940 18000 {}
C {lab_pin.sym} 4940 18000 0 0 {name=l14527 lab=BLB25}
N 4960 17960 4940 17960 {}
C {lab_pin.sym} 4940 17960 0 0 {name=l14528 lab=WL90}
N 5040 18040 5060 18040 {}
C {lab_pin.sym} 5060 18040 0 0 {name=l14529 lab=VDD}
N 5040 17960 5060 17960 {}
C {lab_pin.sym} 5060 17960 0 0 {name=l14530 lab=VSS}
C {bitcell_6t.sym} 5200 18000 0 0 {name=Xr90c26}
N 5160 18040 5140 18040 {}
C {lab_pin.sym} 5140 18040 0 0 {name=l14531 lab=BL26}
N 5160 18000 5140 18000 {}
C {lab_pin.sym} 5140 18000 0 0 {name=l14532 lab=BLB26}
N 5160 17960 5140 17960 {}
C {lab_pin.sym} 5140 17960 0 0 {name=l14533 lab=WL90}
N 5240 18040 5260 18040 {}
C {lab_pin.sym} 5260 18040 0 0 {name=l14534 lab=VDD}
N 5240 17960 5260 17960 {}
C {lab_pin.sym} 5260 17960 0 0 {name=l14535 lab=VSS}
C {bitcell_6t.sym} 5400 18000 0 0 {name=Xr90c27}
N 5360 18040 5340 18040 {}
C {lab_pin.sym} 5340 18040 0 0 {name=l14536 lab=BL27}
N 5360 18000 5340 18000 {}
C {lab_pin.sym} 5340 18000 0 0 {name=l14537 lab=BLB27}
N 5360 17960 5340 17960 {}
C {lab_pin.sym} 5340 17960 0 0 {name=l14538 lab=WL90}
N 5440 18040 5460 18040 {}
C {lab_pin.sym} 5460 18040 0 0 {name=l14539 lab=VDD}
N 5440 17960 5460 17960 {}
C {lab_pin.sym} 5460 17960 0 0 {name=l14540 lab=VSS}
C {bitcell_6t.sym} 5600 18000 0 0 {name=Xr90c28}
N 5560 18040 5540 18040 {}
C {lab_pin.sym} 5540 18040 0 0 {name=l14541 lab=BL28}
N 5560 18000 5540 18000 {}
C {lab_pin.sym} 5540 18000 0 0 {name=l14542 lab=BLB28}
N 5560 17960 5540 17960 {}
C {lab_pin.sym} 5540 17960 0 0 {name=l14543 lab=WL90}
N 5640 18040 5660 18040 {}
C {lab_pin.sym} 5660 18040 0 0 {name=l14544 lab=VDD}
N 5640 17960 5660 17960 {}
C {lab_pin.sym} 5660 17960 0 0 {name=l14545 lab=VSS}
C {bitcell_6t.sym} 5800 18000 0 0 {name=Xr90c29}
N 5760 18040 5740 18040 {}
C {lab_pin.sym} 5740 18040 0 0 {name=l14546 lab=BL29}
N 5760 18000 5740 18000 {}
C {lab_pin.sym} 5740 18000 0 0 {name=l14547 lab=BLB29}
N 5760 17960 5740 17960 {}
C {lab_pin.sym} 5740 17960 0 0 {name=l14548 lab=WL90}
N 5840 18040 5860 18040 {}
C {lab_pin.sym} 5860 18040 0 0 {name=l14549 lab=VDD}
N 5840 17960 5860 17960 {}
C {lab_pin.sym} 5860 17960 0 0 {name=l14550 lab=VSS}
C {bitcell_6t.sym} 6000 18000 0 0 {name=Xr90c30}
N 5960 18040 5940 18040 {}
C {lab_pin.sym} 5940 18040 0 0 {name=l14551 lab=BL30}
N 5960 18000 5940 18000 {}
C {lab_pin.sym} 5940 18000 0 0 {name=l14552 lab=BLB30}
N 5960 17960 5940 17960 {}
C {lab_pin.sym} 5940 17960 0 0 {name=l14553 lab=WL90}
N 6040 18040 6060 18040 {}
C {lab_pin.sym} 6060 18040 0 0 {name=l14554 lab=VDD}
N 6040 17960 6060 17960 {}
C {lab_pin.sym} 6060 17960 0 0 {name=l14555 lab=VSS}
C {bitcell_6t.sym} 6200 18000 0 0 {name=Xr90c31}
N 6160 18040 6140 18040 {}
C {lab_pin.sym} 6140 18040 0 0 {name=l14556 lab=BL31}
N 6160 18000 6140 18000 {}
C {lab_pin.sym} 6140 18000 0 0 {name=l14557 lab=BLB31}
N 6160 17960 6140 17960 {}
C {lab_pin.sym} 6140 17960 0 0 {name=l14558 lab=WL90}
N 6240 18040 6260 18040 {}
C {lab_pin.sym} 6260 18040 0 0 {name=l14559 lab=VDD}
N 6240 17960 6260 17960 {}
C {lab_pin.sym} 6260 17960 0 0 {name=l14560 lab=VSS}
C {bitcell_6t.sym} 0 18200 0 0 {name=Xr91c0}
N -40 18240 -60 18240 {}
C {lab_pin.sym} -60 18240 0 0 {name=l14561 lab=BL0}
N -40 18200 -60 18200 {}
C {lab_pin.sym} -60 18200 0 0 {name=l14562 lab=BLB0}
N -40 18160 -60 18160 {}
C {lab_pin.sym} -60 18160 0 0 {name=l14563 lab=WL91}
N 40 18240 60 18240 {}
C {lab_pin.sym} 60 18240 0 0 {name=l14564 lab=VDD}
N 40 18160 60 18160 {}
C {lab_pin.sym} 60 18160 0 0 {name=l14565 lab=VSS}
C {bitcell_6t.sym} 200 18200 0 0 {name=Xr91c1}
N 160 18240 140 18240 {}
C {lab_pin.sym} 140 18240 0 0 {name=l14566 lab=BL1}
N 160 18200 140 18200 {}
C {lab_pin.sym} 140 18200 0 0 {name=l14567 lab=BLB1}
N 160 18160 140 18160 {}
C {lab_pin.sym} 140 18160 0 0 {name=l14568 lab=WL91}
N 240 18240 260 18240 {}
C {lab_pin.sym} 260 18240 0 0 {name=l14569 lab=VDD}
N 240 18160 260 18160 {}
C {lab_pin.sym} 260 18160 0 0 {name=l14570 lab=VSS}
C {bitcell_6t.sym} 400 18200 0 0 {name=Xr91c2}
N 360 18240 340 18240 {}
C {lab_pin.sym} 340 18240 0 0 {name=l14571 lab=BL2}
N 360 18200 340 18200 {}
C {lab_pin.sym} 340 18200 0 0 {name=l14572 lab=BLB2}
N 360 18160 340 18160 {}
C {lab_pin.sym} 340 18160 0 0 {name=l14573 lab=WL91}
N 440 18240 460 18240 {}
C {lab_pin.sym} 460 18240 0 0 {name=l14574 lab=VDD}
N 440 18160 460 18160 {}
C {lab_pin.sym} 460 18160 0 0 {name=l14575 lab=VSS}
C {bitcell_6t.sym} 600 18200 0 0 {name=Xr91c3}
N 560 18240 540 18240 {}
C {lab_pin.sym} 540 18240 0 0 {name=l14576 lab=BL3}
N 560 18200 540 18200 {}
C {lab_pin.sym} 540 18200 0 0 {name=l14577 lab=BLB3}
N 560 18160 540 18160 {}
C {lab_pin.sym} 540 18160 0 0 {name=l14578 lab=WL91}
N 640 18240 660 18240 {}
C {lab_pin.sym} 660 18240 0 0 {name=l14579 lab=VDD}
N 640 18160 660 18160 {}
C {lab_pin.sym} 660 18160 0 0 {name=l14580 lab=VSS}
C {bitcell_6t.sym} 800 18200 0 0 {name=Xr91c4}
N 760 18240 740 18240 {}
C {lab_pin.sym} 740 18240 0 0 {name=l14581 lab=BL4}
N 760 18200 740 18200 {}
C {lab_pin.sym} 740 18200 0 0 {name=l14582 lab=BLB4}
N 760 18160 740 18160 {}
C {lab_pin.sym} 740 18160 0 0 {name=l14583 lab=WL91}
N 840 18240 860 18240 {}
C {lab_pin.sym} 860 18240 0 0 {name=l14584 lab=VDD}
N 840 18160 860 18160 {}
C {lab_pin.sym} 860 18160 0 0 {name=l14585 lab=VSS}
C {bitcell_6t.sym} 1000 18200 0 0 {name=Xr91c5}
N 960 18240 940 18240 {}
C {lab_pin.sym} 940 18240 0 0 {name=l14586 lab=BL5}
N 960 18200 940 18200 {}
C {lab_pin.sym} 940 18200 0 0 {name=l14587 lab=BLB5}
N 960 18160 940 18160 {}
C {lab_pin.sym} 940 18160 0 0 {name=l14588 lab=WL91}
N 1040 18240 1060 18240 {}
C {lab_pin.sym} 1060 18240 0 0 {name=l14589 lab=VDD}
N 1040 18160 1060 18160 {}
C {lab_pin.sym} 1060 18160 0 0 {name=l14590 lab=VSS}
C {bitcell_6t.sym} 1200 18200 0 0 {name=Xr91c6}
N 1160 18240 1140 18240 {}
C {lab_pin.sym} 1140 18240 0 0 {name=l14591 lab=BL6}
N 1160 18200 1140 18200 {}
C {lab_pin.sym} 1140 18200 0 0 {name=l14592 lab=BLB6}
N 1160 18160 1140 18160 {}
C {lab_pin.sym} 1140 18160 0 0 {name=l14593 lab=WL91}
N 1240 18240 1260 18240 {}
C {lab_pin.sym} 1260 18240 0 0 {name=l14594 lab=VDD}
N 1240 18160 1260 18160 {}
C {lab_pin.sym} 1260 18160 0 0 {name=l14595 lab=VSS}
C {bitcell_6t.sym} 1400 18200 0 0 {name=Xr91c7}
N 1360 18240 1340 18240 {}
C {lab_pin.sym} 1340 18240 0 0 {name=l14596 lab=BL7}
N 1360 18200 1340 18200 {}
C {lab_pin.sym} 1340 18200 0 0 {name=l14597 lab=BLB7}
N 1360 18160 1340 18160 {}
C {lab_pin.sym} 1340 18160 0 0 {name=l14598 lab=WL91}
N 1440 18240 1460 18240 {}
C {lab_pin.sym} 1460 18240 0 0 {name=l14599 lab=VDD}
N 1440 18160 1460 18160 {}
C {lab_pin.sym} 1460 18160 0 0 {name=l14600 lab=VSS}
C {bitcell_6t.sym} 1600 18200 0 0 {name=Xr91c8}
N 1560 18240 1540 18240 {}
C {lab_pin.sym} 1540 18240 0 0 {name=l14601 lab=BL8}
N 1560 18200 1540 18200 {}
C {lab_pin.sym} 1540 18200 0 0 {name=l14602 lab=BLB8}
N 1560 18160 1540 18160 {}
C {lab_pin.sym} 1540 18160 0 0 {name=l14603 lab=WL91}
N 1640 18240 1660 18240 {}
C {lab_pin.sym} 1660 18240 0 0 {name=l14604 lab=VDD}
N 1640 18160 1660 18160 {}
C {lab_pin.sym} 1660 18160 0 0 {name=l14605 lab=VSS}
C {bitcell_6t.sym} 1800 18200 0 0 {name=Xr91c9}
N 1760 18240 1740 18240 {}
C {lab_pin.sym} 1740 18240 0 0 {name=l14606 lab=BL9}
N 1760 18200 1740 18200 {}
C {lab_pin.sym} 1740 18200 0 0 {name=l14607 lab=BLB9}
N 1760 18160 1740 18160 {}
C {lab_pin.sym} 1740 18160 0 0 {name=l14608 lab=WL91}
N 1840 18240 1860 18240 {}
C {lab_pin.sym} 1860 18240 0 0 {name=l14609 lab=VDD}
N 1840 18160 1860 18160 {}
C {lab_pin.sym} 1860 18160 0 0 {name=l14610 lab=VSS}
C {bitcell_6t.sym} 2000 18200 0 0 {name=Xr91c10}
N 1960 18240 1940 18240 {}
C {lab_pin.sym} 1940 18240 0 0 {name=l14611 lab=BL10}
N 1960 18200 1940 18200 {}
C {lab_pin.sym} 1940 18200 0 0 {name=l14612 lab=BLB10}
N 1960 18160 1940 18160 {}
C {lab_pin.sym} 1940 18160 0 0 {name=l14613 lab=WL91}
N 2040 18240 2060 18240 {}
C {lab_pin.sym} 2060 18240 0 0 {name=l14614 lab=VDD}
N 2040 18160 2060 18160 {}
C {lab_pin.sym} 2060 18160 0 0 {name=l14615 lab=VSS}
C {bitcell_6t.sym} 2200 18200 0 0 {name=Xr91c11}
N 2160 18240 2140 18240 {}
C {lab_pin.sym} 2140 18240 0 0 {name=l14616 lab=BL11}
N 2160 18200 2140 18200 {}
C {lab_pin.sym} 2140 18200 0 0 {name=l14617 lab=BLB11}
N 2160 18160 2140 18160 {}
C {lab_pin.sym} 2140 18160 0 0 {name=l14618 lab=WL91}
N 2240 18240 2260 18240 {}
C {lab_pin.sym} 2260 18240 0 0 {name=l14619 lab=VDD}
N 2240 18160 2260 18160 {}
C {lab_pin.sym} 2260 18160 0 0 {name=l14620 lab=VSS}
C {bitcell_6t.sym} 2400 18200 0 0 {name=Xr91c12}
N 2360 18240 2340 18240 {}
C {lab_pin.sym} 2340 18240 0 0 {name=l14621 lab=BL12}
N 2360 18200 2340 18200 {}
C {lab_pin.sym} 2340 18200 0 0 {name=l14622 lab=BLB12}
N 2360 18160 2340 18160 {}
C {lab_pin.sym} 2340 18160 0 0 {name=l14623 lab=WL91}
N 2440 18240 2460 18240 {}
C {lab_pin.sym} 2460 18240 0 0 {name=l14624 lab=VDD}
N 2440 18160 2460 18160 {}
C {lab_pin.sym} 2460 18160 0 0 {name=l14625 lab=VSS}
C {bitcell_6t.sym} 2600 18200 0 0 {name=Xr91c13}
N 2560 18240 2540 18240 {}
C {lab_pin.sym} 2540 18240 0 0 {name=l14626 lab=BL13}
N 2560 18200 2540 18200 {}
C {lab_pin.sym} 2540 18200 0 0 {name=l14627 lab=BLB13}
N 2560 18160 2540 18160 {}
C {lab_pin.sym} 2540 18160 0 0 {name=l14628 lab=WL91}
N 2640 18240 2660 18240 {}
C {lab_pin.sym} 2660 18240 0 0 {name=l14629 lab=VDD}
N 2640 18160 2660 18160 {}
C {lab_pin.sym} 2660 18160 0 0 {name=l14630 lab=VSS}
C {bitcell_6t.sym} 2800 18200 0 0 {name=Xr91c14}
N 2760 18240 2740 18240 {}
C {lab_pin.sym} 2740 18240 0 0 {name=l14631 lab=BL14}
N 2760 18200 2740 18200 {}
C {lab_pin.sym} 2740 18200 0 0 {name=l14632 lab=BLB14}
N 2760 18160 2740 18160 {}
C {lab_pin.sym} 2740 18160 0 0 {name=l14633 lab=WL91}
N 2840 18240 2860 18240 {}
C {lab_pin.sym} 2860 18240 0 0 {name=l14634 lab=VDD}
N 2840 18160 2860 18160 {}
C {lab_pin.sym} 2860 18160 0 0 {name=l14635 lab=VSS}
C {bitcell_6t.sym} 3000 18200 0 0 {name=Xr91c15}
N 2960 18240 2940 18240 {}
C {lab_pin.sym} 2940 18240 0 0 {name=l14636 lab=BL15}
N 2960 18200 2940 18200 {}
C {lab_pin.sym} 2940 18200 0 0 {name=l14637 lab=BLB15}
N 2960 18160 2940 18160 {}
C {lab_pin.sym} 2940 18160 0 0 {name=l14638 lab=WL91}
N 3040 18240 3060 18240 {}
C {lab_pin.sym} 3060 18240 0 0 {name=l14639 lab=VDD}
N 3040 18160 3060 18160 {}
C {lab_pin.sym} 3060 18160 0 0 {name=l14640 lab=VSS}
C {bitcell_6t.sym} 3200 18200 0 0 {name=Xr91c16}
N 3160 18240 3140 18240 {}
C {lab_pin.sym} 3140 18240 0 0 {name=l14641 lab=BL16}
N 3160 18200 3140 18200 {}
C {lab_pin.sym} 3140 18200 0 0 {name=l14642 lab=BLB16}
N 3160 18160 3140 18160 {}
C {lab_pin.sym} 3140 18160 0 0 {name=l14643 lab=WL91}
N 3240 18240 3260 18240 {}
C {lab_pin.sym} 3260 18240 0 0 {name=l14644 lab=VDD}
N 3240 18160 3260 18160 {}
C {lab_pin.sym} 3260 18160 0 0 {name=l14645 lab=VSS}
C {bitcell_6t.sym} 3400 18200 0 0 {name=Xr91c17}
N 3360 18240 3340 18240 {}
C {lab_pin.sym} 3340 18240 0 0 {name=l14646 lab=BL17}
N 3360 18200 3340 18200 {}
C {lab_pin.sym} 3340 18200 0 0 {name=l14647 lab=BLB17}
N 3360 18160 3340 18160 {}
C {lab_pin.sym} 3340 18160 0 0 {name=l14648 lab=WL91}
N 3440 18240 3460 18240 {}
C {lab_pin.sym} 3460 18240 0 0 {name=l14649 lab=VDD}
N 3440 18160 3460 18160 {}
C {lab_pin.sym} 3460 18160 0 0 {name=l14650 lab=VSS}
C {bitcell_6t.sym} 3600 18200 0 0 {name=Xr91c18}
N 3560 18240 3540 18240 {}
C {lab_pin.sym} 3540 18240 0 0 {name=l14651 lab=BL18}
N 3560 18200 3540 18200 {}
C {lab_pin.sym} 3540 18200 0 0 {name=l14652 lab=BLB18}
N 3560 18160 3540 18160 {}
C {lab_pin.sym} 3540 18160 0 0 {name=l14653 lab=WL91}
N 3640 18240 3660 18240 {}
C {lab_pin.sym} 3660 18240 0 0 {name=l14654 lab=VDD}
N 3640 18160 3660 18160 {}
C {lab_pin.sym} 3660 18160 0 0 {name=l14655 lab=VSS}
C {bitcell_6t.sym} 3800 18200 0 0 {name=Xr91c19}
N 3760 18240 3740 18240 {}
C {lab_pin.sym} 3740 18240 0 0 {name=l14656 lab=BL19}
N 3760 18200 3740 18200 {}
C {lab_pin.sym} 3740 18200 0 0 {name=l14657 lab=BLB19}
N 3760 18160 3740 18160 {}
C {lab_pin.sym} 3740 18160 0 0 {name=l14658 lab=WL91}
N 3840 18240 3860 18240 {}
C {lab_pin.sym} 3860 18240 0 0 {name=l14659 lab=VDD}
N 3840 18160 3860 18160 {}
C {lab_pin.sym} 3860 18160 0 0 {name=l14660 lab=VSS}
C {bitcell_6t.sym} 4000 18200 0 0 {name=Xr91c20}
N 3960 18240 3940 18240 {}
C {lab_pin.sym} 3940 18240 0 0 {name=l14661 lab=BL20}
N 3960 18200 3940 18200 {}
C {lab_pin.sym} 3940 18200 0 0 {name=l14662 lab=BLB20}
N 3960 18160 3940 18160 {}
C {lab_pin.sym} 3940 18160 0 0 {name=l14663 lab=WL91}
N 4040 18240 4060 18240 {}
C {lab_pin.sym} 4060 18240 0 0 {name=l14664 lab=VDD}
N 4040 18160 4060 18160 {}
C {lab_pin.sym} 4060 18160 0 0 {name=l14665 lab=VSS}
C {bitcell_6t.sym} 4200 18200 0 0 {name=Xr91c21}
N 4160 18240 4140 18240 {}
C {lab_pin.sym} 4140 18240 0 0 {name=l14666 lab=BL21}
N 4160 18200 4140 18200 {}
C {lab_pin.sym} 4140 18200 0 0 {name=l14667 lab=BLB21}
N 4160 18160 4140 18160 {}
C {lab_pin.sym} 4140 18160 0 0 {name=l14668 lab=WL91}
N 4240 18240 4260 18240 {}
C {lab_pin.sym} 4260 18240 0 0 {name=l14669 lab=VDD}
N 4240 18160 4260 18160 {}
C {lab_pin.sym} 4260 18160 0 0 {name=l14670 lab=VSS}
C {bitcell_6t.sym} 4400 18200 0 0 {name=Xr91c22}
N 4360 18240 4340 18240 {}
C {lab_pin.sym} 4340 18240 0 0 {name=l14671 lab=BL22}
N 4360 18200 4340 18200 {}
C {lab_pin.sym} 4340 18200 0 0 {name=l14672 lab=BLB22}
N 4360 18160 4340 18160 {}
C {lab_pin.sym} 4340 18160 0 0 {name=l14673 lab=WL91}
N 4440 18240 4460 18240 {}
C {lab_pin.sym} 4460 18240 0 0 {name=l14674 lab=VDD}
N 4440 18160 4460 18160 {}
C {lab_pin.sym} 4460 18160 0 0 {name=l14675 lab=VSS}
C {bitcell_6t.sym} 4600 18200 0 0 {name=Xr91c23}
N 4560 18240 4540 18240 {}
C {lab_pin.sym} 4540 18240 0 0 {name=l14676 lab=BL23}
N 4560 18200 4540 18200 {}
C {lab_pin.sym} 4540 18200 0 0 {name=l14677 lab=BLB23}
N 4560 18160 4540 18160 {}
C {lab_pin.sym} 4540 18160 0 0 {name=l14678 lab=WL91}
N 4640 18240 4660 18240 {}
C {lab_pin.sym} 4660 18240 0 0 {name=l14679 lab=VDD}
N 4640 18160 4660 18160 {}
C {lab_pin.sym} 4660 18160 0 0 {name=l14680 lab=VSS}
C {bitcell_6t.sym} 4800 18200 0 0 {name=Xr91c24}
N 4760 18240 4740 18240 {}
C {lab_pin.sym} 4740 18240 0 0 {name=l14681 lab=BL24}
N 4760 18200 4740 18200 {}
C {lab_pin.sym} 4740 18200 0 0 {name=l14682 lab=BLB24}
N 4760 18160 4740 18160 {}
C {lab_pin.sym} 4740 18160 0 0 {name=l14683 lab=WL91}
N 4840 18240 4860 18240 {}
C {lab_pin.sym} 4860 18240 0 0 {name=l14684 lab=VDD}
N 4840 18160 4860 18160 {}
C {lab_pin.sym} 4860 18160 0 0 {name=l14685 lab=VSS}
C {bitcell_6t.sym} 5000 18200 0 0 {name=Xr91c25}
N 4960 18240 4940 18240 {}
C {lab_pin.sym} 4940 18240 0 0 {name=l14686 lab=BL25}
N 4960 18200 4940 18200 {}
C {lab_pin.sym} 4940 18200 0 0 {name=l14687 lab=BLB25}
N 4960 18160 4940 18160 {}
C {lab_pin.sym} 4940 18160 0 0 {name=l14688 lab=WL91}
N 5040 18240 5060 18240 {}
C {lab_pin.sym} 5060 18240 0 0 {name=l14689 lab=VDD}
N 5040 18160 5060 18160 {}
C {lab_pin.sym} 5060 18160 0 0 {name=l14690 lab=VSS}
C {bitcell_6t.sym} 5200 18200 0 0 {name=Xr91c26}
N 5160 18240 5140 18240 {}
C {lab_pin.sym} 5140 18240 0 0 {name=l14691 lab=BL26}
N 5160 18200 5140 18200 {}
C {lab_pin.sym} 5140 18200 0 0 {name=l14692 lab=BLB26}
N 5160 18160 5140 18160 {}
C {lab_pin.sym} 5140 18160 0 0 {name=l14693 lab=WL91}
N 5240 18240 5260 18240 {}
C {lab_pin.sym} 5260 18240 0 0 {name=l14694 lab=VDD}
N 5240 18160 5260 18160 {}
C {lab_pin.sym} 5260 18160 0 0 {name=l14695 lab=VSS}
C {bitcell_6t.sym} 5400 18200 0 0 {name=Xr91c27}
N 5360 18240 5340 18240 {}
C {lab_pin.sym} 5340 18240 0 0 {name=l14696 lab=BL27}
N 5360 18200 5340 18200 {}
C {lab_pin.sym} 5340 18200 0 0 {name=l14697 lab=BLB27}
N 5360 18160 5340 18160 {}
C {lab_pin.sym} 5340 18160 0 0 {name=l14698 lab=WL91}
N 5440 18240 5460 18240 {}
C {lab_pin.sym} 5460 18240 0 0 {name=l14699 lab=VDD}
N 5440 18160 5460 18160 {}
C {lab_pin.sym} 5460 18160 0 0 {name=l14700 lab=VSS}
C {bitcell_6t.sym} 5600 18200 0 0 {name=Xr91c28}
N 5560 18240 5540 18240 {}
C {lab_pin.sym} 5540 18240 0 0 {name=l14701 lab=BL28}
N 5560 18200 5540 18200 {}
C {lab_pin.sym} 5540 18200 0 0 {name=l14702 lab=BLB28}
N 5560 18160 5540 18160 {}
C {lab_pin.sym} 5540 18160 0 0 {name=l14703 lab=WL91}
N 5640 18240 5660 18240 {}
C {lab_pin.sym} 5660 18240 0 0 {name=l14704 lab=VDD}
N 5640 18160 5660 18160 {}
C {lab_pin.sym} 5660 18160 0 0 {name=l14705 lab=VSS}
C {bitcell_6t.sym} 5800 18200 0 0 {name=Xr91c29}
N 5760 18240 5740 18240 {}
C {lab_pin.sym} 5740 18240 0 0 {name=l14706 lab=BL29}
N 5760 18200 5740 18200 {}
C {lab_pin.sym} 5740 18200 0 0 {name=l14707 lab=BLB29}
N 5760 18160 5740 18160 {}
C {lab_pin.sym} 5740 18160 0 0 {name=l14708 lab=WL91}
N 5840 18240 5860 18240 {}
C {lab_pin.sym} 5860 18240 0 0 {name=l14709 lab=VDD}
N 5840 18160 5860 18160 {}
C {lab_pin.sym} 5860 18160 0 0 {name=l14710 lab=VSS}
C {bitcell_6t.sym} 6000 18200 0 0 {name=Xr91c30}
N 5960 18240 5940 18240 {}
C {lab_pin.sym} 5940 18240 0 0 {name=l14711 lab=BL30}
N 5960 18200 5940 18200 {}
C {lab_pin.sym} 5940 18200 0 0 {name=l14712 lab=BLB30}
N 5960 18160 5940 18160 {}
C {lab_pin.sym} 5940 18160 0 0 {name=l14713 lab=WL91}
N 6040 18240 6060 18240 {}
C {lab_pin.sym} 6060 18240 0 0 {name=l14714 lab=VDD}
N 6040 18160 6060 18160 {}
C {lab_pin.sym} 6060 18160 0 0 {name=l14715 lab=VSS}
C {bitcell_6t.sym} 6200 18200 0 0 {name=Xr91c31}
N 6160 18240 6140 18240 {}
C {lab_pin.sym} 6140 18240 0 0 {name=l14716 lab=BL31}
N 6160 18200 6140 18200 {}
C {lab_pin.sym} 6140 18200 0 0 {name=l14717 lab=BLB31}
N 6160 18160 6140 18160 {}
C {lab_pin.sym} 6140 18160 0 0 {name=l14718 lab=WL91}
N 6240 18240 6260 18240 {}
C {lab_pin.sym} 6260 18240 0 0 {name=l14719 lab=VDD}
N 6240 18160 6260 18160 {}
C {lab_pin.sym} 6260 18160 0 0 {name=l14720 lab=VSS}
C {bitcell_6t.sym} 0 18400 0 0 {name=Xr92c0}
N -40 18440 -60 18440 {}
C {lab_pin.sym} -60 18440 0 0 {name=l14721 lab=BL0}
N -40 18400 -60 18400 {}
C {lab_pin.sym} -60 18400 0 0 {name=l14722 lab=BLB0}
N -40 18360 -60 18360 {}
C {lab_pin.sym} -60 18360 0 0 {name=l14723 lab=WL92}
N 40 18440 60 18440 {}
C {lab_pin.sym} 60 18440 0 0 {name=l14724 lab=VDD}
N 40 18360 60 18360 {}
C {lab_pin.sym} 60 18360 0 0 {name=l14725 lab=VSS}
C {bitcell_6t.sym} 200 18400 0 0 {name=Xr92c1}
N 160 18440 140 18440 {}
C {lab_pin.sym} 140 18440 0 0 {name=l14726 lab=BL1}
N 160 18400 140 18400 {}
C {lab_pin.sym} 140 18400 0 0 {name=l14727 lab=BLB1}
N 160 18360 140 18360 {}
C {lab_pin.sym} 140 18360 0 0 {name=l14728 lab=WL92}
N 240 18440 260 18440 {}
C {lab_pin.sym} 260 18440 0 0 {name=l14729 lab=VDD}
N 240 18360 260 18360 {}
C {lab_pin.sym} 260 18360 0 0 {name=l14730 lab=VSS}
C {bitcell_6t.sym} 400 18400 0 0 {name=Xr92c2}
N 360 18440 340 18440 {}
C {lab_pin.sym} 340 18440 0 0 {name=l14731 lab=BL2}
N 360 18400 340 18400 {}
C {lab_pin.sym} 340 18400 0 0 {name=l14732 lab=BLB2}
N 360 18360 340 18360 {}
C {lab_pin.sym} 340 18360 0 0 {name=l14733 lab=WL92}
N 440 18440 460 18440 {}
C {lab_pin.sym} 460 18440 0 0 {name=l14734 lab=VDD}
N 440 18360 460 18360 {}
C {lab_pin.sym} 460 18360 0 0 {name=l14735 lab=VSS}
C {bitcell_6t.sym} 600 18400 0 0 {name=Xr92c3}
N 560 18440 540 18440 {}
C {lab_pin.sym} 540 18440 0 0 {name=l14736 lab=BL3}
N 560 18400 540 18400 {}
C {lab_pin.sym} 540 18400 0 0 {name=l14737 lab=BLB3}
N 560 18360 540 18360 {}
C {lab_pin.sym} 540 18360 0 0 {name=l14738 lab=WL92}
N 640 18440 660 18440 {}
C {lab_pin.sym} 660 18440 0 0 {name=l14739 lab=VDD}
N 640 18360 660 18360 {}
C {lab_pin.sym} 660 18360 0 0 {name=l14740 lab=VSS}
C {bitcell_6t.sym} 800 18400 0 0 {name=Xr92c4}
N 760 18440 740 18440 {}
C {lab_pin.sym} 740 18440 0 0 {name=l14741 lab=BL4}
N 760 18400 740 18400 {}
C {lab_pin.sym} 740 18400 0 0 {name=l14742 lab=BLB4}
N 760 18360 740 18360 {}
C {lab_pin.sym} 740 18360 0 0 {name=l14743 lab=WL92}
N 840 18440 860 18440 {}
C {lab_pin.sym} 860 18440 0 0 {name=l14744 lab=VDD}
N 840 18360 860 18360 {}
C {lab_pin.sym} 860 18360 0 0 {name=l14745 lab=VSS}
C {bitcell_6t.sym} 1000 18400 0 0 {name=Xr92c5}
N 960 18440 940 18440 {}
C {lab_pin.sym} 940 18440 0 0 {name=l14746 lab=BL5}
N 960 18400 940 18400 {}
C {lab_pin.sym} 940 18400 0 0 {name=l14747 lab=BLB5}
N 960 18360 940 18360 {}
C {lab_pin.sym} 940 18360 0 0 {name=l14748 lab=WL92}
N 1040 18440 1060 18440 {}
C {lab_pin.sym} 1060 18440 0 0 {name=l14749 lab=VDD}
N 1040 18360 1060 18360 {}
C {lab_pin.sym} 1060 18360 0 0 {name=l14750 lab=VSS}
C {bitcell_6t.sym} 1200 18400 0 0 {name=Xr92c6}
N 1160 18440 1140 18440 {}
C {lab_pin.sym} 1140 18440 0 0 {name=l14751 lab=BL6}
N 1160 18400 1140 18400 {}
C {lab_pin.sym} 1140 18400 0 0 {name=l14752 lab=BLB6}
N 1160 18360 1140 18360 {}
C {lab_pin.sym} 1140 18360 0 0 {name=l14753 lab=WL92}
N 1240 18440 1260 18440 {}
C {lab_pin.sym} 1260 18440 0 0 {name=l14754 lab=VDD}
N 1240 18360 1260 18360 {}
C {lab_pin.sym} 1260 18360 0 0 {name=l14755 lab=VSS}
C {bitcell_6t.sym} 1400 18400 0 0 {name=Xr92c7}
N 1360 18440 1340 18440 {}
C {lab_pin.sym} 1340 18440 0 0 {name=l14756 lab=BL7}
N 1360 18400 1340 18400 {}
C {lab_pin.sym} 1340 18400 0 0 {name=l14757 lab=BLB7}
N 1360 18360 1340 18360 {}
C {lab_pin.sym} 1340 18360 0 0 {name=l14758 lab=WL92}
N 1440 18440 1460 18440 {}
C {lab_pin.sym} 1460 18440 0 0 {name=l14759 lab=VDD}
N 1440 18360 1460 18360 {}
C {lab_pin.sym} 1460 18360 0 0 {name=l14760 lab=VSS}
C {bitcell_6t.sym} 1600 18400 0 0 {name=Xr92c8}
N 1560 18440 1540 18440 {}
C {lab_pin.sym} 1540 18440 0 0 {name=l14761 lab=BL8}
N 1560 18400 1540 18400 {}
C {lab_pin.sym} 1540 18400 0 0 {name=l14762 lab=BLB8}
N 1560 18360 1540 18360 {}
C {lab_pin.sym} 1540 18360 0 0 {name=l14763 lab=WL92}
N 1640 18440 1660 18440 {}
C {lab_pin.sym} 1660 18440 0 0 {name=l14764 lab=VDD}
N 1640 18360 1660 18360 {}
C {lab_pin.sym} 1660 18360 0 0 {name=l14765 lab=VSS}
C {bitcell_6t.sym} 1800 18400 0 0 {name=Xr92c9}
N 1760 18440 1740 18440 {}
C {lab_pin.sym} 1740 18440 0 0 {name=l14766 lab=BL9}
N 1760 18400 1740 18400 {}
C {lab_pin.sym} 1740 18400 0 0 {name=l14767 lab=BLB9}
N 1760 18360 1740 18360 {}
C {lab_pin.sym} 1740 18360 0 0 {name=l14768 lab=WL92}
N 1840 18440 1860 18440 {}
C {lab_pin.sym} 1860 18440 0 0 {name=l14769 lab=VDD}
N 1840 18360 1860 18360 {}
C {lab_pin.sym} 1860 18360 0 0 {name=l14770 lab=VSS}
C {bitcell_6t.sym} 2000 18400 0 0 {name=Xr92c10}
N 1960 18440 1940 18440 {}
C {lab_pin.sym} 1940 18440 0 0 {name=l14771 lab=BL10}
N 1960 18400 1940 18400 {}
C {lab_pin.sym} 1940 18400 0 0 {name=l14772 lab=BLB10}
N 1960 18360 1940 18360 {}
C {lab_pin.sym} 1940 18360 0 0 {name=l14773 lab=WL92}
N 2040 18440 2060 18440 {}
C {lab_pin.sym} 2060 18440 0 0 {name=l14774 lab=VDD}
N 2040 18360 2060 18360 {}
C {lab_pin.sym} 2060 18360 0 0 {name=l14775 lab=VSS}
C {bitcell_6t.sym} 2200 18400 0 0 {name=Xr92c11}
N 2160 18440 2140 18440 {}
C {lab_pin.sym} 2140 18440 0 0 {name=l14776 lab=BL11}
N 2160 18400 2140 18400 {}
C {lab_pin.sym} 2140 18400 0 0 {name=l14777 lab=BLB11}
N 2160 18360 2140 18360 {}
C {lab_pin.sym} 2140 18360 0 0 {name=l14778 lab=WL92}
N 2240 18440 2260 18440 {}
C {lab_pin.sym} 2260 18440 0 0 {name=l14779 lab=VDD}
N 2240 18360 2260 18360 {}
C {lab_pin.sym} 2260 18360 0 0 {name=l14780 lab=VSS}
C {bitcell_6t.sym} 2400 18400 0 0 {name=Xr92c12}
N 2360 18440 2340 18440 {}
C {lab_pin.sym} 2340 18440 0 0 {name=l14781 lab=BL12}
N 2360 18400 2340 18400 {}
C {lab_pin.sym} 2340 18400 0 0 {name=l14782 lab=BLB12}
N 2360 18360 2340 18360 {}
C {lab_pin.sym} 2340 18360 0 0 {name=l14783 lab=WL92}
N 2440 18440 2460 18440 {}
C {lab_pin.sym} 2460 18440 0 0 {name=l14784 lab=VDD}
N 2440 18360 2460 18360 {}
C {lab_pin.sym} 2460 18360 0 0 {name=l14785 lab=VSS}
C {bitcell_6t.sym} 2600 18400 0 0 {name=Xr92c13}
N 2560 18440 2540 18440 {}
C {lab_pin.sym} 2540 18440 0 0 {name=l14786 lab=BL13}
N 2560 18400 2540 18400 {}
C {lab_pin.sym} 2540 18400 0 0 {name=l14787 lab=BLB13}
N 2560 18360 2540 18360 {}
C {lab_pin.sym} 2540 18360 0 0 {name=l14788 lab=WL92}
N 2640 18440 2660 18440 {}
C {lab_pin.sym} 2660 18440 0 0 {name=l14789 lab=VDD}
N 2640 18360 2660 18360 {}
C {lab_pin.sym} 2660 18360 0 0 {name=l14790 lab=VSS}
C {bitcell_6t.sym} 2800 18400 0 0 {name=Xr92c14}
N 2760 18440 2740 18440 {}
C {lab_pin.sym} 2740 18440 0 0 {name=l14791 lab=BL14}
N 2760 18400 2740 18400 {}
C {lab_pin.sym} 2740 18400 0 0 {name=l14792 lab=BLB14}
N 2760 18360 2740 18360 {}
C {lab_pin.sym} 2740 18360 0 0 {name=l14793 lab=WL92}
N 2840 18440 2860 18440 {}
C {lab_pin.sym} 2860 18440 0 0 {name=l14794 lab=VDD}
N 2840 18360 2860 18360 {}
C {lab_pin.sym} 2860 18360 0 0 {name=l14795 lab=VSS}
C {bitcell_6t.sym} 3000 18400 0 0 {name=Xr92c15}
N 2960 18440 2940 18440 {}
C {lab_pin.sym} 2940 18440 0 0 {name=l14796 lab=BL15}
N 2960 18400 2940 18400 {}
C {lab_pin.sym} 2940 18400 0 0 {name=l14797 lab=BLB15}
N 2960 18360 2940 18360 {}
C {lab_pin.sym} 2940 18360 0 0 {name=l14798 lab=WL92}
N 3040 18440 3060 18440 {}
C {lab_pin.sym} 3060 18440 0 0 {name=l14799 lab=VDD}
N 3040 18360 3060 18360 {}
C {lab_pin.sym} 3060 18360 0 0 {name=l14800 lab=VSS}
C {bitcell_6t.sym} 3200 18400 0 0 {name=Xr92c16}
N 3160 18440 3140 18440 {}
C {lab_pin.sym} 3140 18440 0 0 {name=l14801 lab=BL16}
N 3160 18400 3140 18400 {}
C {lab_pin.sym} 3140 18400 0 0 {name=l14802 lab=BLB16}
N 3160 18360 3140 18360 {}
C {lab_pin.sym} 3140 18360 0 0 {name=l14803 lab=WL92}
N 3240 18440 3260 18440 {}
C {lab_pin.sym} 3260 18440 0 0 {name=l14804 lab=VDD}
N 3240 18360 3260 18360 {}
C {lab_pin.sym} 3260 18360 0 0 {name=l14805 lab=VSS}
C {bitcell_6t.sym} 3400 18400 0 0 {name=Xr92c17}
N 3360 18440 3340 18440 {}
C {lab_pin.sym} 3340 18440 0 0 {name=l14806 lab=BL17}
N 3360 18400 3340 18400 {}
C {lab_pin.sym} 3340 18400 0 0 {name=l14807 lab=BLB17}
N 3360 18360 3340 18360 {}
C {lab_pin.sym} 3340 18360 0 0 {name=l14808 lab=WL92}
N 3440 18440 3460 18440 {}
C {lab_pin.sym} 3460 18440 0 0 {name=l14809 lab=VDD}
N 3440 18360 3460 18360 {}
C {lab_pin.sym} 3460 18360 0 0 {name=l14810 lab=VSS}
C {bitcell_6t.sym} 3600 18400 0 0 {name=Xr92c18}
N 3560 18440 3540 18440 {}
C {lab_pin.sym} 3540 18440 0 0 {name=l14811 lab=BL18}
N 3560 18400 3540 18400 {}
C {lab_pin.sym} 3540 18400 0 0 {name=l14812 lab=BLB18}
N 3560 18360 3540 18360 {}
C {lab_pin.sym} 3540 18360 0 0 {name=l14813 lab=WL92}
N 3640 18440 3660 18440 {}
C {lab_pin.sym} 3660 18440 0 0 {name=l14814 lab=VDD}
N 3640 18360 3660 18360 {}
C {lab_pin.sym} 3660 18360 0 0 {name=l14815 lab=VSS}
C {bitcell_6t.sym} 3800 18400 0 0 {name=Xr92c19}
N 3760 18440 3740 18440 {}
C {lab_pin.sym} 3740 18440 0 0 {name=l14816 lab=BL19}
N 3760 18400 3740 18400 {}
C {lab_pin.sym} 3740 18400 0 0 {name=l14817 lab=BLB19}
N 3760 18360 3740 18360 {}
C {lab_pin.sym} 3740 18360 0 0 {name=l14818 lab=WL92}
N 3840 18440 3860 18440 {}
C {lab_pin.sym} 3860 18440 0 0 {name=l14819 lab=VDD}
N 3840 18360 3860 18360 {}
C {lab_pin.sym} 3860 18360 0 0 {name=l14820 lab=VSS}
C {bitcell_6t.sym} 4000 18400 0 0 {name=Xr92c20}
N 3960 18440 3940 18440 {}
C {lab_pin.sym} 3940 18440 0 0 {name=l14821 lab=BL20}
N 3960 18400 3940 18400 {}
C {lab_pin.sym} 3940 18400 0 0 {name=l14822 lab=BLB20}
N 3960 18360 3940 18360 {}
C {lab_pin.sym} 3940 18360 0 0 {name=l14823 lab=WL92}
N 4040 18440 4060 18440 {}
C {lab_pin.sym} 4060 18440 0 0 {name=l14824 lab=VDD}
N 4040 18360 4060 18360 {}
C {lab_pin.sym} 4060 18360 0 0 {name=l14825 lab=VSS}
C {bitcell_6t.sym} 4200 18400 0 0 {name=Xr92c21}
N 4160 18440 4140 18440 {}
C {lab_pin.sym} 4140 18440 0 0 {name=l14826 lab=BL21}
N 4160 18400 4140 18400 {}
C {lab_pin.sym} 4140 18400 0 0 {name=l14827 lab=BLB21}
N 4160 18360 4140 18360 {}
C {lab_pin.sym} 4140 18360 0 0 {name=l14828 lab=WL92}
N 4240 18440 4260 18440 {}
C {lab_pin.sym} 4260 18440 0 0 {name=l14829 lab=VDD}
N 4240 18360 4260 18360 {}
C {lab_pin.sym} 4260 18360 0 0 {name=l14830 lab=VSS}
C {bitcell_6t.sym} 4400 18400 0 0 {name=Xr92c22}
N 4360 18440 4340 18440 {}
C {lab_pin.sym} 4340 18440 0 0 {name=l14831 lab=BL22}
N 4360 18400 4340 18400 {}
C {lab_pin.sym} 4340 18400 0 0 {name=l14832 lab=BLB22}
N 4360 18360 4340 18360 {}
C {lab_pin.sym} 4340 18360 0 0 {name=l14833 lab=WL92}
N 4440 18440 4460 18440 {}
C {lab_pin.sym} 4460 18440 0 0 {name=l14834 lab=VDD}
N 4440 18360 4460 18360 {}
C {lab_pin.sym} 4460 18360 0 0 {name=l14835 lab=VSS}
C {bitcell_6t.sym} 4600 18400 0 0 {name=Xr92c23}
N 4560 18440 4540 18440 {}
C {lab_pin.sym} 4540 18440 0 0 {name=l14836 lab=BL23}
N 4560 18400 4540 18400 {}
C {lab_pin.sym} 4540 18400 0 0 {name=l14837 lab=BLB23}
N 4560 18360 4540 18360 {}
C {lab_pin.sym} 4540 18360 0 0 {name=l14838 lab=WL92}
N 4640 18440 4660 18440 {}
C {lab_pin.sym} 4660 18440 0 0 {name=l14839 lab=VDD}
N 4640 18360 4660 18360 {}
C {lab_pin.sym} 4660 18360 0 0 {name=l14840 lab=VSS}
C {bitcell_6t.sym} 4800 18400 0 0 {name=Xr92c24}
N 4760 18440 4740 18440 {}
C {lab_pin.sym} 4740 18440 0 0 {name=l14841 lab=BL24}
N 4760 18400 4740 18400 {}
C {lab_pin.sym} 4740 18400 0 0 {name=l14842 lab=BLB24}
N 4760 18360 4740 18360 {}
C {lab_pin.sym} 4740 18360 0 0 {name=l14843 lab=WL92}
N 4840 18440 4860 18440 {}
C {lab_pin.sym} 4860 18440 0 0 {name=l14844 lab=VDD}
N 4840 18360 4860 18360 {}
C {lab_pin.sym} 4860 18360 0 0 {name=l14845 lab=VSS}
C {bitcell_6t.sym} 5000 18400 0 0 {name=Xr92c25}
N 4960 18440 4940 18440 {}
C {lab_pin.sym} 4940 18440 0 0 {name=l14846 lab=BL25}
N 4960 18400 4940 18400 {}
C {lab_pin.sym} 4940 18400 0 0 {name=l14847 lab=BLB25}
N 4960 18360 4940 18360 {}
C {lab_pin.sym} 4940 18360 0 0 {name=l14848 lab=WL92}
N 5040 18440 5060 18440 {}
C {lab_pin.sym} 5060 18440 0 0 {name=l14849 lab=VDD}
N 5040 18360 5060 18360 {}
C {lab_pin.sym} 5060 18360 0 0 {name=l14850 lab=VSS}
C {bitcell_6t.sym} 5200 18400 0 0 {name=Xr92c26}
N 5160 18440 5140 18440 {}
C {lab_pin.sym} 5140 18440 0 0 {name=l14851 lab=BL26}
N 5160 18400 5140 18400 {}
C {lab_pin.sym} 5140 18400 0 0 {name=l14852 lab=BLB26}
N 5160 18360 5140 18360 {}
C {lab_pin.sym} 5140 18360 0 0 {name=l14853 lab=WL92}
N 5240 18440 5260 18440 {}
C {lab_pin.sym} 5260 18440 0 0 {name=l14854 lab=VDD}
N 5240 18360 5260 18360 {}
C {lab_pin.sym} 5260 18360 0 0 {name=l14855 lab=VSS}
C {bitcell_6t.sym} 5400 18400 0 0 {name=Xr92c27}
N 5360 18440 5340 18440 {}
C {lab_pin.sym} 5340 18440 0 0 {name=l14856 lab=BL27}
N 5360 18400 5340 18400 {}
C {lab_pin.sym} 5340 18400 0 0 {name=l14857 lab=BLB27}
N 5360 18360 5340 18360 {}
C {lab_pin.sym} 5340 18360 0 0 {name=l14858 lab=WL92}
N 5440 18440 5460 18440 {}
C {lab_pin.sym} 5460 18440 0 0 {name=l14859 lab=VDD}
N 5440 18360 5460 18360 {}
C {lab_pin.sym} 5460 18360 0 0 {name=l14860 lab=VSS}
C {bitcell_6t.sym} 5600 18400 0 0 {name=Xr92c28}
N 5560 18440 5540 18440 {}
C {lab_pin.sym} 5540 18440 0 0 {name=l14861 lab=BL28}
N 5560 18400 5540 18400 {}
C {lab_pin.sym} 5540 18400 0 0 {name=l14862 lab=BLB28}
N 5560 18360 5540 18360 {}
C {lab_pin.sym} 5540 18360 0 0 {name=l14863 lab=WL92}
N 5640 18440 5660 18440 {}
C {lab_pin.sym} 5660 18440 0 0 {name=l14864 lab=VDD}
N 5640 18360 5660 18360 {}
C {lab_pin.sym} 5660 18360 0 0 {name=l14865 lab=VSS}
C {bitcell_6t.sym} 5800 18400 0 0 {name=Xr92c29}
N 5760 18440 5740 18440 {}
C {lab_pin.sym} 5740 18440 0 0 {name=l14866 lab=BL29}
N 5760 18400 5740 18400 {}
C {lab_pin.sym} 5740 18400 0 0 {name=l14867 lab=BLB29}
N 5760 18360 5740 18360 {}
C {lab_pin.sym} 5740 18360 0 0 {name=l14868 lab=WL92}
N 5840 18440 5860 18440 {}
C {lab_pin.sym} 5860 18440 0 0 {name=l14869 lab=VDD}
N 5840 18360 5860 18360 {}
C {lab_pin.sym} 5860 18360 0 0 {name=l14870 lab=VSS}
C {bitcell_6t.sym} 6000 18400 0 0 {name=Xr92c30}
N 5960 18440 5940 18440 {}
C {lab_pin.sym} 5940 18440 0 0 {name=l14871 lab=BL30}
N 5960 18400 5940 18400 {}
C {lab_pin.sym} 5940 18400 0 0 {name=l14872 lab=BLB30}
N 5960 18360 5940 18360 {}
C {lab_pin.sym} 5940 18360 0 0 {name=l14873 lab=WL92}
N 6040 18440 6060 18440 {}
C {lab_pin.sym} 6060 18440 0 0 {name=l14874 lab=VDD}
N 6040 18360 6060 18360 {}
C {lab_pin.sym} 6060 18360 0 0 {name=l14875 lab=VSS}
C {bitcell_6t.sym} 6200 18400 0 0 {name=Xr92c31}
N 6160 18440 6140 18440 {}
C {lab_pin.sym} 6140 18440 0 0 {name=l14876 lab=BL31}
N 6160 18400 6140 18400 {}
C {lab_pin.sym} 6140 18400 0 0 {name=l14877 lab=BLB31}
N 6160 18360 6140 18360 {}
C {lab_pin.sym} 6140 18360 0 0 {name=l14878 lab=WL92}
N 6240 18440 6260 18440 {}
C {lab_pin.sym} 6260 18440 0 0 {name=l14879 lab=VDD}
N 6240 18360 6260 18360 {}
C {lab_pin.sym} 6260 18360 0 0 {name=l14880 lab=VSS}
C {bitcell_6t.sym} 0 18600 0 0 {name=Xr93c0}
N -40 18640 -60 18640 {}
C {lab_pin.sym} -60 18640 0 0 {name=l14881 lab=BL0}
N -40 18600 -60 18600 {}
C {lab_pin.sym} -60 18600 0 0 {name=l14882 lab=BLB0}
N -40 18560 -60 18560 {}
C {lab_pin.sym} -60 18560 0 0 {name=l14883 lab=WL93}
N 40 18640 60 18640 {}
C {lab_pin.sym} 60 18640 0 0 {name=l14884 lab=VDD}
N 40 18560 60 18560 {}
C {lab_pin.sym} 60 18560 0 0 {name=l14885 lab=VSS}
C {bitcell_6t.sym} 200 18600 0 0 {name=Xr93c1}
N 160 18640 140 18640 {}
C {lab_pin.sym} 140 18640 0 0 {name=l14886 lab=BL1}
N 160 18600 140 18600 {}
C {lab_pin.sym} 140 18600 0 0 {name=l14887 lab=BLB1}
N 160 18560 140 18560 {}
C {lab_pin.sym} 140 18560 0 0 {name=l14888 lab=WL93}
N 240 18640 260 18640 {}
C {lab_pin.sym} 260 18640 0 0 {name=l14889 lab=VDD}
N 240 18560 260 18560 {}
C {lab_pin.sym} 260 18560 0 0 {name=l14890 lab=VSS}
C {bitcell_6t.sym} 400 18600 0 0 {name=Xr93c2}
N 360 18640 340 18640 {}
C {lab_pin.sym} 340 18640 0 0 {name=l14891 lab=BL2}
N 360 18600 340 18600 {}
C {lab_pin.sym} 340 18600 0 0 {name=l14892 lab=BLB2}
N 360 18560 340 18560 {}
C {lab_pin.sym} 340 18560 0 0 {name=l14893 lab=WL93}
N 440 18640 460 18640 {}
C {lab_pin.sym} 460 18640 0 0 {name=l14894 lab=VDD}
N 440 18560 460 18560 {}
C {lab_pin.sym} 460 18560 0 0 {name=l14895 lab=VSS}
C {bitcell_6t.sym} 600 18600 0 0 {name=Xr93c3}
N 560 18640 540 18640 {}
C {lab_pin.sym} 540 18640 0 0 {name=l14896 lab=BL3}
N 560 18600 540 18600 {}
C {lab_pin.sym} 540 18600 0 0 {name=l14897 lab=BLB3}
N 560 18560 540 18560 {}
C {lab_pin.sym} 540 18560 0 0 {name=l14898 lab=WL93}
N 640 18640 660 18640 {}
C {lab_pin.sym} 660 18640 0 0 {name=l14899 lab=VDD}
N 640 18560 660 18560 {}
C {lab_pin.sym} 660 18560 0 0 {name=l14900 lab=VSS}
C {bitcell_6t.sym} 800 18600 0 0 {name=Xr93c4}
N 760 18640 740 18640 {}
C {lab_pin.sym} 740 18640 0 0 {name=l14901 lab=BL4}
N 760 18600 740 18600 {}
C {lab_pin.sym} 740 18600 0 0 {name=l14902 lab=BLB4}
N 760 18560 740 18560 {}
C {lab_pin.sym} 740 18560 0 0 {name=l14903 lab=WL93}
N 840 18640 860 18640 {}
C {lab_pin.sym} 860 18640 0 0 {name=l14904 lab=VDD}
N 840 18560 860 18560 {}
C {lab_pin.sym} 860 18560 0 0 {name=l14905 lab=VSS}
C {bitcell_6t.sym} 1000 18600 0 0 {name=Xr93c5}
N 960 18640 940 18640 {}
C {lab_pin.sym} 940 18640 0 0 {name=l14906 lab=BL5}
N 960 18600 940 18600 {}
C {lab_pin.sym} 940 18600 0 0 {name=l14907 lab=BLB5}
N 960 18560 940 18560 {}
C {lab_pin.sym} 940 18560 0 0 {name=l14908 lab=WL93}
N 1040 18640 1060 18640 {}
C {lab_pin.sym} 1060 18640 0 0 {name=l14909 lab=VDD}
N 1040 18560 1060 18560 {}
C {lab_pin.sym} 1060 18560 0 0 {name=l14910 lab=VSS}
C {bitcell_6t.sym} 1200 18600 0 0 {name=Xr93c6}
N 1160 18640 1140 18640 {}
C {lab_pin.sym} 1140 18640 0 0 {name=l14911 lab=BL6}
N 1160 18600 1140 18600 {}
C {lab_pin.sym} 1140 18600 0 0 {name=l14912 lab=BLB6}
N 1160 18560 1140 18560 {}
C {lab_pin.sym} 1140 18560 0 0 {name=l14913 lab=WL93}
N 1240 18640 1260 18640 {}
C {lab_pin.sym} 1260 18640 0 0 {name=l14914 lab=VDD}
N 1240 18560 1260 18560 {}
C {lab_pin.sym} 1260 18560 0 0 {name=l14915 lab=VSS}
C {bitcell_6t.sym} 1400 18600 0 0 {name=Xr93c7}
N 1360 18640 1340 18640 {}
C {lab_pin.sym} 1340 18640 0 0 {name=l14916 lab=BL7}
N 1360 18600 1340 18600 {}
C {lab_pin.sym} 1340 18600 0 0 {name=l14917 lab=BLB7}
N 1360 18560 1340 18560 {}
C {lab_pin.sym} 1340 18560 0 0 {name=l14918 lab=WL93}
N 1440 18640 1460 18640 {}
C {lab_pin.sym} 1460 18640 0 0 {name=l14919 lab=VDD}
N 1440 18560 1460 18560 {}
C {lab_pin.sym} 1460 18560 0 0 {name=l14920 lab=VSS}
C {bitcell_6t.sym} 1600 18600 0 0 {name=Xr93c8}
N 1560 18640 1540 18640 {}
C {lab_pin.sym} 1540 18640 0 0 {name=l14921 lab=BL8}
N 1560 18600 1540 18600 {}
C {lab_pin.sym} 1540 18600 0 0 {name=l14922 lab=BLB8}
N 1560 18560 1540 18560 {}
C {lab_pin.sym} 1540 18560 0 0 {name=l14923 lab=WL93}
N 1640 18640 1660 18640 {}
C {lab_pin.sym} 1660 18640 0 0 {name=l14924 lab=VDD}
N 1640 18560 1660 18560 {}
C {lab_pin.sym} 1660 18560 0 0 {name=l14925 lab=VSS}
C {bitcell_6t.sym} 1800 18600 0 0 {name=Xr93c9}
N 1760 18640 1740 18640 {}
C {lab_pin.sym} 1740 18640 0 0 {name=l14926 lab=BL9}
N 1760 18600 1740 18600 {}
C {lab_pin.sym} 1740 18600 0 0 {name=l14927 lab=BLB9}
N 1760 18560 1740 18560 {}
C {lab_pin.sym} 1740 18560 0 0 {name=l14928 lab=WL93}
N 1840 18640 1860 18640 {}
C {lab_pin.sym} 1860 18640 0 0 {name=l14929 lab=VDD}
N 1840 18560 1860 18560 {}
C {lab_pin.sym} 1860 18560 0 0 {name=l14930 lab=VSS}
C {bitcell_6t.sym} 2000 18600 0 0 {name=Xr93c10}
N 1960 18640 1940 18640 {}
C {lab_pin.sym} 1940 18640 0 0 {name=l14931 lab=BL10}
N 1960 18600 1940 18600 {}
C {lab_pin.sym} 1940 18600 0 0 {name=l14932 lab=BLB10}
N 1960 18560 1940 18560 {}
C {lab_pin.sym} 1940 18560 0 0 {name=l14933 lab=WL93}
N 2040 18640 2060 18640 {}
C {lab_pin.sym} 2060 18640 0 0 {name=l14934 lab=VDD}
N 2040 18560 2060 18560 {}
C {lab_pin.sym} 2060 18560 0 0 {name=l14935 lab=VSS}
C {bitcell_6t.sym} 2200 18600 0 0 {name=Xr93c11}
N 2160 18640 2140 18640 {}
C {lab_pin.sym} 2140 18640 0 0 {name=l14936 lab=BL11}
N 2160 18600 2140 18600 {}
C {lab_pin.sym} 2140 18600 0 0 {name=l14937 lab=BLB11}
N 2160 18560 2140 18560 {}
C {lab_pin.sym} 2140 18560 0 0 {name=l14938 lab=WL93}
N 2240 18640 2260 18640 {}
C {lab_pin.sym} 2260 18640 0 0 {name=l14939 lab=VDD}
N 2240 18560 2260 18560 {}
C {lab_pin.sym} 2260 18560 0 0 {name=l14940 lab=VSS}
C {bitcell_6t.sym} 2400 18600 0 0 {name=Xr93c12}
N 2360 18640 2340 18640 {}
C {lab_pin.sym} 2340 18640 0 0 {name=l14941 lab=BL12}
N 2360 18600 2340 18600 {}
C {lab_pin.sym} 2340 18600 0 0 {name=l14942 lab=BLB12}
N 2360 18560 2340 18560 {}
C {lab_pin.sym} 2340 18560 0 0 {name=l14943 lab=WL93}
N 2440 18640 2460 18640 {}
C {lab_pin.sym} 2460 18640 0 0 {name=l14944 lab=VDD}
N 2440 18560 2460 18560 {}
C {lab_pin.sym} 2460 18560 0 0 {name=l14945 lab=VSS}
C {bitcell_6t.sym} 2600 18600 0 0 {name=Xr93c13}
N 2560 18640 2540 18640 {}
C {lab_pin.sym} 2540 18640 0 0 {name=l14946 lab=BL13}
N 2560 18600 2540 18600 {}
C {lab_pin.sym} 2540 18600 0 0 {name=l14947 lab=BLB13}
N 2560 18560 2540 18560 {}
C {lab_pin.sym} 2540 18560 0 0 {name=l14948 lab=WL93}
N 2640 18640 2660 18640 {}
C {lab_pin.sym} 2660 18640 0 0 {name=l14949 lab=VDD}
N 2640 18560 2660 18560 {}
C {lab_pin.sym} 2660 18560 0 0 {name=l14950 lab=VSS}
C {bitcell_6t.sym} 2800 18600 0 0 {name=Xr93c14}
N 2760 18640 2740 18640 {}
C {lab_pin.sym} 2740 18640 0 0 {name=l14951 lab=BL14}
N 2760 18600 2740 18600 {}
C {lab_pin.sym} 2740 18600 0 0 {name=l14952 lab=BLB14}
N 2760 18560 2740 18560 {}
C {lab_pin.sym} 2740 18560 0 0 {name=l14953 lab=WL93}
N 2840 18640 2860 18640 {}
C {lab_pin.sym} 2860 18640 0 0 {name=l14954 lab=VDD}
N 2840 18560 2860 18560 {}
C {lab_pin.sym} 2860 18560 0 0 {name=l14955 lab=VSS}
C {bitcell_6t.sym} 3000 18600 0 0 {name=Xr93c15}
N 2960 18640 2940 18640 {}
C {lab_pin.sym} 2940 18640 0 0 {name=l14956 lab=BL15}
N 2960 18600 2940 18600 {}
C {lab_pin.sym} 2940 18600 0 0 {name=l14957 lab=BLB15}
N 2960 18560 2940 18560 {}
C {lab_pin.sym} 2940 18560 0 0 {name=l14958 lab=WL93}
N 3040 18640 3060 18640 {}
C {lab_pin.sym} 3060 18640 0 0 {name=l14959 lab=VDD}
N 3040 18560 3060 18560 {}
C {lab_pin.sym} 3060 18560 0 0 {name=l14960 lab=VSS}
C {bitcell_6t.sym} 3200 18600 0 0 {name=Xr93c16}
N 3160 18640 3140 18640 {}
C {lab_pin.sym} 3140 18640 0 0 {name=l14961 lab=BL16}
N 3160 18600 3140 18600 {}
C {lab_pin.sym} 3140 18600 0 0 {name=l14962 lab=BLB16}
N 3160 18560 3140 18560 {}
C {lab_pin.sym} 3140 18560 0 0 {name=l14963 lab=WL93}
N 3240 18640 3260 18640 {}
C {lab_pin.sym} 3260 18640 0 0 {name=l14964 lab=VDD}
N 3240 18560 3260 18560 {}
C {lab_pin.sym} 3260 18560 0 0 {name=l14965 lab=VSS}
C {bitcell_6t.sym} 3400 18600 0 0 {name=Xr93c17}
N 3360 18640 3340 18640 {}
C {lab_pin.sym} 3340 18640 0 0 {name=l14966 lab=BL17}
N 3360 18600 3340 18600 {}
C {lab_pin.sym} 3340 18600 0 0 {name=l14967 lab=BLB17}
N 3360 18560 3340 18560 {}
C {lab_pin.sym} 3340 18560 0 0 {name=l14968 lab=WL93}
N 3440 18640 3460 18640 {}
C {lab_pin.sym} 3460 18640 0 0 {name=l14969 lab=VDD}
N 3440 18560 3460 18560 {}
C {lab_pin.sym} 3460 18560 0 0 {name=l14970 lab=VSS}
C {bitcell_6t.sym} 3600 18600 0 0 {name=Xr93c18}
N 3560 18640 3540 18640 {}
C {lab_pin.sym} 3540 18640 0 0 {name=l14971 lab=BL18}
N 3560 18600 3540 18600 {}
C {lab_pin.sym} 3540 18600 0 0 {name=l14972 lab=BLB18}
N 3560 18560 3540 18560 {}
C {lab_pin.sym} 3540 18560 0 0 {name=l14973 lab=WL93}
N 3640 18640 3660 18640 {}
C {lab_pin.sym} 3660 18640 0 0 {name=l14974 lab=VDD}
N 3640 18560 3660 18560 {}
C {lab_pin.sym} 3660 18560 0 0 {name=l14975 lab=VSS}
C {bitcell_6t.sym} 3800 18600 0 0 {name=Xr93c19}
N 3760 18640 3740 18640 {}
C {lab_pin.sym} 3740 18640 0 0 {name=l14976 lab=BL19}
N 3760 18600 3740 18600 {}
C {lab_pin.sym} 3740 18600 0 0 {name=l14977 lab=BLB19}
N 3760 18560 3740 18560 {}
C {lab_pin.sym} 3740 18560 0 0 {name=l14978 lab=WL93}
N 3840 18640 3860 18640 {}
C {lab_pin.sym} 3860 18640 0 0 {name=l14979 lab=VDD}
N 3840 18560 3860 18560 {}
C {lab_pin.sym} 3860 18560 0 0 {name=l14980 lab=VSS}
C {bitcell_6t.sym} 4000 18600 0 0 {name=Xr93c20}
N 3960 18640 3940 18640 {}
C {lab_pin.sym} 3940 18640 0 0 {name=l14981 lab=BL20}
N 3960 18600 3940 18600 {}
C {lab_pin.sym} 3940 18600 0 0 {name=l14982 lab=BLB20}
N 3960 18560 3940 18560 {}
C {lab_pin.sym} 3940 18560 0 0 {name=l14983 lab=WL93}
N 4040 18640 4060 18640 {}
C {lab_pin.sym} 4060 18640 0 0 {name=l14984 lab=VDD}
N 4040 18560 4060 18560 {}
C {lab_pin.sym} 4060 18560 0 0 {name=l14985 lab=VSS}
C {bitcell_6t.sym} 4200 18600 0 0 {name=Xr93c21}
N 4160 18640 4140 18640 {}
C {lab_pin.sym} 4140 18640 0 0 {name=l14986 lab=BL21}
N 4160 18600 4140 18600 {}
C {lab_pin.sym} 4140 18600 0 0 {name=l14987 lab=BLB21}
N 4160 18560 4140 18560 {}
C {lab_pin.sym} 4140 18560 0 0 {name=l14988 lab=WL93}
N 4240 18640 4260 18640 {}
C {lab_pin.sym} 4260 18640 0 0 {name=l14989 lab=VDD}
N 4240 18560 4260 18560 {}
C {lab_pin.sym} 4260 18560 0 0 {name=l14990 lab=VSS}
C {bitcell_6t.sym} 4400 18600 0 0 {name=Xr93c22}
N 4360 18640 4340 18640 {}
C {lab_pin.sym} 4340 18640 0 0 {name=l14991 lab=BL22}
N 4360 18600 4340 18600 {}
C {lab_pin.sym} 4340 18600 0 0 {name=l14992 lab=BLB22}
N 4360 18560 4340 18560 {}
C {lab_pin.sym} 4340 18560 0 0 {name=l14993 lab=WL93}
N 4440 18640 4460 18640 {}
C {lab_pin.sym} 4460 18640 0 0 {name=l14994 lab=VDD}
N 4440 18560 4460 18560 {}
C {lab_pin.sym} 4460 18560 0 0 {name=l14995 lab=VSS}
C {bitcell_6t.sym} 4600 18600 0 0 {name=Xr93c23}
N 4560 18640 4540 18640 {}
C {lab_pin.sym} 4540 18640 0 0 {name=l14996 lab=BL23}
N 4560 18600 4540 18600 {}
C {lab_pin.sym} 4540 18600 0 0 {name=l14997 lab=BLB23}
N 4560 18560 4540 18560 {}
C {lab_pin.sym} 4540 18560 0 0 {name=l14998 lab=WL93}
N 4640 18640 4660 18640 {}
C {lab_pin.sym} 4660 18640 0 0 {name=l14999 lab=VDD}
N 4640 18560 4660 18560 {}
C {lab_pin.sym} 4660 18560 0 0 {name=l15000 lab=VSS}
C {bitcell_6t.sym} 4800 18600 0 0 {name=Xr93c24}
N 4760 18640 4740 18640 {}
C {lab_pin.sym} 4740 18640 0 0 {name=l15001 lab=BL24}
N 4760 18600 4740 18600 {}
C {lab_pin.sym} 4740 18600 0 0 {name=l15002 lab=BLB24}
N 4760 18560 4740 18560 {}
C {lab_pin.sym} 4740 18560 0 0 {name=l15003 lab=WL93}
N 4840 18640 4860 18640 {}
C {lab_pin.sym} 4860 18640 0 0 {name=l15004 lab=VDD}
N 4840 18560 4860 18560 {}
C {lab_pin.sym} 4860 18560 0 0 {name=l15005 lab=VSS}
C {bitcell_6t.sym} 5000 18600 0 0 {name=Xr93c25}
N 4960 18640 4940 18640 {}
C {lab_pin.sym} 4940 18640 0 0 {name=l15006 lab=BL25}
N 4960 18600 4940 18600 {}
C {lab_pin.sym} 4940 18600 0 0 {name=l15007 lab=BLB25}
N 4960 18560 4940 18560 {}
C {lab_pin.sym} 4940 18560 0 0 {name=l15008 lab=WL93}
N 5040 18640 5060 18640 {}
C {lab_pin.sym} 5060 18640 0 0 {name=l15009 lab=VDD}
N 5040 18560 5060 18560 {}
C {lab_pin.sym} 5060 18560 0 0 {name=l15010 lab=VSS}
C {bitcell_6t.sym} 5200 18600 0 0 {name=Xr93c26}
N 5160 18640 5140 18640 {}
C {lab_pin.sym} 5140 18640 0 0 {name=l15011 lab=BL26}
N 5160 18600 5140 18600 {}
C {lab_pin.sym} 5140 18600 0 0 {name=l15012 lab=BLB26}
N 5160 18560 5140 18560 {}
C {lab_pin.sym} 5140 18560 0 0 {name=l15013 lab=WL93}
N 5240 18640 5260 18640 {}
C {lab_pin.sym} 5260 18640 0 0 {name=l15014 lab=VDD}
N 5240 18560 5260 18560 {}
C {lab_pin.sym} 5260 18560 0 0 {name=l15015 lab=VSS}
C {bitcell_6t.sym} 5400 18600 0 0 {name=Xr93c27}
N 5360 18640 5340 18640 {}
C {lab_pin.sym} 5340 18640 0 0 {name=l15016 lab=BL27}
N 5360 18600 5340 18600 {}
C {lab_pin.sym} 5340 18600 0 0 {name=l15017 lab=BLB27}
N 5360 18560 5340 18560 {}
C {lab_pin.sym} 5340 18560 0 0 {name=l15018 lab=WL93}
N 5440 18640 5460 18640 {}
C {lab_pin.sym} 5460 18640 0 0 {name=l15019 lab=VDD}
N 5440 18560 5460 18560 {}
C {lab_pin.sym} 5460 18560 0 0 {name=l15020 lab=VSS}
C {bitcell_6t.sym} 5600 18600 0 0 {name=Xr93c28}
N 5560 18640 5540 18640 {}
C {lab_pin.sym} 5540 18640 0 0 {name=l15021 lab=BL28}
N 5560 18600 5540 18600 {}
C {lab_pin.sym} 5540 18600 0 0 {name=l15022 lab=BLB28}
N 5560 18560 5540 18560 {}
C {lab_pin.sym} 5540 18560 0 0 {name=l15023 lab=WL93}
N 5640 18640 5660 18640 {}
C {lab_pin.sym} 5660 18640 0 0 {name=l15024 lab=VDD}
N 5640 18560 5660 18560 {}
C {lab_pin.sym} 5660 18560 0 0 {name=l15025 lab=VSS}
C {bitcell_6t.sym} 5800 18600 0 0 {name=Xr93c29}
N 5760 18640 5740 18640 {}
C {lab_pin.sym} 5740 18640 0 0 {name=l15026 lab=BL29}
N 5760 18600 5740 18600 {}
C {lab_pin.sym} 5740 18600 0 0 {name=l15027 lab=BLB29}
N 5760 18560 5740 18560 {}
C {lab_pin.sym} 5740 18560 0 0 {name=l15028 lab=WL93}
N 5840 18640 5860 18640 {}
C {lab_pin.sym} 5860 18640 0 0 {name=l15029 lab=VDD}
N 5840 18560 5860 18560 {}
C {lab_pin.sym} 5860 18560 0 0 {name=l15030 lab=VSS}
C {bitcell_6t.sym} 6000 18600 0 0 {name=Xr93c30}
N 5960 18640 5940 18640 {}
C {lab_pin.sym} 5940 18640 0 0 {name=l15031 lab=BL30}
N 5960 18600 5940 18600 {}
C {lab_pin.sym} 5940 18600 0 0 {name=l15032 lab=BLB30}
N 5960 18560 5940 18560 {}
C {lab_pin.sym} 5940 18560 0 0 {name=l15033 lab=WL93}
N 6040 18640 6060 18640 {}
C {lab_pin.sym} 6060 18640 0 0 {name=l15034 lab=VDD}
N 6040 18560 6060 18560 {}
C {lab_pin.sym} 6060 18560 0 0 {name=l15035 lab=VSS}
C {bitcell_6t.sym} 6200 18600 0 0 {name=Xr93c31}
N 6160 18640 6140 18640 {}
C {lab_pin.sym} 6140 18640 0 0 {name=l15036 lab=BL31}
N 6160 18600 6140 18600 {}
C {lab_pin.sym} 6140 18600 0 0 {name=l15037 lab=BLB31}
N 6160 18560 6140 18560 {}
C {lab_pin.sym} 6140 18560 0 0 {name=l15038 lab=WL93}
N 6240 18640 6260 18640 {}
C {lab_pin.sym} 6260 18640 0 0 {name=l15039 lab=VDD}
N 6240 18560 6260 18560 {}
C {lab_pin.sym} 6260 18560 0 0 {name=l15040 lab=VSS}
C {bitcell_6t.sym} 0 18800 0 0 {name=Xr94c0}
N -40 18840 -60 18840 {}
C {lab_pin.sym} -60 18840 0 0 {name=l15041 lab=BL0}
N -40 18800 -60 18800 {}
C {lab_pin.sym} -60 18800 0 0 {name=l15042 lab=BLB0}
N -40 18760 -60 18760 {}
C {lab_pin.sym} -60 18760 0 0 {name=l15043 lab=WL94}
N 40 18840 60 18840 {}
C {lab_pin.sym} 60 18840 0 0 {name=l15044 lab=VDD}
N 40 18760 60 18760 {}
C {lab_pin.sym} 60 18760 0 0 {name=l15045 lab=VSS}
C {bitcell_6t.sym} 200 18800 0 0 {name=Xr94c1}
N 160 18840 140 18840 {}
C {lab_pin.sym} 140 18840 0 0 {name=l15046 lab=BL1}
N 160 18800 140 18800 {}
C {lab_pin.sym} 140 18800 0 0 {name=l15047 lab=BLB1}
N 160 18760 140 18760 {}
C {lab_pin.sym} 140 18760 0 0 {name=l15048 lab=WL94}
N 240 18840 260 18840 {}
C {lab_pin.sym} 260 18840 0 0 {name=l15049 lab=VDD}
N 240 18760 260 18760 {}
C {lab_pin.sym} 260 18760 0 0 {name=l15050 lab=VSS}
C {bitcell_6t.sym} 400 18800 0 0 {name=Xr94c2}
N 360 18840 340 18840 {}
C {lab_pin.sym} 340 18840 0 0 {name=l15051 lab=BL2}
N 360 18800 340 18800 {}
C {lab_pin.sym} 340 18800 0 0 {name=l15052 lab=BLB2}
N 360 18760 340 18760 {}
C {lab_pin.sym} 340 18760 0 0 {name=l15053 lab=WL94}
N 440 18840 460 18840 {}
C {lab_pin.sym} 460 18840 0 0 {name=l15054 lab=VDD}
N 440 18760 460 18760 {}
C {lab_pin.sym} 460 18760 0 0 {name=l15055 lab=VSS}
C {bitcell_6t.sym} 600 18800 0 0 {name=Xr94c3}
N 560 18840 540 18840 {}
C {lab_pin.sym} 540 18840 0 0 {name=l15056 lab=BL3}
N 560 18800 540 18800 {}
C {lab_pin.sym} 540 18800 0 0 {name=l15057 lab=BLB3}
N 560 18760 540 18760 {}
C {lab_pin.sym} 540 18760 0 0 {name=l15058 lab=WL94}
N 640 18840 660 18840 {}
C {lab_pin.sym} 660 18840 0 0 {name=l15059 lab=VDD}
N 640 18760 660 18760 {}
C {lab_pin.sym} 660 18760 0 0 {name=l15060 lab=VSS}
C {bitcell_6t.sym} 800 18800 0 0 {name=Xr94c4}
N 760 18840 740 18840 {}
C {lab_pin.sym} 740 18840 0 0 {name=l15061 lab=BL4}
N 760 18800 740 18800 {}
C {lab_pin.sym} 740 18800 0 0 {name=l15062 lab=BLB4}
N 760 18760 740 18760 {}
C {lab_pin.sym} 740 18760 0 0 {name=l15063 lab=WL94}
N 840 18840 860 18840 {}
C {lab_pin.sym} 860 18840 0 0 {name=l15064 lab=VDD}
N 840 18760 860 18760 {}
C {lab_pin.sym} 860 18760 0 0 {name=l15065 lab=VSS}
C {bitcell_6t.sym} 1000 18800 0 0 {name=Xr94c5}
N 960 18840 940 18840 {}
C {lab_pin.sym} 940 18840 0 0 {name=l15066 lab=BL5}
N 960 18800 940 18800 {}
C {lab_pin.sym} 940 18800 0 0 {name=l15067 lab=BLB5}
N 960 18760 940 18760 {}
C {lab_pin.sym} 940 18760 0 0 {name=l15068 lab=WL94}
N 1040 18840 1060 18840 {}
C {lab_pin.sym} 1060 18840 0 0 {name=l15069 lab=VDD}
N 1040 18760 1060 18760 {}
C {lab_pin.sym} 1060 18760 0 0 {name=l15070 lab=VSS}
C {bitcell_6t.sym} 1200 18800 0 0 {name=Xr94c6}
N 1160 18840 1140 18840 {}
C {lab_pin.sym} 1140 18840 0 0 {name=l15071 lab=BL6}
N 1160 18800 1140 18800 {}
C {lab_pin.sym} 1140 18800 0 0 {name=l15072 lab=BLB6}
N 1160 18760 1140 18760 {}
C {lab_pin.sym} 1140 18760 0 0 {name=l15073 lab=WL94}
N 1240 18840 1260 18840 {}
C {lab_pin.sym} 1260 18840 0 0 {name=l15074 lab=VDD}
N 1240 18760 1260 18760 {}
C {lab_pin.sym} 1260 18760 0 0 {name=l15075 lab=VSS}
C {bitcell_6t.sym} 1400 18800 0 0 {name=Xr94c7}
N 1360 18840 1340 18840 {}
C {lab_pin.sym} 1340 18840 0 0 {name=l15076 lab=BL7}
N 1360 18800 1340 18800 {}
C {lab_pin.sym} 1340 18800 0 0 {name=l15077 lab=BLB7}
N 1360 18760 1340 18760 {}
C {lab_pin.sym} 1340 18760 0 0 {name=l15078 lab=WL94}
N 1440 18840 1460 18840 {}
C {lab_pin.sym} 1460 18840 0 0 {name=l15079 lab=VDD}
N 1440 18760 1460 18760 {}
C {lab_pin.sym} 1460 18760 0 0 {name=l15080 lab=VSS}
C {bitcell_6t.sym} 1600 18800 0 0 {name=Xr94c8}
N 1560 18840 1540 18840 {}
C {lab_pin.sym} 1540 18840 0 0 {name=l15081 lab=BL8}
N 1560 18800 1540 18800 {}
C {lab_pin.sym} 1540 18800 0 0 {name=l15082 lab=BLB8}
N 1560 18760 1540 18760 {}
C {lab_pin.sym} 1540 18760 0 0 {name=l15083 lab=WL94}
N 1640 18840 1660 18840 {}
C {lab_pin.sym} 1660 18840 0 0 {name=l15084 lab=VDD}
N 1640 18760 1660 18760 {}
C {lab_pin.sym} 1660 18760 0 0 {name=l15085 lab=VSS}
C {bitcell_6t.sym} 1800 18800 0 0 {name=Xr94c9}
N 1760 18840 1740 18840 {}
C {lab_pin.sym} 1740 18840 0 0 {name=l15086 lab=BL9}
N 1760 18800 1740 18800 {}
C {lab_pin.sym} 1740 18800 0 0 {name=l15087 lab=BLB9}
N 1760 18760 1740 18760 {}
C {lab_pin.sym} 1740 18760 0 0 {name=l15088 lab=WL94}
N 1840 18840 1860 18840 {}
C {lab_pin.sym} 1860 18840 0 0 {name=l15089 lab=VDD}
N 1840 18760 1860 18760 {}
C {lab_pin.sym} 1860 18760 0 0 {name=l15090 lab=VSS}
C {bitcell_6t.sym} 2000 18800 0 0 {name=Xr94c10}
N 1960 18840 1940 18840 {}
C {lab_pin.sym} 1940 18840 0 0 {name=l15091 lab=BL10}
N 1960 18800 1940 18800 {}
C {lab_pin.sym} 1940 18800 0 0 {name=l15092 lab=BLB10}
N 1960 18760 1940 18760 {}
C {lab_pin.sym} 1940 18760 0 0 {name=l15093 lab=WL94}
N 2040 18840 2060 18840 {}
C {lab_pin.sym} 2060 18840 0 0 {name=l15094 lab=VDD}
N 2040 18760 2060 18760 {}
C {lab_pin.sym} 2060 18760 0 0 {name=l15095 lab=VSS}
C {bitcell_6t.sym} 2200 18800 0 0 {name=Xr94c11}
N 2160 18840 2140 18840 {}
C {lab_pin.sym} 2140 18840 0 0 {name=l15096 lab=BL11}
N 2160 18800 2140 18800 {}
C {lab_pin.sym} 2140 18800 0 0 {name=l15097 lab=BLB11}
N 2160 18760 2140 18760 {}
C {lab_pin.sym} 2140 18760 0 0 {name=l15098 lab=WL94}
N 2240 18840 2260 18840 {}
C {lab_pin.sym} 2260 18840 0 0 {name=l15099 lab=VDD}
N 2240 18760 2260 18760 {}
C {lab_pin.sym} 2260 18760 0 0 {name=l15100 lab=VSS}
C {bitcell_6t.sym} 2400 18800 0 0 {name=Xr94c12}
N 2360 18840 2340 18840 {}
C {lab_pin.sym} 2340 18840 0 0 {name=l15101 lab=BL12}
N 2360 18800 2340 18800 {}
C {lab_pin.sym} 2340 18800 0 0 {name=l15102 lab=BLB12}
N 2360 18760 2340 18760 {}
C {lab_pin.sym} 2340 18760 0 0 {name=l15103 lab=WL94}
N 2440 18840 2460 18840 {}
C {lab_pin.sym} 2460 18840 0 0 {name=l15104 lab=VDD}
N 2440 18760 2460 18760 {}
C {lab_pin.sym} 2460 18760 0 0 {name=l15105 lab=VSS}
C {bitcell_6t.sym} 2600 18800 0 0 {name=Xr94c13}
N 2560 18840 2540 18840 {}
C {lab_pin.sym} 2540 18840 0 0 {name=l15106 lab=BL13}
N 2560 18800 2540 18800 {}
C {lab_pin.sym} 2540 18800 0 0 {name=l15107 lab=BLB13}
N 2560 18760 2540 18760 {}
C {lab_pin.sym} 2540 18760 0 0 {name=l15108 lab=WL94}
N 2640 18840 2660 18840 {}
C {lab_pin.sym} 2660 18840 0 0 {name=l15109 lab=VDD}
N 2640 18760 2660 18760 {}
C {lab_pin.sym} 2660 18760 0 0 {name=l15110 lab=VSS}
C {bitcell_6t.sym} 2800 18800 0 0 {name=Xr94c14}
N 2760 18840 2740 18840 {}
C {lab_pin.sym} 2740 18840 0 0 {name=l15111 lab=BL14}
N 2760 18800 2740 18800 {}
C {lab_pin.sym} 2740 18800 0 0 {name=l15112 lab=BLB14}
N 2760 18760 2740 18760 {}
C {lab_pin.sym} 2740 18760 0 0 {name=l15113 lab=WL94}
N 2840 18840 2860 18840 {}
C {lab_pin.sym} 2860 18840 0 0 {name=l15114 lab=VDD}
N 2840 18760 2860 18760 {}
C {lab_pin.sym} 2860 18760 0 0 {name=l15115 lab=VSS}
C {bitcell_6t.sym} 3000 18800 0 0 {name=Xr94c15}
N 2960 18840 2940 18840 {}
C {lab_pin.sym} 2940 18840 0 0 {name=l15116 lab=BL15}
N 2960 18800 2940 18800 {}
C {lab_pin.sym} 2940 18800 0 0 {name=l15117 lab=BLB15}
N 2960 18760 2940 18760 {}
C {lab_pin.sym} 2940 18760 0 0 {name=l15118 lab=WL94}
N 3040 18840 3060 18840 {}
C {lab_pin.sym} 3060 18840 0 0 {name=l15119 lab=VDD}
N 3040 18760 3060 18760 {}
C {lab_pin.sym} 3060 18760 0 0 {name=l15120 lab=VSS}
C {bitcell_6t.sym} 3200 18800 0 0 {name=Xr94c16}
N 3160 18840 3140 18840 {}
C {lab_pin.sym} 3140 18840 0 0 {name=l15121 lab=BL16}
N 3160 18800 3140 18800 {}
C {lab_pin.sym} 3140 18800 0 0 {name=l15122 lab=BLB16}
N 3160 18760 3140 18760 {}
C {lab_pin.sym} 3140 18760 0 0 {name=l15123 lab=WL94}
N 3240 18840 3260 18840 {}
C {lab_pin.sym} 3260 18840 0 0 {name=l15124 lab=VDD}
N 3240 18760 3260 18760 {}
C {lab_pin.sym} 3260 18760 0 0 {name=l15125 lab=VSS}
C {bitcell_6t.sym} 3400 18800 0 0 {name=Xr94c17}
N 3360 18840 3340 18840 {}
C {lab_pin.sym} 3340 18840 0 0 {name=l15126 lab=BL17}
N 3360 18800 3340 18800 {}
C {lab_pin.sym} 3340 18800 0 0 {name=l15127 lab=BLB17}
N 3360 18760 3340 18760 {}
C {lab_pin.sym} 3340 18760 0 0 {name=l15128 lab=WL94}
N 3440 18840 3460 18840 {}
C {lab_pin.sym} 3460 18840 0 0 {name=l15129 lab=VDD}
N 3440 18760 3460 18760 {}
C {lab_pin.sym} 3460 18760 0 0 {name=l15130 lab=VSS}
C {bitcell_6t.sym} 3600 18800 0 0 {name=Xr94c18}
N 3560 18840 3540 18840 {}
C {lab_pin.sym} 3540 18840 0 0 {name=l15131 lab=BL18}
N 3560 18800 3540 18800 {}
C {lab_pin.sym} 3540 18800 0 0 {name=l15132 lab=BLB18}
N 3560 18760 3540 18760 {}
C {lab_pin.sym} 3540 18760 0 0 {name=l15133 lab=WL94}
N 3640 18840 3660 18840 {}
C {lab_pin.sym} 3660 18840 0 0 {name=l15134 lab=VDD}
N 3640 18760 3660 18760 {}
C {lab_pin.sym} 3660 18760 0 0 {name=l15135 lab=VSS}
C {bitcell_6t.sym} 3800 18800 0 0 {name=Xr94c19}
N 3760 18840 3740 18840 {}
C {lab_pin.sym} 3740 18840 0 0 {name=l15136 lab=BL19}
N 3760 18800 3740 18800 {}
C {lab_pin.sym} 3740 18800 0 0 {name=l15137 lab=BLB19}
N 3760 18760 3740 18760 {}
C {lab_pin.sym} 3740 18760 0 0 {name=l15138 lab=WL94}
N 3840 18840 3860 18840 {}
C {lab_pin.sym} 3860 18840 0 0 {name=l15139 lab=VDD}
N 3840 18760 3860 18760 {}
C {lab_pin.sym} 3860 18760 0 0 {name=l15140 lab=VSS}
C {bitcell_6t.sym} 4000 18800 0 0 {name=Xr94c20}
N 3960 18840 3940 18840 {}
C {lab_pin.sym} 3940 18840 0 0 {name=l15141 lab=BL20}
N 3960 18800 3940 18800 {}
C {lab_pin.sym} 3940 18800 0 0 {name=l15142 lab=BLB20}
N 3960 18760 3940 18760 {}
C {lab_pin.sym} 3940 18760 0 0 {name=l15143 lab=WL94}
N 4040 18840 4060 18840 {}
C {lab_pin.sym} 4060 18840 0 0 {name=l15144 lab=VDD}
N 4040 18760 4060 18760 {}
C {lab_pin.sym} 4060 18760 0 0 {name=l15145 lab=VSS}
C {bitcell_6t.sym} 4200 18800 0 0 {name=Xr94c21}
N 4160 18840 4140 18840 {}
C {lab_pin.sym} 4140 18840 0 0 {name=l15146 lab=BL21}
N 4160 18800 4140 18800 {}
C {lab_pin.sym} 4140 18800 0 0 {name=l15147 lab=BLB21}
N 4160 18760 4140 18760 {}
C {lab_pin.sym} 4140 18760 0 0 {name=l15148 lab=WL94}
N 4240 18840 4260 18840 {}
C {lab_pin.sym} 4260 18840 0 0 {name=l15149 lab=VDD}
N 4240 18760 4260 18760 {}
C {lab_pin.sym} 4260 18760 0 0 {name=l15150 lab=VSS}
C {bitcell_6t.sym} 4400 18800 0 0 {name=Xr94c22}
N 4360 18840 4340 18840 {}
C {lab_pin.sym} 4340 18840 0 0 {name=l15151 lab=BL22}
N 4360 18800 4340 18800 {}
C {lab_pin.sym} 4340 18800 0 0 {name=l15152 lab=BLB22}
N 4360 18760 4340 18760 {}
C {lab_pin.sym} 4340 18760 0 0 {name=l15153 lab=WL94}
N 4440 18840 4460 18840 {}
C {lab_pin.sym} 4460 18840 0 0 {name=l15154 lab=VDD}
N 4440 18760 4460 18760 {}
C {lab_pin.sym} 4460 18760 0 0 {name=l15155 lab=VSS}
C {bitcell_6t.sym} 4600 18800 0 0 {name=Xr94c23}
N 4560 18840 4540 18840 {}
C {lab_pin.sym} 4540 18840 0 0 {name=l15156 lab=BL23}
N 4560 18800 4540 18800 {}
C {lab_pin.sym} 4540 18800 0 0 {name=l15157 lab=BLB23}
N 4560 18760 4540 18760 {}
C {lab_pin.sym} 4540 18760 0 0 {name=l15158 lab=WL94}
N 4640 18840 4660 18840 {}
C {lab_pin.sym} 4660 18840 0 0 {name=l15159 lab=VDD}
N 4640 18760 4660 18760 {}
C {lab_pin.sym} 4660 18760 0 0 {name=l15160 lab=VSS}
C {bitcell_6t.sym} 4800 18800 0 0 {name=Xr94c24}
N 4760 18840 4740 18840 {}
C {lab_pin.sym} 4740 18840 0 0 {name=l15161 lab=BL24}
N 4760 18800 4740 18800 {}
C {lab_pin.sym} 4740 18800 0 0 {name=l15162 lab=BLB24}
N 4760 18760 4740 18760 {}
C {lab_pin.sym} 4740 18760 0 0 {name=l15163 lab=WL94}
N 4840 18840 4860 18840 {}
C {lab_pin.sym} 4860 18840 0 0 {name=l15164 lab=VDD}
N 4840 18760 4860 18760 {}
C {lab_pin.sym} 4860 18760 0 0 {name=l15165 lab=VSS}
C {bitcell_6t.sym} 5000 18800 0 0 {name=Xr94c25}
N 4960 18840 4940 18840 {}
C {lab_pin.sym} 4940 18840 0 0 {name=l15166 lab=BL25}
N 4960 18800 4940 18800 {}
C {lab_pin.sym} 4940 18800 0 0 {name=l15167 lab=BLB25}
N 4960 18760 4940 18760 {}
C {lab_pin.sym} 4940 18760 0 0 {name=l15168 lab=WL94}
N 5040 18840 5060 18840 {}
C {lab_pin.sym} 5060 18840 0 0 {name=l15169 lab=VDD}
N 5040 18760 5060 18760 {}
C {lab_pin.sym} 5060 18760 0 0 {name=l15170 lab=VSS}
C {bitcell_6t.sym} 5200 18800 0 0 {name=Xr94c26}
N 5160 18840 5140 18840 {}
C {lab_pin.sym} 5140 18840 0 0 {name=l15171 lab=BL26}
N 5160 18800 5140 18800 {}
C {lab_pin.sym} 5140 18800 0 0 {name=l15172 lab=BLB26}
N 5160 18760 5140 18760 {}
C {lab_pin.sym} 5140 18760 0 0 {name=l15173 lab=WL94}
N 5240 18840 5260 18840 {}
C {lab_pin.sym} 5260 18840 0 0 {name=l15174 lab=VDD}
N 5240 18760 5260 18760 {}
C {lab_pin.sym} 5260 18760 0 0 {name=l15175 lab=VSS}
C {bitcell_6t.sym} 5400 18800 0 0 {name=Xr94c27}
N 5360 18840 5340 18840 {}
C {lab_pin.sym} 5340 18840 0 0 {name=l15176 lab=BL27}
N 5360 18800 5340 18800 {}
C {lab_pin.sym} 5340 18800 0 0 {name=l15177 lab=BLB27}
N 5360 18760 5340 18760 {}
C {lab_pin.sym} 5340 18760 0 0 {name=l15178 lab=WL94}
N 5440 18840 5460 18840 {}
C {lab_pin.sym} 5460 18840 0 0 {name=l15179 lab=VDD}
N 5440 18760 5460 18760 {}
C {lab_pin.sym} 5460 18760 0 0 {name=l15180 lab=VSS}
C {bitcell_6t.sym} 5600 18800 0 0 {name=Xr94c28}
N 5560 18840 5540 18840 {}
C {lab_pin.sym} 5540 18840 0 0 {name=l15181 lab=BL28}
N 5560 18800 5540 18800 {}
C {lab_pin.sym} 5540 18800 0 0 {name=l15182 lab=BLB28}
N 5560 18760 5540 18760 {}
C {lab_pin.sym} 5540 18760 0 0 {name=l15183 lab=WL94}
N 5640 18840 5660 18840 {}
C {lab_pin.sym} 5660 18840 0 0 {name=l15184 lab=VDD}
N 5640 18760 5660 18760 {}
C {lab_pin.sym} 5660 18760 0 0 {name=l15185 lab=VSS}
C {bitcell_6t.sym} 5800 18800 0 0 {name=Xr94c29}
N 5760 18840 5740 18840 {}
C {lab_pin.sym} 5740 18840 0 0 {name=l15186 lab=BL29}
N 5760 18800 5740 18800 {}
C {lab_pin.sym} 5740 18800 0 0 {name=l15187 lab=BLB29}
N 5760 18760 5740 18760 {}
C {lab_pin.sym} 5740 18760 0 0 {name=l15188 lab=WL94}
N 5840 18840 5860 18840 {}
C {lab_pin.sym} 5860 18840 0 0 {name=l15189 lab=VDD}
N 5840 18760 5860 18760 {}
C {lab_pin.sym} 5860 18760 0 0 {name=l15190 lab=VSS}
C {bitcell_6t.sym} 6000 18800 0 0 {name=Xr94c30}
N 5960 18840 5940 18840 {}
C {lab_pin.sym} 5940 18840 0 0 {name=l15191 lab=BL30}
N 5960 18800 5940 18800 {}
C {lab_pin.sym} 5940 18800 0 0 {name=l15192 lab=BLB30}
N 5960 18760 5940 18760 {}
C {lab_pin.sym} 5940 18760 0 0 {name=l15193 lab=WL94}
N 6040 18840 6060 18840 {}
C {lab_pin.sym} 6060 18840 0 0 {name=l15194 lab=VDD}
N 6040 18760 6060 18760 {}
C {lab_pin.sym} 6060 18760 0 0 {name=l15195 lab=VSS}
C {bitcell_6t.sym} 6200 18800 0 0 {name=Xr94c31}
N 6160 18840 6140 18840 {}
C {lab_pin.sym} 6140 18840 0 0 {name=l15196 lab=BL31}
N 6160 18800 6140 18800 {}
C {lab_pin.sym} 6140 18800 0 0 {name=l15197 lab=BLB31}
N 6160 18760 6140 18760 {}
C {lab_pin.sym} 6140 18760 0 0 {name=l15198 lab=WL94}
N 6240 18840 6260 18840 {}
C {lab_pin.sym} 6260 18840 0 0 {name=l15199 lab=VDD}
N 6240 18760 6260 18760 {}
C {lab_pin.sym} 6260 18760 0 0 {name=l15200 lab=VSS}
C {bitcell_6t.sym} 0 19000 0 0 {name=Xr95c0}
N -40 19040 -60 19040 {}
C {lab_pin.sym} -60 19040 0 0 {name=l15201 lab=BL0}
N -40 19000 -60 19000 {}
C {lab_pin.sym} -60 19000 0 0 {name=l15202 lab=BLB0}
N -40 18960 -60 18960 {}
C {lab_pin.sym} -60 18960 0 0 {name=l15203 lab=WL95}
N 40 19040 60 19040 {}
C {lab_pin.sym} 60 19040 0 0 {name=l15204 lab=VDD}
N 40 18960 60 18960 {}
C {lab_pin.sym} 60 18960 0 0 {name=l15205 lab=VSS}
C {bitcell_6t.sym} 200 19000 0 0 {name=Xr95c1}
N 160 19040 140 19040 {}
C {lab_pin.sym} 140 19040 0 0 {name=l15206 lab=BL1}
N 160 19000 140 19000 {}
C {lab_pin.sym} 140 19000 0 0 {name=l15207 lab=BLB1}
N 160 18960 140 18960 {}
C {lab_pin.sym} 140 18960 0 0 {name=l15208 lab=WL95}
N 240 19040 260 19040 {}
C {lab_pin.sym} 260 19040 0 0 {name=l15209 lab=VDD}
N 240 18960 260 18960 {}
C {lab_pin.sym} 260 18960 0 0 {name=l15210 lab=VSS}
C {bitcell_6t.sym} 400 19000 0 0 {name=Xr95c2}
N 360 19040 340 19040 {}
C {lab_pin.sym} 340 19040 0 0 {name=l15211 lab=BL2}
N 360 19000 340 19000 {}
C {lab_pin.sym} 340 19000 0 0 {name=l15212 lab=BLB2}
N 360 18960 340 18960 {}
C {lab_pin.sym} 340 18960 0 0 {name=l15213 lab=WL95}
N 440 19040 460 19040 {}
C {lab_pin.sym} 460 19040 0 0 {name=l15214 lab=VDD}
N 440 18960 460 18960 {}
C {lab_pin.sym} 460 18960 0 0 {name=l15215 lab=VSS}
C {bitcell_6t.sym} 600 19000 0 0 {name=Xr95c3}
N 560 19040 540 19040 {}
C {lab_pin.sym} 540 19040 0 0 {name=l15216 lab=BL3}
N 560 19000 540 19000 {}
C {lab_pin.sym} 540 19000 0 0 {name=l15217 lab=BLB3}
N 560 18960 540 18960 {}
C {lab_pin.sym} 540 18960 0 0 {name=l15218 lab=WL95}
N 640 19040 660 19040 {}
C {lab_pin.sym} 660 19040 0 0 {name=l15219 lab=VDD}
N 640 18960 660 18960 {}
C {lab_pin.sym} 660 18960 0 0 {name=l15220 lab=VSS}
C {bitcell_6t.sym} 800 19000 0 0 {name=Xr95c4}
N 760 19040 740 19040 {}
C {lab_pin.sym} 740 19040 0 0 {name=l15221 lab=BL4}
N 760 19000 740 19000 {}
C {lab_pin.sym} 740 19000 0 0 {name=l15222 lab=BLB4}
N 760 18960 740 18960 {}
C {lab_pin.sym} 740 18960 0 0 {name=l15223 lab=WL95}
N 840 19040 860 19040 {}
C {lab_pin.sym} 860 19040 0 0 {name=l15224 lab=VDD}
N 840 18960 860 18960 {}
C {lab_pin.sym} 860 18960 0 0 {name=l15225 lab=VSS}
C {bitcell_6t.sym} 1000 19000 0 0 {name=Xr95c5}
N 960 19040 940 19040 {}
C {lab_pin.sym} 940 19040 0 0 {name=l15226 lab=BL5}
N 960 19000 940 19000 {}
C {lab_pin.sym} 940 19000 0 0 {name=l15227 lab=BLB5}
N 960 18960 940 18960 {}
C {lab_pin.sym} 940 18960 0 0 {name=l15228 lab=WL95}
N 1040 19040 1060 19040 {}
C {lab_pin.sym} 1060 19040 0 0 {name=l15229 lab=VDD}
N 1040 18960 1060 18960 {}
C {lab_pin.sym} 1060 18960 0 0 {name=l15230 lab=VSS}
C {bitcell_6t.sym} 1200 19000 0 0 {name=Xr95c6}
N 1160 19040 1140 19040 {}
C {lab_pin.sym} 1140 19040 0 0 {name=l15231 lab=BL6}
N 1160 19000 1140 19000 {}
C {lab_pin.sym} 1140 19000 0 0 {name=l15232 lab=BLB6}
N 1160 18960 1140 18960 {}
C {lab_pin.sym} 1140 18960 0 0 {name=l15233 lab=WL95}
N 1240 19040 1260 19040 {}
C {lab_pin.sym} 1260 19040 0 0 {name=l15234 lab=VDD}
N 1240 18960 1260 18960 {}
C {lab_pin.sym} 1260 18960 0 0 {name=l15235 lab=VSS}
C {bitcell_6t.sym} 1400 19000 0 0 {name=Xr95c7}
N 1360 19040 1340 19040 {}
C {lab_pin.sym} 1340 19040 0 0 {name=l15236 lab=BL7}
N 1360 19000 1340 19000 {}
C {lab_pin.sym} 1340 19000 0 0 {name=l15237 lab=BLB7}
N 1360 18960 1340 18960 {}
C {lab_pin.sym} 1340 18960 0 0 {name=l15238 lab=WL95}
N 1440 19040 1460 19040 {}
C {lab_pin.sym} 1460 19040 0 0 {name=l15239 lab=VDD}
N 1440 18960 1460 18960 {}
C {lab_pin.sym} 1460 18960 0 0 {name=l15240 lab=VSS}
C {bitcell_6t.sym} 1600 19000 0 0 {name=Xr95c8}
N 1560 19040 1540 19040 {}
C {lab_pin.sym} 1540 19040 0 0 {name=l15241 lab=BL8}
N 1560 19000 1540 19000 {}
C {lab_pin.sym} 1540 19000 0 0 {name=l15242 lab=BLB8}
N 1560 18960 1540 18960 {}
C {lab_pin.sym} 1540 18960 0 0 {name=l15243 lab=WL95}
N 1640 19040 1660 19040 {}
C {lab_pin.sym} 1660 19040 0 0 {name=l15244 lab=VDD}
N 1640 18960 1660 18960 {}
C {lab_pin.sym} 1660 18960 0 0 {name=l15245 lab=VSS}
C {bitcell_6t.sym} 1800 19000 0 0 {name=Xr95c9}
N 1760 19040 1740 19040 {}
C {lab_pin.sym} 1740 19040 0 0 {name=l15246 lab=BL9}
N 1760 19000 1740 19000 {}
C {lab_pin.sym} 1740 19000 0 0 {name=l15247 lab=BLB9}
N 1760 18960 1740 18960 {}
C {lab_pin.sym} 1740 18960 0 0 {name=l15248 lab=WL95}
N 1840 19040 1860 19040 {}
C {lab_pin.sym} 1860 19040 0 0 {name=l15249 lab=VDD}
N 1840 18960 1860 18960 {}
C {lab_pin.sym} 1860 18960 0 0 {name=l15250 lab=VSS}
C {bitcell_6t.sym} 2000 19000 0 0 {name=Xr95c10}
N 1960 19040 1940 19040 {}
C {lab_pin.sym} 1940 19040 0 0 {name=l15251 lab=BL10}
N 1960 19000 1940 19000 {}
C {lab_pin.sym} 1940 19000 0 0 {name=l15252 lab=BLB10}
N 1960 18960 1940 18960 {}
C {lab_pin.sym} 1940 18960 0 0 {name=l15253 lab=WL95}
N 2040 19040 2060 19040 {}
C {lab_pin.sym} 2060 19040 0 0 {name=l15254 lab=VDD}
N 2040 18960 2060 18960 {}
C {lab_pin.sym} 2060 18960 0 0 {name=l15255 lab=VSS}
C {bitcell_6t.sym} 2200 19000 0 0 {name=Xr95c11}
N 2160 19040 2140 19040 {}
C {lab_pin.sym} 2140 19040 0 0 {name=l15256 lab=BL11}
N 2160 19000 2140 19000 {}
C {lab_pin.sym} 2140 19000 0 0 {name=l15257 lab=BLB11}
N 2160 18960 2140 18960 {}
C {lab_pin.sym} 2140 18960 0 0 {name=l15258 lab=WL95}
N 2240 19040 2260 19040 {}
C {lab_pin.sym} 2260 19040 0 0 {name=l15259 lab=VDD}
N 2240 18960 2260 18960 {}
C {lab_pin.sym} 2260 18960 0 0 {name=l15260 lab=VSS}
C {bitcell_6t.sym} 2400 19000 0 0 {name=Xr95c12}
N 2360 19040 2340 19040 {}
C {lab_pin.sym} 2340 19040 0 0 {name=l15261 lab=BL12}
N 2360 19000 2340 19000 {}
C {lab_pin.sym} 2340 19000 0 0 {name=l15262 lab=BLB12}
N 2360 18960 2340 18960 {}
C {lab_pin.sym} 2340 18960 0 0 {name=l15263 lab=WL95}
N 2440 19040 2460 19040 {}
C {lab_pin.sym} 2460 19040 0 0 {name=l15264 lab=VDD}
N 2440 18960 2460 18960 {}
C {lab_pin.sym} 2460 18960 0 0 {name=l15265 lab=VSS}
C {bitcell_6t.sym} 2600 19000 0 0 {name=Xr95c13}
N 2560 19040 2540 19040 {}
C {lab_pin.sym} 2540 19040 0 0 {name=l15266 lab=BL13}
N 2560 19000 2540 19000 {}
C {lab_pin.sym} 2540 19000 0 0 {name=l15267 lab=BLB13}
N 2560 18960 2540 18960 {}
C {lab_pin.sym} 2540 18960 0 0 {name=l15268 lab=WL95}
N 2640 19040 2660 19040 {}
C {lab_pin.sym} 2660 19040 0 0 {name=l15269 lab=VDD}
N 2640 18960 2660 18960 {}
C {lab_pin.sym} 2660 18960 0 0 {name=l15270 lab=VSS}
C {bitcell_6t.sym} 2800 19000 0 0 {name=Xr95c14}
N 2760 19040 2740 19040 {}
C {lab_pin.sym} 2740 19040 0 0 {name=l15271 lab=BL14}
N 2760 19000 2740 19000 {}
C {lab_pin.sym} 2740 19000 0 0 {name=l15272 lab=BLB14}
N 2760 18960 2740 18960 {}
C {lab_pin.sym} 2740 18960 0 0 {name=l15273 lab=WL95}
N 2840 19040 2860 19040 {}
C {lab_pin.sym} 2860 19040 0 0 {name=l15274 lab=VDD}
N 2840 18960 2860 18960 {}
C {lab_pin.sym} 2860 18960 0 0 {name=l15275 lab=VSS}
C {bitcell_6t.sym} 3000 19000 0 0 {name=Xr95c15}
N 2960 19040 2940 19040 {}
C {lab_pin.sym} 2940 19040 0 0 {name=l15276 lab=BL15}
N 2960 19000 2940 19000 {}
C {lab_pin.sym} 2940 19000 0 0 {name=l15277 lab=BLB15}
N 2960 18960 2940 18960 {}
C {lab_pin.sym} 2940 18960 0 0 {name=l15278 lab=WL95}
N 3040 19040 3060 19040 {}
C {lab_pin.sym} 3060 19040 0 0 {name=l15279 lab=VDD}
N 3040 18960 3060 18960 {}
C {lab_pin.sym} 3060 18960 0 0 {name=l15280 lab=VSS}
C {bitcell_6t.sym} 3200 19000 0 0 {name=Xr95c16}
N 3160 19040 3140 19040 {}
C {lab_pin.sym} 3140 19040 0 0 {name=l15281 lab=BL16}
N 3160 19000 3140 19000 {}
C {lab_pin.sym} 3140 19000 0 0 {name=l15282 lab=BLB16}
N 3160 18960 3140 18960 {}
C {lab_pin.sym} 3140 18960 0 0 {name=l15283 lab=WL95}
N 3240 19040 3260 19040 {}
C {lab_pin.sym} 3260 19040 0 0 {name=l15284 lab=VDD}
N 3240 18960 3260 18960 {}
C {lab_pin.sym} 3260 18960 0 0 {name=l15285 lab=VSS}
C {bitcell_6t.sym} 3400 19000 0 0 {name=Xr95c17}
N 3360 19040 3340 19040 {}
C {lab_pin.sym} 3340 19040 0 0 {name=l15286 lab=BL17}
N 3360 19000 3340 19000 {}
C {lab_pin.sym} 3340 19000 0 0 {name=l15287 lab=BLB17}
N 3360 18960 3340 18960 {}
C {lab_pin.sym} 3340 18960 0 0 {name=l15288 lab=WL95}
N 3440 19040 3460 19040 {}
C {lab_pin.sym} 3460 19040 0 0 {name=l15289 lab=VDD}
N 3440 18960 3460 18960 {}
C {lab_pin.sym} 3460 18960 0 0 {name=l15290 lab=VSS}
C {bitcell_6t.sym} 3600 19000 0 0 {name=Xr95c18}
N 3560 19040 3540 19040 {}
C {lab_pin.sym} 3540 19040 0 0 {name=l15291 lab=BL18}
N 3560 19000 3540 19000 {}
C {lab_pin.sym} 3540 19000 0 0 {name=l15292 lab=BLB18}
N 3560 18960 3540 18960 {}
C {lab_pin.sym} 3540 18960 0 0 {name=l15293 lab=WL95}
N 3640 19040 3660 19040 {}
C {lab_pin.sym} 3660 19040 0 0 {name=l15294 lab=VDD}
N 3640 18960 3660 18960 {}
C {lab_pin.sym} 3660 18960 0 0 {name=l15295 lab=VSS}
C {bitcell_6t.sym} 3800 19000 0 0 {name=Xr95c19}
N 3760 19040 3740 19040 {}
C {lab_pin.sym} 3740 19040 0 0 {name=l15296 lab=BL19}
N 3760 19000 3740 19000 {}
C {lab_pin.sym} 3740 19000 0 0 {name=l15297 lab=BLB19}
N 3760 18960 3740 18960 {}
C {lab_pin.sym} 3740 18960 0 0 {name=l15298 lab=WL95}
N 3840 19040 3860 19040 {}
C {lab_pin.sym} 3860 19040 0 0 {name=l15299 lab=VDD}
N 3840 18960 3860 18960 {}
C {lab_pin.sym} 3860 18960 0 0 {name=l15300 lab=VSS}
C {bitcell_6t.sym} 4000 19000 0 0 {name=Xr95c20}
N 3960 19040 3940 19040 {}
C {lab_pin.sym} 3940 19040 0 0 {name=l15301 lab=BL20}
N 3960 19000 3940 19000 {}
C {lab_pin.sym} 3940 19000 0 0 {name=l15302 lab=BLB20}
N 3960 18960 3940 18960 {}
C {lab_pin.sym} 3940 18960 0 0 {name=l15303 lab=WL95}
N 4040 19040 4060 19040 {}
C {lab_pin.sym} 4060 19040 0 0 {name=l15304 lab=VDD}
N 4040 18960 4060 18960 {}
C {lab_pin.sym} 4060 18960 0 0 {name=l15305 lab=VSS}
C {bitcell_6t.sym} 4200 19000 0 0 {name=Xr95c21}
N 4160 19040 4140 19040 {}
C {lab_pin.sym} 4140 19040 0 0 {name=l15306 lab=BL21}
N 4160 19000 4140 19000 {}
C {lab_pin.sym} 4140 19000 0 0 {name=l15307 lab=BLB21}
N 4160 18960 4140 18960 {}
C {lab_pin.sym} 4140 18960 0 0 {name=l15308 lab=WL95}
N 4240 19040 4260 19040 {}
C {lab_pin.sym} 4260 19040 0 0 {name=l15309 lab=VDD}
N 4240 18960 4260 18960 {}
C {lab_pin.sym} 4260 18960 0 0 {name=l15310 lab=VSS}
C {bitcell_6t.sym} 4400 19000 0 0 {name=Xr95c22}
N 4360 19040 4340 19040 {}
C {lab_pin.sym} 4340 19040 0 0 {name=l15311 lab=BL22}
N 4360 19000 4340 19000 {}
C {lab_pin.sym} 4340 19000 0 0 {name=l15312 lab=BLB22}
N 4360 18960 4340 18960 {}
C {lab_pin.sym} 4340 18960 0 0 {name=l15313 lab=WL95}
N 4440 19040 4460 19040 {}
C {lab_pin.sym} 4460 19040 0 0 {name=l15314 lab=VDD}
N 4440 18960 4460 18960 {}
C {lab_pin.sym} 4460 18960 0 0 {name=l15315 lab=VSS}
C {bitcell_6t.sym} 4600 19000 0 0 {name=Xr95c23}
N 4560 19040 4540 19040 {}
C {lab_pin.sym} 4540 19040 0 0 {name=l15316 lab=BL23}
N 4560 19000 4540 19000 {}
C {lab_pin.sym} 4540 19000 0 0 {name=l15317 lab=BLB23}
N 4560 18960 4540 18960 {}
C {lab_pin.sym} 4540 18960 0 0 {name=l15318 lab=WL95}
N 4640 19040 4660 19040 {}
C {lab_pin.sym} 4660 19040 0 0 {name=l15319 lab=VDD}
N 4640 18960 4660 18960 {}
C {lab_pin.sym} 4660 18960 0 0 {name=l15320 lab=VSS}
C {bitcell_6t.sym} 4800 19000 0 0 {name=Xr95c24}
N 4760 19040 4740 19040 {}
C {lab_pin.sym} 4740 19040 0 0 {name=l15321 lab=BL24}
N 4760 19000 4740 19000 {}
C {lab_pin.sym} 4740 19000 0 0 {name=l15322 lab=BLB24}
N 4760 18960 4740 18960 {}
C {lab_pin.sym} 4740 18960 0 0 {name=l15323 lab=WL95}
N 4840 19040 4860 19040 {}
C {lab_pin.sym} 4860 19040 0 0 {name=l15324 lab=VDD}
N 4840 18960 4860 18960 {}
C {lab_pin.sym} 4860 18960 0 0 {name=l15325 lab=VSS}
C {bitcell_6t.sym} 5000 19000 0 0 {name=Xr95c25}
N 4960 19040 4940 19040 {}
C {lab_pin.sym} 4940 19040 0 0 {name=l15326 lab=BL25}
N 4960 19000 4940 19000 {}
C {lab_pin.sym} 4940 19000 0 0 {name=l15327 lab=BLB25}
N 4960 18960 4940 18960 {}
C {lab_pin.sym} 4940 18960 0 0 {name=l15328 lab=WL95}
N 5040 19040 5060 19040 {}
C {lab_pin.sym} 5060 19040 0 0 {name=l15329 lab=VDD}
N 5040 18960 5060 18960 {}
C {lab_pin.sym} 5060 18960 0 0 {name=l15330 lab=VSS}
C {bitcell_6t.sym} 5200 19000 0 0 {name=Xr95c26}
N 5160 19040 5140 19040 {}
C {lab_pin.sym} 5140 19040 0 0 {name=l15331 lab=BL26}
N 5160 19000 5140 19000 {}
C {lab_pin.sym} 5140 19000 0 0 {name=l15332 lab=BLB26}
N 5160 18960 5140 18960 {}
C {lab_pin.sym} 5140 18960 0 0 {name=l15333 lab=WL95}
N 5240 19040 5260 19040 {}
C {lab_pin.sym} 5260 19040 0 0 {name=l15334 lab=VDD}
N 5240 18960 5260 18960 {}
C {lab_pin.sym} 5260 18960 0 0 {name=l15335 lab=VSS}
C {bitcell_6t.sym} 5400 19000 0 0 {name=Xr95c27}
N 5360 19040 5340 19040 {}
C {lab_pin.sym} 5340 19040 0 0 {name=l15336 lab=BL27}
N 5360 19000 5340 19000 {}
C {lab_pin.sym} 5340 19000 0 0 {name=l15337 lab=BLB27}
N 5360 18960 5340 18960 {}
C {lab_pin.sym} 5340 18960 0 0 {name=l15338 lab=WL95}
N 5440 19040 5460 19040 {}
C {lab_pin.sym} 5460 19040 0 0 {name=l15339 lab=VDD}
N 5440 18960 5460 18960 {}
C {lab_pin.sym} 5460 18960 0 0 {name=l15340 lab=VSS}
C {bitcell_6t.sym} 5600 19000 0 0 {name=Xr95c28}
N 5560 19040 5540 19040 {}
C {lab_pin.sym} 5540 19040 0 0 {name=l15341 lab=BL28}
N 5560 19000 5540 19000 {}
C {lab_pin.sym} 5540 19000 0 0 {name=l15342 lab=BLB28}
N 5560 18960 5540 18960 {}
C {lab_pin.sym} 5540 18960 0 0 {name=l15343 lab=WL95}
N 5640 19040 5660 19040 {}
C {lab_pin.sym} 5660 19040 0 0 {name=l15344 lab=VDD}
N 5640 18960 5660 18960 {}
C {lab_pin.sym} 5660 18960 0 0 {name=l15345 lab=VSS}
C {bitcell_6t.sym} 5800 19000 0 0 {name=Xr95c29}
N 5760 19040 5740 19040 {}
C {lab_pin.sym} 5740 19040 0 0 {name=l15346 lab=BL29}
N 5760 19000 5740 19000 {}
C {lab_pin.sym} 5740 19000 0 0 {name=l15347 lab=BLB29}
N 5760 18960 5740 18960 {}
C {lab_pin.sym} 5740 18960 0 0 {name=l15348 lab=WL95}
N 5840 19040 5860 19040 {}
C {lab_pin.sym} 5860 19040 0 0 {name=l15349 lab=VDD}
N 5840 18960 5860 18960 {}
C {lab_pin.sym} 5860 18960 0 0 {name=l15350 lab=VSS}
C {bitcell_6t.sym} 6000 19000 0 0 {name=Xr95c30}
N 5960 19040 5940 19040 {}
C {lab_pin.sym} 5940 19040 0 0 {name=l15351 lab=BL30}
N 5960 19000 5940 19000 {}
C {lab_pin.sym} 5940 19000 0 0 {name=l15352 lab=BLB30}
N 5960 18960 5940 18960 {}
C {lab_pin.sym} 5940 18960 0 0 {name=l15353 lab=WL95}
N 6040 19040 6060 19040 {}
C {lab_pin.sym} 6060 19040 0 0 {name=l15354 lab=VDD}
N 6040 18960 6060 18960 {}
C {lab_pin.sym} 6060 18960 0 0 {name=l15355 lab=VSS}
C {bitcell_6t.sym} 6200 19000 0 0 {name=Xr95c31}
N 6160 19040 6140 19040 {}
C {lab_pin.sym} 6140 19040 0 0 {name=l15356 lab=BL31}
N 6160 19000 6140 19000 {}
C {lab_pin.sym} 6140 19000 0 0 {name=l15357 lab=BLB31}
N 6160 18960 6140 18960 {}
C {lab_pin.sym} 6140 18960 0 0 {name=l15358 lab=WL95}
N 6240 19040 6260 19040 {}
C {lab_pin.sym} 6260 19040 0 0 {name=l15359 lab=VDD}
N 6240 18960 6260 18960 {}
C {lab_pin.sym} 6260 18960 0 0 {name=l15360 lab=VSS}
C {bitcell_6t.sym} 0 19200 0 0 {name=Xr96c0}
N -40 19240 -60 19240 {}
C {lab_pin.sym} -60 19240 0 0 {name=l15361 lab=BL0}
N -40 19200 -60 19200 {}
C {lab_pin.sym} -60 19200 0 0 {name=l15362 lab=BLB0}
N -40 19160 -60 19160 {}
C {lab_pin.sym} -60 19160 0 0 {name=l15363 lab=WL96}
N 40 19240 60 19240 {}
C {lab_pin.sym} 60 19240 0 0 {name=l15364 lab=VDD}
N 40 19160 60 19160 {}
C {lab_pin.sym} 60 19160 0 0 {name=l15365 lab=VSS}
C {bitcell_6t.sym} 200 19200 0 0 {name=Xr96c1}
N 160 19240 140 19240 {}
C {lab_pin.sym} 140 19240 0 0 {name=l15366 lab=BL1}
N 160 19200 140 19200 {}
C {lab_pin.sym} 140 19200 0 0 {name=l15367 lab=BLB1}
N 160 19160 140 19160 {}
C {lab_pin.sym} 140 19160 0 0 {name=l15368 lab=WL96}
N 240 19240 260 19240 {}
C {lab_pin.sym} 260 19240 0 0 {name=l15369 lab=VDD}
N 240 19160 260 19160 {}
C {lab_pin.sym} 260 19160 0 0 {name=l15370 lab=VSS}
C {bitcell_6t.sym} 400 19200 0 0 {name=Xr96c2}
N 360 19240 340 19240 {}
C {lab_pin.sym} 340 19240 0 0 {name=l15371 lab=BL2}
N 360 19200 340 19200 {}
C {lab_pin.sym} 340 19200 0 0 {name=l15372 lab=BLB2}
N 360 19160 340 19160 {}
C {lab_pin.sym} 340 19160 0 0 {name=l15373 lab=WL96}
N 440 19240 460 19240 {}
C {lab_pin.sym} 460 19240 0 0 {name=l15374 lab=VDD}
N 440 19160 460 19160 {}
C {lab_pin.sym} 460 19160 0 0 {name=l15375 lab=VSS}
C {bitcell_6t.sym} 600 19200 0 0 {name=Xr96c3}
N 560 19240 540 19240 {}
C {lab_pin.sym} 540 19240 0 0 {name=l15376 lab=BL3}
N 560 19200 540 19200 {}
C {lab_pin.sym} 540 19200 0 0 {name=l15377 lab=BLB3}
N 560 19160 540 19160 {}
C {lab_pin.sym} 540 19160 0 0 {name=l15378 lab=WL96}
N 640 19240 660 19240 {}
C {lab_pin.sym} 660 19240 0 0 {name=l15379 lab=VDD}
N 640 19160 660 19160 {}
C {lab_pin.sym} 660 19160 0 0 {name=l15380 lab=VSS}
C {bitcell_6t.sym} 800 19200 0 0 {name=Xr96c4}
N 760 19240 740 19240 {}
C {lab_pin.sym} 740 19240 0 0 {name=l15381 lab=BL4}
N 760 19200 740 19200 {}
C {lab_pin.sym} 740 19200 0 0 {name=l15382 lab=BLB4}
N 760 19160 740 19160 {}
C {lab_pin.sym} 740 19160 0 0 {name=l15383 lab=WL96}
N 840 19240 860 19240 {}
C {lab_pin.sym} 860 19240 0 0 {name=l15384 lab=VDD}
N 840 19160 860 19160 {}
C {lab_pin.sym} 860 19160 0 0 {name=l15385 lab=VSS}
C {bitcell_6t.sym} 1000 19200 0 0 {name=Xr96c5}
N 960 19240 940 19240 {}
C {lab_pin.sym} 940 19240 0 0 {name=l15386 lab=BL5}
N 960 19200 940 19200 {}
C {lab_pin.sym} 940 19200 0 0 {name=l15387 lab=BLB5}
N 960 19160 940 19160 {}
C {lab_pin.sym} 940 19160 0 0 {name=l15388 lab=WL96}
N 1040 19240 1060 19240 {}
C {lab_pin.sym} 1060 19240 0 0 {name=l15389 lab=VDD}
N 1040 19160 1060 19160 {}
C {lab_pin.sym} 1060 19160 0 0 {name=l15390 lab=VSS}
C {bitcell_6t.sym} 1200 19200 0 0 {name=Xr96c6}
N 1160 19240 1140 19240 {}
C {lab_pin.sym} 1140 19240 0 0 {name=l15391 lab=BL6}
N 1160 19200 1140 19200 {}
C {lab_pin.sym} 1140 19200 0 0 {name=l15392 lab=BLB6}
N 1160 19160 1140 19160 {}
C {lab_pin.sym} 1140 19160 0 0 {name=l15393 lab=WL96}
N 1240 19240 1260 19240 {}
C {lab_pin.sym} 1260 19240 0 0 {name=l15394 lab=VDD}
N 1240 19160 1260 19160 {}
C {lab_pin.sym} 1260 19160 0 0 {name=l15395 lab=VSS}
C {bitcell_6t.sym} 1400 19200 0 0 {name=Xr96c7}
N 1360 19240 1340 19240 {}
C {lab_pin.sym} 1340 19240 0 0 {name=l15396 lab=BL7}
N 1360 19200 1340 19200 {}
C {lab_pin.sym} 1340 19200 0 0 {name=l15397 lab=BLB7}
N 1360 19160 1340 19160 {}
C {lab_pin.sym} 1340 19160 0 0 {name=l15398 lab=WL96}
N 1440 19240 1460 19240 {}
C {lab_pin.sym} 1460 19240 0 0 {name=l15399 lab=VDD}
N 1440 19160 1460 19160 {}
C {lab_pin.sym} 1460 19160 0 0 {name=l15400 lab=VSS}
C {bitcell_6t.sym} 1600 19200 0 0 {name=Xr96c8}
N 1560 19240 1540 19240 {}
C {lab_pin.sym} 1540 19240 0 0 {name=l15401 lab=BL8}
N 1560 19200 1540 19200 {}
C {lab_pin.sym} 1540 19200 0 0 {name=l15402 lab=BLB8}
N 1560 19160 1540 19160 {}
C {lab_pin.sym} 1540 19160 0 0 {name=l15403 lab=WL96}
N 1640 19240 1660 19240 {}
C {lab_pin.sym} 1660 19240 0 0 {name=l15404 lab=VDD}
N 1640 19160 1660 19160 {}
C {lab_pin.sym} 1660 19160 0 0 {name=l15405 lab=VSS}
C {bitcell_6t.sym} 1800 19200 0 0 {name=Xr96c9}
N 1760 19240 1740 19240 {}
C {lab_pin.sym} 1740 19240 0 0 {name=l15406 lab=BL9}
N 1760 19200 1740 19200 {}
C {lab_pin.sym} 1740 19200 0 0 {name=l15407 lab=BLB9}
N 1760 19160 1740 19160 {}
C {lab_pin.sym} 1740 19160 0 0 {name=l15408 lab=WL96}
N 1840 19240 1860 19240 {}
C {lab_pin.sym} 1860 19240 0 0 {name=l15409 lab=VDD}
N 1840 19160 1860 19160 {}
C {lab_pin.sym} 1860 19160 0 0 {name=l15410 lab=VSS}
C {bitcell_6t.sym} 2000 19200 0 0 {name=Xr96c10}
N 1960 19240 1940 19240 {}
C {lab_pin.sym} 1940 19240 0 0 {name=l15411 lab=BL10}
N 1960 19200 1940 19200 {}
C {lab_pin.sym} 1940 19200 0 0 {name=l15412 lab=BLB10}
N 1960 19160 1940 19160 {}
C {lab_pin.sym} 1940 19160 0 0 {name=l15413 lab=WL96}
N 2040 19240 2060 19240 {}
C {lab_pin.sym} 2060 19240 0 0 {name=l15414 lab=VDD}
N 2040 19160 2060 19160 {}
C {lab_pin.sym} 2060 19160 0 0 {name=l15415 lab=VSS}
C {bitcell_6t.sym} 2200 19200 0 0 {name=Xr96c11}
N 2160 19240 2140 19240 {}
C {lab_pin.sym} 2140 19240 0 0 {name=l15416 lab=BL11}
N 2160 19200 2140 19200 {}
C {lab_pin.sym} 2140 19200 0 0 {name=l15417 lab=BLB11}
N 2160 19160 2140 19160 {}
C {lab_pin.sym} 2140 19160 0 0 {name=l15418 lab=WL96}
N 2240 19240 2260 19240 {}
C {lab_pin.sym} 2260 19240 0 0 {name=l15419 lab=VDD}
N 2240 19160 2260 19160 {}
C {lab_pin.sym} 2260 19160 0 0 {name=l15420 lab=VSS}
C {bitcell_6t.sym} 2400 19200 0 0 {name=Xr96c12}
N 2360 19240 2340 19240 {}
C {lab_pin.sym} 2340 19240 0 0 {name=l15421 lab=BL12}
N 2360 19200 2340 19200 {}
C {lab_pin.sym} 2340 19200 0 0 {name=l15422 lab=BLB12}
N 2360 19160 2340 19160 {}
C {lab_pin.sym} 2340 19160 0 0 {name=l15423 lab=WL96}
N 2440 19240 2460 19240 {}
C {lab_pin.sym} 2460 19240 0 0 {name=l15424 lab=VDD}
N 2440 19160 2460 19160 {}
C {lab_pin.sym} 2460 19160 0 0 {name=l15425 lab=VSS}
C {bitcell_6t.sym} 2600 19200 0 0 {name=Xr96c13}
N 2560 19240 2540 19240 {}
C {lab_pin.sym} 2540 19240 0 0 {name=l15426 lab=BL13}
N 2560 19200 2540 19200 {}
C {lab_pin.sym} 2540 19200 0 0 {name=l15427 lab=BLB13}
N 2560 19160 2540 19160 {}
C {lab_pin.sym} 2540 19160 0 0 {name=l15428 lab=WL96}
N 2640 19240 2660 19240 {}
C {lab_pin.sym} 2660 19240 0 0 {name=l15429 lab=VDD}
N 2640 19160 2660 19160 {}
C {lab_pin.sym} 2660 19160 0 0 {name=l15430 lab=VSS}
C {bitcell_6t.sym} 2800 19200 0 0 {name=Xr96c14}
N 2760 19240 2740 19240 {}
C {lab_pin.sym} 2740 19240 0 0 {name=l15431 lab=BL14}
N 2760 19200 2740 19200 {}
C {lab_pin.sym} 2740 19200 0 0 {name=l15432 lab=BLB14}
N 2760 19160 2740 19160 {}
C {lab_pin.sym} 2740 19160 0 0 {name=l15433 lab=WL96}
N 2840 19240 2860 19240 {}
C {lab_pin.sym} 2860 19240 0 0 {name=l15434 lab=VDD}
N 2840 19160 2860 19160 {}
C {lab_pin.sym} 2860 19160 0 0 {name=l15435 lab=VSS}
C {bitcell_6t.sym} 3000 19200 0 0 {name=Xr96c15}
N 2960 19240 2940 19240 {}
C {lab_pin.sym} 2940 19240 0 0 {name=l15436 lab=BL15}
N 2960 19200 2940 19200 {}
C {lab_pin.sym} 2940 19200 0 0 {name=l15437 lab=BLB15}
N 2960 19160 2940 19160 {}
C {lab_pin.sym} 2940 19160 0 0 {name=l15438 lab=WL96}
N 3040 19240 3060 19240 {}
C {lab_pin.sym} 3060 19240 0 0 {name=l15439 lab=VDD}
N 3040 19160 3060 19160 {}
C {lab_pin.sym} 3060 19160 0 0 {name=l15440 lab=VSS}
C {bitcell_6t.sym} 3200 19200 0 0 {name=Xr96c16}
N 3160 19240 3140 19240 {}
C {lab_pin.sym} 3140 19240 0 0 {name=l15441 lab=BL16}
N 3160 19200 3140 19200 {}
C {lab_pin.sym} 3140 19200 0 0 {name=l15442 lab=BLB16}
N 3160 19160 3140 19160 {}
C {lab_pin.sym} 3140 19160 0 0 {name=l15443 lab=WL96}
N 3240 19240 3260 19240 {}
C {lab_pin.sym} 3260 19240 0 0 {name=l15444 lab=VDD}
N 3240 19160 3260 19160 {}
C {lab_pin.sym} 3260 19160 0 0 {name=l15445 lab=VSS}
C {bitcell_6t.sym} 3400 19200 0 0 {name=Xr96c17}
N 3360 19240 3340 19240 {}
C {lab_pin.sym} 3340 19240 0 0 {name=l15446 lab=BL17}
N 3360 19200 3340 19200 {}
C {lab_pin.sym} 3340 19200 0 0 {name=l15447 lab=BLB17}
N 3360 19160 3340 19160 {}
C {lab_pin.sym} 3340 19160 0 0 {name=l15448 lab=WL96}
N 3440 19240 3460 19240 {}
C {lab_pin.sym} 3460 19240 0 0 {name=l15449 lab=VDD}
N 3440 19160 3460 19160 {}
C {lab_pin.sym} 3460 19160 0 0 {name=l15450 lab=VSS}
C {bitcell_6t.sym} 3600 19200 0 0 {name=Xr96c18}
N 3560 19240 3540 19240 {}
C {lab_pin.sym} 3540 19240 0 0 {name=l15451 lab=BL18}
N 3560 19200 3540 19200 {}
C {lab_pin.sym} 3540 19200 0 0 {name=l15452 lab=BLB18}
N 3560 19160 3540 19160 {}
C {lab_pin.sym} 3540 19160 0 0 {name=l15453 lab=WL96}
N 3640 19240 3660 19240 {}
C {lab_pin.sym} 3660 19240 0 0 {name=l15454 lab=VDD}
N 3640 19160 3660 19160 {}
C {lab_pin.sym} 3660 19160 0 0 {name=l15455 lab=VSS}
C {bitcell_6t.sym} 3800 19200 0 0 {name=Xr96c19}
N 3760 19240 3740 19240 {}
C {lab_pin.sym} 3740 19240 0 0 {name=l15456 lab=BL19}
N 3760 19200 3740 19200 {}
C {lab_pin.sym} 3740 19200 0 0 {name=l15457 lab=BLB19}
N 3760 19160 3740 19160 {}
C {lab_pin.sym} 3740 19160 0 0 {name=l15458 lab=WL96}
N 3840 19240 3860 19240 {}
C {lab_pin.sym} 3860 19240 0 0 {name=l15459 lab=VDD}
N 3840 19160 3860 19160 {}
C {lab_pin.sym} 3860 19160 0 0 {name=l15460 lab=VSS}
C {bitcell_6t.sym} 4000 19200 0 0 {name=Xr96c20}
N 3960 19240 3940 19240 {}
C {lab_pin.sym} 3940 19240 0 0 {name=l15461 lab=BL20}
N 3960 19200 3940 19200 {}
C {lab_pin.sym} 3940 19200 0 0 {name=l15462 lab=BLB20}
N 3960 19160 3940 19160 {}
C {lab_pin.sym} 3940 19160 0 0 {name=l15463 lab=WL96}
N 4040 19240 4060 19240 {}
C {lab_pin.sym} 4060 19240 0 0 {name=l15464 lab=VDD}
N 4040 19160 4060 19160 {}
C {lab_pin.sym} 4060 19160 0 0 {name=l15465 lab=VSS}
C {bitcell_6t.sym} 4200 19200 0 0 {name=Xr96c21}
N 4160 19240 4140 19240 {}
C {lab_pin.sym} 4140 19240 0 0 {name=l15466 lab=BL21}
N 4160 19200 4140 19200 {}
C {lab_pin.sym} 4140 19200 0 0 {name=l15467 lab=BLB21}
N 4160 19160 4140 19160 {}
C {lab_pin.sym} 4140 19160 0 0 {name=l15468 lab=WL96}
N 4240 19240 4260 19240 {}
C {lab_pin.sym} 4260 19240 0 0 {name=l15469 lab=VDD}
N 4240 19160 4260 19160 {}
C {lab_pin.sym} 4260 19160 0 0 {name=l15470 lab=VSS}
C {bitcell_6t.sym} 4400 19200 0 0 {name=Xr96c22}
N 4360 19240 4340 19240 {}
C {lab_pin.sym} 4340 19240 0 0 {name=l15471 lab=BL22}
N 4360 19200 4340 19200 {}
C {lab_pin.sym} 4340 19200 0 0 {name=l15472 lab=BLB22}
N 4360 19160 4340 19160 {}
C {lab_pin.sym} 4340 19160 0 0 {name=l15473 lab=WL96}
N 4440 19240 4460 19240 {}
C {lab_pin.sym} 4460 19240 0 0 {name=l15474 lab=VDD}
N 4440 19160 4460 19160 {}
C {lab_pin.sym} 4460 19160 0 0 {name=l15475 lab=VSS}
C {bitcell_6t.sym} 4600 19200 0 0 {name=Xr96c23}
N 4560 19240 4540 19240 {}
C {lab_pin.sym} 4540 19240 0 0 {name=l15476 lab=BL23}
N 4560 19200 4540 19200 {}
C {lab_pin.sym} 4540 19200 0 0 {name=l15477 lab=BLB23}
N 4560 19160 4540 19160 {}
C {lab_pin.sym} 4540 19160 0 0 {name=l15478 lab=WL96}
N 4640 19240 4660 19240 {}
C {lab_pin.sym} 4660 19240 0 0 {name=l15479 lab=VDD}
N 4640 19160 4660 19160 {}
C {lab_pin.sym} 4660 19160 0 0 {name=l15480 lab=VSS}
C {bitcell_6t.sym} 4800 19200 0 0 {name=Xr96c24}
N 4760 19240 4740 19240 {}
C {lab_pin.sym} 4740 19240 0 0 {name=l15481 lab=BL24}
N 4760 19200 4740 19200 {}
C {lab_pin.sym} 4740 19200 0 0 {name=l15482 lab=BLB24}
N 4760 19160 4740 19160 {}
C {lab_pin.sym} 4740 19160 0 0 {name=l15483 lab=WL96}
N 4840 19240 4860 19240 {}
C {lab_pin.sym} 4860 19240 0 0 {name=l15484 lab=VDD}
N 4840 19160 4860 19160 {}
C {lab_pin.sym} 4860 19160 0 0 {name=l15485 lab=VSS}
C {bitcell_6t.sym} 5000 19200 0 0 {name=Xr96c25}
N 4960 19240 4940 19240 {}
C {lab_pin.sym} 4940 19240 0 0 {name=l15486 lab=BL25}
N 4960 19200 4940 19200 {}
C {lab_pin.sym} 4940 19200 0 0 {name=l15487 lab=BLB25}
N 4960 19160 4940 19160 {}
C {lab_pin.sym} 4940 19160 0 0 {name=l15488 lab=WL96}
N 5040 19240 5060 19240 {}
C {lab_pin.sym} 5060 19240 0 0 {name=l15489 lab=VDD}
N 5040 19160 5060 19160 {}
C {lab_pin.sym} 5060 19160 0 0 {name=l15490 lab=VSS}
C {bitcell_6t.sym} 5200 19200 0 0 {name=Xr96c26}
N 5160 19240 5140 19240 {}
C {lab_pin.sym} 5140 19240 0 0 {name=l15491 lab=BL26}
N 5160 19200 5140 19200 {}
C {lab_pin.sym} 5140 19200 0 0 {name=l15492 lab=BLB26}
N 5160 19160 5140 19160 {}
C {lab_pin.sym} 5140 19160 0 0 {name=l15493 lab=WL96}
N 5240 19240 5260 19240 {}
C {lab_pin.sym} 5260 19240 0 0 {name=l15494 lab=VDD}
N 5240 19160 5260 19160 {}
C {lab_pin.sym} 5260 19160 0 0 {name=l15495 lab=VSS}
C {bitcell_6t.sym} 5400 19200 0 0 {name=Xr96c27}
N 5360 19240 5340 19240 {}
C {lab_pin.sym} 5340 19240 0 0 {name=l15496 lab=BL27}
N 5360 19200 5340 19200 {}
C {lab_pin.sym} 5340 19200 0 0 {name=l15497 lab=BLB27}
N 5360 19160 5340 19160 {}
C {lab_pin.sym} 5340 19160 0 0 {name=l15498 lab=WL96}
N 5440 19240 5460 19240 {}
C {lab_pin.sym} 5460 19240 0 0 {name=l15499 lab=VDD}
N 5440 19160 5460 19160 {}
C {lab_pin.sym} 5460 19160 0 0 {name=l15500 lab=VSS}
C {bitcell_6t.sym} 5600 19200 0 0 {name=Xr96c28}
N 5560 19240 5540 19240 {}
C {lab_pin.sym} 5540 19240 0 0 {name=l15501 lab=BL28}
N 5560 19200 5540 19200 {}
C {lab_pin.sym} 5540 19200 0 0 {name=l15502 lab=BLB28}
N 5560 19160 5540 19160 {}
C {lab_pin.sym} 5540 19160 0 0 {name=l15503 lab=WL96}
N 5640 19240 5660 19240 {}
C {lab_pin.sym} 5660 19240 0 0 {name=l15504 lab=VDD}
N 5640 19160 5660 19160 {}
C {lab_pin.sym} 5660 19160 0 0 {name=l15505 lab=VSS}
C {bitcell_6t.sym} 5800 19200 0 0 {name=Xr96c29}
N 5760 19240 5740 19240 {}
C {lab_pin.sym} 5740 19240 0 0 {name=l15506 lab=BL29}
N 5760 19200 5740 19200 {}
C {lab_pin.sym} 5740 19200 0 0 {name=l15507 lab=BLB29}
N 5760 19160 5740 19160 {}
C {lab_pin.sym} 5740 19160 0 0 {name=l15508 lab=WL96}
N 5840 19240 5860 19240 {}
C {lab_pin.sym} 5860 19240 0 0 {name=l15509 lab=VDD}
N 5840 19160 5860 19160 {}
C {lab_pin.sym} 5860 19160 0 0 {name=l15510 lab=VSS}
C {bitcell_6t.sym} 6000 19200 0 0 {name=Xr96c30}
N 5960 19240 5940 19240 {}
C {lab_pin.sym} 5940 19240 0 0 {name=l15511 lab=BL30}
N 5960 19200 5940 19200 {}
C {lab_pin.sym} 5940 19200 0 0 {name=l15512 lab=BLB30}
N 5960 19160 5940 19160 {}
C {lab_pin.sym} 5940 19160 0 0 {name=l15513 lab=WL96}
N 6040 19240 6060 19240 {}
C {lab_pin.sym} 6060 19240 0 0 {name=l15514 lab=VDD}
N 6040 19160 6060 19160 {}
C {lab_pin.sym} 6060 19160 0 0 {name=l15515 lab=VSS}
C {bitcell_6t.sym} 6200 19200 0 0 {name=Xr96c31}
N 6160 19240 6140 19240 {}
C {lab_pin.sym} 6140 19240 0 0 {name=l15516 lab=BL31}
N 6160 19200 6140 19200 {}
C {lab_pin.sym} 6140 19200 0 0 {name=l15517 lab=BLB31}
N 6160 19160 6140 19160 {}
C {lab_pin.sym} 6140 19160 0 0 {name=l15518 lab=WL96}
N 6240 19240 6260 19240 {}
C {lab_pin.sym} 6260 19240 0 0 {name=l15519 lab=VDD}
N 6240 19160 6260 19160 {}
C {lab_pin.sym} 6260 19160 0 0 {name=l15520 lab=VSS}
C {bitcell_6t.sym} 0 19400 0 0 {name=Xr97c0}
N -40 19440 -60 19440 {}
C {lab_pin.sym} -60 19440 0 0 {name=l15521 lab=BL0}
N -40 19400 -60 19400 {}
C {lab_pin.sym} -60 19400 0 0 {name=l15522 lab=BLB0}
N -40 19360 -60 19360 {}
C {lab_pin.sym} -60 19360 0 0 {name=l15523 lab=WL97}
N 40 19440 60 19440 {}
C {lab_pin.sym} 60 19440 0 0 {name=l15524 lab=VDD}
N 40 19360 60 19360 {}
C {lab_pin.sym} 60 19360 0 0 {name=l15525 lab=VSS}
C {bitcell_6t.sym} 200 19400 0 0 {name=Xr97c1}
N 160 19440 140 19440 {}
C {lab_pin.sym} 140 19440 0 0 {name=l15526 lab=BL1}
N 160 19400 140 19400 {}
C {lab_pin.sym} 140 19400 0 0 {name=l15527 lab=BLB1}
N 160 19360 140 19360 {}
C {lab_pin.sym} 140 19360 0 0 {name=l15528 lab=WL97}
N 240 19440 260 19440 {}
C {lab_pin.sym} 260 19440 0 0 {name=l15529 lab=VDD}
N 240 19360 260 19360 {}
C {lab_pin.sym} 260 19360 0 0 {name=l15530 lab=VSS}
C {bitcell_6t.sym} 400 19400 0 0 {name=Xr97c2}
N 360 19440 340 19440 {}
C {lab_pin.sym} 340 19440 0 0 {name=l15531 lab=BL2}
N 360 19400 340 19400 {}
C {lab_pin.sym} 340 19400 0 0 {name=l15532 lab=BLB2}
N 360 19360 340 19360 {}
C {lab_pin.sym} 340 19360 0 0 {name=l15533 lab=WL97}
N 440 19440 460 19440 {}
C {lab_pin.sym} 460 19440 0 0 {name=l15534 lab=VDD}
N 440 19360 460 19360 {}
C {lab_pin.sym} 460 19360 0 0 {name=l15535 lab=VSS}
C {bitcell_6t.sym} 600 19400 0 0 {name=Xr97c3}
N 560 19440 540 19440 {}
C {lab_pin.sym} 540 19440 0 0 {name=l15536 lab=BL3}
N 560 19400 540 19400 {}
C {lab_pin.sym} 540 19400 0 0 {name=l15537 lab=BLB3}
N 560 19360 540 19360 {}
C {lab_pin.sym} 540 19360 0 0 {name=l15538 lab=WL97}
N 640 19440 660 19440 {}
C {lab_pin.sym} 660 19440 0 0 {name=l15539 lab=VDD}
N 640 19360 660 19360 {}
C {lab_pin.sym} 660 19360 0 0 {name=l15540 lab=VSS}
C {bitcell_6t.sym} 800 19400 0 0 {name=Xr97c4}
N 760 19440 740 19440 {}
C {lab_pin.sym} 740 19440 0 0 {name=l15541 lab=BL4}
N 760 19400 740 19400 {}
C {lab_pin.sym} 740 19400 0 0 {name=l15542 lab=BLB4}
N 760 19360 740 19360 {}
C {lab_pin.sym} 740 19360 0 0 {name=l15543 lab=WL97}
N 840 19440 860 19440 {}
C {lab_pin.sym} 860 19440 0 0 {name=l15544 lab=VDD}
N 840 19360 860 19360 {}
C {lab_pin.sym} 860 19360 0 0 {name=l15545 lab=VSS}
C {bitcell_6t.sym} 1000 19400 0 0 {name=Xr97c5}
N 960 19440 940 19440 {}
C {lab_pin.sym} 940 19440 0 0 {name=l15546 lab=BL5}
N 960 19400 940 19400 {}
C {lab_pin.sym} 940 19400 0 0 {name=l15547 lab=BLB5}
N 960 19360 940 19360 {}
C {lab_pin.sym} 940 19360 0 0 {name=l15548 lab=WL97}
N 1040 19440 1060 19440 {}
C {lab_pin.sym} 1060 19440 0 0 {name=l15549 lab=VDD}
N 1040 19360 1060 19360 {}
C {lab_pin.sym} 1060 19360 0 0 {name=l15550 lab=VSS}
C {bitcell_6t.sym} 1200 19400 0 0 {name=Xr97c6}
N 1160 19440 1140 19440 {}
C {lab_pin.sym} 1140 19440 0 0 {name=l15551 lab=BL6}
N 1160 19400 1140 19400 {}
C {lab_pin.sym} 1140 19400 0 0 {name=l15552 lab=BLB6}
N 1160 19360 1140 19360 {}
C {lab_pin.sym} 1140 19360 0 0 {name=l15553 lab=WL97}
N 1240 19440 1260 19440 {}
C {lab_pin.sym} 1260 19440 0 0 {name=l15554 lab=VDD}
N 1240 19360 1260 19360 {}
C {lab_pin.sym} 1260 19360 0 0 {name=l15555 lab=VSS}
C {bitcell_6t.sym} 1400 19400 0 0 {name=Xr97c7}
N 1360 19440 1340 19440 {}
C {lab_pin.sym} 1340 19440 0 0 {name=l15556 lab=BL7}
N 1360 19400 1340 19400 {}
C {lab_pin.sym} 1340 19400 0 0 {name=l15557 lab=BLB7}
N 1360 19360 1340 19360 {}
C {lab_pin.sym} 1340 19360 0 0 {name=l15558 lab=WL97}
N 1440 19440 1460 19440 {}
C {lab_pin.sym} 1460 19440 0 0 {name=l15559 lab=VDD}
N 1440 19360 1460 19360 {}
C {lab_pin.sym} 1460 19360 0 0 {name=l15560 lab=VSS}
C {bitcell_6t.sym} 1600 19400 0 0 {name=Xr97c8}
N 1560 19440 1540 19440 {}
C {lab_pin.sym} 1540 19440 0 0 {name=l15561 lab=BL8}
N 1560 19400 1540 19400 {}
C {lab_pin.sym} 1540 19400 0 0 {name=l15562 lab=BLB8}
N 1560 19360 1540 19360 {}
C {lab_pin.sym} 1540 19360 0 0 {name=l15563 lab=WL97}
N 1640 19440 1660 19440 {}
C {lab_pin.sym} 1660 19440 0 0 {name=l15564 lab=VDD}
N 1640 19360 1660 19360 {}
C {lab_pin.sym} 1660 19360 0 0 {name=l15565 lab=VSS}
C {bitcell_6t.sym} 1800 19400 0 0 {name=Xr97c9}
N 1760 19440 1740 19440 {}
C {lab_pin.sym} 1740 19440 0 0 {name=l15566 lab=BL9}
N 1760 19400 1740 19400 {}
C {lab_pin.sym} 1740 19400 0 0 {name=l15567 lab=BLB9}
N 1760 19360 1740 19360 {}
C {lab_pin.sym} 1740 19360 0 0 {name=l15568 lab=WL97}
N 1840 19440 1860 19440 {}
C {lab_pin.sym} 1860 19440 0 0 {name=l15569 lab=VDD}
N 1840 19360 1860 19360 {}
C {lab_pin.sym} 1860 19360 0 0 {name=l15570 lab=VSS}
C {bitcell_6t.sym} 2000 19400 0 0 {name=Xr97c10}
N 1960 19440 1940 19440 {}
C {lab_pin.sym} 1940 19440 0 0 {name=l15571 lab=BL10}
N 1960 19400 1940 19400 {}
C {lab_pin.sym} 1940 19400 0 0 {name=l15572 lab=BLB10}
N 1960 19360 1940 19360 {}
C {lab_pin.sym} 1940 19360 0 0 {name=l15573 lab=WL97}
N 2040 19440 2060 19440 {}
C {lab_pin.sym} 2060 19440 0 0 {name=l15574 lab=VDD}
N 2040 19360 2060 19360 {}
C {lab_pin.sym} 2060 19360 0 0 {name=l15575 lab=VSS}
C {bitcell_6t.sym} 2200 19400 0 0 {name=Xr97c11}
N 2160 19440 2140 19440 {}
C {lab_pin.sym} 2140 19440 0 0 {name=l15576 lab=BL11}
N 2160 19400 2140 19400 {}
C {lab_pin.sym} 2140 19400 0 0 {name=l15577 lab=BLB11}
N 2160 19360 2140 19360 {}
C {lab_pin.sym} 2140 19360 0 0 {name=l15578 lab=WL97}
N 2240 19440 2260 19440 {}
C {lab_pin.sym} 2260 19440 0 0 {name=l15579 lab=VDD}
N 2240 19360 2260 19360 {}
C {lab_pin.sym} 2260 19360 0 0 {name=l15580 lab=VSS}
C {bitcell_6t.sym} 2400 19400 0 0 {name=Xr97c12}
N 2360 19440 2340 19440 {}
C {lab_pin.sym} 2340 19440 0 0 {name=l15581 lab=BL12}
N 2360 19400 2340 19400 {}
C {lab_pin.sym} 2340 19400 0 0 {name=l15582 lab=BLB12}
N 2360 19360 2340 19360 {}
C {lab_pin.sym} 2340 19360 0 0 {name=l15583 lab=WL97}
N 2440 19440 2460 19440 {}
C {lab_pin.sym} 2460 19440 0 0 {name=l15584 lab=VDD}
N 2440 19360 2460 19360 {}
C {lab_pin.sym} 2460 19360 0 0 {name=l15585 lab=VSS}
C {bitcell_6t.sym} 2600 19400 0 0 {name=Xr97c13}
N 2560 19440 2540 19440 {}
C {lab_pin.sym} 2540 19440 0 0 {name=l15586 lab=BL13}
N 2560 19400 2540 19400 {}
C {lab_pin.sym} 2540 19400 0 0 {name=l15587 lab=BLB13}
N 2560 19360 2540 19360 {}
C {lab_pin.sym} 2540 19360 0 0 {name=l15588 lab=WL97}
N 2640 19440 2660 19440 {}
C {lab_pin.sym} 2660 19440 0 0 {name=l15589 lab=VDD}
N 2640 19360 2660 19360 {}
C {lab_pin.sym} 2660 19360 0 0 {name=l15590 lab=VSS}
C {bitcell_6t.sym} 2800 19400 0 0 {name=Xr97c14}
N 2760 19440 2740 19440 {}
C {lab_pin.sym} 2740 19440 0 0 {name=l15591 lab=BL14}
N 2760 19400 2740 19400 {}
C {lab_pin.sym} 2740 19400 0 0 {name=l15592 lab=BLB14}
N 2760 19360 2740 19360 {}
C {lab_pin.sym} 2740 19360 0 0 {name=l15593 lab=WL97}
N 2840 19440 2860 19440 {}
C {lab_pin.sym} 2860 19440 0 0 {name=l15594 lab=VDD}
N 2840 19360 2860 19360 {}
C {lab_pin.sym} 2860 19360 0 0 {name=l15595 lab=VSS}
C {bitcell_6t.sym} 3000 19400 0 0 {name=Xr97c15}
N 2960 19440 2940 19440 {}
C {lab_pin.sym} 2940 19440 0 0 {name=l15596 lab=BL15}
N 2960 19400 2940 19400 {}
C {lab_pin.sym} 2940 19400 0 0 {name=l15597 lab=BLB15}
N 2960 19360 2940 19360 {}
C {lab_pin.sym} 2940 19360 0 0 {name=l15598 lab=WL97}
N 3040 19440 3060 19440 {}
C {lab_pin.sym} 3060 19440 0 0 {name=l15599 lab=VDD}
N 3040 19360 3060 19360 {}
C {lab_pin.sym} 3060 19360 0 0 {name=l15600 lab=VSS}
C {bitcell_6t.sym} 3200 19400 0 0 {name=Xr97c16}
N 3160 19440 3140 19440 {}
C {lab_pin.sym} 3140 19440 0 0 {name=l15601 lab=BL16}
N 3160 19400 3140 19400 {}
C {lab_pin.sym} 3140 19400 0 0 {name=l15602 lab=BLB16}
N 3160 19360 3140 19360 {}
C {lab_pin.sym} 3140 19360 0 0 {name=l15603 lab=WL97}
N 3240 19440 3260 19440 {}
C {lab_pin.sym} 3260 19440 0 0 {name=l15604 lab=VDD}
N 3240 19360 3260 19360 {}
C {lab_pin.sym} 3260 19360 0 0 {name=l15605 lab=VSS}
C {bitcell_6t.sym} 3400 19400 0 0 {name=Xr97c17}
N 3360 19440 3340 19440 {}
C {lab_pin.sym} 3340 19440 0 0 {name=l15606 lab=BL17}
N 3360 19400 3340 19400 {}
C {lab_pin.sym} 3340 19400 0 0 {name=l15607 lab=BLB17}
N 3360 19360 3340 19360 {}
C {lab_pin.sym} 3340 19360 0 0 {name=l15608 lab=WL97}
N 3440 19440 3460 19440 {}
C {lab_pin.sym} 3460 19440 0 0 {name=l15609 lab=VDD}
N 3440 19360 3460 19360 {}
C {lab_pin.sym} 3460 19360 0 0 {name=l15610 lab=VSS}
C {bitcell_6t.sym} 3600 19400 0 0 {name=Xr97c18}
N 3560 19440 3540 19440 {}
C {lab_pin.sym} 3540 19440 0 0 {name=l15611 lab=BL18}
N 3560 19400 3540 19400 {}
C {lab_pin.sym} 3540 19400 0 0 {name=l15612 lab=BLB18}
N 3560 19360 3540 19360 {}
C {lab_pin.sym} 3540 19360 0 0 {name=l15613 lab=WL97}
N 3640 19440 3660 19440 {}
C {lab_pin.sym} 3660 19440 0 0 {name=l15614 lab=VDD}
N 3640 19360 3660 19360 {}
C {lab_pin.sym} 3660 19360 0 0 {name=l15615 lab=VSS}
C {bitcell_6t.sym} 3800 19400 0 0 {name=Xr97c19}
N 3760 19440 3740 19440 {}
C {lab_pin.sym} 3740 19440 0 0 {name=l15616 lab=BL19}
N 3760 19400 3740 19400 {}
C {lab_pin.sym} 3740 19400 0 0 {name=l15617 lab=BLB19}
N 3760 19360 3740 19360 {}
C {lab_pin.sym} 3740 19360 0 0 {name=l15618 lab=WL97}
N 3840 19440 3860 19440 {}
C {lab_pin.sym} 3860 19440 0 0 {name=l15619 lab=VDD}
N 3840 19360 3860 19360 {}
C {lab_pin.sym} 3860 19360 0 0 {name=l15620 lab=VSS}
C {bitcell_6t.sym} 4000 19400 0 0 {name=Xr97c20}
N 3960 19440 3940 19440 {}
C {lab_pin.sym} 3940 19440 0 0 {name=l15621 lab=BL20}
N 3960 19400 3940 19400 {}
C {lab_pin.sym} 3940 19400 0 0 {name=l15622 lab=BLB20}
N 3960 19360 3940 19360 {}
C {lab_pin.sym} 3940 19360 0 0 {name=l15623 lab=WL97}
N 4040 19440 4060 19440 {}
C {lab_pin.sym} 4060 19440 0 0 {name=l15624 lab=VDD}
N 4040 19360 4060 19360 {}
C {lab_pin.sym} 4060 19360 0 0 {name=l15625 lab=VSS}
C {bitcell_6t.sym} 4200 19400 0 0 {name=Xr97c21}
N 4160 19440 4140 19440 {}
C {lab_pin.sym} 4140 19440 0 0 {name=l15626 lab=BL21}
N 4160 19400 4140 19400 {}
C {lab_pin.sym} 4140 19400 0 0 {name=l15627 lab=BLB21}
N 4160 19360 4140 19360 {}
C {lab_pin.sym} 4140 19360 0 0 {name=l15628 lab=WL97}
N 4240 19440 4260 19440 {}
C {lab_pin.sym} 4260 19440 0 0 {name=l15629 lab=VDD}
N 4240 19360 4260 19360 {}
C {lab_pin.sym} 4260 19360 0 0 {name=l15630 lab=VSS}
C {bitcell_6t.sym} 4400 19400 0 0 {name=Xr97c22}
N 4360 19440 4340 19440 {}
C {lab_pin.sym} 4340 19440 0 0 {name=l15631 lab=BL22}
N 4360 19400 4340 19400 {}
C {lab_pin.sym} 4340 19400 0 0 {name=l15632 lab=BLB22}
N 4360 19360 4340 19360 {}
C {lab_pin.sym} 4340 19360 0 0 {name=l15633 lab=WL97}
N 4440 19440 4460 19440 {}
C {lab_pin.sym} 4460 19440 0 0 {name=l15634 lab=VDD}
N 4440 19360 4460 19360 {}
C {lab_pin.sym} 4460 19360 0 0 {name=l15635 lab=VSS}
C {bitcell_6t.sym} 4600 19400 0 0 {name=Xr97c23}
N 4560 19440 4540 19440 {}
C {lab_pin.sym} 4540 19440 0 0 {name=l15636 lab=BL23}
N 4560 19400 4540 19400 {}
C {lab_pin.sym} 4540 19400 0 0 {name=l15637 lab=BLB23}
N 4560 19360 4540 19360 {}
C {lab_pin.sym} 4540 19360 0 0 {name=l15638 lab=WL97}
N 4640 19440 4660 19440 {}
C {lab_pin.sym} 4660 19440 0 0 {name=l15639 lab=VDD}
N 4640 19360 4660 19360 {}
C {lab_pin.sym} 4660 19360 0 0 {name=l15640 lab=VSS}
C {bitcell_6t.sym} 4800 19400 0 0 {name=Xr97c24}
N 4760 19440 4740 19440 {}
C {lab_pin.sym} 4740 19440 0 0 {name=l15641 lab=BL24}
N 4760 19400 4740 19400 {}
C {lab_pin.sym} 4740 19400 0 0 {name=l15642 lab=BLB24}
N 4760 19360 4740 19360 {}
C {lab_pin.sym} 4740 19360 0 0 {name=l15643 lab=WL97}
N 4840 19440 4860 19440 {}
C {lab_pin.sym} 4860 19440 0 0 {name=l15644 lab=VDD}
N 4840 19360 4860 19360 {}
C {lab_pin.sym} 4860 19360 0 0 {name=l15645 lab=VSS}
C {bitcell_6t.sym} 5000 19400 0 0 {name=Xr97c25}
N 4960 19440 4940 19440 {}
C {lab_pin.sym} 4940 19440 0 0 {name=l15646 lab=BL25}
N 4960 19400 4940 19400 {}
C {lab_pin.sym} 4940 19400 0 0 {name=l15647 lab=BLB25}
N 4960 19360 4940 19360 {}
C {lab_pin.sym} 4940 19360 0 0 {name=l15648 lab=WL97}
N 5040 19440 5060 19440 {}
C {lab_pin.sym} 5060 19440 0 0 {name=l15649 lab=VDD}
N 5040 19360 5060 19360 {}
C {lab_pin.sym} 5060 19360 0 0 {name=l15650 lab=VSS}
C {bitcell_6t.sym} 5200 19400 0 0 {name=Xr97c26}
N 5160 19440 5140 19440 {}
C {lab_pin.sym} 5140 19440 0 0 {name=l15651 lab=BL26}
N 5160 19400 5140 19400 {}
C {lab_pin.sym} 5140 19400 0 0 {name=l15652 lab=BLB26}
N 5160 19360 5140 19360 {}
C {lab_pin.sym} 5140 19360 0 0 {name=l15653 lab=WL97}
N 5240 19440 5260 19440 {}
C {lab_pin.sym} 5260 19440 0 0 {name=l15654 lab=VDD}
N 5240 19360 5260 19360 {}
C {lab_pin.sym} 5260 19360 0 0 {name=l15655 lab=VSS}
C {bitcell_6t.sym} 5400 19400 0 0 {name=Xr97c27}
N 5360 19440 5340 19440 {}
C {lab_pin.sym} 5340 19440 0 0 {name=l15656 lab=BL27}
N 5360 19400 5340 19400 {}
C {lab_pin.sym} 5340 19400 0 0 {name=l15657 lab=BLB27}
N 5360 19360 5340 19360 {}
C {lab_pin.sym} 5340 19360 0 0 {name=l15658 lab=WL97}
N 5440 19440 5460 19440 {}
C {lab_pin.sym} 5460 19440 0 0 {name=l15659 lab=VDD}
N 5440 19360 5460 19360 {}
C {lab_pin.sym} 5460 19360 0 0 {name=l15660 lab=VSS}
C {bitcell_6t.sym} 5600 19400 0 0 {name=Xr97c28}
N 5560 19440 5540 19440 {}
C {lab_pin.sym} 5540 19440 0 0 {name=l15661 lab=BL28}
N 5560 19400 5540 19400 {}
C {lab_pin.sym} 5540 19400 0 0 {name=l15662 lab=BLB28}
N 5560 19360 5540 19360 {}
C {lab_pin.sym} 5540 19360 0 0 {name=l15663 lab=WL97}
N 5640 19440 5660 19440 {}
C {lab_pin.sym} 5660 19440 0 0 {name=l15664 lab=VDD}
N 5640 19360 5660 19360 {}
C {lab_pin.sym} 5660 19360 0 0 {name=l15665 lab=VSS}
C {bitcell_6t.sym} 5800 19400 0 0 {name=Xr97c29}
N 5760 19440 5740 19440 {}
C {lab_pin.sym} 5740 19440 0 0 {name=l15666 lab=BL29}
N 5760 19400 5740 19400 {}
C {lab_pin.sym} 5740 19400 0 0 {name=l15667 lab=BLB29}
N 5760 19360 5740 19360 {}
C {lab_pin.sym} 5740 19360 0 0 {name=l15668 lab=WL97}
N 5840 19440 5860 19440 {}
C {lab_pin.sym} 5860 19440 0 0 {name=l15669 lab=VDD}
N 5840 19360 5860 19360 {}
C {lab_pin.sym} 5860 19360 0 0 {name=l15670 lab=VSS}
C {bitcell_6t.sym} 6000 19400 0 0 {name=Xr97c30}
N 5960 19440 5940 19440 {}
C {lab_pin.sym} 5940 19440 0 0 {name=l15671 lab=BL30}
N 5960 19400 5940 19400 {}
C {lab_pin.sym} 5940 19400 0 0 {name=l15672 lab=BLB30}
N 5960 19360 5940 19360 {}
C {lab_pin.sym} 5940 19360 0 0 {name=l15673 lab=WL97}
N 6040 19440 6060 19440 {}
C {lab_pin.sym} 6060 19440 0 0 {name=l15674 lab=VDD}
N 6040 19360 6060 19360 {}
C {lab_pin.sym} 6060 19360 0 0 {name=l15675 lab=VSS}
C {bitcell_6t.sym} 6200 19400 0 0 {name=Xr97c31}
N 6160 19440 6140 19440 {}
C {lab_pin.sym} 6140 19440 0 0 {name=l15676 lab=BL31}
N 6160 19400 6140 19400 {}
C {lab_pin.sym} 6140 19400 0 0 {name=l15677 lab=BLB31}
N 6160 19360 6140 19360 {}
C {lab_pin.sym} 6140 19360 0 0 {name=l15678 lab=WL97}
N 6240 19440 6260 19440 {}
C {lab_pin.sym} 6260 19440 0 0 {name=l15679 lab=VDD}
N 6240 19360 6260 19360 {}
C {lab_pin.sym} 6260 19360 0 0 {name=l15680 lab=VSS}
C {bitcell_6t.sym} 0 19600 0 0 {name=Xr98c0}
N -40 19640 -60 19640 {}
C {lab_pin.sym} -60 19640 0 0 {name=l15681 lab=BL0}
N -40 19600 -60 19600 {}
C {lab_pin.sym} -60 19600 0 0 {name=l15682 lab=BLB0}
N -40 19560 -60 19560 {}
C {lab_pin.sym} -60 19560 0 0 {name=l15683 lab=WL98}
N 40 19640 60 19640 {}
C {lab_pin.sym} 60 19640 0 0 {name=l15684 lab=VDD}
N 40 19560 60 19560 {}
C {lab_pin.sym} 60 19560 0 0 {name=l15685 lab=VSS}
C {bitcell_6t.sym} 200 19600 0 0 {name=Xr98c1}
N 160 19640 140 19640 {}
C {lab_pin.sym} 140 19640 0 0 {name=l15686 lab=BL1}
N 160 19600 140 19600 {}
C {lab_pin.sym} 140 19600 0 0 {name=l15687 lab=BLB1}
N 160 19560 140 19560 {}
C {lab_pin.sym} 140 19560 0 0 {name=l15688 lab=WL98}
N 240 19640 260 19640 {}
C {lab_pin.sym} 260 19640 0 0 {name=l15689 lab=VDD}
N 240 19560 260 19560 {}
C {lab_pin.sym} 260 19560 0 0 {name=l15690 lab=VSS}
C {bitcell_6t.sym} 400 19600 0 0 {name=Xr98c2}
N 360 19640 340 19640 {}
C {lab_pin.sym} 340 19640 0 0 {name=l15691 lab=BL2}
N 360 19600 340 19600 {}
C {lab_pin.sym} 340 19600 0 0 {name=l15692 lab=BLB2}
N 360 19560 340 19560 {}
C {lab_pin.sym} 340 19560 0 0 {name=l15693 lab=WL98}
N 440 19640 460 19640 {}
C {lab_pin.sym} 460 19640 0 0 {name=l15694 lab=VDD}
N 440 19560 460 19560 {}
C {lab_pin.sym} 460 19560 0 0 {name=l15695 lab=VSS}
C {bitcell_6t.sym} 600 19600 0 0 {name=Xr98c3}
N 560 19640 540 19640 {}
C {lab_pin.sym} 540 19640 0 0 {name=l15696 lab=BL3}
N 560 19600 540 19600 {}
C {lab_pin.sym} 540 19600 0 0 {name=l15697 lab=BLB3}
N 560 19560 540 19560 {}
C {lab_pin.sym} 540 19560 0 0 {name=l15698 lab=WL98}
N 640 19640 660 19640 {}
C {lab_pin.sym} 660 19640 0 0 {name=l15699 lab=VDD}
N 640 19560 660 19560 {}
C {lab_pin.sym} 660 19560 0 0 {name=l15700 lab=VSS}
C {bitcell_6t.sym} 800 19600 0 0 {name=Xr98c4}
N 760 19640 740 19640 {}
C {lab_pin.sym} 740 19640 0 0 {name=l15701 lab=BL4}
N 760 19600 740 19600 {}
C {lab_pin.sym} 740 19600 0 0 {name=l15702 lab=BLB4}
N 760 19560 740 19560 {}
C {lab_pin.sym} 740 19560 0 0 {name=l15703 lab=WL98}
N 840 19640 860 19640 {}
C {lab_pin.sym} 860 19640 0 0 {name=l15704 lab=VDD}
N 840 19560 860 19560 {}
C {lab_pin.sym} 860 19560 0 0 {name=l15705 lab=VSS}
C {bitcell_6t.sym} 1000 19600 0 0 {name=Xr98c5}
N 960 19640 940 19640 {}
C {lab_pin.sym} 940 19640 0 0 {name=l15706 lab=BL5}
N 960 19600 940 19600 {}
C {lab_pin.sym} 940 19600 0 0 {name=l15707 lab=BLB5}
N 960 19560 940 19560 {}
C {lab_pin.sym} 940 19560 0 0 {name=l15708 lab=WL98}
N 1040 19640 1060 19640 {}
C {lab_pin.sym} 1060 19640 0 0 {name=l15709 lab=VDD}
N 1040 19560 1060 19560 {}
C {lab_pin.sym} 1060 19560 0 0 {name=l15710 lab=VSS}
C {bitcell_6t.sym} 1200 19600 0 0 {name=Xr98c6}
N 1160 19640 1140 19640 {}
C {lab_pin.sym} 1140 19640 0 0 {name=l15711 lab=BL6}
N 1160 19600 1140 19600 {}
C {lab_pin.sym} 1140 19600 0 0 {name=l15712 lab=BLB6}
N 1160 19560 1140 19560 {}
C {lab_pin.sym} 1140 19560 0 0 {name=l15713 lab=WL98}
N 1240 19640 1260 19640 {}
C {lab_pin.sym} 1260 19640 0 0 {name=l15714 lab=VDD}
N 1240 19560 1260 19560 {}
C {lab_pin.sym} 1260 19560 0 0 {name=l15715 lab=VSS}
C {bitcell_6t.sym} 1400 19600 0 0 {name=Xr98c7}
N 1360 19640 1340 19640 {}
C {lab_pin.sym} 1340 19640 0 0 {name=l15716 lab=BL7}
N 1360 19600 1340 19600 {}
C {lab_pin.sym} 1340 19600 0 0 {name=l15717 lab=BLB7}
N 1360 19560 1340 19560 {}
C {lab_pin.sym} 1340 19560 0 0 {name=l15718 lab=WL98}
N 1440 19640 1460 19640 {}
C {lab_pin.sym} 1460 19640 0 0 {name=l15719 lab=VDD}
N 1440 19560 1460 19560 {}
C {lab_pin.sym} 1460 19560 0 0 {name=l15720 lab=VSS}
C {bitcell_6t.sym} 1600 19600 0 0 {name=Xr98c8}
N 1560 19640 1540 19640 {}
C {lab_pin.sym} 1540 19640 0 0 {name=l15721 lab=BL8}
N 1560 19600 1540 19600 {}
C {lab_pin.sym} 1540 19600 0 0 {name=l15722 lab=BLB8}
N 1560 19560 1540 19560 {}
C {lab_pin.sym} 1540 19560 0 0 {name=l15723 lab=WL98}
N 1640 19640 1660 19640 {}
C {lab_pin.sym} 1660 19640 0 0 {name=l15724 lab=VDD}
N 1640 19560 1660 19560 {}
C {lab_pin.sym} 1660 19560 0 0 {name=l15725 lab=VSS}
C {bitcell_6t.sym} 1800 19600 0 0 {name=Xr98c9}
N 1760 19640 1740 19640 {}
C {lab_pin.sym} 1740 19640 0 0 {name=l15726 lab=BL9}
N 1760 19600 1740 19600 {}
C {lab_pin.sym} 1740 19600 0 0 {name=l15727 lab=BLB9}
N 1760 19560 1740 19560 {}
C {lab_pin.sym} 1740 19560 0 0 {name=l15728 lab=WL98}
N 1840 19640 1860 19640 {}
C {lab_pin.sym} 1860 19640 0 0 {name=l15729 lab=VDD}
N 1840 19560 1860 19560 {}
C {lab_pin.sym} 1860 19560 0 0 {name=l15730 lab=VSS}
C {bitcell_6t.sym} 2000 19600 0 0 {name=Xr98c10}
N 1960 19640 1940 19640 {}
C {lab_pin.sym} 1940 19640 0 0 {name=l15731 lab=BL10}
N 1960 19600 1940 19600 {}
C {lab_pin.sym} 1940 19600 0 0 {name=l15732 lab=BLB10}
N 1960 19560 1940 19560 {}
C {lab_pin.sym} 1940 19560 0 0 {name=l15733 lab=WL98}
N 2040 19640 2060 19640 {}
C {lab_pin.sym} 2060 19640 0 0 {name=l15734 lab=VDD}
N 2040 19560 2060 19560 {}
C {lab_pin.sym} 2060 19560 0 0 {name=l15735 lab=VSS}
C {bitcell_6t.sym} 2200 19600 0 0 {name=Xr98c11}
N 2160 19640 2140 19640 {}
C {lab_pin.sym} 2140 19640 0 0 {name=l15736 lab=BL11}
N 2160 19600 2140 19600 {}
C {lab_pin.sym} 2140 19600 0 0 {name=l15737 lab=BLB11}
N 2160 19560 2140 19560 {}
C {lab_pin.sym} 2140 19560 0 0 {name=l15738 lab=WL98}
N 2240 19640 2260 19640 {}
C {lab_pin.sym} 2260 19640 0 0 {name=l15739 lab=VDD}
N 2240 19560 2260 19560 {}
C {lab_pin.sym} 2260 19560 0 0 {name=l15740 lab=VSS}
C {bitcell_6t.sym} 2400 19600 0 0 {name=Xr98c12}
N 2360 19640 2340 19640 {}
C {lab_pin.sym} 2340 19640 0 0 {name=l15741 lab=BL12}
N 2360 19600 2340 19600 {}
C {lab_pin.sym} 2340 19600 0 0 {name=l15742 lab=BLB12}
N 2360 19560 2340 19560 {}
C {lab_pin.sym} 2340 19560 0 0 {name=l15743 lab=WL98}
N 2440 19640 2460 19640 {}
C {lab_pin.sym} 2460 19640 0 0 {name=l15744 lab=VDD}
N 2440 19560 2460 19560 {}
C {lab_pin.sym} 2460 19560 0 0 {name=l15745 lab=VSS}
C {bitcell_6t.sym} 2600 19600 0 0 {name=Xr98c13}
N 2560 19640 2540 19640 {}
C {lab_pin.sym} 2540 19640 0 0 {name=l15746 lab=BL13}
N 2560 19600 2540 19600 {}
C {lab_pin.sym} 2540 19600 0 0 {name=l15747 lab=BLB13}
N 2560 19560 2540 19560 {}
C {lab_pin.sym} 2540 19560 0 0 {name=l15748 lab=WL98}
N 2640 19640 2660 19640 {}
C {lab_pin.sym} 2660 19640 0 0 {name=l15749 lab=VDD}
N 2640 19560 2660 19560 {}
C {lab_pin.sym} 2660 19560 0 0 {name=l15750 lab=VSS}
C {bitcell_6t.sym} 2800 19600 0 0 {name=Xr98c14}
N 2760 19640 2740 19640 {}
C {lab_pin.sym} 2740 19640 0 0 {name=l15751 lab=BL14}
N 2760 19600 2740 19600 {}
C {lab_pin.sym} 2740 19600 0 0 {name=l15752 lab=BLB14}
N 2760 19560 2740 19560 {}
C {lab_pin.sym} 2740 19560 0 0 {name=l15753 lab=WL98}
N 2840 19640 2860 19640 {}
C {lab_pin.sym} 2860 19640 0 0 {name=l15754 lab=VDD}
N 2840 19560 2860 19560 {}
C {lab_pin.sym} 2860 19560 0 0 {name=l15755 lab=VSS}
C {bitcell_6t.sym} 3000 19600 0 0 {name=Xr98c15}
N 2960 19640 2940 19640 {}
C {lab_pin.sym} 2940 19640 0 0 {name=l15756 lab=BL15}
N 2960 19600 2940 19600 {}
C {lab_pin.sym} 2940 19600 0 0 {name=l15757 lab=BLB15}
N 2960 19560 2940 19560 {}
C {lab_pin.sym} 2940 19560 0 0 {name=l15758 lab=WL98}
N 3040 19640 3060 19640 {}
C {lab_pin.sym} 3060 19640 0 0 {name=l15759 lab=VDD}
N 3040 19560 3060 19560 {}
C {lab_pin.sym} 3060 19560 0 0 {name=l15760 lab=VSS}
C {bitcell_6t.sym} 3200 19600 0 0 {name=Xr98c16}
N 3160 19640 3140 19640 {}
C {lab_pin.sym} 3140 19640 0 0 {name=l15761 lab=BL16}
N 3160 19600 3140 19600 {}
C {lab_pin.sym} 3140 19600 0 0 {name=l15762 lab=BLB16}
N 3160 19560 3140 19560 {}
C {lab_pin.sym} 3140 19560 0 0 {name=l15763 lab=WL98}
N 3240 19640 3260 19640 {}
C {lab_pin.sym} 3260 19640 0 0 {name=l15764 lab=VDD}
N 3240 19560 3260 19560 {}
C {lab_pin.sym} 3260 19560 0 0 {name=l15765 lab=VSS}
C {bitcell_6t.sym} 3400 19600 0 0 {name=Xr98c17}
N 3360 19640 3340 19640 {}
C {lab_pin.sym} 3340 19640 0 0 {name=l15766 lab=BL17}
N 3360 19600 3340 19600 {}
C {lab_pin.sym} 3340 19600 0 0 {name=l15767 lab=BLB17}
N 3360 19560 3340 19560 {}
C {lab_pin.sym} 3340 19560 0 0 {name=l15768 lab=WL98}
N 3440 19640 3460 19640 {}
C {lab_pin.sym} 3460 19640 0 0 {name=l15769 lab=VDD}
N 3440 19560 3460 19560 {}
C {lab_pin.sym} 3460 19560 0 0 {name=l15770 lab=VSS}
C {bitcell_6t.sym} 3600 19600 0 0 {name=Xr98c18}
N 3560 19640 3540 19640 {}
C {lab_pin.sym} 3540 19640 0 0 {name=l15771 lab=BL18}
N 3560 19600 3540 19600 {}
C {lab_pin.sym} 3540 19600 0 0 {name=l15772 lab=BLB18}
N 3560 19560 3540 19560 {}
C {lab_pin.sym} 3540 19560 0 0 {name=l15773 lab=WL98}
N 3640 19640 3660 19640 {}
C {lab_pin.sym} 3660 19640 0 0 {name=l15774 lab=VDD}
N 3640 19560 3660 19560 {}
C {lab_pin.sym} 3660 19560 0 0 {name=l15775 lab=VSS}
C {bitcell_6t.sym} 3800 19600 0 0 {name=Xr98c19}
N 3760 19640 3740 19640 {}
C {lab_pin.sym} 3740 19640 0 0 {name=l15776 lab=BL19}
N 3760 19600 3740 19600 {}
C {lab_pin.sym} 3740 19600 0 0 {name=l15777 lab=BLB19}
N 3760 19560 3740 19560 {}
C {lab_pin.sym} 3740 19560 0 0 {name=l15778 lab=WL98}
N 3840 19640 3860 19640 {}
C {lab_pin.sym} 3860 19640 0 0 {name=l15779 lab=VDD}
N 3840 19560 3860 19560 {}
C {lab_pin.sym} 3860 19560 0 0 {name=l15780 lab=VSS}
C {bitcell_6t.sym} 4000 19600 0 0 {name=Xr98c20}
N 3960 19640 3940 19640 {}
C {lab_pin.sym} 3940 19640 0 0 {name=l15781 lab=BL20}
N 3960 19600 3940 19600 {}
C {lab_pin.sym} 3940 19600 0 0 {name=l15782 lab=BLB20}
N 3960 19560 3940 19560 {}
C {lab_pin.sym} 3940 19560 0 0 {name=l15783 lab=WL98}
N 4040 19640 4060 19640 {}
C {lab_pin.sym} 4060 19640 0 0 {name=l15784 lab=VDD}
N 4040 19560 4060 19560 {}
C {lab_pin.sym} 4060 19560 0 0 {name=l15785 lab=VSS}
C {bitcell_6t.sym} 4200 19600 0 0 {name=Xr98c21}
N 4160 19640 4140 19640 {}
C {lab_pin.sym} 4140 19640 0 0 {name=l15786 lab=BL21}
N 4160 19600 4140 19600 {}
C {lab_pin.sym} 4140 19600 0 0 {name=l15787 lab=BLB21}
N 4160 19560 4140 19560 {}
C {lab_pin.sym} 4140 19560 0 0 {name=l15788 lab=WL98}
N 4240 19640 4260 19640 {}
C {lab_pin.sym} 4260 19640 0 0 {name=l15789 lab=VDD}
N 4240 19560 4260 19560 {}
C {lab_pin.sym} 4260 19560 0 0 {name=l15790 lab=VSS}
C {bitcell_6t.sym} 4400 19600 0 0 {name=Xr98c22}
N 4360 19640 4340 19640 {}
C {lab_pin.sym} 4340 19640 0 0 {name=l15791 lab=BL22}
N 4360 19600 4340 19600 {}
C {lab_pin.sym} 4340 19600 0 0 {name=l15792 lab=BLB22}
N 4360 19560 4340 19560 {}
C {lab_pin.sym} 4340 19560 0 0 {name=l15793 lab=WL98}
N 4440 19640 4460 19640 {}
C {lab_pin.sym} 4460 19640 0 0 {name=l15794 lab=VDD}
N 4440 19560 4460 19560 {}
C {lab_pin.sym} 4460 19560 0 0 {name=l15795 lab=VSS}
C {bitcell_6t.sym} 4600 19600 0 0 {name=Xr98c23}
N 4560 19640 4540 19640 {}
C {lab_pin.sym} 4540 19640 0 0 {name=l15796 lab=BL23}
N 4560 19600 4540 19600 {}
C {lab_pin.sym} 4540 19600 0 0 {name=l15797 lab=BLB23}
N 4560 19560 4540 19560 {}
C {lab_pin.sym} 4540 19560 0 0 {name=l15798 lab=WL98}
N 4640 19640 4660 19640 {}
C {lab_pin.sym} 4660 19640 0 0 {name=l15799 lab=VDD}
N 4640 19560 4660 19560 {}
C {lab_pin.sym} 4660 19560 0 0 {name=l15800 lab=VSS}
C {bitcell_6t.sym} 4800 19600 0 0 {name=Xr98c24}
N 4760 19640 4740 19640 {}
C {lab_pin.sym} 4740 19640 0 0 {name=l15801 lab=BL24}
N 4760 19600 4740 19600 {}
C {lab_pin.sym} 4740 19600 0 0 {name=l15802 lab=BLB24}
N 4760 19560 4740 19560 {}
C {lab_pin.sym} 4740 19560 0 0 {name=l15803 lab=WL98}
N 4840 19640 4860 19640 {}
C {lab_pin.sym} 4860 19640 0 0 {name=l15804 lab=VDD}
N 4840 19560 4860 19560 {}
C {lab_pin.sym} 4860 19560 0 0 {name=l15805 lab=VSS}
C {bitcell_6t.sym} 5000 19600 0 0 {name=Xr98c25}
N 4960 19640 4940 19640 {}
C {lab_pin.sym} 4940 19640 0 0 {name=l15806 lab=BL25}
N 4960 19600 4940 19600 {}
C {lab_pin.sym} 4940 19600 0 0 {name=l15807 lab=BLB25}
N 4960 19560 4940 19560 {}
C {lab_pin.sym} 4940 19560 0 0 {name=l15808 lab=WL98}
N 5040 19640 5060 19640 {}
C {lab_pin.sym} 5060 19640 0 0 {name=l15809 lab=VDD}
N 5040 19560 5060 19560 {}
C {lab_pin.sym} 5060 19560 0 0 {name=l15810 lab=VSS}
C {bitcell_6t.sym} 5200 19600 0 0 {name=Xr98c26}
N 5160 19640 5140 19640 {}
C {lab_pin.sym} 5140 19640 0 0 {name=l15811 lab=BL26}
N 5160 19600 5140 19600 {}
C {lab_pin.sym} 5140 19600 0 0 {name=l15812 lab=BLB26}
N 5160 19560 5140 19560 {}
C {lab_pin.sym} 5140 19560 0 0 {name=l15813 lab=WL98}
N 5240 19640 5260 19640 {}
C {lab_pin.sym} 5260 19640 0 0 {name=l15814 lab=VDD}
N 5240 19560 5260 19560 {}
C {lab_pin.sym} 5260 19560 0 0 {name=l15815 lab=VSS}
C {bitcell_6t.sym} 5400 19600 0 0 {name=Xr98c27}
N 5360 19640 5340 19640 {}
C {lab_pin.sym} 5340 19640 0 0 {name=l15816 lab=BL27}
N 5360 19600 5340 19600 {}
C {lab_pin.sym} 5340 19600 0 0 {name=l15817 lab=BLB27}
N 5360 19560 5340 19560 {}
C {lab_pin.sym} 5340 19560 0 0 {name=l15818 lab=WL98}
N 5440 19640 5460 19640 {}
C {lab_pin.sym} 5460 19640 0 0 {name=l15819 lab=VDD}
N 5440 19560 5460 19560 {}
C {lab_pin.sym} 5460 19560 0 0 {name=l15820 lab=VSS}
C {bitcell_6t.sym} 5600 19600 0 0 {name=Xr98c28}
N 5560 19640 5540 19640 {}
C {lab_pin.sym} 5540 19640 0 0 {name=l15821 lab=BL28}
N 5560 19600 5540 19600 {}
C {lab_pin.sym} 5540 19600 0 0 {name=l15822 lab=BLB28}
N 5560 19560 5540 19560 {}
C {lab_pin.sym} 5540 19560 0 0 {name=l15823 lab=WL98}
N 5640 19640 5660 19640 {}
C {lab_pin.sym} 5660 19640 0 0 {name=l15824 lab=VDD}
N 5640 19560 5660 19560 {}
C {lab_pin.sym} 5660 19560 0 0 {name=l15825 lab=VSS}
C {bitcell_6t.sym} 5800 19600 0 0 {name=Xr98c29}
N 5760 19640 5740 19640 {}
C {lab_pin.sym} 5740 19640 0 0 {name=l15826 lab=BL29}
N 5760 19600 5740 19600 {}
C {lab_pin.sym} 5740 19600 0 0 {name=l15827 lab=BLB29}
N 5760 19560 5740 19560 {}
C {lab_pin.sym} 5740 19560 0 0 {name=l15828 lab=WL98}
N 5840 19640 5860 19640 {}
C {lab_pin.sym} 5860 19640 0 0 {name=l15829 lab=VDD}
N 5840 19560 5860 19560 {}
C {lab_pin.sym} 5860 19560 0 0 {name=l15830 lab=VSS}
C {bitcell_6t.sym} 6000 19600 0 0 {name=Xr98c30}
N 5960 19640 5940 19640 {}
C {lab_pin.sym} 5940 19640 0 0 {name=l15831 lab=BL30}
N 5960 19600 5940 19600 {}
C {lab_pin.sym} 5940 19600 0 0 {name=l15832 lab=BLB30}
N 5960 19560 5940 19560 {}
C {lab_pin.sym} 5940 19560 0 0 {name=l15833 lab=WL98}
N 6040 19640 6060 19640 {}
C {lab_pin.sym} 6060 19640 0 0 {name=l15834 lab=VDD}
N 6040 19560 6060 19560 {}
C {lab_pin.sym} 6060 19560 0 0 {name=l15835 lab=VSS}
C {bitcell_6t.sym} 6200 19600 0 0 {name=Xr98c31}
N 6160 19640 6140 19640 {}
C {lab_pin.sym} 6140 19640 0 0 {name=l15836 lab=BL31}
N 6160 19600 6140 19600 {}
C {lab_pin.sym} 6140 19600 0 0 {name=l15837 lab=BLB31}
N 6160 19560 6140 19560 {}
C {lab_pin.sym} 6140 19560 0 0 {name=l15838 lab=WL98}
N 6240 19640 6260 19640 {}
C {lab_pin.sym} 6260 19640 0 0 {name=l15839 lab=VDD}
N 6240 19560 6260 19560 {}
C {lab_pin.sym} 6260 19560 0 0 {name=l15840 lab=VSS}
C {bitcell_6t.sym} 0 19800 0 0 {name=Xr99c0}
N -40 19840 -60 19840 {}
C {lab_pin.sym} -60 19840 0 0 {name=l15841 lab=BL0}
N -40 19800 -60 19800 {}
C {lab_pin.sym} -60 19800 0 0 {name=l15842 lab=BLB0}
N -40 19760 -60 19760 {}
C {lab_pin.sym} -60 19760 0 0 {name=l15843 lab=WL99}
N 40 19840 60 19840 {}
C {lab_pin.sym} 60 19840 0 0 {name=l15844 lab=VDD}
N 40 19760 60 19760 {}
C {lab_pin.sym} 60 19760 0 0 {name=l15845 lab=VSS}
C {bitcell_6t.sym} 200 19800 0 0 {name=Xr99c1}
N 160 19840 140 19840 {}
C {lab_pin.sym} 140 19840 0 0 {name=l15846 lab=BL1}
N 160 19800 140 19800 {}
C {lab_pin.sym} 140 19800 0 0 {name=l15847 lab=BLB1}
N 160 19760 140 19760 {}
C {lab_pin.sym} 140 19760 0 0 {name=l15848 lab=WL99}
N 240 19840 260 19840 {}
C {lab_pin.sym} 260 19840 0 0 {name=l15849 lab=VDD}
N 240 19760 260 19760 {}
C {lab_pin.sym} 260 19760 0 0 {name=l15850 lab=VSS}
C {bitcell_6t.sym} 400 19800 0 0 {name=Xr99c2}
N 360 19840 340 19840 {}
C {lab_pin.sym} 340 19840 0 0 {name=l15851 lab=BL2}
N 360 19800 340 19800 {}
C {lab_pin.sym} 340 19800 0 0 {name=l15852 lab=BLB2}
N 360 19760 340 19760 {}
C {lab_pin.sym} 340 19760 0 0 {name=l15853 lab=WL99}
N 440 19840 460 19840 {}
C {lab_pin.sym} 460 19840 0 0 {name=l15854 lab=VDD}
N 440 19760 460 19760 {}
C {lab_pin.sym} 460 19760 0 0 {name=l15855 lab=VSS}
C {bitcell_6t.sym} 600 19800 0 0 {name=Xr99c3}
N 560 19840 540 19840 {}
C {lab_pin.sym} 540 19840 0 0 {name=l15856 lab=BL3}
N 560 19800 540 19800 {}
C {lab_pin.sym} 540 19800 0 0 {name=l15857 lab=BLB3}
N 560 19760 540 19760 {}
C {lab_pin.sym} 540 19760 0 0 {name=l15858 lab=WL99}
N 640 19840 660 19840 {}
C {lab_pin.sym} 660 19840 0 0 {name=l15859 lab=VDD}
N 640 19760 660 19760 {}
C {lab_pin.sym} 660 19760 0 0 {name=l15860 lab=VSS}
C {bitcell_6t.sym} 800 19800 0 0 {name=Xr99c4}
N 760 19840 740 19840 {}
C {lab_pin.sym} 740 19840 0 0 {name=l15861 lab=BL4}
N 760 19800 740 19800 {}
C {lab_pin.sym} 740 19800 0 0 {name=l15862 lab=BLB4}
N 760 19760 740 19760 {}
C {lab_pin.sym} 740 19760 0 0 {name=l15863 lab=WL99}
N 840 19840 860 19840 {}
C {lab_pin.sym} 860 19840 0 0 {name=l15864 lab=VDD}
N 840 19760 860 19760 {}
C {lab_pin.sym} 860 19760 0 0 {name=l15865 lab=VSS}
C {bitcell_6t.sym} 1000 19800 0 0 {name=Xr99c5}
N 960 19840 940 19840 {}
C {lab_pin.sym} 940 19840 0 0 {name=l15866 lab=BL5}
N 960 19800 940 19800 {}
C {lab_pin.sym} 940 19800 0 0 {name=l15867 lab=BLB5}
N 960 19760 940 19760 {}
C {lab_pin.sym} 940 19760 0 0 {name=l15868 lab=WL99}
N 1040 19840 1060 19840 {}
C {lab_pin.sym} 1060 19840 0 0 {name=l15869 lab=VDD}
N 1040 19760 1060 19760 {}
C {lab_pin.sym} 1060 19760 0 0 {name=l15870 lab=VSS}
C {bitcell_6t.sym} 1200 19800 0 0 {name=Xr99c6}
N 1160 19840 1140 19840 {}
C {lab_pin.sym} 1140 19840 0 0 {name=l15871 lab=BL6}
N 1160 19800 1140 19800 {}
C {lab_pin.sym} 1140 19800 0 0 {name=l15872 lab=BLB6}
N 1160 19760 1140 19760 {}
C {lab_pin.sym} 1140 19760 0 0 {name=l15873 lab=WL99}
N 1240 19840 1260 19840 {}
C {lab_pin.sym} 1260 19840 0 0 {name=l15874 lab=VDD}
N 1240 19760 1260 19760 {}
C {lab_pin.sym} 1260 19760 0 0 {name=l15875 lab=VSS}
C {bitcell_6t.sym} 1400 19800 0 0 {name=Xr99c7}
N 1360 19840 1340 19840 {}
C {lab_pin.sym} 1340 19840 0 0 {name=l15876 lab=BL7}
N 1360 19800 1340 19800 {}
C {lab_pin.sym} 1340 19800 0 0 {name=l15877 lab=BLB7}
N 1360 19760 1340 19760 {}
C {lab_pin.sym} 1340 19760 0 0 {name=l15878 lab=WL99}
N 1440 19840 1460 19840 {}
C {lab_pin.sym} 1460 19840 0 0 {name=l15879 lab=VDD}
N 1440 19760 1460 19760 {}
C {lab_pin.sym} 1460 19760 0 0 {name=l15880 lab=VSS}
C {bitcell_6t.sym} 1600 19800 0 0 {name=Xr99c8}
N 1560 19840 1540 19840 {}
C {lab_pin.sym} 1540 19840 0 0 {name=l15881 lab=BL8}
N 1560 19800 1540 19800 {}
C {lab_pin.sym} 1540 19800 0 0 {name=l15882 lab=BLB8}
N 1560 19760 1540 19760 {}
C {lab_pin.sym} 1540 19760 0 0 {name=l15883 lab=WL99}
N 1640 19840 1660 19840 {}
C {lab_pin.sym} 1660 19840 0 0 {name=l15884 lab=VDD}
N 1640 19760 1660 19760 {}
C {lab_pin.sym} 1660 19760 0 0 {name=l15885 lab=VSS}
C {bitcell_6t.sym} 1800 19800 0 0 {name=Xr99c9}
N 1760 19840 1740 19840 {}
C {lab_pin.sym} 1740 19840 0 0 {name=l15886 lab=BL9}
N 1760 19800 1740 19800 {}
C {lab_pin.sym} 1740 19800 0 0 {name=l15887 lab=BLB9}
N 1760 19760 1740 19760 {}
C {lab_pin.sym} 1740 19760 0 0 {name=l15888 lab=WL99}
N 1840 19840 1860 19840 {}
C {lab_pin.sym} 1860 19840 0 0 {name=l15889 lab=VDD}
N 1840 19760 1860 19760 {}
C {lab_pin.sym} 1860 19760 0 0 {name=l15890 lab=VSS}
C {bitcell_6t.sym} 2000 19800 0 0 {name=Xr99c10}
N 1960 19840 1940 19840 {}
C {lab_pin.sym} 1940 19840 0 0 {name=l15891 lab=BL10}
N 1960 19800 1940 19800 {}
C {lab_pin.sym} 1940 19800 0 0 {name=l15892 lab=BLB10}
N 1960 19760 1940 19760 {}
C {lab_pin.sym} 1940 19760 0 0 {name=l15893 lab=WL99}
N 2040 19840 2060 19840 {}
C {lab_pin.sym} 2060 19840 0 0 {name=l15894 lab=VDD}
N 2040 19760 2060 19760 {}
C {lab_pin.sym} 2060 19760 0 0 {name=l15895 lab=VSS}
C {bitcell_6t.sym} 2200 19800 0 0 {name=Xr99c11}
N 2160 19840 2140 19840 {}
C {lab_pin.sym} 2140 19840 0 0 {name=l15896 lab=BL11}
N 2160 19800 2140 19800 {}
C {lab_pin.sym} 2140 19800 0 0 {name=l15897 lab=BLB11}
N 2160 19760 2140 19760 {}
C {lab_pin.sym} 2140 19760 0 0 {name=l15898 lab=WL99}
N 2240 19840 2260 19840 {}
C {lab_pin.sym} 2260 19840 0 0 {name=l15899 lab=VDD}
N 2240 19760 2260 19760 {}
C {lab_pin.sym} 2260 19760 0 0 {name=l15900 lab=VSS}
C {bitcell_6t.sym} 2400 19800 0 0 {name=Xr99c12}
N 2360 19840 2340 19840 {}
C {lab_pin.sym} 2340 19840 0 0 {name=l15901 lab=BL12}
N 2360 19800 2340 19800 {}
C {lab_pin.sym} 2340 19800 0 0 {name=l15902 lab=BLB12}
N 2360 19760 2340 19760 {}
C {lab_pin.sym} 2340 19760 0 0 {name=l15903 lab=WL99}
N 2440 19840 2460 19840 {}
C {lab_pin.sym} 2460 19840 0 0 {name=l15904 lab=VDD}
N 2440 19760 2460 19760 {}
C {lab_pin.sym} 2460 19760 0 0 {name=l15905 lab=VSS}
C {bitcell_6t.sym} 2600 19800 0 0 {name=Xr99c13}
N 2560 19840 2540 19840 {}
C {lab_pin.sym} 2540 19840 0 0 {name=l15906 lab=BL13}
N 2560 19800 2540 19800 {}
C {lab_pin.sym} 2540 19800 0 0 {name=l15907 lab=BLB13}
N 2560 19760 2540 19760 {}
C {lab_pin.sym} 2540 19760 0 0 {name=l15908 lab=WL99}
N 2640 19840 2660 19840 {}
C {lab_pin.sym} 2660 19840 0 0 {name=l15909 lab=VDD}
N 2640 19760 2660 19760 {}
C {lab_pin.sym} 2660 19760 0 0 {name=l15910 lab=VSS}
C {bitcell_6t.sym} 2800 19800 0 0 {name=Xr99c14}
N 2760 19840 2740 19840 {}
C {lab_pin.sym} 2740 19840 0 0 {name=l15911 lab=BL14}
N 2760 19800 2740 19800 {}
C {lab_pin.sym} 2740 19800 0 0 {name=l15912 lab=BLB14}
N 2760 19760 2740 19760 {}
C {lab_pin.sym} 2740 19760 0 0 {name=l15913 lab=WL99}
N 2840 19840 2860 19840 {}
C {lab_pin.sym} 2860 19840 0 0 {name=l15914 lab=VDD}
N 2840 19760 2860 19760 {}
C {lab_pin.sym} 2860 19760 0 0 {name=l15915 lab=VSS}
C {bitcell_6t.sym} 3000 19800 0 0 {name=Xr99c15}
N 2960 19840 2940 19840 {}
C {lab_pin.sym} 2940 19840 0 0 {name=l15916 lab=BL15}
N 2960 19800 2940 19800 {}
C {lab_pin.sym} 2940 19800 0 0 {name=l15917 lab=BLB15}
N 2960 19760 2940 19760 {}
C {lab_pin.sym} 2940 19760 0 0 {name=l15918 lab=WL99}
N 3040 19840 3060 19840 {}
C {lab_pin.sym} 3060 19840 0 0 {name=l15919 lab=VDD}
N 3040 19760 3060 19760 {}
C {lab_pin.sym} 3060 19760 0 0 {name=l15920 lab=VSS}
C {bitcell_6t.sym} 3200 19800 0 0 {name=Xr99c16}
N 3160 19840 3140 19840 {}
C {lab_pin.sym} 3140 19840 0 0 {name=l15921 lab=BL16}
N 3160 19800 3140 19800 {}
C {lab_pin.sym} 3140 19800 0 0 {name=l15922 lab=BLB16}
N 3160 19760 3140 19760 {}
C {lab_pin.sym} 3140 19760 0 0 {name=l15923 lab=WL99}
N 3240 19840 3260 19840 {}
C {lab_pin.sym} 3260 19840 0 0 {name=l15924 lab=VDD}
N 3240 19760 3260 19760 {}
C {lab_pin.sym} 3260 19760 0 0 {name=l15925 lab=VSS}
C {bitcell_6t.sym} 3400 19800 0 0 {name=Xr99c17}
N 3360 19840 3340 19840 {}
C {lab_pin.sym} 3340 19840 0 0 {name=l15926 lab=BL17}
N 3360 19800 3340 19800 {}
C {lab_pin.sym} 3340 19800 0 0 {name=l15927 lab=BLB17}
N 3360 19760 3340 19760 {}
C {lab_pin.sym} 3340 19760 0 0 {name=l15928 lab=WL99}
N 3440 19840 3460 19840 {}
C {lab_pin.sym} 3460 19840 0 0 {name=l15929 lab=VDD}
N 3440 19760 3460 19760 {}
C {lab_pin.sym} 3460 19760 0 0 {name=l15930 lab=VSS}
C {bitcell_6t.sym} 3600 19800 0 0 {name=Xr99c18}
N 3560 19840 3540 19840 {}
C {lab_pin.sym} 3540 19840 0 0 {name=l15931 lab=BL18}
N 3560 19800 3540 19800 {}
C {lab_pin.sym} 3540 19800 0 0 {name=l15932 lab=BLB18}
N 3560 19760 3540 19760 {}
C {lab_pin.sym} 3540 19760 0 0 {name=l15933 lab=WL99}
N 3640 19840 3660 19840 {}
C {lab_pin.sym} 3660 19840 0 0 {name=l15934 lab=VDD}
N 3640 19760 3660 19760 {}
C {lab_pin.sym} 3660 19760 0 0 {name=l15935 lab=VSS}
C {bitcell_6t.sym} 3800 19800 0 0 {name=Xr99c19}
N 3760 19840 3740 19840 {}
C {lab_pin.sym} 3740 19840 0 0 {name=l15936 lab=BL19}
N 3760 19800 3740 19800 {}
C {lab_pin.sym} 3740 19800 0 0 {name=l15937 lab=BLB19}
N 3760 19760 3740 19760 {}
C {lab_pin.sym} 3740 19760 0 0 {name=l15938 lab=WL99}
N 3840 19840 3860 19840 {}
C {lab_pin.sym} 3860 19840 0 0 {name=l15939 lab=VDD}
N 3840 19760 3860 19760 {}
C {lab_pin.sym} 3860 19760 0 0 {name=l15940 lab=VSS}
C {bitcell_6t.sym} 4000 19800 0 0 {name=Xr99c20}
N 3960 19840 3940 19840 {}
C {lab_pin.sym} 3940 19840 0 0 {name=l15941 lab=BL20}
N 3960 19800 3940 19800 {}
C {lab_pin.sym} 3940 19800 0 0 {name=l15942 lab=BLB20}
N 3960 19760 3940 19760 {}
C {lab_pin.sym} 3940 19760 0 0 {name=l15943 lab=WL99}
N 4040 19840 4060 19840 {}
C {lab_pin.sym} 4060 19840 0 0 {name=l15944 lab=VDD}
N 4040 19760 4060 19760 {}
C {lab_pin.sym} 4060 19760 0 0 {name=l15945 lab=VSS}
C {bitcell_6t.sym} 4200 19800 0 0 {name=Xr99c21}
N 4160 19840 4140 19840 {}
C {lab_pin.sym} 4140 19840 0 0 {name=l15946 lab=BL21}
N 4160 19800 4140 19800 {}
C {lab_pin.sym} 4140 19800 0 0 {name=l15947 lab=BLB21}
N 4160 19760 4140 19760 {}
C {lab_pin.sym} 4140 19760 0 0 {name=l15948 lab=WL99}
N 4240 19840 4260 19840 {}
C {lab_pin.sym} 4260 19840 0 0 {name=l15949 lab=VDD}
N 4240 19760 4260 19760 {}
C {lab_pin.sym} 4260 19760 0 0 {name=l15950 lab=VSS}
C {bitcell_6t.sym} 4400 19800 0 0 {name=Xr99c22}
N 4360 19840 4340 19840 {}
C {lab_pin.sym} 4340 19840 0 0 {name=l15951 lab=BL22}
N 4360 19800 4340 19800 {}
C {lab_pin.sym} 4340 19800 0 0 {name=l15952 lab=BLB22}
N 4360 19760 4340 19760 {}
C {lab_pin.sym} 4340 19760 0 0 {name=l15953 lab=WL99}
N 4440 19840 4460 19840 {}
C {lab_pin.sym} 4460 19840 0 0 {name=l15954 lab=VDD}
N 4440 19760 4460 19760 {}
C {lab_pin.sym} 4460 19760 0 0 {name=l15955 lab=VSS}
C {bitcell_6t.sym} 4600 19800 0 0 {name=Xr99c23}
N 4560 19840 4540 19840 {}
C {lab_pin.sym} 4540 19840 0 0 {name=l15956 lab=BL23}
N 4560 19800 4540 19800 {}
C {lab_pin.sym} 4540 19800 0 0 {name=l15957 lab=BLB23}
N 4560 19760 4540 19760 {}
C {lab_pin.sym} 4540 19760 0 0 {name=l15958 lab=WL99}
N 4640 19840 4660 19840 {}
C {lab_pin.sym} 4660 19840 0 0 {name=l15959 lab=VDD}
N 4640 19760 4660 19760 {}
C {lab_pin.sym} 4660 19760 0 0 {name=l15960 lab=VSS}
C {bitcell_6t.sym} 4800 19800 0 0 {name=Xr99c24}
N 4760 19840 4740 19840 {}
C {lab_pin.sym} 4740 19840 0 0 {name=l15961 lab=BL24}
N 4760 19800 4740 19800 {}
C {lab_pin.sym} 4740 19800 0 0 {name=l15962 lab=BLB24}
N 4760 19760 4740 19760 {}
C {lab_pin.sym} 4740 19760 0 0 {name=l15963 lab=WL99}
N 4840 19840 4860 19840 {}
C {lab_pin.sym} 4860 19840 0 0 {name=l15964 lab=VDD}
N 4840 19760 4860 19760 {}
C {lab_pin.sym} 4860 19760 0 0 {name=l15965 lab=VSS}
C {bitcell_6t.sym} 5000 19800 0 0 {name=Xr99c25}
N 4960 19840 4940 19840 {}
C {lab_pin.sym} 4940 19840 0 0 {name=l15966 lab=BL25}
N 4960 19800 4940 19800 {}
C {lab_pin.sym} 4940 19800 0 0 {name=l15967 lab=BLB25}
N 4960 19760 4940 19760 {}
C {lab_pin.sym} 4940 19760 0 0 {name=l15968 lab=WL99}
N 5040 19840 5060 19840 {}
C {lab_pin.sym} 5060 19840 0 0 {name=l15969 lab=VDD}
N 5040 19760 5060 19760 {}
C {lab_pin.sym} 5060 19760 0 0 {name=l15970 lab=VSS}
C {bitcell_6t.sym} 5200 19800 0 0 {name=Xr99c26}
N 5160 19840 5140 19840 {}
C {lab_pin.sym} 5140 19840 0 0 {name=l15971 lab=BL26}
N 5160 19800 5140 19800 {}
C {lab_pin.sym} 5140 19800 0 0 {name=l15972 lab=BLB26}
N 5160 19760 5140 19760 {}
C {lab_pin.sym} 5140 19760 0 0 {name=l15973 lab=WL99}
N 5240 19840 5260 19840 {}
C {lab_pin.sym} 5260 19840 0 0 {name=l15974 lab=VDD}
N 5240 19760 5260 19760 {}
C {lab_pin.sym} 5260 19760 0 0 {name=l15975 lab=VSS}
C {bitcell_6t.sym} 5400 19800 0 0 {name=Xr99c27}
N 5360 19840 5340 19840 {}
C {lab_pin.sym} 5340 19840 0 0 {name=l15976 lab=BL27}
N 5360 19800 5340 19800 {}
C {lab_pin.sym} 5340 19800 0 0 {name=l15977 lab=BLB27}
N 5360 19760 5340 19760 {}
C {lab_pin.sym} 5340 19760 0 0 {name=l15978 lab=WL99}
N 5440 19840 5460 19840 {}
C {lab_pin.sym} 5460 19840 0 0 {name=l15979 lab=VDD}
N 5440 19760 5460 19760 {}
C {lab_pin.sym} 5460 19760 0 0 {name=l15980 lab=VSS}
C {bitcell_6t.sym} 5600 19800 0 0 {name=Xr99c28}
N 5560 19840 5540 19840 {}
C {lab_pin.sym} 5540 19840 0 0 {name=l15981 lab=BL28}
N 5560 19800 5540 19800 {}
C {lab_pin.sym} 5540 19800 0 0 {name=l15982 lab=BLB28}
N 5560 19760 5540 19760 {}
C {lab_pin.sym} 5540 19760 0 0 {name=l15983 lab=WL99}
N 5640 19840 5660 19840 {}
C {lab_pin.sym} 5660 19840 0 0 {name=l15984 lab=VDD}
N 5640 19760 5660 19760 {}
C {lab_pin.sym} 5660 19760 0 0 {name=l15985 lab=VSS}
C {bitcell_6t.sym} 5800 19800 0 0 {name=Xr99c29}
N 5760 19840 5740 19840 {}
C {lab_pin.sym} 5740 19840 0 0 {name=l15986 lab=BL29}
N 5760 19800 5740 19800 {}
C {lab_pin.sym} 5740 19800 0 0 {name=l15987 lab=BLB29}
N 5760 19760 5740 19760 {}
C {lab_pin.sym} 5740 19760 0 0 {name=l15988 lab=WL99}
N 5840 19840 5860 19840 {}
C {lab_pin.sym} 5860 19840 0 0 {name=l15989 lab=VDD}
N 5840 19760 5860 19760 {}
C {lab_pin.sym} 5860 19760 0 0 {name=l15990 lab=VSS}
C {bitcell_6t.sym} 6000 19800 0 0 {name=Xr99c30}
N 5960 19840 5940 19840 {}
C {lab_pin.sym} 5940 19840 0 0 {name=l15991 lab=BL30}
N 5960 19800 5940 19800 {}
C {lab_pin.sym} 5940 19800 0 0 {name=l15992 lab=BLB30}
N 5960 19760 5940 19760 {}
C {lab_pin.sym} 5940 19760 0 0 {name=l15993 lab=WL99}
N 6040 19840 6060 19840 {}
C {lab_pin.sym} 6060 19840 0 0 {name=l15994 lab=VDD}
N 6040 19760 6060 19760 {}
C {lab_pin.sym} 6060 19760 0 0 {name=l15995 lab=VSS}
C {bitcell_6t.sym} 6200 19800 0 0 {name=Xr99c31}
N 6160 19840 6140 19840 {}
C {lab_pin.sym} 6140 19840 0 0 {name=l15996 lab=BL31}
N 6160 19800 6140 19800 {}
C {lab_pin.sym} 6140 19800 0 0 {name=l15997 lab=BLB31}
N 6160 19760 6140 19760 {}
C {lab_pin.sym} 6140 19760 0 0 {name=l15998 lab=WL99}
N 6240 19840 6260 19840 {}
C {lab_pin.sym} 6260 19840 0 0 {name=l15999 lab=VDD}
N 6240 19760 6260 19760 {}
C {lab_pin.sym} 6260 19760 0 0 {name=l16000 lab=VSS}
C {bitcell_6t.sym} 0 20000 0 0 {name=Xr100c0}
N -40 20040 -60 20040 {}
C {lab_pin.sym} -60 20040 0 0 {name=l16001 lab=BL0}
N -40 20000 -60 20000 {}
C {lab_pin.sym} -60 20000 0 0 {name=l16002 lab=BLB0}
N -40 19960 -60 19960 {}
C {lab_pin.sym} -60 19960 0 0 {name=l16003 lab=WL100}
N 40 20040 60 20040 {}
C {lab_pin.sym} 60 20040 0 0 {name=l16004 lab=VDD}
N 40 19960 60 19960 {}
C {lab_pin.sym} 60 19960 0 0 {name=l16005 lab=VSS}
C {bitcell_6t.sym} 200 20000 0 0 {name=Xr100c1}
N 160 20040 140 20040 {}
C {lab_pin.sym} 140 20040 0 0 {name=l16006 lab=BL1}
N 160 20000 140 20000 {}
C {lab_pin.sym} 140 20000 0 0 {name=l16007 lab=BLB1}
N 160 19960 140 19960 {}
C {lab_pin.sym} 140 19960 0 0 {name=l16008 lab=WL100}
N 240 20040 260 20040 {}
C {lab_pin.sym} 260 20040 0 0 {name=l16009 lab=VDD}
N 240 19960 260 19960 {}
C {lab_pin.sym} 260 19960 0 0 {name=l16010 lab=VSS}
C {bitcell_6t.sym} 400 20000 0 0 {name=Xr100c2}
N 360 20040 340 20040 {}
C {lab_pin.sym} 340 20040 0 0 {name=l16011 lab=BL2}
N 360 20000 340 20000 {}
C {lab_pin.sym} 340 20000 0 0 {name=l16012 lab=BLB2}
N 360 19960 340 19960 {}
C {lab_pin.sym} 340 19960 0 0 {name=l16013 lab=WL100}
N 440 20040 460 20040 {}
C {lab_pin.sym} 460 20040 0 0 {name=l16014 lab=VDD}
N 440 19960 460 19960 {}
C {lab_pin.sym} 460 19960 0 0 {name=l16015 lab=VSS}
C {bitcell_6t.sym} 600 20000 0 0 {name=Xr100c3}
N 560 20040 540 20040 {}
C {lab_pin.sym} 540 20040 0 0 {name=l16016 lab=BL3}
N 560 20000 540 20000 {}
C {lab_pin.sym} 540 20000 0 0 {name=l16017 lab=BLB3}
N 560 19960 540 19960 {}
C {lab_pin.sym} 540 19960 0 0 {name=l16018 lab=WL100}
N 640 20040 660 20040 {}
C {lab_pin.sym} 660 20040 0 0 {name=l16019 lab=VDD}
N 640 19960 660 19960 {}
C {lab_pin.sym} 660 19960 0 0 {name=l16020 lab=VSS}
C {bitcell_6t.sym} 800 20000 0 0 {name=Xr100c4}
N 760 20040 740 20040 {}
C {lab_pin.sym} 740 20040 0 0 {name=l16021 lab=BL4}
N 760 20000 740 20000 {}
C {lab_pin.sym} 740 20000 0 0 {name=l16022 lab=BLB4}
N 760 19960 740 19960 {}
C {lab_pin.sym} 740 19960 0 0 {name=l16023 lab=WL100}
N 840 20040 860 20040 {}
C {lab_pin.sym} 860 20040 0 0 {name=l16024 lab=VDD}
N 840 19960 860 19960 {}
C {lab_pin.sym} 860 19960 0 0 {name=l16025 lab=VSS}
C {bitcell_6t.sym} 1000 20000 0 0 {name=Xr100c5}
N 960 20040 940 20040 {}
C {lab_pin.sym} 940 20040 0 0 {name=l16026 lab=BL5}
N 960 20000 940 20000 {}
C {lab_pin.sym} 940 20000 0 0 {name=l16027 lab=BLB5}
N 960 19960 940 19960 {}
C {lab_pin.sym} 940 19960 0 0 {name=l16028 lab=WL100}
N 1040 20040 1060 20040 {}
C {lab_pin.sym} 1060 20040 0 0 {name=l16029 lab=VDD}
N 1040 19960 1060 19960 {}
C {lab_pin.sym} 1060 19960 0 0 {name=l16030 lab=VSS}
C {bitcell_6t.sym} 1200 20000 0 0 {name=Xr100c6}
N 1160 20040 1140 20040 {}
C {lab_pin.sym} 1140 20040 0 0 {name=l16031 lab=BL6}
N 1160 20000 1140 20000 {}
C {lab_pin.sym} 1140 20000 0 0 {name=l16032 lab=BLB6}
N 1160 19960 1140 19960 {}
C {lab_pin.sym} 1140 19960 0 0 {name=l16033 lab=WL100}
N 1240 20040 1260 20040 {}
C {lab_pin.sym} 1260 20040 0 0 {name=l16034 lab=VDD}
N 1240 19960 1260 19960 {}
C {lab_pin.sym} 1260 19960 0 0 {name=l16035 lab=VSS}
C {bitcell_6t.sym} 1400 20000 0 0 {name=Xr100c7}
N 1360 20040 1340 20040 {}
C {lab_pin.sym} 1340 20040 0 0 {name=l16036 lab=BL7}
N 1360 20000 1340 20000 {}
C {lab_pin.sym} 1340 20000 0 0 {name=l16037 lab=BLB7}
N 1360 19960 1340 19960 {}
C {lab_pin.sym} 1340 19960 0 0 {name=l16038 lab=WL100}
N 1440 20040 1460 20040 {}
C {lab_pin.sym} 1460 20040 0 0 {name=l16039 lab=VDD}
N 1440 19960 1460 19960 {}
C {lab_pin.sym} 1460 19960 0 0 {name=l16040 lab=VSS}
C {bitcell_6t.sym} 1600 20000 0 0 {name=Xr100c8}
N 1560 20040 1540 20040 {}
C {lab_pin.sym} 1540 20040 0 0 {name=l16041 lab=BL8}
N 1560 20000 1540 20000 {}
C {lab_pin.sym} 1540 20000 0 0 {name=l16042 lab=BLB8}
N 1560 19960 1540 19960 {}
C {lab_pin.sym} 1540 19960 0 0 {name=l16043 lab=WL100}
N 1640 20040 1660 20040 {}
C {lab_pin.sym} 1660 20040 0 0 {name=l16044 lab=VDD}
N 1640 19960 1660 19960 {}
C {lab_pin.sym} 1660 19960 0 0 {name=l16045 lab=VSS}
C {bitcell_6t.sym} 1800 20000 0 0 {name=Xr100c9}
N 1760 20040 1740 20040 {}
C {lab_pin.sym} 1740 20040 0 0 {name=l16046 lab=BL9}
N 1760 20000 1740 20000 {}
C {lab_pin.sym} 1740 20000 0 0 {name=l16047 lab=BLB9}
N 1760 19960 1740 19960 {}
C {lab_pin.sym} 1740 19960 0 0 {name=l16048 lab=WL100}
N 1840 20040 1860 20040 {}
C {lab_pin.sym} 1860 20040 0 0 {name=l16049 lab=VDD}
N 1840 19960 1860 19960 {}
C {lab_pin.sym} 1860 19960 0 0 {name=l16050 lab=VSS}
C {bitcell_6t.sym} 2000 20000 0 0 {name=Xr100c10}
N 1960 20040 1940 20040 {}
C {lab_pin.sym} 1940 20040 0 0 {name=l16051 lab=BL10}
N 1960 20000 1940 20000 {}
C {lab_pin.sym} 1940 20000 0 0 {name=l16052 lab=BLB10}
N 1960 19960 1940 19960 {}
C {lab_pin.sym} 1940 19960 0 0 {name=l16053 lab=WL100}
N 2040 20040 2060 20040 {}
C {lab_pin.sym} 2060 20040 0 0 {name=l16054 lab=VDD}
N 2040 19960 2060 19960 {}
C {lab_pin.sym} 2060 19960 0 0 {name=l16055 lab=VSS}
C {bitcell_6t.sym} 2200 20000 0 0 {name=Xr100c11}
N 2160 20040 2140 20040 {}
C {lab_pin.sym} 2140 20040 0 0 {name=l16056 lab=BL11}
N 2160 20000 2140 20000 {}
C {lab_pin.sym} 2140 20000 0 0 {name=l16057 lab=BLB11}
N 2160 19960 2140 19960 {}
C {lab_pin.sym} 2140 19960 0 0 {name=l16058 lab=WL100}
N 2240 20040 2260 20040 {}
C {lab_pin.sym} 2260 20040 0 0 {name=l16059 lab=VDD}
N 2240 19960 2260 19960 {}
C {lab_pin.sym} 2260 19960 0 0 {name=l16060 lab=VSS}
C {bitcell_6t.sym} 2400 20000 0 0 {name=Xr100c12}
N 2360 20040 2340 20040 {}
C {lab_pin.sym} 2340 20040 0 0 {name=l16061 lab=BL12}
N 2360 20000 2340 20000 {}
C {lab_pin.sym} 2340 20000 0 0 {name=l16062 lab=BLB12}
N 2360 19960 2340 19960 {}
C {lab_pin.sym} 2340 19960 0 0 {name=l16063 lab=WL100}
N 2440 20040 2460 20040 {}
C {lab_pin.sym} 2460 20040 0 0 {name=l16064 lab=VDD}
N 2440 19960 2460 19960 {}
C {lab_pin.sym} 2460 19960 0 0 {name=l16065 lab=VSS}
C {bitcell_6t.sym} 2600 20000 0 0 {name=Xr100c13}
N 2560 20040 2540 20040 {}
C {lab_pin.sym} 2540 20040 0 0 {name=l16066 lab=BL13}
N 2560 20000 2540 20000 {}
C {lab_pin.sym} 2540 20000 0 0 {name=l16067 lab=BLB13}
N 2560 19960 2540 19960 {}
C {lab_pin.sym} 2540 19960 0 0 {name=l16068 lab=WL100}
N 2640 20040 2660 20040 {}
C {lab_pin.sym} 2660 20040 0 0 {name=l16069 lab=VDD}
N 2640 19960 2660 19960 {}
C {lab_pin.sym} 2660 19960 0 0 {name=l16070 lab=VSS}
C {bitcell_6t.sym} 2800 20000 0 0 {name=Xr100c14}
N 2760 20040 2740 20040 {}
C {lab_pin.sym} 2740 20040 0 0 {name=l16071 lab=BL14}
N 2760 20000 2740 20000 {}
C {lab_pin.sym} 2740 20000 0 0 {name=l16072 lab=BLB14}
N 2760 19960 2740 19960 {}
C {lab_pin.sym} 2740 19960 0 0 {name=l16073 lab=WL100}
N 2840 20040 2860 20040 {}
C {lab_pin.sym} 2860 20040 0 0 {name=l16074 lab=VDD}
N 2840 19960 2860 19960 {}
C {lab_pin.sym} 2860 19960 0 0 {name=l16075 lab=VSS}
C {bitcell_6t.sym} 3000 20000 0 0 {name=Xr100c15}
N 2960 20040 2940 20040 {}
C {lab_pin.sym} 2940 20040 0 0 {name=l16076 lab=BL15}
N 2960 20000 2940 20000 {}
C {lab_pin.sym} 2940 20000 0 0 {name=l16077 lab=BLB15}
N 2960 19960 2940 19960 {}
C {lab_pin.sym} 2940 19960 0 0 {name=l16078 lab=WL100}
N 3040 20040 3060 20040 {}
C {lab_pin.sym} 3060 20040 0 0 {name=l16079 lab=VDD}
N 3040 19960 3060 19960 {}
C {lab_pin.sym} 3060 19960 0 0 {name=l16080 lab=VSS}
C {bitcell_6t.sym} 3200 20000 0 0 {name=Xr100c16}
N 3160 20040 3140 20040 {}
C {lab_pin.sym} 3140 20040 0 0 {name=l16081 lab=BL16}
N 3160 20000 3140 20000 {}
C {lab_pin.sym} 3140 20000 0 0 {name=l16082 lab=BLB16}
N 3160 19960 3140 19960 {}
C {lab_pin.sym} 3140 19960 0 0 {name=l16083 lab=WL100}
N 3240 20040 3260 20040 {}
C {lab_pin.sym} 3260 20040 0 0 {name=l16084 lab=VDD}
N 3240 19960 3260 19960 {}
C {lab_pin.sym} 3260 19960 0 0 {name=l16085 lab=VSS}
C {bitcell_6t.sym} 3400 20000 0 0 {name=Xr100c17}
N 3360 20040 3340 20040 {}
C {lab_pin.sym} 3340 20040 0 0 {name=l16086 lab=BL17}
N 3360 20000 3340 20000 {}
C {lab_pin.sym} 3340 20000 0 0 {name=l16087 lab=BLB17}
N 3360 19960 3340 19960 {}
C {lab_pin.sym} 3340 19960 0 0 {name=l16088 lab=WL100}
N 3440 20040 3460 20040 {}
C {lab_pin.sym} 3460 20040 0 0 {name=l16089 lab=VDD}
N 3440 19960 3460 19960 {}
C {lab_pin.sym} 3460 19960 0 0 {name=l16090 lab=VSS}
C {bitcell_6t.sym} 3600 20000 0 0 {name=Xr100c18}
N 3560 20040 3540 20040 {}
C {lab_pin.sym} 3540 20040 0 0 {name=l16091 lab=BL18}
N 3560 20000 3540 20000 {}
C {lab_pin.sym} 3540 20000 0 0 {name=l16092 lab=BLB18}
N 3560 19960 3540 19960 {}
C {lab_pin.sym} 3540 19960 0 0 {name=l16093 lab=WL100}
N 3640 20040 3660 20040 {}
C {lab_pin.sym} 3660 20040 0 0 {name=l16094 lab=VDD}
N 3640 19960 3660 19960 {}
C {lab_pin.sym} 3660 19960 0 0 {name=l16095 lab=VSS}
C {bitcell_6t.sym} 3800 20000 0 0 {name=Xr100c19}
N 3760 20040 3740 20040 {}
C {lab_pin.sym} 3740 20040 0 0 {name=l16096 lab=BL19}
N 3760 20000 3740 20000 {}
C {lab_pin.sym} 3740 20000 0 0 {name=l16097 lab=BLB19}
N 3760 19960 3740 19960 {}
C {lab_pin.sym} 3740 19960 0 0 {name=l16098 lab=WL100}
N 3840 20040 3860 20040 {}
C {lab_pin.sym} 3860 20040 0 0 {name=l16099 lab=VDD}
N 3840 19960 3860 19960 {}
C {lab_pin.sym} 3860 19960 0 0 {name=l16100 lab=VSS}
C {bitcell_6t.sym} 4000 20000 0 0 {name=Xr100c20}
N 3960 20040 3940 20040 {}
C {lab_pin.sym} 3940 20040 0 0 {name=l16101 lab=BL20}
N 3960 20000 3940 20000 {}
C {lab_pin.sym} 3940 20000 0 0 {name=l16102 lab=BLB20}
N 3960 19960 3940 19960 {}
C {lab_pin.sym} 3940 19960 0 0 {name=l16103 lab=WL100}
N 4040 20040 4060 20040 {}
C {lab_pin.sym} 4060 20040 0 0 {name=l16104 lab=VDD}
N 4040 19960 4060 19960 {}
C {lab_pin.sym} 4060 19960 0 0 {name=l16105 lab=VSS}
C {bitcell_6t.sym} 4200 20000 0 0 {name=Xr100c21}
N 4160 20040 4140 20040 {}
C {lab_pin.sym} 4140 20040 0 0 {name=l16106 lab=BL21}
N 4160 20000 4140 20000 {}
C {lab_pin.sym} 4140 20000 0 0 {name=l16107 lab=BLB21}
N 4160 19960 4140 19960 {}
C {lab_pin.sym} 4140 19960 0 0 {name=l16108 lab=WL100}
N 4240 20040 4260 20040 {}
C {lab_pin.sym} 4260 20040 0 0 {name=l16109 lab=VDD}
N 4240 19960 4260 19960 {}
C {lab_pin.sym} 4260 19960 0 0 {name=l16110 lab=VSS}
C {bitcell_6t.sym} 4400 20000 0 0 {name=Xr100c22}
N 4360 20040 4340 20040 {}
C {lab_pin.sym} 4340 20040 0 0 {name=l16111 lab=BL22}
N 4360 20000 4340 20000 {}
C {lab_pin.sym} 4340 20000 0 0 {name=l16112 lab=BLB22}
N 4360 19960 4340 19960 {}
C {lab_pin.sym} 4340 19960 0 0 {name=l16113 lab=WL100}
N 4440 20040 4460 20040 {}
C {lab_pin.sym} 4460 20040 0 0 {name=l16114 lab=VDD}
N 4440 19960 4460 19960 {}
C {lab_pin.sym} 4460 19960 0 0 {name=l16115 lab=VSS}
C {bitcell_6t.sym} 4600 20000 0 0 {name=Xr100c23}
N 4560 20040 4540 20040 {}
C {lab_pin.sym} 4540 20040 0 0 {name=l16116 lab=BL23}
N 4560 20000 4540 20000 {}
C {lab_pin.sym} 4540 20000 0 0 {name=l16117 lab=BLB23}
N 4560 19960 4540 19960 {}
C {lab_pin.sym} 4540 19960 0 0 {name=l16118 lab=WL100}
N 4640 20040 4660 20040 {}
C {lab_pin.sym} 4660 20040 0 0 {name=l16119 lab=VDD}
N 4640 19960 4660 19960 {}
C {lab_pin.sym} 4660 19960 0 0 {name=l16120 lab=VSS}
C {bitcell_6t.sym} 4800 20000 0 0 {name=Xr100c24}
N 4760 20040 4740 20040 {}
C {lab_pin.sym} 4740 20040 0 0 {name=l16121 lab=BL24}
N 4760 20000 4740 20000 {}
C {lab_pin.sym} 4740 20000 0 0 {name=l16122 lab=BLB24}
N 4760 19960 4740 19960 {}
C {lab_pin.sym} 4740 19960 0 0 {name=l16123 lab=WL100}
N 4840 20040 4860 20040 {}
C {lab_pin.sym} 4860 20040 0 0 {name=l16124 lab=VDD}
N 4840 19960 4860 19960 {}
C {lab_pin.sym} 4860 19960 0 0 {name=l16125 lab=VSS}
C {bitcell_6t.sym} 5000 20000 0 0 {name=Xr100c25}
N 4960 20040 4940 20040 {}
C {lab_pin.sym} 4940 20040 0 0 {name=l16126 lab=BL25}
N 4960 20000 4940 20000 {}
C {lab_pin.sym} 4940 20000 0 0 {name=l16127 lab=BLB25}
N 4960 19960 4940 19960 {}
C {lab_pin.sym} 4940 19960 0 0 {name=l16128 lab=WL100}
N 5040 20040 5060 20040 {}
C {lab_pin.sym} 5060 20040 0 0 {name=l16129 lab=VDD}
N 5040 19960 5060 19960 {}
C {lab_pin.sym} 5060 19960 0 0 {name=l16130 lab=VSS}
C {bitcell_6t.sym} 5200 20000 0 0 {name=Xr100c26}
N 5160 20040 5140 20040 {}
C {lab_pin.sym} 5140 20040 0 0 {name=l16131 lab=BL26}
N 5160 20000 5140 20000 {}
C {lab_pin.sym} 5140 20000 0 0 {name=l16132 lab=BLB26}
N 5160 19960 5140 19960 {}
C {lab_pin.sym} 5140 19960 0 0 {name=l16133 lab=WL100}
N 5240 20040 5260 20040 {}
C {lab_pin.sym} 5260 20040 0 0 {name=l16134 lab=VDD}
N 5240 19960 5260 19960 {}
C {lab_pin.sym} 5260 19960 0 0 {name=l16135 lab=VSS}
C {bitcell_6t.sym} 5400 20000 0 0 {name=Xr100c27}
N 5360 20040 5340 20040 {}
C {lab_pin.sym} 5340 20040 0 0 {name=l16136 lab=BL27}
N 5360 20000 5340 20000 {}
C {lab_pin.sym} 5340 20000 0 0 {name=l16137 lab=BLB27}
N 5360 19960 5340 19960 {}
C {lab_pin.sym} 5340 19960 0 0 {name=l16138 lab=WL100}
N 5440 20040 5460 20040 {}
C {lab_pin.sym} 5460 20040 0 0 {name=l16139 lab=VDD}
N 5440 19960 5460 19960 {}
C {lab_pin.sym} 5460 19960 0 0 {name=l16140 lab=VSS}
C {bitcell_6t.sym} 5600 20000 0 0 {name=Xr100c28}
N 5560 20040 5540 20040 {}
C {lab_pin.sym} 5540 20040 0 0 {name=l16141 lab=BL28}
N 5560 20000 5540 20000 {}
C {lab_pin.sym} 5540 20000 0 0 {name=l16142 lab=BLB28}
N 5560 19960 5540 19960 {}
C {lab_pin.sym} 5540 19960 0 0 {name=l16143 lab=WL100}
N 5640 20040 5660 20040 {}
C {lab_pin.sym} 5660 20040 0 0 {name=l16144 lab=VDD}
N 5640 19960 5660 19960 {}
C {lab_pin.sym} 5660 19960 0 0 {name=l16145 lab=VSS}
C {bitcell_6t.sym} 5800 20000 0 0 {name=Xr100c29}
N 5760 20040 5740 20040 {}
C {lab_pin.sym} 5740 20040 0 0 {name=l16146 lab=BL29}
N 5760 20000 5740 20000 {}
C {lab_pin.sym} 5740 20000 0 0 {name=l16147 lab=BLB29}
N 5760 19960 5740 19960 {}
C {lab_pin.sym} 5740 19960 0 0 {name=l16148 lab=WL100}
N 5840 20040 5860 20040 {}
C {lab_pin.sym} 5860 20040 0 0 {name=l16149 lab=VDD}
N 5840 19960 5860 19960 {}
C {lab_pin.sym} 5860 19960 0 0 {name=l16150 lab=VSS}
C {bitcell_6t.sym} 6000 20000 0 0 {name=Xr100c30}
N 5960 20040 5940 20040 {}
C {lab_pin.sym} 5940 20040 0 0 {name=l16151 lab=BL30}
N 5960 20000 5940 20000 {}
C {lab_pin.sym} 5940 20000 0 0 {name=l16152 lab=BLB30}
N 5960 19960 5940 19960 {}
C {lab_pin.sym} 5940 19960 0 0 {name=l16153 lab=WL100}
N 6040 20040 6060 20040 {}
C {lab_pin.sym} 6060 20040 0 0 {name=l16154 lab=VDD}
N 6040 19960 6060 19960 {}
C {lab_pin.sym} 6060 19960 0 0 {name=l16155 lab=VSS}
C {bitcell_6t.sym} 6200 20000 0 0 {name=Xr100c31}
N 6160 20040 6140 20040 {}
C {lab_pin.sym} 6140 20040 0 0 {name=l16156 lab=BL31}
N 6160 20000 6140 20000 {}
C {lab_pin.sym} 6140 20000 0 0 {name=l16157 lab=BLB31}
N 6160 19960 6140 19960 {}
C {lab_pin.sym} 6140 19960 0 0 {name=l16158 lab=WL100}
N 6240 20040 6260 20040 {}
C {lab_pin.sym} 6260 20040 0 0 {name=l16159 lab=VDD}
N 6240 19960 6260 19960 {}
C {lab_pin.sym} 6260 19960 0 0 {name=l16160 lab=VSS}
C {bitcell_6t.sym} 0 20200 0 0 {name=Xr101c0}
N -40 20240 -60 20240 {}
C {lab_pin.sym} -60 20240 0 0 {name=l16161 lab=BL0}
N -40 20200 -60 20200 {}
C {lab_pin.sym} -60 20200 0 0 {name=l16162 lab=BLB0}
N -40 20160 -60 20160 {}
C {lab_pin.sym} -60 20160 0 0 {name=l16163 lab=WL101}
N 40 20240 60 20240 {}
C {lab_pin.sym} 60 20240 0 0 {name=l16164 lab=VDD}
N 40 20160 60 20160 {}
C {lab_pin.sym} 60 20160 0 0 {name=l16165 lab=VSS}
C {bitcell_6t.sym} 200 20200 0 0 {name=Xr101c1}
N 160 20240 140 20240 {}
C {lab_pin.sym} 140 20240 0 0 {name=l16166 lab=BL1}
N 160 20200 140 20200 {}
C {lab_pin.sym} 140 20200 0 0 {name=l16167 lab=BLB1}
N 160 20160 140 20160 {}
C {lab_pin.sym} 140 20160 0 0 {name=l16168 lab=WL101}
N 240 20240 260 20240 {}
C {lab_pin.sym} 260 20240 0 0 {name=l16169 lab=VDD}
N 240 20160 260 20160 {}
C {lab_pin.sym} 260 20160 0 0 {name=l16170 lab=VSS}
C {bitcell_6t.sym} 400 20200 0 0 {name=Xr101c2}
N 360 20240 340 20240 {}
C {lab_pin.sym} 340 20240 0 0 {name=l16171 lab=BL2}
N 360 20200 340 20200 {}
C {lab_pin.sym} 340 20200 0 0 {name=l16172 lab=BLB2}
N 360 20160 340 20160 {}
C {lab_pin.sym} 340 20160 0 0 {name=l16173 lab=WL101}
N 440 20240 460 20240 {}
C {lab_pin.sym} 460 20240 0 0 {name=l16174 lab=VDD}
N 440 20160 460 20160 {}
C {lab_pin.sym} 460 20160 0 0 {name=l16175 lab=VSS}
C {bitcell_6t.sym} 600 20200 0 0 {name=Xr101c3}
N 560 20240 540 20240 {}
C {lab_pin.sym} 540 20240 0 0 {name=l16176 lab=BL3}
N 560 20200 540 20200 {}
C {lab_pin.sym} 540 20200 0 0 {name=l16177 lab=BLB3}
N 560 20160 540 20160 {}
C {lab_pin.sym} 540 20160 0 0 {name=l16178 lab=WL101}
N 640 20240 660 20240 {}
C {lab_pin.sym} 660 20240 0 0 {name=l16179 lab=VDD}
N 640 20160 660 20160 {}
C {lab_pin.sym} 660 20160 0 0 {name=l16180 lab=VSS}
C {bitcell_6t.sym} 800 20200 0 0 {name=Xr101c4}
N 760 20240 740 20240 {}
C {lab_pin.sym} 740 20240 0 0 {name=l16181 lab=BL4}
N 760 20200 740 20200 {}
C {lab_pin.sym} 740 20200 0 0 {name=l16182 lab=BLB4}
N 760 20160 740 20160 {}
C {lab_pin.sym} 740 20160 0 0 {name=l16183 lab=WL101}
N 840 20240 860 20240 {}
C {lab_pin.sym} 860 20240 0 0 {name=l16184 lab=VDD}
N 840 20160 860 20160 {}
C {lab_pin.sym} 860 20160 0 0 {name=l16185 lab=VSS}
C {bitcell_6t.sym} 1000 20200 0 0 {name=Xr101c5}
N 960 20240 940 20240 {}
C {lab_pin.sym} 940 20240 0 0 {name=l16186 lab=BL5}
N 960 20200 940 20200 {}
C {lab_pin.sym} 940 20200 0 0 {name=l16187 lab=BLB5}
N 960 20160 940 20160 {}
C {lab_pin.sym} 940 20160 0 0 {name=l16188 lab=WL101}
N 1040 20240 1060 20240 {}
C {lab_pin.sym} 1060 20240 0 0 {name=l16189 lab=VDD}
N 1040 20160 1060 20160 {}
C {lab_pin.sym} 1060 20160 0 0 {name=l16190 lab=VSS}
C {bitcell_6t.sym} 1200 20200 0 0 {name=Xr101c6}
N 1160 20240 1140 20240 {}
C {lab_pin.sym} 1140 20240 0 0 {name=l16191 lab=BL6}
N 1160 20200 1140 20200 {}
C {lab_pin.sym} 1140 20200 0 0 {name=l16192 lab=BLB6}
N 1160 20160 1140 20160 {}
C {lab_pin.sym} 1140 20160 0 0 {name=l16193 lab=WL101}
N 1240 20240 1260 20240 {}
C {lab_pin.sym} 1260 20240 0 0 {name=l16194 lab=VDD}
N 1240 20160 1260 20160 {}
C {lab_pin.sym} 1260 20160 0 0 {name=l16195 lab=VSS}
C {bitcell_6t.sym} 1400 20200 0 0 {name=Xr101c7}
N 1360 20240 1340 20240 {}
C {lab_pin.sym} 1340 20240 0 0 {name=l16196 lab=BL7}
N 1360 20200 1340 20200 {}
C {lab_pin.sym} 1340 20200 0 0 {name=l16197 lab=BLB7}
N 1360 20160 1340 20160 {}
C {lab_pin.sym} 1340 20160 0 0 {name=l16198 lab=WL101}
N 1440 20240 1460 20240 {}
C {lab_pin.sym} 1460 20240 0 0 {name=l16199 lab=VDD}
N 1440 20160 1460 20160 {}
C {lab_pin.sym} 1460 20160 0 0 {name=l16200 lab=VSS}
C {bitcell_6t.sym} 1600 20200 0 0 {name=Xr101c8}
N 1560 20240 1540 20240 {}
C {lab_pin.sym} 1540 20240 0 0 {name=l16201 lab=BL8}
N 1560 20200 1540 20200 {}
C {lab_pin.sym} 1540 20200 0 0 {name=l16202 lab=BLB8}
N 1560 20160 1540 20160 {}
C {lab_pin.sym} 1540 20160 0 0 {name=l16203 lab=WL101}
N 1640 20240 1660 20240 {}
C {lab_pin.sym} 1660 20240 0 0 {name=l16204 lab=VDD}
N 1640 20160 1660 20160 {}
C {lab_pin.sym} 1660 20160 0 0 {name=l16205 lab=VSS}
C {bitcell_6t.sym} 1800 20200 0 0 {name=Xr101c9}
N 1760 20240 1740 20240 {}
C {lab_pin.sym} 1740 20240 0 0 {name=l16206 lab=BL9}
N 1760 20200 1740 20200 {}
C {lab_pin.sym} 1740 20200 0 0 {name=l16207 lab=BLB9}
N 1760 20160 1740 20160 {}
C {lab_pin.sym} 1740 20160 0 0 {name=l16208 lab=WL101}
N 1840 20240 1860 20240 {}
C {lab_pin.sym} 1860 20240 0 0 {name=l16209 lab=VDD}
N 1840 20160 1860 20160 {}
C {lab_pin.sym} 1860 20160 0 0 {name=l16210 lab=VSS}
C {bitcell_6t.sym} 2000 20200 0 0 {name=Xr101c10}
N 1960 20240 1940 20240 {}
C {lab_pin.sym} 1940 20240 0 0 {name=l16211 lab=BL10}
N 1960 20200 1940 20200 {}
C {lab_pin.sym} 1940 20200 0 0 {name=l16212 lab=BLB10}
N 1960 20160 1940 20160 {}
C {lab_pin.sym} 1940 20160 0 0 {name=l16213 lab=WL101}
N 2040 20240 2060 20240 {}
C {lab_pin.sym} 2060 20240 0 0 {name=l16214 lab=VDD}
N 2040 20160 2060 20160 {}
C {lab_pin.sym} 2060 20160 0 0 {name=l16215 lab=VSS}
C {bitcell_6t.sym} 2200 20200 0 0 {name=Xr101c11}
N 2160 20240 2140 20240 {}
C {lab_pin.sym} 2140 20240 0 0 {name=l16216 lab=BL11}
N 2160 20200 2140 20200 {}
C {lab_pin.sym} 2140 20200 0 0 {name=l16217 lab=BLB11}
N 2160 20160 2140 20160 {}
C {lab_pin.sym} 2140 20160 0 0 {name=l16218 lab=WL101}
N 2240 20240 2260 20240 {}
C {lab_pin.sym} 2260 20240 0 0 {name=l16219 lab=VDD}
N 2240 20160 2260 20160 {}
C {lab_pin.sym} 2260 20160 0 0 {name=l16220 lab=VSS}
C {bitcell_6t.sym} 2400 20200 0 0 {name=Xr101c12}
N 2360 20240 2340 20240 {}
C {lab_pin.sym} 2340 20240 0 0 {name=l16221 lab=BL12}
N 2360 20200 2340 20200 {}
C {lab_pin.sym} 2340 20200 0 0 {name=l16222 lab=BLB12}
N 2360 20160 2340 20160 {}
C {lab_pin.sym} 2340 20160 0 0 {name=l16223 lab=WL101}
N 2440 20240 2460 20240 {}
C {lab_pin.sym} 2460 20240 0 0 {name=l16224 lab=VDD}
N 2440 20160 2460 20160 {}
C {lab_pin.sym} 2460 20160 0 0 {name=l16225 lab=VSS}
C {bitcell_6t.sym} 2600 20200 0 0 {name=Xr101c13}
N 2560 20240 2540 20240 {}
C {lab_pin.sym} 2540 20240 0 0 {name=l16226 lab=BL13}
N 2560 20200 2540 20200 {}
C {lab_pin.sym} 2540 20200 0 0 {name=l16227 lab=BLB13}
N 2560 20160 2540 20160 {}
C {lab_pin.sym} 2540 20160 0 0 {name=l16228 lab=WL101}
N 2640 20240 2660 20240 {}
C {lab_pin.sym} 2660 20240 0 0 {name=l16229 lab=VDD}
N 2640 20160 2660 20160 {}
C {lab_pin.sym} 2660 20160 0 0 {name=l16230 lab=VSS}
C {bitcell_6t.sym} 2800 20200 0 0 {name=Xr101c14}
N 2760 20240 2740 20240 {}
C {lab_pin.sym} 2740 20240 0 0 {name=l16231 lab=BL14}
N 2760 20200 2740 20200 {}
C {lab_pin.sym} 2740 20200 0 0 {name=l16232 lab=BLB14}
N 2760 20160 2740 20160 {}
C {lab_pin.sym} 2740 20160 0 0 {name=l16233 lab=WL101}
N 2840 20240 2860 20240 {}
C {lab_pin.sym} 2860 20240 0 0 {name=l16234 lab=VDD}
N 2840 20160 2860 20160 {}
C {lab_pin.sym} 2860 20160 0 0 {name=l16235 lab=VSS}
C {bitcell_6t.sym} 3000 20200 0 0 {name=Xr101c15}
N 2960 20240 2940 20240 {}
C {lab_pin.sym} 2940 20240 0 0 {name=l16236 lab=BL15}
N 2960 20200 2940 20200 {}
C {lab_pin.sym} 2940 20200 0 0 {name=l16237 lab=BLB15}
N 2960 20160 2940 20160 {}
C {lab_pin.sym} 2940 20160 0 0 {name=l16238 lab=WL101}
N 3040 20240 3060 20240 {}
C {lab_pin.sym} 3060 20240 0 0 {name=l16239 lab=VDD}
N 3040 20160 3060 20160 {}
C {lab_pin.sym} 3060 20160 0 0 {name=l16240 lab=VSS}
C {bitcell_6t.sym} 3200 20200 0 0 {name=Xr101c16}
N 3160 20240 3140 20240 {}
C {lab_pin.sym} 3140 20240 0 0 {name=l16241 lab=BL16}
N 3160 20200 3140 20200 {}
C {lab_pin.sym} 3140 20200 0 0 {name=l16242 lab=BLB16}
N 3160 20160 3140 20160 {}
C {lab_pin.sym} 3140 20160 0 0 {name=l16243 lab=WL101}
N 3240 20240 3260 20240 {}
C {lab_pin.sym} 3260 20240 0 0 {name=l16244 lab=VDD}
N 3240 20160 3260 20160 {}
C {lab_pin.sym} 3260 20160 0 0 {name=l16245 lab=VSS}
C {bitcell_6t.sym} 3400 20200 0 0 {name=Xr101c17}
N 3360 20240 3340 20240 {}
C {lab_pin.sym} 3340 20240 0 0 {name=l16246 lab=BL17}
N 3360 20200 3340 20200 {}
C {lab_pin.sym} 3340 20200 0 0 {name=l16247 lab=BLB17}
N 3360 20160 3340 20160 {}
C {lab_pin.sym} 3340 20160 0 0 {name=l16248 lab=WL101}
N 3440 20240 3460 20240 {}
C {lab_pin.sym} 3460 20240 0 0 {name=l16249 lab=VDD}
N 3440 20160 3460 20160 {}
C {lab_pin.sym} 3460 20160 0 0 {name=l16250 lab=VSS}
C {bitcell_6t.sym} 3600 20200 0 0 {name=Xr101c18}
N 3560 20240 3540 20240 {}
C {lab_pin.sym} 3540 20240 0 0 {name=l16251 lab=BL18}
N 3560 20200 3540 20200 {}
C {lab_pin.sym} 3540 20200 0 0 {name=l16252 lab=BLB18}
N 3560 20160 3540 20160 {}
C {lab_pin.sym} 3540 20160 0 0 {name=l16253 lab=WL101}
N 3640 20240 3660 20240 {}
C {lab_pin.sym} 3660 20240 0 0 {name=l16254 lab=VDD}
N 3640 20160 3660 20160 {}
C {lab_pin.sym} 3660 20160 0 0 {name=l16255 lab=VSS}
C {bitcell_6t.sym} 3800 20200 0 0 {name=Xr101c19}
N 3760 20240 3740 20240 {}
C {lab_pin.sym} 3740 20240 0 0 {name=l16256 lab=BL19}
N 3760 20200 3740 20200 {}
C {lab_pin.sym} 3740 20200 0 0 {name=l16257 lab=BLB19}
N 3760 20160 3740 20160 {}
C {lab_pin.sym} 3740 20160 0 0 {name=l16258 lab=WL101}
N 3840 20240 3860 20240 {}
C {lab_pin.sym} 3860 20240 0 0 {name=l16259 lab=VDD}
N 3840 20160 3860 20160 {}
C {lab_pin.sym} 3860 20160 0 0 {name=l16260 lab=VSS}
C {bitcell_6t.sym} 4000 20200 0 0 {name=Xr101c20}
N 3960 20240 3940 20240 {}
C {lab_pin.sym} 3940 20240 0 0 {name=l16261 lab=BL20}
N 3960 20200 3940 20200 {}
C {lab_pin.sym} 3940 20200 0 0 {name=l16262 lab=BLB20}
N 3960 20160 3940 20160 {}
C {lab_pin.sym} 3940 20160 0 0 {name=l16263 lab=WL101}
N 4040 20240 4060 20240 {}
C {lab_pin.sym} 4060 20240 0 0 {name=l16264 lab=VDD}
N 4040 20160 4060 20160 {}
C {lab_pin.sym} 4060 20160 0 0 {name=l16265 lab=VSS}
C {bitcell_6t.sym} 4200 20200 0 0 {name=Xr101c21}
N 4160 20240 4140 20240 {}
C {lab_pin.sym} 4140 20240 0 0 {name=l16266 lab=BL21}
N 4160 20200 4140 20200 {}
C {lab_pin.sym} 4140 20200 0 0 {name=l16267 lab=BLB21}
N 4160 20160 4140 20160 {}
C {lab_pin.sym} 4140 20160 0 0 {name=l16268 lab=WL101}
N 4240 20240 4260 20240 {}
C {lab_pin.sym} 4260 20240 0 0 {name=l16269 lab=VDD}
N 4240 20160 4260 20160 {}
C {lab_pin.sym} 4260 20160 0 0 {name=l16270 lab=VSS}
C {bitcell_6t.sym} 4400 20200 0 0 {name=Xr101c22}
N 4360 20240 4340 20240 {}
C {lab_pin.sym} 4340 20240 0 0 {name=l16271 lab=BL22}
N 4360 20200 4340 20200 {}
C {lab_pin.sym} 4340 20200 0 0 {name=l16272 lab=BLB22}
N 4360 20160 4340 20160 {}
C {lab_pin.sym} 4340 20160 0 0 {name=l16273 lab=WL101}
N 4440 20240 4460 20240 {}
C {lab_pin.sym} 4460 20240 0 0 {name=l16274 lab=VDD}
N 4440 20160 4460 20160 {}
C {lab_pin.sym} 4460 20160 0 0 {name=l16275 lab=VSS}
C {bitcell_6t.sym} 4600 20200 0 0 {name=Xr101c23}
N 4560 20240 4540 20240 {}
C {lab_pin.sym} 4540 20240 0 0 {name=l16276 lab=BL23}
N 4560 20200 4540 20200 {}
C {lab_pin.sym} 4540 20200 0 0 {name=l16277 lab=BLB23}
N 4560 20160 4540 20160 {}
C {lab_pin.sym} 4540 20160 0 0 {name=l16278 lab=WL101}
N 4640 20240 4660 20240 {}
C {lab_pin.sym} 4660 20240 0 0 {name=l16279 lab=VDD}
N 4640 20160 4660 20160 {}
C {lab_pin.sym} 4660 20160 0 0 {name=l16280 lab=VSS}
C {bitcell_6t.sym} 4800 20200 0 0 {name=Xr101c24}
N 4760 20240 4740 20240 {}
C {lab_pin.sym} 4740 20240 0 0 {name=l16281 lab=BL24}
N 4760 20200 4740 20200 {}
C {lab_pin.sym} 4740 20200 0 0 {name=l16282 lab=BLB24}
N 4760 20160 4740 20160 {}
C {lab_pin.sym} 4740 20160 0 0 {name=l16283 lab=WL101}
N 4840 20240 4860 20240 {}
C {lab_pin.sym} 4860 20240 0 0 {name=l16284 lab=VDD}
N 4840 20160 4860 20160 {}
C {lab_pin.sym} 4860 20160 0 0 {name=l16285 lab=VSS}
C {bitcell_6t.sym} 5000 20200 0 0 {name=Xr101c25}
N 4960 20240 4940 20240 {}
C {lab_pin.sym} 4940 20240 0 0 {name=l16286 lab=BL25}
N 4960 20200 4940 20200 {}
C {lab_pin.sym} 4940 20200 0 0 {name=l16287 lab=BLB25}
N 4960 20160 4940 20160 {}
C {lab_pin.sym} 4940 20160 0 0 {name=l16288 lab=WL101}
N 5040 20240 5060 20240 {}
C {lab_pin.sym} 5060 20240 0 0 {name=l16289 lab=VDD}
N 5040 20160 5060 20160 {}
C {lab_pin.sym} 5060 20160 0 0 {name=l16290 lab=VSS}
C {bitcell_6t.sym} 5200 20200 0 0 {name=Xr101c26}
N 5160 20240 5140 20240 {}
C {lab_pin.sym} 5140 20240 0 0 {name=l16291 lab=BL26}
N 5160 20200 5140 20200 {}
C {lab_pin.sym} 5140 20200 0 0 {name=l16292 lab=BLB26}
N 5160 20160 5140 20160 {}
C {lab_pin.sym} 5140 20160 0 0 {name=l16293 lab=WL101}
N 5240 20240 5260 20240 {}
C {lab_pin.sym} 5260 20240 0 0 {name=l16294 lab=VDD}
N 5240 20160 5260 20160 {}
C {lab_pin.sym} 5260 20160 0 0 {name=l16295 lab=VSS}
C {bitcell_6t.sym} 5400 20200 0 0 {name=Xr101c27}
N 5360 20240 5340 20240 {}
C {lab_pin.sym} 5340 20240 0 0 {name=l16296 lab=BL27}
N 5360 20200 5340 20200 {}
C {lab_pin.sym} 5340 20200 0 0 {name=l16297 lab=BLB27}
N 5360 20160 5340 20160 {}
C {lab_pin.sym} 5340 20160 0 0 {name=l16298 lab=WL101}
N 5440 20240 5460 20240 {}
C {lab_pin.sym} 5460 20240 0 0 {name=l16299 lab=VDD}
N 5440 20160 5460 20160 {}
C {lab_pin.sym} 5460 20160 0 0 {name=l16300 lab=VSS}
C {bitcell_6t.sym} 5600 20200 0 0 {name=Xr101c28}
N 5560 20240 5540 20240 {}
C {lab_pin.sym} 5540 20240 0 0 {name=l16301 lab=BL28}
N 5560 20200 5540 20200 {}
C {lab_pin.sym} 5540 20200 0 0 {name=l16302 lab=BLB28}
N 5560 20160 5540 20160 {}
C {lab_pin.sym} 5540 20160 0 0 {name=l16303 lab=WL101}
N 5640 20240 5660 20240 {}
C {lab_pin.sym} 5660 20240 0 0 {name=l16304 lab=VDD}
N 5640 20160 5660 20160 {}
C {lab_pin.sym} 5660 20160 0 0 {name=l16305 lab=VSS}
C {bitcell_6t.sym} 5800 20200 0 0 {name=Xr101c29}
N 5760 20240 5740 20240 {}
C {lab_pin.sym} 5740 20240 0 0 {name=l16306 lab=BL29}
N 5760 20200 5740 20200 {}
C {lab_pin.sym} 5740 20200 0 0 {name=l16307 lab=BLB29}
N 5760 20160 5740 20160 {}
C {lab_pin.sym} 5740 20160 0 0 {name=l16308 lab=WL101}
N 5840 20240 5860 20240 {}
C {lab_pin.sym} 5860 20240 0 0 {name=l16309 lab=VDD}
N 5840 20160 5860 20160 {}
C {lab_pin.sym} 5860 20160 0 0 {name=l16310 lab=VSS}
C {bitcell_6t.sym} 6000 20200 0 0 {name=Xr101c30}
N 5960 20240 5940 20240 {}
C {lab_pin.sym} 5940 20240 0 0 {name=l16311 lab=BL30}
N 5960 20200 5940 20200 {}
C {lab_pin.sym} 5940 20200 0 0 {name=l16312 lab=BLB30}
N 5960 20160 5940 20160 {}
C {lab_pin.sym} 5940 20160 0 0 {name=l16313 lab=WL101}
N 6040 20240 6060 20240 {}
C {lab_pin.sym} 6060 20240 0 0 {name=l16314 lab=VDD}
N 6040 20160 6060 20160 {}
C {lab_pin.sym} 6060 20160 0 0 {name=l16315 lab=VSS}
C {bitcell_6t.sym} 6200 20200 0 0 {name=Xr101c31}
N 6160 20240 6140 20240 {}
C {lab_pin.sym} 6140 20240 0 0 {name=l16316 lab=BL31}
N 6160 20200 6140 20200 {}
C {lab_pin.sym} 6140 20200 0 0 {name=l16317 lab=BLB31}
N 6160 20160 6140 20160 {}
C {lab_pin.sym} 6140 20160 0 0 {name=l16318 lab=WL101}
N 6240 20240 6260 20240 {}
C {lab_pin.sym} 6260 20240 0 0 {name=l16319 lab=VDD}
N 6240 20160 6260 20160 {}
C {lab_pin.sym} 6260 20160 0 0 {name=l16320 lab=VSS}
C {bitcell_6t.sym} 0 20400 0 0 {name=Xr102c0}
N -40 20440 -60 20440 {}
C {lab_pin.sym} -60 20440 0 0 {name=l16321 lab=BL0}
N -40 20400 -60 20400 {}
C {lab_pin.sym} -60 20400 0 0 {name=l16322 lab=BLB0}
N -40 20360 -60 20360 {}
C {lab_pin.sym} -60 20360 0 0 {name=l16323 lab=WL102}
N 40 20440 60 20440 {}
C {lab_pin.sym} 60 20440 0 0 {name=l16324 lab=VDD}
N 40 20360 60 20360 {}
C {lab_pin.sym} 60 20360 0 0 {name=l16325 lab=VSS}
C {bitcell_6t.sym} 200 20400 0 0 {name=Xr102c1}
N 160 20440 140 20440 {}
C {lab_pin.sym} 140 20440 0 0 {name=l16326 lab=BL1}
N 160 20400 140 20400 {}
C {lab_pin.sym} 140 20400 0 0 {name=l16327 lab=BLB1}
N 160 20360 140 20360 {}
C {lab_pin.sym} 140 20360 0 0 {name=l16328 lab=WL102}
N 240 20440 260 20440 {}
C {lab_pin.sym} 260 20440 0 0 {name=l16329 lab=VDD}
N 240 20360 260 20360 {}
C {lab_pin.sym} 260 20360 0 0 {name=l16330 lab=VSS}
C {bitcell_6t.sym} 400 20400 0 0 {name=Xr102c2}
N 360 20440 340 20440 {}
C {lab_pin.sym} 340 20440 0 0 {name=l16331 lab=BL2}
N 360 20400 340 20400 {}
C {lab_pin.sym} 340 20400 0 0 {name=l16332 lab=BLB2}
N 360 20360 340 20360 {}
C {lab_pin.sym} 340 20360 0 0 {name=l16333 lab=WL102}
N 440 20440 460 20440 {}
C {lab_pin.sym} 460 20440 0 0 {name=l16334 lab=VDD}
N 440 20360 460 20360 {}
C {lab_pin.sym} 460 20360 0 0 {name=l16335 lab=VSS}
C {bitcell_6t.sym} 600 20400 0 0 {name=Xr102c3}
N 560 20440 540 20440 {}
C {lab_pin.sym} 540 20440 0 0 {name=l16336 lab=BL3}
N 560 20400 540 20400 {}
C {lab_pin.sym} 540 20400 0 0 {name=l16337 lab=BLB3}
N 560 20360 540 20360 {}
C {lab_pin.sym} 540 20360 0 0 {name=l16338 lab=WL102}
N 640 20440 660 20440 {}
C {lab_pin.sym} 660 20440 0 0 {name=l16339 lab=VDD}
N 640 20360 660 20360 {}
C {lab_pin.sym} 660 20360 0 0 {name=l16340 lab=VSS}
C {bitcell_6t.sym} 800 20400 0 0 {name=Xr102c4}
N 760 20440 740 20440 {}
C {lab_pin.sym} 740 20440 0 0 {name=l16341 lab=BL4}
N 760 20400 740 20400 {}
C {lab_pin.sym} 740 20400 0 0 {name=l16342 lab=BLB4}
N 760 20360 740 20360 {}
C {lab_pin.sym} 740 20360 0 0 {name=l16343 lab=WL102}
N 840 20440 860 20440 {}
C {lab_pin.sym} 860 20440 0 0 {name=l16344 lab=VDD}
N 840 20360 860 20360 {}
C {lab_pin.sym} 860 20360 0 0 {name=l16345 lab=VSS}
C {bitcell_6t.sym} 1000 20400 0 0 {name=Xr102c5}
N 960 20440 940 20440 {}
C {lab_pin.sym} 940 20440 0 0 {name=l16346 lab=BL5}
N 960 20400 940 20400 {}
C {lab_pin.sym} 940 20400 0 0 {name=l16347 lab=BLB5}
N 960 20360 940 20360 {}
C {lab_pin.sym} 940 20360 0 0 {name=l16348 lab=WL102}
N 1040 20440 1060 20440 {}
C {lab_pin.sym} 1060 20440 0 0 {name=l16349 lab=VDD}
N 1040 20360 1060 20360 {}
C {lab_pin.sym} 1060 20360 0 0 {name=l16350 lab=VSS}
C {bitcell_6t.sym} 1200 20400 0 0 {name=Xr102c6}
N 1160 20440 1140 20440 {}
C {lab_pin.sym} 1140 20440 0 0 {name=l16351 lab=BL6}
N 1160 20400 1140 20400 {}
C {lab_pin.sym} 1140 20400 0 0 {name=l16352 lab=BLB6}
N 1160 20360 1140 20360 {}
C {lab_pin.sym} 1140 20360 0 0 {name=l16353 lab=WL102}
N 1240 20440 1260 20440 {}
C {lab_pin.sym} 1260 20440 0 0 {name=l16354 lab=VDD}
N 1240 20360 1260 20360 {}
C {lab_pin.sym} 1260 20360 0 0 {name=l16355 lab=VSS}
C {bitcell_6t.sym} 1400 20400 0 0 {name=Xr102c7}
N 1360 20440 1340 20440 {}
C {lab_pin.sym} 1340 20440 0 0 {name=l16356 lab=BL7}
N 1360 20400 1340 20400 {}
C {lab_pin.sym} 1340 20400 0 0 {name=l16357 lab=BLB7}
N 1360 20360 1340 20360 {}
C {lab_pin.sym} 1340 20360 0 0 {name=l16358 lab=WL102}
N 1440 20440 1460 20440 {}
C {lab_pin.sym} 1460 20440 0 0 {name=l16359 lab=VDD}
N 1440 20360 1460 20360 {}
C {lab_pin.sym} 1460 20360 0 0 {name=l16360 lab=VSS}
C {bitcell_6t.sym} 1600 20400 0 0 {name=Xr102c8}
N 1560 20440 1540 20440 {}
C {lab_pin.sym} 1540 20440 0 0 {name=l16361 lab=BL8}
N 1560 20400 1540 20400 {}
C {lab_pin.sym} 1540 20400 0 0 {name=l16362 lab=BLB8}
N 1560 20360 1540 20360 {}
C {lab_pin.sym} 1540 20360 0 0 {name=l16363 lab=WL102}
N 1640 20440 1660 20440 {}
C {lab_pin.sym} 1660 20440 0 0 {name=l16364 lab=VDD}
N 1640 20360 1660 20360 {}
C {lab_pin.sym} 1660 20360 0 0 {name=l16365 lab=VSS}
C {bitcell_6t.sym} 1800 20400 0 0 {name=Xr102c9}
N 1760 20440 1740 20440 {}
C {lab_pin.sym} 1740 20440 0 0 {name=l16366 lab=BL9}
N 1760 20400 1740 20400 {}
C {lab_pin.sym} 1740 20400 0 0 {name=l16367 lab=BLB9}
N 1760 20360 1740 20360 {}
C {lab_pin.sym} 1740 20360 0 0 {name=l16368 lab=WL102}
N 1840 20440 1860 20440 {}
C {lab_pin.sym} 1860 20440 0 0 {name=l16369 lab=VDD}
N 1840 20360 1860 20360 {}
C {lab_pin.sym} 1860 20360 0 0 {name=l16370 lab=VSS}
C {bitcell_6t.sym} 2000 20400 0 0 {name=Xr102c10}
N 1960 20440 1940 20440 {}
C {lab_pin.sym} 1940 20440 0 0 {name=l16371 lab=BL10}
N 1960 20400 1940 20400 {}
C {lab_pin.sym} 1940 20400 0 0 {name=l16372 lab=BLB10}
N 1960 20360 1940 20360 {}
C {lab_pin.sym} 1940 20360 0 0 {name=l16373 lab=WL102}
N 2040 20440 2060 20440 {}
C {lab_pin.sym} 2060 20440 0 0 {name=l16374 lab=VDD}
N 2040 20360 2060 20360 {}
C {lab_pin.sym} 2060 20360 0 0 {name=l16375 lab=VSS}
C {bitcell_6t.sym} 2200 20400 0 0 {name=Xr102c11}
N 2160 20440 2140 20440 {}
C {lab_pin.sym} 2140 20440 0 0 {name=l16376 lab=BL11}
N 2160 20400 2140 20400 {}
C {lab_pin.sym} 2140 20400 0 0 {name=l16377 lab=BLB11}
N 2160 20360 2140 20360 {}
C {lab_pin.sym} 2140 20360 0 0 {name=l16378 lab=WL102}
N 2240 20440 2260 20440 {}
C {lab_pin.sym} 2260 20440 0 0 {name=l16379 lab=VDD}
N 2240 20360 2260 20360 {}
C {lab_pin.sym} 2260 20360 0 0 {name=l16380 lab=VSS}
C {bitcell_6t.sym} 2400 20400 0 0 {name=Xr102c12}
N 2360 20440 2340 20440 {}
C {lab_pin.sym} 2340 20440 0 0 {name=l16381 lab=BL12}
N 2360 20400 2340 20400 {}
C {lab_pin.sym} 2340 20400 0 0 {name=l16382 lab=BLB12}
N 2360 20360 2340 20360 {}
C {lab_pin.sym} 2340 20360 0 0 {name=l16383 lab=WL102}
N 2440 20440 2460 20440 {}
C {lab_pin.sym} 2460 20440 0 0 {name=l16384 lab=VDD}
N 2440 20360 2460 20360 {}
C {lab_pin.sym} 2460 20360 0 0 {name=l16385 lab=VSS}
C {bitcell_6t.sym} 2600 20400 0 0 {name=Xr102c13}
N 2560 20440 2540 20440 {}
C {lab_pin.sym} 2540 20440 0 0 {name=l16386 lab=BL13}
N 2560 20400 2540 20400 {}
C {lab_pin.sym} 2540 20400 0 0 {name=l16387 lab=BLB13}
N 2560 20360 2540 20360 {}
C {lab_pin.sym} 2540 20360 0 0 {name=l16388 lab=WL102}
N 2640 20440 2660 20440 {}
C {lab_pin.sym} 2660 20440 0 0 {name=l16389 lab=VDD}
N 2640 20360 2660 20360 {}
C {lab_pin.sym} 2660 20360 0 0 {name=l16390 lab=VSS}
C {bitcell_6t.sym} 2800 20400 0 0 {name=Xr102c14}
N 2760 20440 2740 20440 {}
C {lab_pin.sym} 2740 20440 0 0 {name=l16391 lab=BL14}
N 2760 20400 2740 20400 {}
C {lab_pin.sym} 2740 20400 0 0 {name=l16392 lab=BLB14}
N 2760 20360 2740 20360 {}
C {lab_pin.sym} 2740 20360 0 0 {name=l16393 lab=WL102}
N 2840 20440 2860 20440 {}
C {lab_pin.sym} 2860 20440 0 0 {name=l16394 lab=VDD}
N 2840 20360 2860 20360 {}
C {lab_pin.sym} 2860 20360 0 0 {name=l16395 lab=VSS}
C {bitcell_6t.sym} 3000 20400 0 0 {name=Xr102c15}
N 2960 20440 2940 20440 {}
C {lab_pin.sym} 2940 20440 0 0 {name=l16396 lab=BL15}
N 2960 20400 2940 20400 {}
C {lab_pin.sym} 2940 20400 0 0 {name=l16397 lab=BLB15}
N 2960 20360 2940 20360 {}
C {lab_pin.sym} 2940 20360 0 0 {name=l16398 lab=WL102}
N 3040 20440 3060 20440 {}
C {lab_pin.sym} 3060 20440 0 0 {name=l16399 lab=VDD}
N 3040 20360 3060 20360 {}
C {lab_pin.sym} 3060 20360 0 0 {name=l16400 lab=VSS}
C {bitcell_6t.sym} 3200 20400 0 0 {name=Xr102c16}
N 3160 20440 3140 20440 {}
C {lab_pin.sym} 3140 20440 0 0 {name=l16401 lab=BL16}
N 3160 20400 3140 20400 {}
C {lab_pin.sym} 3140 20400 0 0 {name=l16402 lab=BLB16}
N 3160 20360 3140 20360 {}
C {lab_pin.sym} 3140 20360 0 0 {name=l16403 lab=WL102}
N 3240 20440 3260 20440 {}
C {lab_pin.sym} 3260 20440 0 0 {name=l16404 lab=VDD}
N 3240 20360 3260 20360 {}
C {lab_pin.sym} 3260 20360 0 0 {name=l16405 lab=VSS}
C {bitcell_6t.sym} 3400 20400 0 0 {name=Xr102c17}
N 3360 20440 3340 20440 {}
C {lab_pin.sym} 3340 20440 0 0 {name=l16406 lab=BL17}
N 3360 20400 3340 20400 {}
C {lab_pin.sym} 3340 20400 0 0 {name=l16407 lab=BLB17}
N 3360 20360 3340 20360 {}
C {lab_pin.sym} 3340 20360 0 0 {name=l16408 lab=WL102}
N 3440 20440 3460 20440 {}
C {lab_pin.sym} 3460 20440 0 0 {name=l16409 lab=VDD}
N 3440 20360 3460 20360 {}
C {lab_pin.sym} 3460 20360 0 0 {name=l16410 lab=VSS}
C {bitcell_6t.sym} 3600 20400 0 0 {name=Xr102c18}
N 3560 20440 3540 20440 {}
C {lab_pin.sym} 3540 20440 0 0 {name=l16411 lab=BL18}
N 3560 20400 3540 20400 {}
C {lab_pin.sym} 3540 20400 0 0 {name=l16412 lab=BLB18}
N 3560 20360 3540 20360 {}
C {lab_pin.sym} 3540 20360 0 0 {name=l16413 lab=WL102}
N 3640 20440 3660 20440 {}
C {lab_pin.sym} 3660 20440 0 0 {name=l16414 lab=VDD}
N 3640 20360 3660 20360 {}
C {lab_pin.sym} 3660 20360 0 0 {name=l16415 lab=VSS}
C {bitcell_6t.sym} 3800 20400 0 0 {name=Xr102c19}
N 3760 20440 3740 20440 {}
C {lab_pin.sym} 3740 20440 0 0 {name=l16416 lab=BL19}
N 3760 20400 3740 20400 {}
C {lab_pin.sym} 3740 20400 0 0 {name=l16417 lab=BLB19}
N 3760 20360 3740 20360 {}
C {lab_pin.sym} 3740 20360 0 0 {name=l16418 lab=WL102}
N 3840 20440 3860 20440 {}
C {lab_pin.sym} 3860 20440 0 0 {name=l16419 lab=VDD}
N 3840 20360 3860 20360 {}
C {lab_pin.sym} 3860 20360 0 0 {name=l16420 lab=VSS}
C {bitcell_6t.sym} 4000 20400 0 0 {name=Xr102c20}
N 3960 20440 3940 20440 {}
C {lab_pin.sym} 3940 20440 0 0 {name=l16421 lab=BL20}
N 3960 20400 3940 20400 {}
C {lab_pin.sym} 3940 20400 0 0 {name=l16422 lab=BLB20}
N 3960 20360 3940 20360 {}
C {lab_pin.sym} 3940 20360 0 0 {name=l16423 lab=WL102}
N 4040 20440 4060 20440 {}
C {lab_pin.sym} 4060 20440 0 0 {name=l16424 lab=VDD}
N 4040 20360 4060 20360 {}
C {lab_pin.sym} 4060 20360 0 0 {name=l16425 lab=VSS}
C {bitcell_6t.sym} 4200 20400 0 0 {name=Xr102c21}
N 4160 20440 4140 20440 {}
C {lab_pin.sym} 4140 20440 0 0 {name=l16426 lab=BL21}
N 4160 20400 4140 20400 {}
C {lab_pin.sym} 4140 20400 0 0 {name=l16427 lab=BLB21}
N 4160 20360 4140 20360 {}
C {lab_pin.sym} 4140 20360 0 0 {name=l16428 lab=WL102}
N 4240 20440 4260 20440 {}
C {lab_pin.sym} 4260 20440 0 0 {name=l16429 lab=VDD}
N 4240 20360 4260 20360 {}
C {lab_pin.sym} 4260 20360 0 0 {name=l16430 lab=VSS}
C {bitcell_6t.sym} 4400 20400 0 0 {name=Xr102c22}
N 4360 20440 4340 20440 {}
C {lab_pin.sym} 4340 20440 0 0 {name=l16431 lab=BL22}
N 4360 20400 4340 20400 {}
C {lab_pin.sym} 4340 20400 0 0 {name=l16432 lab=BLB22}
N 4360 20360 4340 20360 {}
C {lab_pin.sym} 4340 20360 0 0 {name=l16433 lab=WL102}
N 4440 20440 4460 20440 {}
C {lab_pin.sym} 4460 20440 0 0 {name=l16434 lab=VDD}
N 4440 20360 4460 20360 {}
C {lab_pin.sym} 4460 20360 0 0 {name=l16435 lab=VSS}
C {bitcell_6t.sym} 4600 20400 0 0 {name=Xr102c23}
N 4560 20440 4540 20440 {}
C {lab_pin.sym} 4540 20440 0 0 {name=l16436 lab=BL23}
N 4560 20400 4540 20400 {}
C {lab_pin.sym} 4540 20400 0 0 {name=l16437 lab=BLB23}
N 4560 20360 4540 20360 {}
C {lab_pin.sym} 4540 20360 0 0 {name=l16438 lab=WL102}
N 4640 20440 4660 20440 {}
C {lab_pin.sym} 4660 20440 0 0 {name=l16439 lab=VDD}
N 4640 20360 4660 20360 {}
C {lab_pin.sym} 4660 20360 0 0 {name=l16440 lab=VSS}
C {bitcell_6t.sym} 4800 20400 0 0 {name=Xr102c24}
N 4760 20440 4740 20440 {}
C {lab_pin.sym} 4740 20440 0 0 {name=l16441 lab=BL24}
N 4760 20400 4740 20400 {}
C {lab_pin.sym} 4740 20400 0 0 {name=l16442 lab=BLB24}
N 4760 20360 4740 20360 {}
C {lab_pin.sym} 4740 20360 0 0 {name=l16443 lab=WL102}
N 4840 20440 4860 20440 {}
C {lab_pin.sym} 4860 20440 0 0 {name=l16444 lab=VDD}
N 4840 20360 4860 20360 {}
C {lab_pin.sym} 4860 20360 0 0 {name=l16445 lab=VSS}
C {bitcell_6t.sym} 5000 20400 0 0 {name=Xr102c25}
N 4960 20440 4940 20440 {}
C {lab_pin.sym} 4940 20440 0 0 {name=l16446 lab=BL25}
N 4960 20400 4940 20400 {}
C {lab_pin.sym} 4940 20400 0 0 {name=l16447 lab=BLB25}
N 4960 20360 4940 20360 {}
C {lab_pin.sym} 4940 20360 0 0 {name=l16448 lab=WL102}
N 5040 20440 5060 20440 {}
C {lab_pin.sym} 5060 20440 0 0 {name=l16449 lab=VDD}
N 5040 20360 5060 20360 {}
C {lab_pin.sym} 5060 20360 0 0 {name=l16450 lab=VSS}
C {bitcell_6t.sym} 5200 20400 0 0 {name=Xr102c26}
N 5160 20440 5140 20440 {}
C {lab_pin.sym} 5140 20440 0 0 {name=l16451 lab=BL26}
N 5160 20400 5140 20400 {}
C {lab_pin.sym} 5140 20400 0 0 {name=l16452 lab=BLB26}
N 5160 20360 5140 20360 {}
C {lab_pin.sym} 5140 20360 0 0 {name=l16453 lab=WL102}
N 5240 20440 5260 20440 {}
C {lab_pin.sym} 5260 20440 0 0 {name=l16454 lab=VDD}
N 5240 20360 5260 20360 {}
C {lab_pin.sym} 5260 20360 0 0 {name=l16455 lab=VSS}
C {bitcell_6t.sym} 5400 20400 0 0 {name=Xr102c27}
N 5360 20440 5340 20440 {}
C {lab_pin.sym} 5340 20440 0 0 {name=l16456 lab=BL27}
N 5360 20400 5340 20400 {}
C {lab_pin.sym} 5340 20400 0 0 {name=l16457 lab=BLB27}
N 5360 20360 5340 20360 {}
C {lab_pin.sym} 5340 20360 0 0 {name=l16458 lab=WL102}
N 5440 20440 5460 20440 {}
C {lab_pin.sym} 5460 20440 0 0 {name=l16459 lab=VDD}
N 5440 20360 5460 20360 {}
C {lab_pin.sym} 5460 20360 0 0 {name=l16460 lab=VSS}
C {bitcell_6t.sym} 5600 20400 0 0 {name=Xr102c28}
N 5560 20440 5540 20440 {}
C {lab_pin.sym} 5540 20440 0 0 {name=l16461 lab=BL28}
N 5560 20400 5540 20400 {}
C {lab_pin.sym} 5540 20400 0 0 {name=l16462 lab=BLB28}
N 5560 20360 5540 20360 {}
C {lab_pin.sym} 5540 20360 0 0 {name=l16463 lab=WL102}
N 5640 20440 5660 20440 {}
C {lab_pin.sym} 5660 20440 0 0 {name=l16464 lab=VDD}
N 5640 20360 5660 20360 {}
C {lab_pin.sym} 5660 20360 0 0 {name=l16465 lab=VSS}
C {bitcell_6t.sym} 5800 20400 0 0 {name=Xr102c29}
N 5760 20440 5740 20440 {}
C {lab_pin.sym} 5740 20440 0 0 {name=l16466 lab=BL29}
N 5760 20400 5740 20400 {}
C {lab_pin.sym} 5740 20400 0 0 {name=l16467 lab=BLB29}
N 5760 20360 5740 20360 {}
C {lab_pin.sym} 5740 20360 0 0 {name=l16468 lab=WL102}
N 5840 20440 5860 20440 {}
C {lab_pin.sym} 5860 20440 0 0 {name=l16469 lab=VDD}
N 5840 20360 5860 20360 {}
C {lab_pin.sym} 5860 20360 0 0 {name=l16470 lab=VSS}
C {bitcell_6t.sym} 6000 20400 0 0 {name=Xr102c30}
N 5960 20440 5940 20440 {}
C {lab_pin.sym} 5940 20440 0 0 {name=l16471 lab=BL30}
N 5960 20400 5940 20400 {}
C {lab_pin.sym} 5940 20400 0 0 {name=l16472 lab=BLB30}
N 5960 20360 5940 20360 {}
C {lab_pin.sym} 5940 20360 0 0 {name=l16473 lab=WL102}
N 6040 20440 6060 20440 {}
C {lab_pin.sym} 6060 20440 0 0 {name=l16474 lab=VDD}
N 6040 20360 6060 20360 {}
C {lab_pin.sym} 6060 20360 0 0 {name=l16475 lab=VSS}
C {bitcell_6t.sym} 6200 20400 0 0 {name=Xr102c31}
N 6160 20440 6140 20440 {}
C {lab_pin.sym} 6140 20440 0 0 {name=l16476 lab=BL31}
N 6160 20400 6140 20400 {}
C {lab_pin.sym} 6140 20400 0 0 {name=l16477 lab=BLB31}
N 6160 20360 6140 20360 {}
C {lab_pin.sym} 6140 20360 0 0 {name=l16478 lab=WL102}
N 6240 20440 6260 20440 {}
C {lab_pin.sym} 6260 20440 0 0 {name=l16479 lab=VDD}
N 6240 20360 6260 20360 {}
C {lab_pin.sym} 6260 20360 0 0 {name=l16480 lab=VSS}
C {bitcell_6t.sym} 0 20600 0 0 {name=Xr103c0}
N -40 20640 -60 20640 {}
C {lab_pin.sym} -60 20640 0 0 {name=l16481 lab=BL0}
N -40 20600 -60 20600 {}
C {lab_pin.sym} -60 20600 0 0 {name=l16482 lab=BLB0}
N -40 20560 -60 20560 {}
C {lab_pin.sym} -60 20560 0 0 {name=l16483 lab=WL103}
N 40 20640 60 20640 {}
C {lab_pin.sym} 60 20640 0 0 {name=l16484 lab=VDD}
N 40 20560 60 20560 {}
C {lab_pin.sym} 60 20560 0 0 {name=l16485 lab=VSS}
C {bitcell_6t.sym} 200 20600 0 0 {name=Xr103c1}
N 160 20640 140 20640 {}
C {lab_pin.sym} 140 20640 0 0 {name=l16486 lab=BL1}
N 160 20600 140 20600 {}
C {lab_pin.sym} 140 20600 0 0 {name=l16487 lab=BLB1}
N 160 20560 140 20560 {}
C {lab_pin.sym} 140 20560 0 0 {name=l16488 lab=WL103}
N 240 20640 260 20640 {}
C {lab_pin.sym} 260 20640 0 0 {name=l16489 lab=VDD}
N 240 20560 260 20560 {}
C {lab_pin.sym} 260 20560 0 0 {name=l16490 lab=VSS}
C {bitcell_6t.sym} 400 20600 0 0 {name=Xr103c2}
N 360 20640 340 20640 {}
C {lab_pin.sym} 340 20640 0 0 {name=l16491 lab=BL2}
N 360 20600 340 20600 {}
C {lab_pin.sym} 340 20600 0 0 {name=l16492 lab=BLB2}
N 360 20560 340 20560 {}
C {lab_pin.sym} 340 20560 0 0 {name=l16493 lab=WL103}
N 440 20640 460 20640 {}
C {lab_pin.sym} 460 20640 0 0 {name=l16494 lab=VDD}
N 440 20560 460 20560 {}
C {lab_pin.sym} 460 20560 0 0 {name=l16495 lab=VSS}
C {bitcell_6t.sym} 600 20600 0 0 {name=Xr103c3}
N 560 20640 540 20640 {}
C {lab_pin.sym} 540 20640 0 0 {name=l16496 lab=BL3}
N 560 20600 540 20600 {}
C {lab_pin.sym} 540 20600 0 0 {name=l16497 lab=BLB3}
N 560 20560 540 20560 {}
C {lab_pin.sym} 540 20560 0 0 {name=l16498 lab=WL103}
N 640 20640 660 20640 {}
C {lab_pin.sym} 660 20640 0 0 {name=l16499 lab=VDD}
N 640 20560 660 20560 {}
C {lab_pin.sym} 660 20560 0 0 {name=l16500 lab=VSS}
C {bitcell_6t.sym} 800 20600 0 0 {name=Xr103c4}
N 760 20640 740 20640 {}
C {lab_pin.sym} 740 20640 0 0 {name=l16501 lab=BL4}
N 760 20600 740 20600 {}
C {lab_pin.sym} 740 20600 0 0 {name=l16502 lab=BLB4}
N 760 20560 740 20560 {}
C {lab_pin.sym} 740 20560 0 0 {name=l16503 lab=WL103}
N 840 20640 860 20640 {}
C {lab_pin.sym} 860 20640 0 0 {name=l16504 lab=VDD}
N 840 20560 860 20560 {}
C {lab_pin.sym} 860 20560 0 0 {name=l16505 lab=VSS}
C {bitcell_6t.sym} 1000 20600 0 0 {name=Xr103c5}
N 960 20640 940 20640 {}
C {lab_pin.sym} 940 20640 0 0 {name=l16506 lab=BL5}
N 960 20600 940 20600 {}
C {lab_pin.sym} 940 20600 0 0 {name=l16507 lab=BLB5}
N 960 20560 940 20560 {}
C {lab_pin.sym} 940 20560 0 0 {name=l16508 lab=WL103}
N 1040 20640 1060 20640 {}
C {lab_pin.sym} 1060 20640 0 0 {name=l16509 lab=VDD}
N 1040 20560 1060 20560 {}
C {lab_pin.sym} 1060 20560 0 0 {name=l16510 lab=VSS}
C {bitcell_6t.sym} 1200 20600 0 0 {name=Xr103c6}
N 1160 20640 1140 20640 {}
C {lab_pin.sym} 1140 20640 0 0 {name=l16511 lab=BL6}
N 1160 20600 1140 20600 {}
C {lab_pin.sym} 1140 20600 0 0 {name=l16512 lab=BLB6}
N 1160 20560 1140 20560 {}
C {lab_pin.sym} 1140 20560 0 0 {name=l16513 lab=WL103}
N 1240 20640 1260 20640 {}
C {lab_pin.sym} 1260 20640 0 0 {name=l16514 lab=VDD}
N 1240 20560 1260 20560 {}
C {lab_pin.sym} 1260 20560 0 0 {name=l16515 lab=VSS}
C {bitcell_6t.sym} 1400 20600 0 0 {name=Xr103c7}
N 1360 20640 1340 20640 {}
C {lab_pin.sym} 1340 20640 0 0 {name=l16516 lab=BL7}
N 1360 20600 1340 20600 {}
C {lab_pin.sym} 1340 20600 0 0 {name=l16517 lab=BLB7}
N 1360 20560 1340 20560 {}
C {lab_pin.sym} 1340 20560 0 0 {name=l16518 lab=WL103}
N 1440 20640 1460 20640 {}
C {lab_pin.sym} 1460 20640 0 0 {name=l16519 lab=VDD}
N 1440 20560 1460 20560 {}
C {lab_pin.sym} 1460 20560 0 0 {name=l16520 lab=VSS}
C {bitcell_6t.sym} 1600 20600 0 0 {name=Xr103c8}
N 1560 20640 1540 20640 {}
C {lab_pin.sym} 1540 20640 0 0 {name=l16521 lab=BL8}
N 1560 20600 1540 20600 {}
C {lab_pin.sym} 1540 20600 0 0 {name=l16522 lab=BLB8}
N 1560 20560 1540 20560 {}
C {lab_pin.sym} 1540 20560 0 0 {name=l16523 lab=WL103}
N 1640 20640 1660 20640 {}
C {lab_pin.sym} 1660 20640 0 0 {name=l16524 lab=VDD}
N 1640 20560 1660 20560 {}
C {lab_pin.sym} 1660 20560 0 0 {name=l16525 lab=VSS}
C {bitcell_6t.sym} 1800 20600 0 0 {name=Xr103c9}
N 1760 20640 1740 20640 {}
C {lab_pin.sym} 1740 20640 0 0 {name=l16526 lab=BL9}
N 1760 20600 1740 20600 {}
C {lab_pin.sym} 1740 20600 0 0 {name=l16527 lab=BLB9}
N 1760 20560 1740 20560 {}
C {lab_pin.sym} 1740 20560 0 0 {name=l16528 lab=WL103}
N 1840 20640 1860 20640 {}
C {lab_pin.sym} 1860 20640 0 0 {name=l16529 lab=VDD}
N 1840 20560 1860 20560 {}
C {lab_pin.sym} 1860 20560 0 0 {name=l16530 lab=VSS}
C {bitcell_6t.sym} 2000 20600 0 0 {name=Xr103c10}
N 1960 20640 1940 20640 {}
C {lab_pin.sym} 1940 20640 0 0 {name=l16531 lab=BL10}
N 1960 20600 1940 20600 {}
C {lab_pin.sym} 1940 20600 0 0 {name=l16532 lab=BLB10}
N 1960 20560 1940 20560 {}
C {lab_pin.sym} 1940 20560 0 0 {name=l16533 lab=WL103}
N 2040 20640 2060 20640 {}
C {lab_pin.sym} 2060 20640 0 0 {name=l16534 lab=VDD}
N 2040 20560 2060 20560 {}
C {lab_pin.sym} 2060 20560 0 0 {name=l16535 lab=VSS}
C {bitcell_6t.sym} 2200 20600 0 0 {name=Xr103c11}
N 2160 20640 2140 20640 {}
C {lab_pin.sym} 2140 20640 0 0 {name=l16536 lab=BL11}
N 2160 20600 2140 20600 {}
C {lab_pin.sym} 2140 20600 0 0 {name=l16537 lab=BLB11}
N 2160 20560 2140 20560 {}
C {lab_pin.sym} 2140 20560 0 0 {name=l16538 lab=WL103}
N 2240 20640 2260 20640 {}
C {lab_pin.sym} 2260 20640 0 0 {name=l16539 lab=VDD}
N 2240 20560 2260 20560 {}
C {lab_pin.sym} 2260 20560 0 0 {name=l16540 lab=VSS}
C {bitcell_6t.sym} 2400 20600 0 0 {name=Xr103c12}
N 2360 20640 2340 20640 {}
C {lab_pin.sym} 2340 20640 0 0 {name=l16541 lab=BL12}
N 2360 20600 2340 20600 {}
C {lab_pin.sym} 2340 20600 0 0 {name=l16542 lab=BLB12}
N 2360 20560 2340 20560 {}
C {lab_pin.sym} 2340 20560 0 0 {name=l16543 lab=WL103}
N 2440 20640 2460 20640 {}
C {lab_pin.sym} 2460 20640 0 0 {name=l16544 lab=VDD}
N 2440 20560 2460 20560 {}
C {lab_pin.sym} 2460 20560 0 0 {name=l16545 lab=VSS}
C {bitcell_6t.sym} 2600 20600 0 0 {name=Xr103c13}
N 2560 20640 2540 20640 {}
C {lab_pin.sym} 2540 20640 0 0 {name=l16546 lab=BL13}
N 2560 20600 2540 20600 {}
C {lab_pin.sym} 2540 20600 0 0 {name=l16547 lab=BLB13}
N 2560 20560 2540 20560 {}
C {lab_pin.sym} 2540 20560 0 0 {name=l16548 lab=WL103}
N 2640 20640 2660 20640 {}
C {lab_pin.sym} 2660 20640 0 0 {name=l16549 lab=VDD}
N 2640 20560 2660 20560 {}
C {lab_pin.sym} 2660 20560 0 0 {name=l16550 lab=VSS}
C {bitcell_6t.sym} 2800 20600 0 0 {name=Xr103c14}
N 2760 20640 2740 20640 {}
C {lab_pin.sym} 2740 20640 0 0 {name=l16551 lab=BL14}
N 2760 20600 2740 20600 {}
C {lab_pin.sym} 2740 20600 0 0 {name=l16552 lab=BLB14}
N 2760 20560 2740 20560 {}
C {lab_pin.sym} 2740 20560 0 0 {name=l16553 lab=WL103}
N 2840 20640 2860 20640 {}
C {lab_pin.sym} 2860 20640 0 0 {name=l16554 lab=VDD}
N 2840 20560 2860 20560 {}
C {lab_pin.sym} 2860 20560 0 0 {name=l16555 lab=VSS}
C {bitcell_6t.sym} 3000 20600 0 0 {name=Xr103c15}
N 2960 20640 2940 20640 {}
C {lab_pin.sym} 2940 20640 0 0 {name=l16556 lab=BL15}
N 2960 20600 2940 20600 {}
C {lab_pin.sym} 2940 20600 0 0 {name=l16557 lab=BLB15}
N 2960 20560 2940 20560 {}
C {lab_pin.sym} 2940 20560 0 0 {name=l16558 lab=WL103}
N 3040 20640 3060 20640 {}
C {lab_pin.sym} 3060 20640 0 0 {name=l16559 lab=VDD}
N 3040 20560 3060 20560 {}
C {lab_pin.sym} 3060 20560 0 0 {name=l16560 lab=VSS}
C {bitcell_6t.sym} 3200 20600 0 0 {name=Xr103c16}
N 3160 20640 3140 20640 {}
C {lab_pin.sym} 3140 20640 0 0 {name=l16561 lab=BL16}
N 3160 20600 3140 20600 {}
C {lab_pin.sym} 3140 20600 0 0 {name=l16562 lab=BLB16}
N 3160 20560 3140 20560 {}
C {lab_pin.sym} 3140 20560 0 0 {name=l16563 lab=WL103}
N 3240 20640 3260 20640 {}
C {lab_pin.sym} 3260 20640 0 0 {name=l16564 lab=VDD}
N 3240 20560 3260 20560 {}
C {lab_pin.sym} 3260 20560 0 0 {name=l16565 lab=VSS}
C {bitcell_6t.sym} 3400 20600 0 0 {name=Xr103c17}
N 3360 20640 3340 20640 {}
C {lab_pin.sym} 3340 20640 0 0 {name=l16566 lab=BL17}
N 3360 20600 3340 20600 {}
C {lab_pin.sym} 3340 20600 0 0 {name=l16567 lab=BLB17}
N 3360 20560 3340 20560 {}
C {lab_pin.sym} 3340 20560 0 0 {name=l16568 lab=WL103}
N 3440 20640 3460 20640 {}
C {lab_pin.sym} 3460 20640 0 0 {name=l16569 lab=VDD}
N 3440 20560 3460 20560 {}
C {lab_pin.sym} 3460 20560 0 0 {name=l16570 lab=VSS}
C {bitcell_6t.sym} 3600 20600 0 0 {name=Xr103c18}
N 3560 20640 3540 20640 {}
C {lab_pin.sym} 3540 20640 0 0 {name=l16571 lab=BL18}
N 3560 20600 3540 20600 {}
C {lab_pin.sym} 3540 20600 0 0 {name=l16572 lab=BLB18}
N 3560 20560 3540 20560 {}
C {lab_pin.sym} 3540 20560 0 0 {name=l16573 lab=WL103}
N 3640 20640 3660 20640 {}
C {lab_pin.sym} 3660 20640 0 0 {name=l16574 lab=VDD}
N 3640 20560 3660 20560 {}
C {lab_pin.sym} 3660 20560 0 0 {name=l16575 lab=VSS}
C {bitcell_6t.sym} 3800 20600 0 0 {name=Xr103c19}
N 3760 20640 3740 20640 {}
C {lab_pin.sym} 3740 20640 0 0 {name=l16576 lab=BL19}
N 3760 20600 3740 20600 {}
C {lab_pin.sym} 3740 20600 0 0 {name=l16577 lab=BLB19}
N 3760 20560 3740 20560 {}
C {lab_pin.sym} 3740 20560 0 0 {name=l16578 lab=WL103}
N 3840 20640 3860 20640 {}
C {lab_pin.sym} 3860 20640 0 0 {name=l16579 lab=VDD}
N 3840 20560 3860 20560 {}
C {lab_pin.sym} 3860 20560 0 0 {name=l16580 lab=VSS}
C {bitcell_6t.sym} 4000 20600 0 0 {name=Xr103c20}
N 3960 20640 3940 20640 {}
C {lab_pin.sym} 3940 20640 0 0 {name=l16581 lab=BL20}
N 3960 20600 3940 20600 {}
C {lab_pin.sym} 3940 20600 0 0 {name=l16582 lab=BLB20}
N 3960 20560 3940 20560 {}
C {lab_pin.sym} 3940 20560 0 0 {name=l16583 lab=WL103}
N 4040 20640 4060 20640 {}
C {lab_pin.sym} 4060 20640 0 0 {name=l16584 lab=VDD}
N 4040 20560 4060 20560 {}
C {lab_pin.sym} 4060 20560 0 0 {name=l16585 lab=VSS}
C {bitcell_6t.sym} 4200 20600 0 0 {name=Xr103c21}
N 4160 20640 4140 20640 {}
C {lab_pin.sym} 4140 20640 0 0 {name=l16586 lab=BL21}
N 4160 20600 4140 20600 {}
C {lab_pin.sym} 4140 20600 0 0 {name=l16587 lab=BLB21}
N 4160 20560 4140 20560 {}
C {lab_pin.sym} 4140 20560 0 0 {name=l16588 lab=WL103}
N 4240 20640 4260 20640 {}
C {lab_pin.sym} 4260 20640 0 0 {name=l16589 lab=VDD}
N 4240 20560 4260 20560 {}
C {lab_pin.sym} 4260 20560 0 0 {name=l16590 lab=VSS}
C {bitcell_6t.sym} 4400 20600 0 0 {name=Xr103c22}
N 4360 20640 4340 20640 {}
C {lab_pin.sym} 4340 20640 0 0 {name=l16591 lab=BL22}
N 4360 20600 4340 20600 {}
C {lab_pin.sym} 4340 20600 0 0 {name=l16592 lab=BLB22}
N 4360 20560 4340 20560 {}
C {lab_pin.sym} 4340 20560 0 0 {name=l16593 lab=WL103}
N 4440 20640 4460 20640 {}
C {lab_pin.sym} 4460 20640 0 0 {name=l16594 lab=VDD}
N 4440 20560 4460 20560 {}
C {lab_pin.sym} 4460 20560 0 0 {name=l16595 lab=VSS}
C {bitcell_6t.sym} 4600 20600 0 0 {name=Xr103c23}
N 4560 20640 4540 20640 {}
C {lab_pin.sym} 4540 20640 0 0 {name=l16596 lab=BL23}
N 4560 20600 4540 20600 {}
C {lab_pin.sym} 4540 20600 0 0 {name=l16597 lab=BLB23}
N 4560 20560 4540 20560 {}
C {lab_pin.sym} 4540 20560 0 0 {name=l16598 lab=WL103}
N 4640 20640 4660 20640 {}
C {lab_pin.sym} 4660 20640 0 0 {name=l16599 lab=VDD}
N 4640 20560 4660 20560 {}
C {lab_pin.sym} 4660 20560 0 0 {name=l16600 lab=VSS}
C {bitcell_6t.sym} 4800 20600 0 0 {name=Xr103c24}
N 4760 20640 4740 20640 {}
C {lab_pin.sym} 4740 20640 0 0 {name=l16601 lab=BL24}
N 4760 20600 4740 20600 {}
C {lab_pin.sym} 4740 20600 0 0 {name=l16602 lab=BLB24}
N 4760 20560 4740 20560 {}
C {lab_pin.sym} 4740 20560 0 0 {name=l16603 lab=WL103}
N 4840 20640 4860 20640 {}
C {lab_pin.sym} 4860 20640 0 0 {name=l16604 lab=VDD}
N 4840 20560 4860 20560 {}
C {lab_pin.sym} 4860 20560 0 0 {name=l16605 lab=VSS}
C {bitcell_6t.sym} 5000 20600 0 0 {name=Xr103c25}
N 4960 20640 4940 20640 {}
C {lab_pin.sym} 4940 20640 0 0 {name=l16606 lab=BL25}
N 4960 20600 4940 20600 {}
C {lab_pin.sym} 4940 20600 0 0 {name=l16607 lab=BLB25}
N 4960 20560 4940 20560 {}
C {lab_pin.sym} 4940 20560 0 0 {name=l16608 lab=WL103}
N 5040 20640 5060 20640 {}
C {lab_pin.sym} 5060 20640 0 0 {name=l16609 lab=VDD}
N 5040 20560 5060 20560 {}
C {lab_pin.sym} 5060 20560 0 0 {name=l16610 lab=VSS}
C {bitcell_6t.sym} 5200 20600 0 0 {name=Xr103c26}
N 5160 20640 5140 20640 {}
C {lab_pin.sym} 5140 20640 0 0 {name=l16611 lab=BL26}
N 5160 20600 5140 20600 {}
C {lab_pin.sym} 5140 20600 0 0 {name=l16612 lab=BLB26}
N 5160 20560 5140 20560 {}
C {lab_pin.sym} 5140 20560 0 0 {name=l16613 lab=WL103}
N 5240 20640 5260 20640 {}
C {lab_pin.sym} 5260 20640 0 0 {name=l16614 lab=VDD}
N 5240 20560 5260 20560 {}
C {lab_pin.sym} 5260 20560 0 0 {name=l16615 lab=VSS}
C {bitcell_6t.sym} 5400 20600 0 0 {name=Xr103c27}
N 5360 20640 5340 20640 {}
C {lab_pin.sym} 5340 20640 0 0 {name=l16616 lab=BL27}
N 5360 20600 5340 20600 {}
C {lab_pin.sym} 5340 20600 0 0 {name=l16617 lab=BLB27}
N 5360 20560 5340 20560 {}
C {lab_pin.sym} 5340 20560 0 0 {name=l16618 lab=WL103}
N 5440 20640 5460 20640 {}
C {lab_pin.sym} 5460 20640 0 0 {name=l16619 lab=VDD}
N 5440 20560 5460 20560 {}
C {lab_pin.sym} 5460 20560 0 0 {name=l16620 lab=VSS}
C {bitcell_6t.sym} 5600 20600 0 0 {name=Xr103c28}
N 5560 20640 5540 20640 {}
C {lab_pin.sym} 5540 20640 0 0 {name=l16621 lab=BL28}
N 5560 20600 5540 20600 {}
C {lab_pin.sym} 5540 20600 0 0 {name=l16622 lab=BLB28}
N 5560 20560 5540 20560 {}
C {lab_pin.sym} 5540 20560 0 0 {name=l16623 lab=WL103}
N 5640 20640 5660 20640 {}
C {lab_pin.sym} 5660 20640 0 0 {name=l16624 lab=VDD}
N 5640 20560 5660 20560 {}
C {lab_pin.sym} 5660 20560 0 0 {name=l16625 lab=VSS}
C {bitcell_6t.sym} 5800 20600 0 0 {name=Xr103c29}
N 5760 20640 5740 20640 {}
C {lab_pin.sym} 5740 20640 0 0 {name=l16626 lab=BL29}
N 5760 20600 5740 20600 {}
C {lab_pin.sym} 5740 20600 0 0 {name=l16627 lab=BLB29}
N 5760 20560 5740 20560 {}
C {lab_pin.sym} 5740 20560 0 0 {name=l16628 lab=WL103}
N 5840 20640 5860 20640 {}
C {lab_pin.sym} 5860 20640 0 0 {name=l16629 lab=VDD}
N 5840 20560 5860 20560 {}
C {lab_pin.sym} 5860 20560 0 0 {name=l16630 lab=VSS}
C {bitcell_6t.sym} 6000 20600 0 0 {name=Xr103c30}
N 5960 20640 5940 20640 {}
C {lab_pin.sym} 5940 20640 0 0 {name=l16631 lab=BL30}
N 5960 20600 5940 20600 {}
C {lab_pin.sym} 5940 20600 0 0 {name=l16632 lab=BLB30}
N 5960 20560 5940 20560 {}
C {lab_pin.sym} 5940 20560 0 0 {name=l16633 lab=WL103}
N 6040 20640 6060 20640 {}
C {lab_pin.sym} 6060 20640 0 0 {name=l16634 lab=VDD}
N 6040 20560 6060 20560 {}
C {lab_pin.sym} 6060 20560 0 0 {name=l16635 lab=VSS}
C {bitcell_6t.sym} 6200 20600 0 0 {name=Xr103c31}
N 6160 20640 6140 20640 {}
C {lab_pin.sym} 6140 20640 0 0 {name=l16636 lab=BL31}
N 6160 20600 6140 20600 {}
C {lab_pin.sym} 6140 20600 0 0 {name=l16637 lab=BLB31}
N 6160 20560 6140 20560 {}
C {lab_pin.sym} 6140 20560 0 0 {name=l16638 lab=WL103}
N 6240 20640 6260 20640 {}
C {lab_pin.sym} 6260 20640 0 0 {name=l16639 lab=VDD}
N 6240 20560 6260 20560 {}
C {lab_pin.sym} 6260 20560 0 0 {name=l16640 lab=VSS}
C {bitcell_6t.sym} 0 20800 0 0 {name=Xr104c0}
N -40 20840 -60 20840 {}
C {lab_pin.sym} -60 20840 0 0 {name=l16641 lab=BL0}
N -40 20800 -60 20800 {}
C {lab_pin.sym} -60 20800 0 0 {name=l16642 lab=BLB0}
N -40 20760 -60 20760 {}
C {lab_pin.sym} -60 20760 0 0 {name=l16643 lab=WL104}
N 40 20840 60 20840 {}
C {lab_pin.sym} 60 20840 0 0 {name=l16644 lab=VDD}
N 40 20760 60 20760 {}
C {lab_pin.sym} 60 20760 0 0 {name=l16645 lab=VSS}
C {bitcell_6t.sym} 200 20800 0 0 {name=Xr104c1}
N 160 20840 140 20840 {}
C {lab_pin.sym} 140 20840 0 0 {name=l16646 lab=BL1}
N 160 20800 140 20800 {}
C {lab_pin.sym} 140 20800 0 0 {name=l16647 lab=BLB1}
N 160 20760 140 20760 {}
C {lab_pin.sym} 140 20760 0 0 {name=l16648 lab=WL104}
N 240 20840 260 20840 {}
C {lab_pin.sym} 260 20840 0 0 {name=l16649 lab=VDD}
N 240 20760 260 20760 {}
C {lab_pin.sym} 260 20760 0 0 {name=l16650 lab=VSS}
C {bitcell_6t.sym} 400 20800 0 0 {name=Xr104c2}
N 360 20840 340 20840 {}
C {lab_pin.sym} 340 20840 0 0 {name=l16651 lab=BL2}
N 360 20800 340 20800 {}
C {lab_pin.sym} 340 20800 0 0 {name=l16652 lab=BLB2}
N 360 20760 340 20760 {}
C {lab_pin.sym} 340 20760 0 0 {name=l16653 lab=WL104}
N 440 20840 460 20840 {}
C {lab_pin.sym} 460 20840 0 0 {name=l16654 lab=VDD}
N 440 20760 460 20760 {}
C {lab_pin.sym} 460 20760 0 0 {name=l16655 lab=VSS}
C {bitcell_6t.sym} 600 20800 0 0 {name=Xr104c3}
N 560 20840 540 20840 {}
C {lab_pin.sym} 540 20840 0 0 {name=l16656 lab=BL3}
N 560 20800 540 20800 {}
C {lab_pin.sym} 540 20800 0 0 {name=l16657 lab=BLB3}
N 560 20760 540 20760 {}
C {lab_pin.sym} 540 20760 0 0 {name=l16658 lab=WL104}
N 640 20840 660 20840 {}
C {lab_pin.sym} 660 20840 0 0 {name=l16659 lab=VDD}
N 640 20760 660 20760 {}
C {lab_pin.sym} 660 20760 0 0 {name=l16660 lab=VSS}
C {bitcell_6t.sym} 800 20800 0 0 {name=Xr104c4}
N 760 20840 740 20840 {}
C {lab_pin.sym} 740 20840 0 0 {name=l16661 lab=BL4}
N 760 20800 740 20800 {}
C {lab_pin.sym} 740 20800 0 0 {name=l16662 lab=BLB4}
N 760 20760 740 20760 {}
C {lab_pin.sym} 740 20760 0 0 {name=l16663 lab=WL104}
N 840 20840 860 20840 {}
C {lab_pin.sym} 860 20840 0 0 {name=l16664 lab=VDD}
N 840 20760 860 20760 {}
C {lab_pin.sym} 860 20760 0 0 {name=l16665 lab=VSS}
C {bitcell_6t.sym} 1000 20800 0 0 {name=Xr104c5}
N 960 20840 940 20840 {}
C {lab_pin.sym} 940 20840 0 0 {name=l16666 lab=BL5}
N 960 20800 940 20800 {}
C {lab_pin.sym} 940 20800 0 0 {name=l16667 lab=BLB5}
N 960 20760 940 20760 {}
C {lab_pin.sym} 940 20760 0 0 {name=l16668 lab=WL104}
N 1040 20840 1060 20840 {}
C {lab_pin.sym} 1060 20840 0 0 {name=l16669 lab=VDD}
N 1040 20760 1060 20760 {}
C {lab_pin.sym} 1060 20760 0 0 {name=l16670 lab=VSS}
C {bitcell_6t.sym} 1200 20800 0 0 {name=Xr104c6}
N 1160 20840 1140 20840 {}
C {lab_pin.sym} 1140 20840 0 0 {name=l16671 lab=BL6}
N 1160 20800 1140 20800 {}
C {lab_pin.sym} 1140 20800 0 0 {name=l16672 lab=BLB6}
N 1160 20760 1140 20760 {}
C {lab_pin.sym} 1140 20760 0 0 {name=l16673 lab=WL104}
N 1240 20840 1260 20840 {}
C {lab_pin.sym} 1260 20840 0 0 {name=l16674 lab=VDD}
N 1240 20760 1260 20760 {}
C {lab_pin.sym} 1260 20760 0 0 {name=l16675 lab=VSS}
C {bitcell_6t.sym} 1400 20800 0 0 {name=Xr104c7}
N 1360 20840 1340 20840 {}
C {lab_pin.sym} 1340 20840 0 0 {name=l16676 lab=BL7}
N 1360 20800 1340 20800 {}
C {lab_pin.sym} 1340 20800 0 0 {name=l16677 lab=BLB7}
N 1360 20760 1340 20760 {}
C {lab_pin.sym} 1340 20760 0 0 {name=l16678 lab=WL104}
N 1440 20840 1460 20840 {}
C {lab_pin.sym} 1460 20840 0 0 {name=l16679 lab=VDD}
N 1440 20760 1460 20760 {}
C {lab_pin.sym} 1460 20760 0 0 {name=l16680 lab=VSS}
C {bitcell_6t.sym} 1600 20800 0 0 {name=Xr104c8}
N 1560 20840 1540 20840 {}
C {lab_pin.sym} 1540 20840 0 0 {name=l16681 lab=BL8}
N 1560 20800 1540 20800 {}
C {lab_pin.sym} 1540 20800 0 0 {name=l16682 lab=BLB8}
N 1560 20760 1540 20760 {}
C {lab_pin.sym} 1540 20760 0 0 {name=l16683 lab=WL104}
N 1640 20840 1660 20840 {}
C {lab_pin.sym} 1660 20840 0 0 {name=l16684 lab=VDD}
N 1640 20760 1660 20760 {}
C {lab_pin.sym} 1660 20760 0 0 {name=l16685 lab=VSS}
C {bitcell_6t.sym} 1800 20800 0 0 {name=Xr104c9}
N 1760 20840 1740 20840 {}
C {lab_pin.sym} 1740 20840 0 0 {name=l16686 lab=BL9}
N 1760 20800 1740 20800 {}
C {lab_pin.sym} 1740 20800 0 0 {name=l16687 lab=BLB9}
N 1760 20760 1740 20760 {}
C {lab_pin.sym} 1740 20760 0 0 {name=l16688 lab=WL104}
N 1840 20840 1860 20840 {}
C {lab_pin.sym} 1860 20840 0 0 {name=l16689 lab=VDD}
N 1840 20760 1860 20760 {}
C {lab_pin.sym} 1860 20760 0 0 {name=l16690 lab=VSS}
C {bitcell_6t.sym} 2000 20800 0 0 {name=Xr104c10}
N 1960 20840 1940 20840 {}
C {lab_pin.sym} 1940 20840 0 0 {name=l16691 lab=BL10}
N 1960 20800 1940 20800 {}
C {lab_pin.sym} 1940 20800 0 0 {name=l16692 lab=BLB10}
N 1960 20760 1940 20760 {}
C {lab_pin.sym} 1940 20760 0 0 {name=l16693 lab=WL104}
N 2040 20840 2060 20840 {}
C {lab_pin.sym} 2060 20840 0 0 {name=l16694 lab=VDD}
N 2040 20760 2060 20760 {}
C {lab_pin.sym} 2060 20760 0 0 {name=l16695 lab=VSS}
C {bitcell_6t.sym} 2200 20800 0 0 {name=Xr104c11}
N 2160 20840 2140 20840 {}
C {lab_pin.sym} 2140 20840 0 0 {name=l16696 lab=BL11}
N 2160 20800 2140 20800 {}
C {lab_pin.sym} 2140 20800 0 0 {name=l16697 lab=BLB11}
N 2160 20760 2140 20760 {}
C {lab_pin.sym} 2140 20760 0 0 {name=l16698 lab=WL104}
N 2240 20840 2260 20840 {}
C {lab_pin.sym} 2260 20840 0 0 {name=l16699 lab=VDD}
N 2240 20760 2260 20760 {}
C {lab_pin.sym} 2260 20760 0 0 {name=l16700 lab=VSS}
C {bitcell_6t.sym} 2400 20800 0 0 {name=Xr104c12}
N 2360 20840 2340 20840 {}
C {lab_pin.sym} 2340 20840 0 0 {name=l16701 lab=BL12}
N 2360 20800 2340 20800 {}
C {lab_pin.sym} 2340 20800 0 0 {name=l16702 lab=BLB12}
N 2360 20760 2340 20760 {}
C {lab_pin.sym} 2340 20760 0 0 {name=l16703 lab=WL104}
N 2440 20840 2460 20840 {}
C {lab_pin.sym} 2460 20840 0 0 {name=l16704 lab=VDD}
N 2440 20760 2460 20760 {}
C {lab_pin.sym} 2460 20760 0 0 {name=l16705 lab=VSS}
C {bitcell_6t.sym} 2600 20800 0 0 {name=Xr104c13}
N 2560 20840 2540 20840 {}
C {lab_pin.sym} 2540 20840 0 0 {name=l16706 lab=BL13}
N 2560 20800 2540 20800 {}
C {lab_pin.sym} 2540 20800 0 0 {name=l16707 lab=BLB13}
N 2560 20760 2540 20760 {}
C {lab_pin.sym} 2540 20760 0 0 {name=l16708 lab=WL104}
N 2640 20840 2660 20840 {}
C {lab_pin.sym} 2660 20840 0 0 {name=l16709 lab=VDD}
N 2640 20760 2660 20760 {}
C {lab_pin.sym} 2660 20760 0 0 {name=l16710 lab=VSS}
C {bitcell_6t.sym} 2800 20800 0 0 {name=Xr104c14}
N 2760 20840 2740 20840 {}
C {lab_pin.sym} 2740 20840 0 0 {name=l16711 lab=BL14}
N 2760 20800 2740 20800 {}
C {lab_pin.sym} 2740 20800 0 0 {name=l16712 lab=BLB14}
N 2760 20760 2740 20760 {}
C {lab_pin.sym} 2740 20760 0 0 {name=l16713 lab=WL104}
N 2840 20840 2860 20840 {}
C {lab_pin.sym} 2860 20840 0 0 {name=l16714 lab=VDD}
N 2840 20760 2860 20760 {}
C {lab_pin.sym} 2860 20760 0 0 {name=l16715 lab=VSS}
C {bitcell_6t.sym} 3000 20800 0 0 {name=Xr104c15}
N 2960 20840 2940 20840 {}
C {lab_pin.sym} 2940 20840 0 0 {name=l16716 lab=BL15}
N 2960 20800 2940 20800 {}
C {lab_pin.sym} 2940 20800 0 0 {name=l16717 lab=BLB15}
N 2960 20760 2940 20760 {}
C {lab_pin.sym} 2940 20760 0 0 {name=l16718 lab=WL104}
N 3040 20840 3060 20840 {}
C {lab_pin.sym} 3060 20840 0 0 {name=l16719 lab=VDD}
N 3040 20760 3060 20760 {}
C {lab_pin.sym} 3060 20760 0 0 {name=l16720 lab=VSS}
C {bitcell_6t.sym} 3200 20800 0 0 {name=Xr104c16}
N 3160 20840 3140 20840 {}
C {lab_pin.sym} 3140 20840 0 0 {name=l16721 lab=BL16}
N 3160 20800 3140 20800 {}
C {lab_pin.sym} 3140 20800 0 0 {name=l16722 lab=BLB16}
N 3160 20760 3140 20760 {}
C {lab_pin.sym} 3140 20760 0 0 {name=l16723 lab=WL104}
N 3240 20840 3260 20840 {}
C {lab_pin.sym} 3260 20840 0 0 {name=l16724 lab=VDD}
N 3240 20760 3260 20760 {}
C {lab_pin.sym} 3260 20760 0 0 {name=l16725 lab=VSS}
C {bitcell_6t.sym} 3400 20800 0 0 {name=Xr104c17}
N 3360 20840 3340 20840 {}
C {lab_pin.sym} 3340 20840 0 0 {name=l16726 lab=BL17}
N 3360 20800 3340 20800 {}
C {lab_pin.sym} 3340 20800 0 0 {name=l16727 lab=BLB17}
N 3360 20760 3340 20760 {}
C {lab_pin.sym} 3340 20760 0 0 {name=l16728 lab=WL104}
N 3440 20840 3460 20840 {}
C {lab_pin.sym} 3460 20840 0 0 {name=l16729 lab=VDD}
N 3440 20760 3460 20760 {}
C {lab_pin.sym} 3460 20760 0 0 {name=l16730 lab=VSS}
C {bitcell_6t.sym} 3600 20800 0 0 {name=Xr104c18}
N 3560 20840 3540 20840 {}
C {lab_pin.sym} 3540 20840 0 0 {name=l16731 lab=BL18}
N 3560 20800 3540 20800 {}
C {lab_pin.sym} 3540 20800 0 0 {name=l16732 lab=BLB18}
N 3560 20760 3540 20760 {}
C {lab_pin.sym} 3540 20760 0 0 {name=l16733 lab=WL104}
N 3640 20840 3660 20840 {}
C {lab_pin.sym} 3660 20840 0 0 {name=l16734 lab=VDD}
N 3640 20760 3660 20760 {}
C {lab_pin.sym} 3660 20760 0 0 {name=l16735 lab=VSS}
C {bitcell_6t.sym} 3800 20800 0 0 {name=Xr104c19}
N 3760 20840 3740 20840 {}
C {lab_pin.sym} 3740 20840 0 0 {name=l16736 lab=BL19}
N 3760 20800 3740 20800 {}
C {lab_pin.sym} 3740 20800 0 0 {name=l16737 lab=BLB19}
N 3760 20760 3740 20760 {}
C {lab_pin.sym} 3740 20760 0 0 {name=l16738 lab=WL104}
N 3840 20840 3860 20840 {}
C {lab_pin.sym} 3860 20840 0 0 {name=l16739 lab=VDD}
N 3840 20760 3860 20760 {}
C {lab_pin.sym} 3860 20760 0 0 {name=l16740 lab=VSS}
C {bitcell_6t.sym} 4000 20800 0 0 {name=Xr104c20}
N 3960 20840 3940 20840 {}
C {lab_pin.sym} 3940 20840 0 0 {name=l16741 lab=BL20}
N 3960 20800 3940 20800 {}
C {lab_pin.sym} 3940 20800 0 0 {name=l16742 lab=BLB20}
N 3960 20760 3940 20760 {}
C {lab_pin.sym} 3940 20760 0 0 {name=l16743 lab=WL104}
N 4040 20840 4060 20840 {}
C {lab_pin.sym} 4060 20840 0 0 {name=l16744 lab=VDD}
N 4040 20760 4060 20760 {}
C {lab_pin.sym} 4060 20760 0 0 {name=l16745 lab=VSS}
C {bitcell_6t.sym} 4200 20800 0 0 {name=Xr104c21}
N 4160 20840 4140 20840 {}
C {lab_pin.sym} 4140 20840 0 0 {name=l16746 lab=BL21}
N 4160 20800 4140 20800 {}
C {lab_pin.sym} 4140 20800 0 0 {name=l16747 lab=BLB21}
N 4160 20760 4140 20760 {}
C {lab_pin.sym} 4140 20760 0 0 {name=l16748 lab=WL104}
N 4240 20840 4260 20840 {}
C {lab_pin.sym} 4260 20840 0 0 {name=l16749 lab=VDD}
N 4240 20760 4260 20760 {}
C {lab_pin.sym} 4260 20760 0 0 {name=l16750 lab=VSS}
C {bitcell_6t.sym} 4400 20800 0 0 {name=Xr104c22}
N 4360 20840 4340 20840 {}
C {lab_pin.sym} 4340 20840 0 0 {name=l16751 lab=BL22}
N 4360 20800 4340 20800 {}
C {lab_pin.sym} 4340 20800 0 0 {name=l16752 lab=BLB22}
N 4360 20760 4340 20760 {}
C {lab_pin.sym} 4340 20760 0 0 {name=l16753 lab=WL104}
N 4440 20840 4460 20840 {}
C {lab_pin.sym} 4460 20840 0 0 {name=l16754 lab=VDD}
N 4440 20760 4460 20760 {}
C {lab_pin.sym} 4460 20760 0 0 {name=l16755 lab=VSS}
C {bitcell_6t.sym} 4600 20800 0 0 {name=Xr104c23}
N 4560 20840 4540 20840 {}
C {lab_pin.sym} 4540 20840 0 0 {name=l16756 lab=BL23}
N 4560 20800 4540 20800 {}
C {lab_pin.sym} 4540 20800 0 0 {name=l16757 lab=BLB23}
N 4560 20760 4540 20760 {}
C {lab_pin.sym} 4540 20760 0 0 {name=l16758 lab=WL104}
N 4640 20840 4660 20840 {}
C {lab_pin.sym} 4660 20840 0 0 {name=l16759 lab=VDD}
N 4640 20760 4660 20760 {}
C {lab_pin.sym} 4660 20760 0 0 {name=l16760 lab=VSS}
C {bitcell_6t.sym} 4800 20800 0 0 {name=Xr104c24}
N 4760 20840 4740 20840 {}
C {lab_pin.sym} 4740 20840 0 0 {name=l16761 lab=BL24}
N 4760 20800 4740 20800 {}
C {lab_pin.sym} 4740 20800 0 0 {name=l16762 lab=BLB24}
N 4760 20760 4740 20760 {}
C {lab_pin.sym} 4740 20760 0 0 {name=l16763 lab=WL104}
N 4840 20840 4860 20840 {}
C {lab_pin.sym} 4860 20840 0 0 {name=l16764 lab=VDD}
N 4840 20760 4860 20760 {}
C {lab_pin.sym} 4860 20760 0 0 {name=l16765 lab=VSS}
C {bitcell_6t.sym} 5000 20800 0 0 {name=Xr104c25}
N 4960 20840 4940 20840 {}
C {lab_pin.sym} 4940 20840 0 0 {name=l16766 lab=BL25}
N 4960 20800 4940 20800 {}
C {lab_pin.sym} 4940 20800 0 0 {name=l16767 lab=BLB25}
N 4960 20760 4940 20760 {}
C {lab_pin.sym} 4940 20760 0 0 {name=l16768 lab=WL104}
N 5040 20840 5060 20840 {}
C {lab_pin.sym} 5060 20840 0 0 {name=l16769 lab=VDD}
N 5040 20760 5060 20760 {}
C {lab_pin.sym} 5060 20760 0 0 {name=l16770 lab=VSS}
C {bitcell_6t.sym} 5200 20800 0 0 {name=Xr104c26}
N 5160 20840 5140 20840 {}
C {lab_pin.sym} 5140 20840 0 0 {name=l16771 lab=BL26}
N 5160 20800 5140 20800 {}
C {lab_pin.sym} 5140 20800 0 0 {name=l16772 lab=BLB26}
N 5160 20760 5140 20760 {}
C {lab_pin.sym} 5140 20760 0 0 {name=l16773 lab=WL104}
N 5240 20840 5260 20840 {}
C {lab_pin.sym} 5260 20840 0 0 {name=l16774 lab=VDD}
N 5240 20760 5260 20760 {}
C {lab_pin.sym} 5260 20760 0 0 {name=l16775 lab=VSS}
C {bitcell_6t.sym} 5400 20800 0 0 {name=Xr104c27}
N 5360 20840 5340 20840 {}
C {lab_pin.sym} 5340 20840 0 0 {name=l16776 lab=BL27}
N 5360 20800 5340 20800 {}
C {lab_pin.sym} 5340 20800 0 0 {name=l16777 lab=BLB27}
N 5360 20760 5340 20760 {}
C {lab_pin.sym} 5340 20760 0 0 {name=l16778 lab=WL104}
N 5440 20840 5460 20840 {}
C {lab_pin.sym} 5460 20840 0 0 {name=l16779 lab=VDD}
N 5440 20760 5460 20760 {}
C {lab_pin.sym} 5460 20760 0 0 {name=l16780 lab=VSS}
C {bitcell_6t.sym} 5600 20800 0 0 {name=Xr104c28}
N 5560 20840 5540 20840 {}
C {lab_pin.sym} 5540 20840 0 0 {name=l16781 lab=BL28}
N 5560 20800 5540 20800 {}
C {lab_pin.sym} 5540 20800 0 0 {name=l16782 lab=BLB28}
N 5560 20760 5540 20760 {}
C {lab_pin.sym} 5540 20760 0 0 {name=l16783 lab=WL104}
N 5640 20840 5660 20840 {}
C {lab_pin.sym} 5660 20840 0 0 {name=l16784 lab=VDD}
N 5640 20760 5660 20760 {}
C {lab_pin.sym} 5660 20760 0 0 {name=l16785 lab=VSS}
C {bitcell_6t.sym} 5800 20800 0 0 {name=Xr104c29}
N 5760 20840 5740 20840 {}
C {lab_pin.sym} 5740 20840 0 0 {name=l16786 lab=BL29}
N 5760 20800 5740 20800 {}
C {lab_pin.sym} 5740 20800 0 0 {name=l16787 lab=BLB29}
N 5760 20760 5740 20760 {}
C {lab_pin.sym} 5740 20760 0 0 {name=l16788 lab=WL104}
N 5840 20840 5860 20840 {}
C {lab_pin.sym} 5860 20840 0 0 {name=l16789 lab=VDD}
N 5840 20760 5860 20760 {}
C {lab_pin.sym} 5860 20760 0 0 {name=l16790 lab=VSS}
C {bitcell_6t.sym} 6000 20800 0 0 {name=Xr104c30}
N 5960 20840 5940 20840 {}
C {lab_pin.sym} 5940 20840 0 0 {name=l16791 lab=BL30}
N 5960 20800 5940 20800 {}
C {lab_pin.sym} 5940 20800 0 0 {name=l16792 lab=BLB30}
N 5960 20760 5940 20760 {}
C {lab_pin.sym} 5940 20760 0 0 {name=l16793 lab=WL104}
N 6040 20840 6060 20840 {}
C {lab_pin.sym} 6060 20840 0 0 {name=l16794 lab=VDD}
N 6040 20760 6060 20760 {}
C {lab_pin.sym} 6060 20760 0 0 {name=l16795 lab=VSS}
C {bitcell_6t.sym} 6200 20800 0 0 {name=Xr104c31}
N 6160 20840 6140 20840 {}
C {lab_pin.sym} 6140 20840 0 0 {name=l16796 lab=BL31}
N 6160 20800 6140 20800 {}
C {lab_pin.sym} 6140 20800 0 0 {name=l16797 lab=BLB31}
N 6160 20760 6140 20760 {}
C {lab_pin.sym} 6140 20760 0 0 {name=l16798 lab=WL104}
N 6240 20840 6260 20840 {}
C {lab_pin.sym} 6260 20840 0 0 {name=l16799 lab=VDD}
N 6240 20760 6260 20760 {}
C {lab_pin.sym} 6260 20760 0 0 {name=l16800 lab=VSS}
C {bitcell_6t.sym} 0 21000 0 0 {name=Xr105c0}
N -40 21040 -60 21040 {}
C {lab_pin.sym} -60 21040 0 0 {name=l16801 lab=BL0}
N -40 21000 -60 21000 {}
C {lab_pin.sym} -60 21000 0 0 {name=l16802 lab=BLB0}
N -40 20960 -60 20960 {}
C {lab_pin.sym} -60 20960 0 0 {name=l16803 lab=WL105}
N 40 21040 60 21040 {}
C {lab_pin.sym} 60 21040 0 0 {name=l16804 lab=VDD}
N 40 20960 60 20960 {}
C {lab_pin.sym} 60 20960 0 0 {name=l16805 lab=VSS}
C {bitcell_6t.sym} 200 21000 0 0 {name=Xr105c1}
N 160 21040 140 21040 {}
C {lab_pin.sym} 140 21040 0 0 {name=l16806 lab=BL1}
N 160 21000 140 21000 {}
C {lab_pin.sym} 140 21000 0 0 {name=l16807 lab=BLB1}
N 160 20960 140 20960 {}
C {lab_pin.sym} 140 20960 0 0 {name=l16808 lab=WL105}
N 240 21040 260 21040 {}
C {lab_pin.sym} 260 21040 0 0 {name=l16809 lab=VDD}
N 240 20960 260 20960 {}
C {lab_pin.sym} 260 20960 0 0 {name=l16810 lab=VSS}
C {bitcell_6t.sym} 400 21000 0 0 {name=Xr105c2}
N 360 21040 340 21040 {}
C {lab_pin.sym} 340 21040 0 0 {name=l16811 lab=BL2}
N 360 21000 340 21000 {}
C {lab_pin.sym} 340 21000 0 0 {name=l16812 lab=BLB2}
N 360 20960 340 20960 {}
C {lab_pin.sym} 340 20960 0 0 {name=l16813 lab=WL105}
N 440 21040 460 21040 {}
C {lab_pin.sym} 460 21040 0 0 {name=l16814 lab=VDD}
N 440 20960 460 20960 {}
C {lab_pin.sym} 460 20960 0 0 {name=l16815 lab=VSS}
C {bitcell_6t.sym} 600 21000 0 0 {name=Xr105c3}
N 560 21040 540 21040 {}
C {lab_pin.sym} 540 21040 0 0 {name=l16816 lab=BL3}
N 560 21000 540 21000 {}
C {lab_pin.sym} 540 21000 0 0 {name=l16817 lab=BLB3}
N 560 20960 540 20960 {}
C {lab_pin.sym} 540 20960 0 0 {name=l16818 lab=WL105}
N 640 21040 660 21040 {}
C {lab_pin.sym} 660 21040 0 0 {name=l16819 lab=VDD}
N 640 20960 660 20960 {}
C {lab_pin.sym} 660 20960 0 0 {name=l16820 lab=VSS}
C {bitcell_6t.sym} 800 21000 0 0 {name=Xr105c4}
N 760 21040 740 21040 {}
C {lab_pin.sym} 740 21040 0 0 {name=l16821 lab=BL4}
N 760 21000 740 21000 {}
C {lab_pin.sym} 740 21000 0 0 {name=l16822 lab=BLB4}
N 760 20960 740 20960 {}
C {lab_pin.sym} 740 20960 0 0 {name=l16823 lab=WL105}
N 840 21040 860 21040 {}
C {lab_pin.sym} 860 21040 0 0 {name=l16824 lab=VDD}
N 840 20960 860 20960 {}
C {lab_pin.sym} 860 20960 0 0 {name=l16825 lab=VSS}
C {bitcell_6t.sym} 1000 21000 0 0 {name=Xr105c5}
N 960 21040 940 21040 {}
C {lab_pin.sym} 940 21040 0 0 {name=l16826 lab=BL5}
N 960 21000 940 21000 {}
C {lab_pin.sym} 940 21000 0 0 {name=l16827 lab=BLB5}
N 960 20960 940 20960 {}
C {lab_pin.sym} 940 20960 0 0 {name=l16828 lab=WL105}
N 1040 21040 1060 21040 {}
C {lab_pin.sym} 1060 21040 0 0 {name=l16829 lab=VDD}
N 1040 20960 1060 20960 {}
C {lab_pin.sym} 1060 20960 0 0 {name=l16830 lab=VSS}
C {bitcell_6t.sym} 1200 21000 0 0 {name=Xr105c6}
N 1160 21040 1140 21040 {}
C {lab_pin.sym} 1140 21040 0 0 {name=l16831 lab=BL6}
N 1160 21000 1140 21000 {}
C {lab_pin.sym} 1140 21000 0 0 {name=l16832 lab=BLB6}
N 1160 20960 1140 20960 {}
C {lab_pin.sym} 1140 20960 0 0 {name=l16833 lab=WL105}
N 1240 21040 1260 21040 {}
C {lab_pin.sym} 1260 21040 0 0 {name=l16834 lab=VDD}
N 1240 20960 1260 20960 {}
C {lab_pin.sym} 1260 20960 0 0 {name=l16835 lab=VSS}
C {bitcell_6t.sym} 1400 21000 0 0 {name=Xr105c7}
N 1360 21040 1340 21040 {}
C {lab_pin.sym} 1340 21040 0 0 {name=l16836 lab=BL7}
N 1360 21000 1340 21000 {}
C {lab_pin.sym} 1340 21000 0 0 {name=l16837 lab=BLB7}
N 1360 20960 1340 20960 {}
C {lab_pin.sym} 1340 20960 0 0 {name=l16838 lab=WL105}
N 1440 21040 1460 21040 {}
C {lab_pin.sym} 1460 21040 0 0 {name=l16839 lab=VDD}
N 1440 20960 1460 20960 {}
C {lab_pin.sym} 1460 20960 0 0 {name=l16840 lab=VSS}
C {bitcell_6t.sym} 1600 21000 0 0 {name=Xr105c8}
N 1560 21040 1540 21040 {}
C {lab_pin.sym} 1540 21040 0 0 {name=l16841 lab=BL8}
N 1560 21000 1540 21000 {}
C {lab_pin.sym} 1540 21000 0 0 {name=l16842 lab=BLB8}
N 1560 20960 1540 20960 {}
C {lab_pin.sym} 1540 20960 0 0 {name=l16843 lab=WL105}
N 1640 21040 1660 21040 {}
C {lab_pin.sym} 1660 21040 0 0 {name=l16844 lab=VDD}
N 1640 20960 1660 20960 {}
C {lab_pin.sym} 1660 20960 0 0 {name=l16845 lab=VSS}
C {bitcell_6t.sym} 1800 21000 0 0 {name=Xr105c9}
N 1760 21040 1740 21040 {}
C {lab_pin.sym} 1740 21040 0 0 {name=l16846 lab=BL9}
N 1760 21000 1740 21000 {}
C {lab_pin.sym} 1740 21000 0 0 {name=l16847 lab=BLB9}
N 1760 20960 1740 20960 {}
C {lab_pin.sym} 1740 20960 0 0 {name=l16848 lab=WL105}
N 1840 21040 1860 21040 {}
C {lab_pin.sym} 1860 21040 0 0 {name=l16849 lab=VDD}
N 1840 20960 1860 20960 {}
C {lab_pin.sym} 1860 20960 0 0 {name=l16850 lab=VSS}
C {bitcell_6t.sym} 2000 21000 0 0 {name=Xr105c10}
N 1960 21040 1940 21040 {}
C {lab_pin.sym} 1940 21040 0 0 {name=l16851 lab=BL10}
N 1960 21000 1940 21000 {}
C {lab_pin.sym} 1940 21000 0 0 {name=l16852 lab=BLB10}
N 1960 20960 1940 20960 {}
C {lab_pin.sym} 1940 20960 0 0 {name=l16853 lab=WL105}
N 2040 21040 2060 21040 {}
C {lab_pin.sym} 2060 21040 0 0 {name=l16854 lab=VDD}
N 2040 20960 2060 20960 {}
C {lab_pin.sym} 2060 20960 0 0 {name=l16855 lab=VSS}
C {bitcell_6t.sym} 2200 21000 0 0 {name=Xr105c11}
N 2160 21040 2140 21040 {}
C {lab_pin.sym} 2140 21040 0 0 {name=l16856 lab=BL11}
N 2160 21000 2140 21000 {}
C {lab_pin.sym} 2140 21000 0 0 {name=l16857 lab=BLB11}
N 2160 20960 2140 20960 {}
C {lab_pin.sym} 2140 20960 0 0 {name=l16858 lab=WL105}
N 2240 21040 2260 21040 {}
C {lab_pin.sym} 2260 21040 0 0 {name=l16859 lab=VDD}
N 2240 20960 2260 20960 {}
C {lab_pin.sym} 2260 20960 0 0 {name=l16860 lab=VSS}
C {bitcell_6t.sym} 2400 21000 0 0 {name=Xr105c12}
N 2360 21040 2340 21040 {}
C {lab_pin.sym} 2340 21040 0 0 {name=l16861 lab=BL12}
N 2360 21000 2340 21000 {}
C {lab_pin.sym} 2340 21000 0 0 {name=l16862 lab=BLB12}
N 2360 20960 2340 20960 {}
C {lab_pin.sym} 2340 20960 0 0 {name=l16863 lab=WL105}
N 2440 21040 2460 21040 {}
C {lab_pin.sym} 2460 21040 0 0 {name=l16864 lab=VDD}
N 2440 20960 2460 20960 {}
C {lab_pin.sym} 2460 20960 0 0 {name=l16865 lab=VSS}
C {bitcell_6t.sym} 2600 21000 0 0 {name=Xr105c13}
N 2560 21040 2540 21040 {}
C {lab_pin.sym} 2540 21040 0 0 {name=l16866 lab=BL13}
N 2560 21000 2540 21000 {}
C {lab_pin.sym} 2540 21000 0 0 {name=l16867 lab=BLB13}
N 2560 20960 2540 20960 {}
C {lab_pin.sym} 2540 20960 0 0 {name=l16868 lab=WL105}
N 2640 21040 2660 21040 {}
C {lab_pin.sym} 2660 21040 0 0 {name=l16869 lab=VDD}
N 2640 20960 2660 20960 {}
C {lab_pin.sym} 2660 20960 0 0 {name=l16870 lab=VSS}
C {bitcell_6t.sym} 2800 21000 0 0 {name=Xr105c14}
N 2760 21040 2740 21040 {}
C {lab_pin.sym} 2740 21040 0 0 {name=l16871 lab=BL14}
N 2760 21000 2740 21000 {}
C {lab_pin.sym} 2740 21000 0 0 {name=l16872 lab=BLB14}
N 2760 20960 2740 20960 {}
C {lab_pin.sym} 2740 20960 0 0 {name=l16873 lab=WL105}
N 2840 21040 2860 21040 {}
C {lab_pin.sym} 2860 21040 0 0 {name=l16874 lab=VDD}
N 2840 20960 2860 20960 {}
C {lab_pin.sym} 2860 20960 0 0 {name=l16875 lab=VSS}
C {bitcell_6t.sym} 3000 21000 0 0 {name=Xr105c15}
N 2960 21040 2940 21040 {}
C {lab_pin.sym} 2940 21040 0 0 {name=l16876 lab=BL15}
N 2960 21000 2940 21000 {}
C {lab_pin.sym} 2940 21000 0 0 {name=l16877 lab=BLB15}
N 2960 20960 2940 20960 {}
C {lab_pin.sym} 2940 20960 0 0 {name=l16878 lab=WL105}
N 3040 21040 3060 21040 {}
C {lab_pin.sym} 3060 21040 0 0 {name=l16879 lab=VDD}
N 3040 20960 3060 20960 {}
C {lab_pin.sym} 3060 20960 0 0 {name=l16880 lab=VSS}
C {bitcell_6t.sym} 3200 21000 0 0 {name=Xr105c16}
N 3160 21040 3140 21040 {}
C {lab_pin.sym} 3140 21040 0 0 {name=l16881 lab=BL16}
N 3160 21000 3140 21000 {}
C {lab_pin.sym} 3140 21000 0 0 {name=l16882 lab=BLB16}
N 3160 20960 3140 20960 {}
C {lab_pin.sym} 3140 20960 0 0 {name=l16883 lab=WL105}
N 3240 21040 3260 21040 {}
C {lab_pin.sym} 3260 21040 0 0 {name=l16884 lab=VDD}
N 3240 20960 3260 20960 {}
C {lab_pin.sym} 3260 20960 0 0 {name=l16885 lab=VSS}
C {bitcell_6t.sym} 3400 21000 0 0 {name=Xr105c17}
N 3360 21040 3340 21040 {}
C {lab_pin.sym} 3340 21040 0 0 {name=l16886 lab=BL17}
N 3360 21000 3340 21000 {}
C {lab_pin.sym} 3340 21000 0 0 {name=l16887 lab=BLB17}
N 3360 20960 3340 20960 {}
C {lab_pin.sym} 3340 20960 0 0 {name=l16888 lab=WL105}
N 3440 21040 3460 21040 {}
C {lab_pin.sym} 3460 21040 0 0 {name=l16889 lab=VDD}
N 3440 20960 3460 20960 {}
C {lab_pin.sym} 3460 20960 0 0 {name=l16890 lab=VSS}
C {bitcell_6t.sym} 3600 21000 0 0 {name=Xr105c18}
N 3560 21040 3540 21040 {}
C {lab_pin.sym} 3540 21040 0 0 {name=l16891 lab=BL18}
N 3560 21000 3540 21000 {}
C {lab_pin.sym} 3540 21000 0 0 {name=l16892 lab=BLB18}
N 3560 20960 3540 20960 {}
C {lab_pin.sym} 3540 20960 0 0 {name=l16893 lab=WL105}
N 3640 21040 3660 21040 {}
C {lab_pin.sym} 3660 21040 0 0 {name=l16894 lab=VDD}
N 3640 20960 3660 20960 {}
C {lab_pin.sym} 3660 20960 0 0 {name=l16895 lab=VSS}
C {bitcell_6t.sym} 3800 21000 0 0 {name=Xr105c19}
N 3760 21040 3740 21040 {}
C {lab_pin.sym} 3740 21040 0 0 {name=l16896 lab=BL19}
N 3760 21000 3740 21000 {}
C {lab_pin.sym} 3740 21000 0 0 {name=l16897 lab=BLB19}
N 3760 20960 3740 20960 {}
C {lab_pin.sym} 3740 20960 0 0 {name=l16898 lab=WL105}
N 3840 21040 3860 21040 {}
C {lab_pin.sym} 3860 21040 0 0 {name=l16899 lab=VDD}
N 3840 20960 3860 20960 {}
C {lab_pin.sym} 3860 20960 0 0 {name=l16900 lab=VSS}
C {bitcell_6t.sym} 4000 21000 0 0 {name=Xr105c20}
N 3960 21040 3940 21040 {}
C {lab_pin.sym} 3940 21040 0 0 {name=l16901 lab=BL20}
N 3960 21000 3940 21000 {}
C {lab_pin.sym} 3940 21000 0 0 {name=l16902 lab=BLB20}
N 3960 20960 3940 20960 {}
C {lab_pin.sym} 3940 20960 0 0 {name=l16903 lab=WL105}
N 4040 21040 4060 21040 {}
C {lab_pin.sym} 4060 21040 0 0 {name=l16904 lab=VDD}
N 4040 20960 4060 20960 {}
C {lab_pin.sym} 4060 20960 0 0 {name=l16905 lab=VSS}
C {bitcell_6t.sym} 4200 21000 0 0 {name=Xr105c21}
N 4160 21040 4140 21040 {}
C {lab_pin.sym} 4140 21040 0 0 {name=l16906 lab=BL21}
N 4160 21000 4140 21000 {}
C {lab_pin.sym} 4140 21000 0 0 {name=l16907 lab=BLB21}
N 4160 20960 4140 20960 {}
C {lab_pin.sym} 4140 20960 0 0 {name=l16908 lab=WL105}
N 4240 21040 4260 21040 {}
C {lab_pin.sym} 4260 21040 0 0 {name=l16909 lab=VDD}
N 4240 20960 4260 20960 {}
C {lab_pin.sym} 4260 20960 0 0 {name=l16910 lab=VSS}
C {bitcell_6t.sym} 4400 21000 0 0 {name=Xr105c22}
N 4360 21040 4340 21040 {}
C {lab_pin.sym} 4340 21040 0 0 {name=l16911 lab=BL22}
N 4360 21000 4340 21000 {}
C {lab_pin.sym} 4340 21000 0 0 {name=l16912 lab=BLB22}
N 4360 20960 4340 20960 {}
C {lab_pin.sym} 4340 20960 0 0 {name=l16913 lab=WL105}
N 4440 21040 4460 21040 {}
C {lab_pin.sym} 4460 21040 0 0 {name=l16914 lab=VDD}
N 4440 20960 4460 20960 {}
C {lab_pin.sym} 4460 20960 0 0 {name=l16915 lab=VSS}
C {bitcell_6t.sym} 4600 21000 0 0 {name=Xr105c23}
N 4560 21040 4540 21040 {}
C {lab_pin.sym} 4540 21040 0 0 {name=l16916 lab=BL23}
N 4560 21000 4540 21000 {}
C {lab_pin.sym} 4540 21000 0 0 {name=l16917 lab=BLB23}
N 4560 20960 4540 20960 {}
C {lab_pin.sym} 4540 20960 0 0 {name=l16918 lab=WL105}
N 4640 21040 4660 21040 {}
C {lab_pin.sym} 4660 21040 0 0 {name=l16919 lab=VDD}
N 4640 20960 4660 20960 {}
C {lab_pin.sym} 4660 20960 0 0 {name=l16920 lab=VSS}
C {bitcell_6t.sym} 4800 21000 0 0 {name=Xr105c24}
N 4760 21040 4740 21040 {}
C {lab_pin.sym} 4740 21040 0 0 {name=l16921 lab=BL24}
N 4760 21000 4740 21000 {}
C {lab_pin.sym} 4740 21000 0 0 {name=l16922 lab=BLB24}
N 4760 20960 4740 20960 {}
C {lab_pin.sym} 4740 20960 0 0 {name=l16923 lab=WL105}
N 4840 21040 4860 21040 {}
C {lab_pin.sym} 4860 21040 0 0 {name=l16924 lab=VDD}
N 4840 20960 4860 20960 {}
C {lab_pin.sym} 4860 20960 0 0 {name=l16925 lab=VSS}
C {bitcell_6t.sym} 5000 21000 0 0 {name=Xr105c25}
N 4960 21040 4940 21040 {}
C {lab_pin.sym} 4940 21040 0 0 {name=l16926 lab=BL25}
N 4960 21000 4940 21000 {}
C {lab_pin.sym} 4940 21000 0 0 {name=l16927 lab=BLB25}
N 4960 20960 4940 20960 {}
C {lab_pin.sym} 4940 20960 0 0 {name=l16928 lab=WL105}
N 5040 21040 5060 21040 {}
C {lab_pin.sym} 5060 21040 0 0 {name=l16929 lab=VDD}
N 5040 20960 5060 20960 {}
C {lab_pin.sym} 5060 20960 0 0 {name=l16930 lab=VSS}
C {bitcell_6t.sym} 5200 21000 0 0 {name=Xr105c26}
N 5160 21040 5140 21040 {}
C {lab_pin.sym} 5140 21040 0 0 {name=l16931 lab=BL26}
N 5160 21000 5140 21000 {}
C {lab_pin.sym} 5140 21000 0 0 {name=l16932 lab=BLB26}
N 5160 20960 5140 20960 {}
C {lab_pin.sym} 5140 20960 0 0 {name=l16933 lab=WL105}
N 5240 21040 5260 21040 {}
C {lab_pin.sym} 5260 21040 0 0 {name=l16934 lab=VDD}
N 5240 20960 5260 20960 {}
C {lab_pin.sym} 5260 20960 0 0 {name=l16935 lab=VSS}
C {bitcell_6t.sym} 5400 21000 0 0 {name=Xr105c27}
N 5360 21040 5340 21040 {}
C {lab_pin.sym} 5340 21040 0 0 {name=l16936 lab=BL27}
N 5360 21000 5340 21000 {}
C {lab_pin.sym} 5340 21000 0 0 {name=l16937 lab=BLB27}
N 5360 20960 5340 20960 {}
C {lab_pin.sym} 5340 20960 0 0 {name=l16938 lab=WL105}
N 5440 21040 5460 21040 {}
C {lab_pin.sym} 5460 21040 0 0 {name=l16939 lab=VDD}
N 5440 20960 5460 20960 {}
C {lab_pin.sym} 5460 20960 0 0 {name=l16940 lab=VSS}
C {bitcell_6t.sym} 5600 21000 0 0 {name=Xr105c28}
N 5560 21040 5540 21040 {}
C {lab_pin.sym} 5540 21040 0 0 {name=l16941 lab=BL28}
N 5560 21000 5540 21000 {}
C {lab_pin.sym} 5540 21000 0 0 {name=l16942 lab=BLB28}
N 5560 20960 5540 20960 {}
C {lab_pin.sym} 5540 20960 0 0 {name=l16943 lab=WL105}
N 5640 21040 5660 21040 {}
C {lab_pin.sym} 5660 21040 0 0 {name=l16944 lab=VDD}
N 5640 20960 5660 20960 {}
C {lab_pin.sym} 5660 20960 0 0 {name=l16945 lab=VSS}
C {bitcell_6t.sym} 5800 21000 0 0 {name=Xr105c29}
N 5760 21040 5740 21040 {}
C {lab_pin.sym} 5740 21040 0 0 {name=l16946 lab=BL29}
N 5760 21000 5740 21000 {}
C {lab_pin.sym} 5740 21000 0 0 {name=l16947 lab=BLB29}
N 5760 20960 5740 20960 {}
C {lab_pin.sym} 5740 20960 0 0 {name=l16948 lab=WL105}
N 5840 21040 5860 21040 {}
C {lab_pin.sym} 5860 21040 0 0 {name=l16949 lab=VDD}
N 5840 20960 5860 20960 {}
C {lab_pin.sym} 5860 20960 0 0 {name=l16950 lab=VSS}
C {bitcell_6t.sym} 6000 21000 0 0 {name=Xr105c30}
N 5960 21040 5940 21040 {}
C {lab_pin.sym} 5940 21040 0 0 {name=l16951 lab=BL30}
N 5960 21000 5940 21000 {}
C {lab_pin.sym} 5940 21000 0 0 {name=l16952 lab=BLB30}
N 5960 20960 5940 20960 {}
C {lab_pin.sym} 5940 20960 0 0 {name=l16953 lab=WL105}
N 6040 21040 6060 21040 {}
C {lab_pin.sym} 6060 21040 0 0 {name=l16954 lab=VDD}
N 6040 20960 6060 20960 {}
C {lab_pin.sym} 6060 20960 0 0 {name=l16955 lab=VSS}
C {bitcell_6t.sym} 6200 21000 0 0 {name=Xr105c31}
N 6160 21040 6140 21040 {}
C {lab_pin.sym} 6140 21040 0 0 {name=l16956 lab=BL31}
N 6160 21000 6140 21000 {}
C {lab_pin.sym} 6140 21000 0 0 {name=l16957 lab=BLB31}
N 6160 20960 6140 20960 {}
C {lab_pin.sym} 6140 20960 0 0 {name=l16958 lab=WL105}
N 6240 21040 6260 21040 {}
C {lab_pin.sym} 6260 21040 0 0 {name=l16959 lab=VDD}
N 6240 20960 6260 20960 {}
C {lab_pin.sym} 6260 20960 0 0 {name=l16960 lab=VSS}
C {bitcell_6t.sym} 0 21200 0 0 {name=Xr106c0}
N -40 21240 -60 21240 {}
C {lab_pin.sym} -60 21240 0 0 {name=l16961 lab=BL0}
N -40 21200 -60 21200 {}
C {lab_pin.sym} -60 21200 0 0 {name=l16962 lab=BLB0}
N -40 21160 -60 21160 {}
C {lab_pin.sym} -60 21160 0 0 {name=l16963 lab=WL106}
N 40 21240 60 21240 {}
C {lab_pin.sym} 60 21240 0 0 {name=l16964 lab=VDD}
N 40 21160 60 21160 {}
C {lab_pin.sym} 60 21160 0 0 {name=l16965 lab=VSS}
C {bitcell_6t.sym} 200 21200 0 0 {name=Xr106c1}
N 160 21240 140 21240 {}
C {lab_pin.sym} 140 21240 0 0 {name=l16966 lab=BL1}
N 160 21200 140 21200 {}
C {lab_pin.sym} 140 21200 0 0 {name=l16967 lab=BLB1}
N 160 21160 140 21160 {}
C {lab_pin.sym} 140 21160 0 0 {name=l16968 lab=WL106}
N 240 21240 260 21240 {}
C {lab_pin.sym} 260 21240 0 0 {name=l16969 lab=VDD}
N 240 21160 260 21160 {}
C {lab_pin.sym} 260 21160 0 0 {name=l16970 lab=VSS}
C {bitcell_6t.sym} 400 21200 0 0 {name=Xr106c2}
N 360 21240 340 21240 {}
C {lab_pin.sym} 340 21240 0 0 {name=l16971 lab=BL2}
N 360 21200 340 21200 {}
C {lab_pin.sym} 340 21200 0 0 {name=l16972 lab=BLB2}
N 360 21160 340 21160 {}
C {lab_pin.sym} 340 21160 0 0 {name=l16973 lab=WL106}
N 440 21240 460 21240 {}
C {lab_pin.sym} 460 21240 0 0 {name=l16974 lab=VDD}
N 440 21160 460 21160 {}
C {lab_pin.sym} 460 21160 0 0 {name=l16975 lab=VSS}
C {bitcell_6t.sym} 600 21200 0 0 {name=Xr106c3}
N 560 21240 540 21240 {}
C {lab_pin.sym} 540 21240 0 0 {name=l16976 lab=BL3}
N 560 21200 540 21200 {}
C {lab_pin.sym} 540 21200 0 0 {name=l16977 lab=BLB3}
N 560 21160 540 21160 {}
C {lab_pin.sym} 540 21160 0 0 {name=l16978 lab=WL106}
N 640 21240 660 21240 {}
C {lab_pin.sym} 660 21240 0 0 {name=l16979 lab=VDD}
N 640 21160 660 21160 {}
C {lab_pin.sym} 660 21160 0 0 {name=l16980 lab=VSS}
C {bitcell_6t.sym} 800 21200 0 0 {name=Xr106c4}
N 760 21240 740 21240 {}
C {lab_pin.sym} 740 21240 0 0 {name=l16981 lab=BL4}
N 760 21200 740 21200 {}
C {lab_pin.sym} 740 21200 0 0 {name=l16982 lab=BLB4}
N 760 21160 740 21160 {}
C {lab_pin.sym} 740 21160 0 0 {name=l16983 lab=WL106}
N 840 21240 860 21240 {}
C {lab_pin.sym} 860 21240 0 0 {name=l16984 lab=VDD}
N 840 21160 860 21160 {}
C {lab_pin.sym} 860 21160 0 0 {name=l16985 lab=VSS}
C {bitcell_6t.sym} 1000 21200 0 0 {name=Xr106c5}
N 960 21240 940 21240 {}
C {lab_pin.sym} 940 21240 0 0 {name=l16986 lab=BL5}
N 960 21200 940 21200 {}
C {lab_pin.sym} 940 21200 0 0 {name=l16987 lab=BLB5}
N 960 21160 940 21160 {}
C {lab_pin.sym} 940 21160 0 0 {name=l16988 lab=WL106}
N 1040 21240 1060 21240 {}
C {lab_pin.sym} 1060 21240 0 0 {name=l16989 lab=VDD}
N 1040 21160 1060 21160 {}
C {lab_pin.sym} 1060 21160 0 0 {name=l16990 lab=VSS}
C {bitcell_6t.sym} 1200 21200 0 0 {name=Xr106c6}
N 1160 21240 1140 21240 {}
C {lab_pin.sym} 1140 21240 0 0 {name=l16991 lab=BL6}
N 1160 21200 1140 21200 {}
C {lab_pin.sym} 1140 21200 0 0 {name=l16992 lab=BLB6}
N 1160 21160 1140 21160 {}
C {lab_pin.sym} 1140 21160 0 0 {name=l16993 lab=WL106}
N 1240 21240 1260 21240 {}
C {lab_pin.sym} 1260 21240 0 0 {name=l16994 lab=VDD}
N 1240 21160 1260 21160 {}
C {lab_pin.sym} 1260 21160 0 0 {name=l16995 lab=VSS}
C {bitcell_6t.sym} 1400 21200 0 0 {name=Xr106c7}
N 1360 21240 1340 21240 {}
C {lab_pin.sym} 1340 21240 0 0 {name=l16996 lab=BL7}
N 1360 21200 1340 21200 {}
C {lab_pin.sym} 1340 21200 0 0 {name=l16997 lab=BLB7}
N 1360 21160 1340 21160 {}
C {lab_pin.sym} 1340 21160 0 0 {name=l16998 lab=WL106}
N 1440 21240 1460 21240 {}
C {lab_pin.sym} 1460 21240 0 0 {name=l16999 lab=VDD}
N 1440 21160 1460 21160 {}
C {lab_pin.sym} 1460 21160 0 0 {name=l17000 lab=VSS}
C {bitcell_6t.sym} 1600 21200 0 0 {name=Xr106c8}
N 1560 21240 1540 21240 {}
C {lab_pin.sym} 1540 21240 0 0 {name=l17001 lab=BL8}
N 1560 21200 1540 21200 {}
C {lab_pin.sym} 1540 21200 0 0 {name=l17002 lab=BLB8}
N 1560 21160 1540 21160 {}
C {lab_pin.sym} 1540 21160 0 0 {name=l17003 lab=WL106}
N 1640 21240 1660 21240 {}
C {lab_pin.sym} 1660 21240 0 0 {name=l17004 lab=VDD}
N 1640 21160 1660 21160 {}
C {lab_pin.sym} 1660 21160 0 0 {name=l17005 lab=VSS}
C {bitcell_6t.sym} 1800 21200 0 0 {name=Xr106c9}
N 1760 21240 1740 21240 {}
C {lab_pin.sym} 1740 21240 0 0 {name=l17006 lab=BL9}
N 1760 21200 1740 21200 {}
C {lab_pin.sym} 1740 21200 0 0 {name=l17007 lab=BLB9}
N 1760 21160 1740 21160 {}
C {lab_pin.sym} 1740 21160 0 0 {name=l17008 lab=WL106}
N 1840 21240 1860 21240 {}
C {lab_pin.sym} 1860 21240 0 0 {name=l17009 lab=VDD}
N 1840 21160 1860 21160 {}
C {lab_pin.sym} 1860 21160 0 0 {name=l17010 lab=VSS}
C {bitcell_6t.sym} 2000 21200 0 0 {name=Xr106c10}
N 1960 21240 1940 21240 {}
C {lab_pin.sym} 1940 21240 0 0 {name=l17011 lab=BL10}
N 1960 21200 1940 21200 {}
C {lab_pin.sym} 1940 21200 0 0 {name=l17012 lab=BLB10}
N 1960 21160 1940 21160 {}
C {lab_pin.sym} 1940 21160 0 0 {name=l17013 lab=WL106}
N 2040 21240 2060 21240 {}
C {lab_pin.sym} 2060 21240 0 0 {name=l17014 lab=VDD}
N 2040 21160 2060 21160 {}
C {lab_pin.sym} 2060 21160 0 0 {name=l17015 lab=VSS}
C {bitcell_6t.sym} 2200 21200 0 0 {name=Xr106c11}
N 2160 21240 2140 21240 {}
C {lab_pin.sym} 2140 21240 0 0 {name=l17016 lab=BL11}
N 2160 21200 2140 21200 {}
C {lab_pin.sym} 2140 21200 0 0 {name=l17017 lab=BLB11}
N 2160 21160 2140 21160 {}
C {lab_pin.sym} 2140 21160 0 0 {name=l17018 lab=WL106}
N 2240 21240 2260 21240 {}
C {lab_pin.sym} 2260 21240 0 0 {name=l17019 lab=VDD}
N 2240 21160 2260 21160 {}
C {lab_pin.sym} 2260 21160 0 0 {name=l17020 lab=VSS}
C {bitcell_6t.sym} 2400 21200 0 0 {name=Xr106c12}
N 2360 21240 2340 21240 {}
C {lab_pin.sym} 2340 21240 0 0 {name=l17021 lab=BL12}
N 2360 21200 2340 21200 {}
C {lab_pin.sym} 2340 21200 0 0 {name=l17022 lab=BLB12}
N 2360 21160 2340 21160 {}
C {lab_pin.sym} 2340 21160 0 0 {name=l17023 lab=WL106}
N 2440 21240 2460 21240 {}
C {lab_pin.sym} 2460 21240 0 0 {name=l17024 lab=VDD}
N 2440 21160 2460 21160 {}
C {lab_pin.sym} 2460 21160 0 0 {name=l17025 lab=VSS}
C {bitcell_6t.sym} 2600 21200 0 0 {name=Xr106c13}
N 2560 21240 2540 21240 {}
C {lab_pin.sym} 2540 21240 0 0 {name=l17026 lab=BL13}
N 2560 21200 2540 21200 {}
C {lab_pin.sym} 2540 21200 0 0 {name=l17027 lab=BLB13}
N 2560 21160 2540 21160 {}
C {lab_pin.sym} 2540 21160 0 0 {name=l17028 lab=WL106}
N 2640 21240 2660 21240 {}
C {lab_pin.sym} 2660 21240 0 0 {name=l17029 lab=VDD}
N 2640 21160 2660 21160 {}
C {lab_pin.sym} 2660 21160 0 0 {name=l17030 lab=VSS}
C {bitcell_6t.sym} 2800 21200 0 0 {name=Xr106c14}
N 2760 21240 2740 21240 {}
C {lab_pin.sym} 2740 21240 0 0 {name=l17031 lab=BL14}
N 2760 21200 2740 21200 {}
C {lab_pin.sym} 2740 21200 0 0 {name=l17032 lab=BLB14}
N 2760 21160 2740 21160 {}
C {lab_pin.sym} 2740 21160 0 0 {name=l17033 lab=WL106}
N 2840 21240 2860 21240 {}
C {lab_pin.sym} 2860 21240 0 0 {name=l17034 lab=VDD}
N 2840 21160 2860 21160 {}
C {lab_pin.sym} 2860 21160 0 0 {name=l17035 lab=VSS}
C {bitcell_6t.sym} 3000 21200 0 0 {name=Xr106c15}
N 2960 21240 2940 21240 {}
C {lab_pin.sym} 2940 21240 0 0 {name=l17036 lab=BL15}
N 2960 21200 2940 21200 {}
C {lab_pin.sym} 2940 21200 0 0 {name=l17037 lab=BLB15}
N 2960 21160 2940 21160 {}
C {lab_pin.sym} 2940 21160 0 0 {name=l17038 lab=WL106}
N 3040 21240 3060 21240 {}
C {lab_pin.sym} 3060 21240 0 0 {name=l17039 lab=VDD}
N 3040 21160 3060 21160 {}
C {lab_pin.sym} 3060 21160 0 0 {name=l17040 lab=VSS}
C {bitcell_6t.sym} 3200 21200 0 0 {name=Xr106c16}
N 3160 21240 3140 21240 {}
C {lab_pin.sym} 3140 21240 0 0 {name=l17041 lab=BL16}
N 3160 21200 3140 21200 {}
C {lab_pin.sym} 3140 21200 0 0 {name=l17042 lab=BLB16}
N 3160 21160 3140 21160 {}
C {lab_pin.sym} 3140 21160 0 0 {name=l17043 lab=WL106}
N 3240 21240 3260 21240 {}
C {lab_pin.sym} 3260 21240 0 0 {name=l17044 lab=VDD}
N 3240 21160 3260 21160 {}
C {lab_pin.sym} 3260 21160 0 0 {name=l17045 lab=VSS}
C {bitcell_6t.sym} 3400 21200 0 0 {name=Xr106c17}
N 3360 21240 3340 21240 {}
C {lab_pin.sym} 3340 21240 0 0 {name=l17046 lab=BL17}
N 3360 21200 3340 21200 {}
C {lab_pin.sym} 3340 21200 0 0 {name=l17047 lab=BLB17}
N 3360 21160 3340 21160 {}
C {lab_pin.sym} 3340 21160 0 0 {name=l17048 lab=WL106}
N 3440 21240 3460 21240 {}
C {lab_pin.sym} 3460 21240 0 0 {name=l17049 lab=VDD}
N 3440 21160 3460 21160 {}
C {lab_pin.sym} 3460 21160 0 0 {name=l17050 lab=VSS}
C {bitcell_6t.sym} 3600 21200 0 0 {name=Xr106c18}
N 3560 21240 3540 21240 {}
C {lab_pin.sym} 3540 21240 0 0 {name=l17051 lab=BL18}
N 3560 21200 3540 21200 {}
C {lab_pin.sym} 3540 21200 0 0 {name=l17052 lab=BLB18}
N 3560 21160 3540 21160 {}
C {lab_pin.sym} 3540 21160 0 0 {name=l17053 lab=WL106}
N 3640 21240 3660 21240 {}
C {lab_pin.sym} 3660 21240 0 0 {name=l17054 lab=VDD}
N 3640 21160 3660 21160 {}
C {lab_pin.sym} 3660 21160 0 0 {name=l17055 lab=VSS}
C {bitcell_6t.sym} 3800 21200 0 0 {name=Xr106c19}
N 3760 21240 3740 21240 {}
C {lab_pin.sym} 3740 21240 0 0 {name=l17056 lab=BL19}
N 3760 21200 3740 21200 {}
C {lab_pin.sym} 3740 21200 0 0 {name=l17057 lab=BLB19}
N 3760 21160 3740 21160 {}
C {lab_pin.sym} 3740 21160 0 0 {name=l17058 lab=WL106}
N 3840 21240 3860 21240 {}
C {lab_pin.sym} 3860 21240 0 0 {name=l17059 lab=VDD}
N 3840 21160 3860 21160 {}
C {lab_pin.sym} 3860 21160 0 0 {name=l17060 lab=VSS}
C {bitcell_6t.sym} 4000 21200 0 0 {name=Xr106c20}
N 3960 21240 3940 21240 {}
C {lab_pin.sym} 3940 21240 0 0 {name=l17061 lab=BL20}
N 3960 21200 3940 21200 {}
C {lab_pin.sym} 3940 21200 0 0 {name=l17062 lab=BLB20}
N 3960 21160 3940 21160 {}
C {lab_pin.sym} 3940 21160 0 0 {name=l17063 lab=WL106}
N 4040 21240 4060 21240 {}
C {lab_pin.sym} 4060 21240 0 0 {name=l17064 lab=VDD}
N 4040 21160 4060 21160 {}
C {lab_pin.sym} 4060 21160 0 0 {name=l17065 lab=VSS}
C {bitcell_6t.sym} 4200 21200 0 0 {name=Xr106c21}
N 4160 21240 4140 21240 {}
C {lab_pin.sym} 4140 21240 0 0 {name=l17066 lab=BL21}
N 4160 21200 4140 21200 {}
C {lab_pin.sym} 4140 21200 0 0 {name=l17067 lab=BLB21}
N 4160 21160 4140 21160 {}
C {lab_pin.sym} 4140 21160 0 0 {name=l17068 lab=WL106}
N 4240 21240 4260 21240 {}
C {lab_pin.sym} 4260 21240 0 0 {name=l17069 lab=VDD}
N 4240 21160 4260 21160 {}
C {lab_pin.sym} 4260 21160 0 0 {name=l17070 lab=VSS}
C {bitcell_6t.sym} 4400 21200 0 0 {name=Xr106c22}
N 4360 21240 4340 21240 {}
C {lab_pin.sym} 4340 21240 0 0 {name=l17071 lab=BL22}
N 4360 21200 4340 21200 {}
C {lab_pin.sym} 4340 21200 0 0 {name=l17072 lab=BLB22}
N 4360 21160 4340 21160 {}
C {lab_pin.sym} 4340 21160 0 0 {name=l17073 lab=WL106}
N 4440 21240 4460 21240 {}
C {lab_pin.sym} 4460 21240 0 0 {name=l17074 lab=VDD}
N 4440 21160 4460 21160 {}
C {lab_pin.sym} 4460 21160 0 0 {name=l17075 lab=VSS}
C {bitcell_6t.sym} 4600 21200 0 0 {name=Xr106c23}
N 4560 21240 4540 21240 {}
C {lab_pin.sym} 4540 21240 0 0 {name=l17076 lab=BL23}
N 4560 21200 4540 21200 {}
C {lab_pin.sym} 4540 21200 0 0 {name=l17077 lab=BLB23}
N 4560 21160 4540 21160 {}
C {lab_pin.sym} 4540 21160 0 0 {name=l17078 lab=WL106}
N 4640 21240 4660 21240 {}
C {lab_pin.sym} 4660 21240 0 0 {name=l17079 lab=VDD}
N 4640 21160 4660 21160 {}
C {lab_pin.sym} 4660 21160 0 0 {name=l17080 lab=VSS}
C {bitcell_6t.sym} 4800 21200 0 0 {name=Xr106c24}
N 4760 21240 4740 21240 {}
C {lab_pin.sym} 4740 21240 0 0 {name=l17081 lab=BL24}
N 4760 21200 4740 21200 {}
C {lab_pin.sym} 4740 21200 0 0 {name=l17082 lab=BLB24}
N 4760 21160 4740 21160 {}
C {lab_pin.sym} 4740 21160 0 0 {name=l17083 lab=WL106}
N 4840 21240 4860 21240 {}
C {lab_pin.sym} 4860 21240 0 0 {name=l17084 lab=VDD}
N 4840 21160 4860 21160 {}
C {lab_pin.sym} 4860 21160 0 0 {name=l17085 lab=VSS}
C {bitcell_6t.sym} 5000 21200 0 0 {name=Xr106c25}
N 4960 21240 4940 21240 {}
C {lab_pin.sym} 4940 21240 0 0 {name=l17086 lab=BL25}
N 4960 21200 4940 21200 {}
C {lab_pin.sym} 4940 21200 0 0 {name=l17087 lab=BLB25}
N 4960 21160 4940 21160 {}
C {lab_pin.sym} 4940 21160 0 0 {name=l17088 lab=WL106}
N 5040 21240 5060 21240 {}
C {lab_pin.sym} 5060 21240 0 0 {name=l17089 lab=VDD}
N 5040 21160 5060 21160 {}
C {lab_pin.sym} 5060 21160 0 0 {name=l17090 lab=VSS}
C {bitcell_6t.sym} 5200 21200 0 0 {name=Xr106c26}
N 5160 21240 5140 21240 {}
C {lab_pin.sym} 5140 21240 0 0 {name=l17091 lab=BL26}
N 5160 21200 5140 21200 {}
C {lab_pin.sym} 5140 21200 0 0 {name=l17092 lab=BLB26}
N 5160 21160 5140 21160 {}
C {lab_pin.sym} 5140 21160 0 0 {name=l17093 lab=WL106}
N 5240 21240 5260 21240 {}
C {lab_pin.sym} 5260 21240 0 0 {name=l17094 lab=VDD}
N 5240 21160 5260 21160 {}
C {lab_pin.sym} 5260 21160 0 0 {name=l17095 lab=VSS}
C {bitcell_6t.sym} 5400 21200 0 0 {name=Xr106c27}
N 5360 21240 5340 21240 {}
C {lab_pin.sym} 5340 21240 0 0 {name=l17096 lab=BL27}
N 5360 21200 5340 21200 {}
C {lab_pin.sym} 5340 21200 0 0 {name=l17097 lab=BLB27}
N 5360 21160 5340 21160 {}
C {lab_pin.sym} 5340 21160 0 0 {name=l17098 lab=WL106}
N 5440 21240 5460 21240 {}
C {lab_pin.sym} 5460 21240 0 0 {name=l17099 lab=VDD}
N 5440 21160 5460 21160 {}
C {lab_pin.sym} 5460 21160 0 0 {name=l17100 lab=VSS}
C {bitcell_6t.sym} 5600 21200 0 0 {name=Xr106c28}
N 5560 21240 5540 21240 {}
C {lab_pin.sym} 5540 21240 0 0 {name=l17101 lab=BL28}
N 5560 21200 5540 21200 {}
C {lab_pin.sym} 5540 21200 0 0 {name=l17102 lab=BLB28}
N 5560 21160 5540 21160 {}
C {lab_pin.sym} 5540 21160 0 0 {name=l17103 lab=WL106}
N 5640 21240 5660 21240 {}
C {lab_pin.sym} 5660 21240 0 0 {name=l17104 lab=VDD}
N 5640 21160 5660 21160 {}
C {lab_pin.sym} 5660 21160 0 0 {name=l17105 lab=VSS}
C {bitcell_6t.sym} 5800 21200 0 0 {name=Xr106c29}
N 5760 21240 5740 21240 {}
C {lab_pin.sym} 5740 21240 0 0 {name=l17106 lab=BL29}
N 5760 21200 5740 21200 {}
C {lab_pin.sym} 5740 21200 0 0 {name=l17107 lab=BLB29}
N 5760 21160 5740 21160 {}
C {lab_pin.sym} 5740 21160 0 0 {name=l17108 lab=WL106}
N 5840 21240 5860 21240 {}
C {lab_pin.sym} 5860 21240 0 0 {name=l17109 lab=VDD}
N 5840 21160 5860 21160 {}
C {lab_pin.sym} 5860 21160 0 0 {name=l17110 lab=VSS}
C {bitcell_6t.sym} 6000 21200 0 0 {name=Xr106c30}
N 5960 21240 5940 21240 {}
C {lab_pin.sym} 5940 21240 0 0 {name=l17111 lab=BL30}
N 5960 21200 5940 21200 {}
C {lab_pin.sym} 5940 21200 0 0 {name=l17112 lab=BLB30}
N 5960 21160 5940 21160 {}
C {lab_pin.sym} 5940 21160 0 0 {name=l17113 lab=WL106}
N 6040 21240 6060 21240 {}
C {lab_pin.sym} 6060 21240 0 0 {name=l17114 lab=VDD}
N 6040 21160 6060 21160 {}
C {lab_pin.sym} 6060 21160 0 0 {name=l17115 lab=VSS}
C {bitcell_6t.sym} 6200 21200 0 0 {name=Xr106c31}
N 6160 21240 6140 21240 {}
C {lab_pin.sym} 6140 21240 0 0 {name=l17116 lab=BL31}
N 6160 21200 6140 21200 {}
C {lab_pin.sym} 6140 21200 0 0 {name=l17117 lab=BLB31}
N 6160 21160 6140 21160 {}
C {lab_pin.sym} 6140 21160 0 0 {name=l17118 lab=WL106}
N 6240 21240 6260 21240 {}
C {lab_pin.sym} 6260 21240 0 0 {name=l17119 lab=VDD}
N 6240 21160 6260 21160 {}
C {lab_pin.sym} 6260 21160 0 0 {name=l17120 lab=VSS}
C {bitcell_6t.sym} 0 21400 0 0 {name=Xr107c0}
N -40 21440 -60 21440 {}
C {lab_pin.sym} -60 21440 0 0 {name=l17121 lab=BL0}
N -40 21400 -60 21400 {}
C {lab_pin.sym} -60 21400 0 0 {name=l17122 lab=BLB0}
N -40 21360 -60 21360 {}
C {lab_pin.sym} -60 21360 0 0 {name=l17123 lab=WL107}
N 40 21440 60 21440 {}
C {lab_pin.sym} 60 21440 0 0 {name=l17124 lab=VDD}
N 40 21360 60 21360 {}
C {lab_pin.sym} 60 21360 0 0 {name=l17125 lab=VSS}
C {bitcell_6t.sym} 200 21400 0 0 {name=Xr107c1}
N 160 21440 140 21440 {}
C {lab_pin.sym} 140 21440 0 0 {name=l17126 lab=BL1}
N 160 21400 140 21400 {}
C {lab_pin.sym} 140 21400 0 0 {name=l17127 lab=BLB1}
N 160 21360 140 21360 {}
C {lab_pin.sym} 140 21360 0 0 {name=l17128 lab=WL107}
N 240 21440 260 21440 {}
C {lab_pin.sym} 260 21440 0 0 {name=l17129 lab=VDD}
N 240 21360 260 21360 {}
C {lab_pin.sym} 260 21360 0 0 {name=l17130 lab=VSS}
C {bitcell_6t.sym} 400 21400 0 0 {name=Xr107c2}
N 360 21440 340 21440 {}
C {lab_pin.sym} 340 21440 0 0 {name=l17131 lab=BL2}
N 360 21400 340 21400 {}
C {lab_pin.sym} 340 21400 0 0 {name=l17132 lab=BLB2}
N 360 21360 340 21360 {}
C {lab_pin.sym} 340 21360 0 0 {name=l17133 lab=WL107}
N 440 21440 460 21440 {}
C {lab_pin.sym} 460 21440 0 0 {name=l17134 lab=VDD}
N 440 21360 460 21360 {}
C {lab_pin.sym} 460 21360 0 0 {name=l17135 lab=VSS}
C {bitcell_6t.sym} 600 21400 0 0 {name=Xr107c3}
N 560 21440 540 21440 {}
C {lab_pin.sym} 540 21440 0 0 {name=l17136 lab=BL3}
N 560 21400 540 21400 {}
C {lab_pin.sym} 540 21400 0 0 {name=l17137 lab=BLB3}
N 560 21360 540 21360 {}
C {lab_pin.sym} 540 21360 0 0 {name=l17138 lab=WL107}
N 640 21440 660 21440 {}
C {lab_pin.sym} 660 21440 0 0 {name=l17139 lab=VDD}
N 640 21360 660 21360 {}
C {lab_pin.sym} 660 21360 0 0 {name=l17140 lab=VSS}
C {bitcell_6t.sym} 800 21400 0 0 {name=Xr107c4}
N 760 21440 740 21440 {}
C {lab_pin.sym} 740 21440 0 0 {name=l17141 lab=BL4}
N 760 21400 740 21400 {}
C {lab_pin.sym} 740 21400 0 0 {name=l17142 lab=BLB4}
N 760 21360 740 21360 {}
C {lab_pin.sym} 740 21360 0 0 {name=l17143 lab=WL107}
N 840 21440 860 21440 {}
C {lab_pin.sym} 860 21440 0 0 {name=l17144 lab=VDD}
N 840 21360 860 21360 {}
C {lab_pin.sym} 860 21360 0 0 {name=l17145 lab=VSS}
C {bitcell_6t.sym} 1000 21400 0 0 {name=Xr107c5}
N 960 21440 940 21440 {}
C {lab_pin.sym} 940 21440 0 0 {name=l17146 lab=BL5}
N 960 21400 940 21400 {}
C {lab_pin.sym} 940 21400 0 0 {name=l17147 lab=BLB5}
N 960 21360 940 21360 {}
C {lab_pin.sym} 940 21360 0 0 {name=l17148 lab=WL107}
N 1040 21440 1060 21440 {}
C {lab_pin.sym} 1060 21440 0 0 {name=l17149 lab=VDD}
N 1040 21360 1060 21360 {}
C {lab_pin.sym} 1060 21360 0 0 {name=l17150 lab=VSS}
C {bitcell_6t.sym} 1200 21400 0 0 {name=Xr107c6}
N 1160 21440 1140 21440 {}
C {lab_pin.sym} 1140 21440 0 0 {name=l17151 lab=BL6}
N 1160 21400 1140 21400 {}
C {lab_pin.sym} 1140 21400 0 0 {name=l17152 lab=BLB6}
N 1160 21360 1140 21360 {}
C {lab_pin.sym} 1140 21360 0 0 {name=l17153 lab=WL107}
N 1240 21440 1260 21440 {}
C {lab_pin.sym} 1260 21440 0 0 {name=l17154 lab=VDD}
N 1240 21360 1260 21360 {}
C {lab_pin.sym} 1260 21360 0 0 {name=l17155 lab=VSS}
C {bitcell_6t.sym} 1400 21400 0 0 {name=Xr107c7}
N 1360 21440 1340 21440 {}
C {lab_pin.sym} 1340 21440 0 0 {name=l17156 lab=BL7}
N 1360 21400 1340 21400 {}
C {lab_pin.sym} 1340 21400 0 0 {name=l17157 lab=BLB7}
N 1360 21360 1340 21360 {}
C {lab_pin.sym} 1340 21360 0 0 {name=l17158 lab=WL107}
N 1440 21440 1460 21440 {}
C {lab_pin.sym} 1460 21440 0 0 {name=l17159 lab=VDD}
N 1440 21360 1460 21360 {}
C {lab_pin.sym} 1460 21360 0 0 {name=l17160 lab=VSS}
C {bitcell_6t.sym} 1600 21400 0 0 {name=Xr107c8}
N 1560 21440 1540 21440 {}
C {lab_pin.sym} 1540 21440 0 0 {name=l17161 lab=BL8}
N 1560 21400 1540 21400 {}
C {lab_pin.sym} 1540 21400 0 0 {name=l17162 lab=BLB8}
N 1560 21360 1540 21360 {}
C {lab_pin.sym} 1540 21360 0 0 {name=l17163 lab=WL107}
N 1640 21440 1660 21440 {}
C {lab_pin.sym} 1660 21440 0 0 {name=l17164 lab=VDD}
N 1640 21360 1660 21360 {}
C {lab_pin.sym} 1660 21360 0 0 {name=l17165 lab=VSS}
C {bitcell_6t.sym} 1800 21400 0 0 {name=Xr107c9}
N 1760 21440 1740 21440 {}
C {lab_pin.sym} 1740 21440 0 0 {name=l17166 lab=BL9}
N 1760 21400 1740 21400 {}
C {lab_pin.sym} 1740 21400 0 0 {name=l17167 lab=BLB9}
N 1760 21360 1740 21360 {}
C {lab_pin.sym} 1740 21360 0 0 {name=l17168 lab=WL107}
N 1840 21440 1860 21440 {}
C {lab_pin.sym} 1860 21440 0 0 {name=l17169 lab=VDD}
N 1840 21360 1860 21360 {}
C {lab_pin.sym} 1860 21360 0 0 {name=l17170 lab=VSS}
C {bitcell_6t.sym} 2000 21400 0 0 {name=Xr107c10}
N 1960 21440 1940 21440 {}
C {lab_pin.sym} 1940 21440 0 0 {name=l17171 lab=BL10}
N 1960 21400 1940 21400 {}
C {lab_pin.sym} 1940 21400 0 0 {name=l17172 lab=BLB10}
N 1960 21360 1940 21360 {}
C {lab_pin.sym} 1940 21360 0 0 {name=l17173 lab=WL107}
N 2040 21440 2060 21440 {}
C {lab_pin.sym} 2060 21440 0 0 {name=l17174 lab=VDD}
N 2040 21360 2060 21360 {}
C {lab_pin.sym} 2060 21360 0 0 {name=l17175 lab=VSS}
C {bitcell_6t.sym} 2200 21400 0 0 {name=Xr107c11}
N 2160 21440 2140 21440 {}
C {lab_pin.sym} 2140 21440 0 0 {name=l17176 lab=BL11}
N 2160 21400 2140 21400 {}
C {lab_pin.sym} 2140 21400 0 0 {name=l17177 lab=BLB11}
N 2160 21360 2140 21360 {}
C {lab_pin.sym} 2140 21360 0 0 {name=l17178 lab=WL107}
N 2240 21440 2260 21440 {}
C {lab_pin.sym} 2260 21440 0 0 {name=l17179 lab=VDD}
N 2240 21360 2260 21360 {}
C {lab_pin.sym} 2260 21360 0 0 {name=l17180 lab=VSS}
C {bitcell_6t.sym} 2400 21400 0 0 {name=Xr107c12}
N 2360 21440 2340 21440 {}
C {lab_pin.sym} 2340 21440 0 0 {name=l17181 lab=BL12}
N 2360 21400 2340 21400 {}
C {lab_pin.sym} 2340 21400 0 0 {name=l17182 lab=BLB12}
N 2360 21360 2340 21360 {}
C {lab_pin.sym} 2340 21360 0 0 {name=l17183 lab=WL107}
N 2440 21440 2460 21440 {}
C {lab_pin.sym} 2460 21440 0 0 {name=l17184 lab=VDD}
N 2440 21360 2460 21360 {}
C {lab_pin.sym} 2460 21360 0 0 {name=l17185 lab=VSS}
C {bitcell_6t.sym} 2600 21400 0 0 {name=Xr107c13}
N 2560 21440 2540 21440 {}
C {lab_pin.sym} 2540 21440 0 0 {name=l17186 lab=BL13}
N 2560 21400 2540 21400 {}
C {lab_pin.sym} 2540 21400 0 0 {name=l17187 lab=BLB13}
N 2560 21360 2540 21360 {}
C {lab_pin.sym} 2540 21360 0 0 {name=l17188 lab=WL107}
N 2640 21440 2660 21440 {}
C {lab_pin.sym} 2660 21440 0 0 {name=l17189 lab=VDD}
N 2640 21360 2660 21360 {}
C {lab_pin.sym} 2660 21360 0 0 {name=l17190 lab=VSS}
C {bitcell_6t.sym} 2800 21400 0 0 {name=Xr107c14}
N 2760 21440 2740 21440 {}
C {lab_pin.sym} 2740 21440 0 0 {name=l17191 lab=BL14}
N 2760 21400 2740 21400 {}
C {lab_pin.sym} 2740 21400 0 0 {name=l17192 lab=BLB14}
N 2760 21360 2740 21360 {}
C {lab_pin.sym} 2740 21360 0 0 {name=l17193 lab=WL107}
N 2840 21440 2860 21440 {}
C {lab_pin.sym} 2860 21440 0 0 {name=l17194 lab=VDD}
N 2840 21360 2860 21360 {}
C {lab_pin.sym} 2860 21360 0 0 {name=l17195 lab=VSS}
C {bitcell_6t.sym} 3000 21400 0 0 {name=Xr107c15}
N 2960 21440 2940 21440 {}
C {lab_pin.sym} 2940 21440 0 0 {name=l17196 lab=BL15}
N 2960 21400 2940 21400 {}
C {lab_pin.sym} 2940 21400 0 0 {name=l17197 lab=BLB15}
N 2960 21360 2940 21360 {}
C {lab_pin.sym} 2940 21360 0 0 {name=l17198 lab=WL107}
N 3040 21440 3060 21440 {}
C {lab_pin.sym} 3060 21440 0 0 {name=l17199 lab=VDD}
N 3040 21360 3060 21360 {}
C {lab_pin.sym} 3060 21360 0 0 {name=l17200 lab=VSS}
C {bitcell_6t.sym} 3200 21400 0 0 {name=Xr107c16}
N 3160 21440 3140 21440 {}
C {lab_pin.sym} 3140 21440 0 0 {name=l17201 lab=BL16}
N 3160 21400 3140 21400 {}
C {lab_pin.sym} 3140 21400 0 0 {name=l17202 lab=BLB16}
N 3160 21360 3140 21360 {}
C {lab_pin.sym} 3140 21360 0 0 {name=l17203 lab=WL107}
N 3240 21440 3260 21440 {}
C {lab_pin.sym} 3260 21440 0 0 {name=l17204 lab=VDD}
N 3240 21360 3260 21360 {}
C {lab_pin.sym} 3260 21360 0 0 {name=l17205 lab=VSS}
C {bitcell_6t.sym} 3400 21400 0 0 {name=Xr107c17}
N 3360 21440 3340 21440 {}
C {lab_pin.sym} 3340 21440 0 0 {name=l17206 lab=BL17}
N 3360 21400 3340 21400 {}
C {lab_pin.sym} 3340 21400 0 0 {name=l17207 lab=BLB17}
N 3360 21360 3340 21360 {}
C {lab_pin.sym} 3340 21360 0 0 {name=l17208 lab=WL107}
N 3440 21440 3460 21440 {}
C {lab_pin.sym} 3460 21440 0 0 {name=l17209 lab=VDD}
N 3440 21360 3460 21360 {}
C {lab_pin.sym} 3460 21360 0 0 {name=l17210 lab=VSS}
C {bitcell_6t.sym} 3600 21400 0 0 {name=Xr107c18}
N 3560 21440 3540 21440 {}
C {lab_pin.sym} 3540 21440 0 0 {name=l17211 lab=BL18}
N 3560 21400 3540 21400 {}
C {lab_pin.sym} 3540 21400 0 0 {name=l17212 lab=BLB18}
N 3560 21360 3540 21360 {}
C {lab_pin.sym} 3540 21360 0 0 {name=l17213 lab=WL107}
N 3640 21440 3660 21440 {}
C {lab_pin.sym} 3660 21440 0 0 {name=l17214 lab=VDD}
N 3640 21360 3660 21360 {}
C {lab_pin.sym} 3660 21360 0 0 {name=l17215 lab=VSS}
C {bitcell_6t.sym} 3800 21400 0 0 {name=Xr107c19}
N 3760 21440 3740 21440 {}
C {lab_pin.sym} 3740 21440 0 0 {name=l17216 lab=BL19}
N 3760 21400 3740 21400 {}
C {lab_pin.sym} 3740 21400 0 0 {name=l17217 lab=BLB19}
N 3760 21360 3740 21360 {}
C {lab_pin.sym} 3740 21360 0 0 {name=l17218 lab=WL107}
N 3840 21440 3860 21440 {}
C {lab_pin.sym} 3860 21440 0 0 {name=l17219 lab=VDD}
N 3840 21360 3860 21360 {}
C {lab_pin.sym} 3860 21360 0 0 {name=l17220 lab=VSS}
C {bitcell_6t.sym} 4000 21400 0 0 {name=Xr107c20}
N 3960 21440 3940 21440 {}
C {lab_pin.sym} 3940 21440 0 0 {name=l17221 lab=BL20}
N 3960 21400 3940 21400 {}
C {lab_pin.sym} 3940 21400 0 0 {name=l17222 lab=BLB20}
N 3960 21360 3940 21360 {}
C {lab_pin.sym} 3940 21360 0 0 {name=l17223 lab=WL107}
N 4040 21440 4060 21440 {}
C {lab_pin.sym} 4060 21440 0 0 {name=l17224 lab=VDD}
N 4040 21360 4060 21360 {}
C {lab_pin.sym} 4060 21360 0 0 {name=l17225 lab=VSS}
C {bitcell_6t.sym} 4200 21400 0 0 {name=Xr107c21}
N 4160 21440 4140 21440 {}
C {lab_pin.sym} 4140 21440 0 0 {name=l17226 lab=BL21}
N 4160 21400 4140 21400 {}
C {lab_pin.sym} 4140 21400 0 0 {name=l17227 lab=BLB21}
N 4160 21360 4140 21360 {}
C {lab_pin.sym} 4140 21360 0 0 {name=l17228 lab=WL107}
N 4240 21440 4260 21440 {}
C {lab_pin.sym} 4260 21440 0 0 {name=l17229 lab=VDD}
N 4240 21360 4260 21360 {}
C {lab_pin.sym} 4260 21360 0 0 {name=l17230 lab=VSS}
C {bitcell_6t.sym} 4400 21400 0 0 {name=Xr107c22}
N 4360 21440 4340 21440 {}
C {lab_pin.sym} 4340 21440 0 0 {name=l17231 lab=BL22}
N 4360 21400 4340 21400 {}
C {lab_pin.sym} 4340 21400 0 0 {name=l17232 lab=BLB22}
N 4360 21360 4340 21360 {}
C {lab_pin.sym} 4340 21360 0 0 {name=l17233 lab=WL107}
N 4440 21440 4460 21440 {}
C {lab_pin.sym} 4460 21440 0 0 {name=l17234 lab=VDD}
N 4440 21360 4460 21360 {}
C {lab_pin.sym} 4460 21360 0 0 {name=l17235 lab=VSS}
C {bitcell_6t.sym} 4600 21400 0 0 {name=Xr107c23}
N 4560 21440 4540 21440 {}
C {lab_pin.sym} 4540 21440 0 0 {name=l17236 lab=BL23}
N 4560 21400 4540 21400 {}
C {lab_pin.sym} 4540 21400 0 0 {name=l17237 lab=BLB23}
N 4560 21360 4540 21360 {}
C {lab_pin.sym} 4540 21360 0 0 {name=l17238 lab=WL107}
N 4640 21440 4660 21440 {}
C {lab_pin.sym} 4660 21440 0 0 {name=l17239 lab=VDD}
N 4640 21360 4660 21360 {}
C {lab_pin.sym} 4660 21360 0 0 {name=l17240 lab=VSS}
C {bitcell_6t.sym} 4800 21400 0 0 {name=Xr107c24}
N 4760 21440 4740 21440 {}
C {lab_pin.sym} 4740 21440 0 0 {name=l17241 lab=BL24}
N 4760 21400 4740 21400 {}
C {lab_pin.sym} 4740 21400 0 0 {name=l17242 lab=BLB24}
N 4760 21360 4740 21360 {}
C {lab_pin.sym} 4740 21360 0 0 {name=l17243 lab=WL107}
N 4840 21440 4860 21440 {}
C {lab_pin.sym} 4860 21440 0 0 {name=l17244 lab=VDD}
N 4840 21360 4860 21360 {}
C {lab_pin.sym} 4860 21360 0 0 {name=l17245 lab=VSS}
C {bitcell_6t.sym} 5000 21400 0 0 {name=Xr107c25}
N 4960 21440 4940 21440 {}
C {lab_pin.sym} 4940 21440 0 0 {name=l17246 lab=BL25}
N 4960 21400 4940 21400 {}
C {lab_pin.sym} 4940 21400 0 0 {name=l17247 lab=BLB25}
N 4960 21360 4940 21360 {}
C {lab_pin.sym} 4940 21360 0 0 {name=l17248 lab=WL107}
N 5040 21440 5060 21440 {}
C {lab_pin.sym} 5060 21440 0 0 {name=l17249 lab=VDD}
N 5040 21360 5060 21360 {}
C {lab_pin.sym} 5060 21360 0 0 {name=l17250 lab=VSS}
C {bitcell_6t.sym} 5200 21400 0 0 {name=Xr107c26}
N 5160 21440 5140 21440 {}
C {lab_pin.sym} 5140 21440 0 0 {name=l17251 lab=BL26}
N 5160 21400 5140 21400 {}
C {lab_pin.sym} 5140 21400 0 0 {name=l17252 lab=BLB26}
N 5160 21360 5140 21360 {}
C {lab_pin.sym} 5140 21360 0 0 {name=l17253 lab=WL107}
N 5240 21440 5260 21440 {}
C {lab_pin.sym} 5260 21440 0 0 {name=l17254 lab=VDD}
N 5240 21360 5260 21360 {}
C {lab_pin.sym} 5260 21360 0 0 {name=l17255 lab=VSS}
C {bitcell_6t.sym} 5400 21400 0 0 {name=Xr107c27}
N 5360 21440 5340 21440 {}
C {lab_pin.sym} 5340 21440 0 0 {name=l17256 lab=BL27}
N 5360 21400 5340 21400 {}
C {lab_pin.sym} 5340 21400 0 0 {name=l17257 lab=BLB27}
N 5360 21360 5340 21360 {}
C {lab_pin.sym} 5340 21360 0 0 {name=l17258 lab=WL107}
N 5440 21440 5460 21440 {}
C {lab_pin.sym} 5460 21440 0 0 {name=l17259 lab=VDD}
N 5440 21360 5460 21360 {}
C {lab_pin.sym} 5460 21360 0 0 {name=l17260 lab=VSS}
C {bitcell_6t.sym} 5600 21400 0 0 {name=Xr107c28}
N 5560 21440 5540 21440 {}
C {lab_pin.sym} 5540 21440 0 0 {name=l17261 lab=BL28}
N 5560 21400 5540 21400 {}
C {lab_pin.sym} 5540 21400 0 0 {name=l17262 lab=BLB28}
N 5560 21360 5540 21360 {}
C {lab_pin.sym} 5540 21360 0 0 {name=l17263 lab=WL107}
N 5640 21440 5660 21440 {}
C {lab_pin.sym} 5660 21440 0 0 {name=l17264 lab=VDD}
N 5640 21360 5660 21360 {}
C {lab_pin.sym} 5660 21360 0 0 {name=l17265 lab=VSS}
C {bitcell_6t.sym} 5800 21400 0 0 {name=Xr107c29}
N 5760 21440 5740 21440 {}
C {lab_pin.sym} 5740 21440 0 0 {name=l17266 lab=BL29}
N 5760 21400 5740 21400 {}
C {lab_pin.sym} 5740 21400 0 0 {name=l17267 lab=BLB29}
N 5760 21360 5740 21360 {}
C {lab_pin.sym} 5740 21360 0 0 {name=l17268 lab=WL107}
N 5840 21440 5860 21440 {}
C {lab_pin.sym} 5860 21440 0 0 {name=l17269 lab=VDD}
N 5840 21360 5860 21360 {}
C {lab_pin.sym} 5860 21360 0 0 {name=l17270 lab=VSS}
C {bitcell_6t.sym} 6000 21400 0 0 {name=Xr107c30}
N 5960 21440 5940 21440 {}
C {lab_pin.sym} 5940 21440 0 0 {name=l17271 lab=BL30}
N 5960 21400 5940 21400 {}
C {lab_pin.sym} 5940 21400 0 0 {name=l17272 lab=BLB30}
N 5960 21360 5940 21360 {}
C {lab_pin.sym} 5940 21360 0 0 {name=l17273 lab=WL107}
N 6040 21440 6060 21440 {}
C {lab_pin.sym} 6060 21440 0 0 {name=l17274 lab=VDD}
N 6040 21360 6060 21360 {}
C {lab_pin.sym} 6060 21360 0 0 {name=l17275 lab=VSS}
C {bitcell_6t.sym} 6200 21400 0 0 {name=Xr107c31}
N 6160 21440 6140 21440 {}
C {lab_pin.sym} 6140 21440 0 0 {name=l17276 lab=BL31}
N 6160 21400 6140 21400 {}
C {lab_pin.sym} 6140 21400 0 0 {name=l17277 lab=BLB31}
N 6160 21360 6140 21360 {}
C {lab_pin.sym} 6140 21360 0 0 {name=l17278 lab=WL107}
N 6240 21440 6260 21440 {}
C {lab_pin.sym} 6260 21440 0 0 {name=l17279 lab=VDD}
N 6240 21360 6260 21360 {}
C {lab_pin.sym} 6260 21360 0 0 {name=l17280 lab=VSS}
C {bitcell_6t.sym} 0 21600 0 0 {name=Xr108c0}
N -40 21640 -60 21640 {}
C {lab_pin.sym} -60 21640 0 0 {name=l17281 lab=BL0}
N -40 21600 -60 21600 {}
C {lab_pin.sym} -60 21600 0 0 {name=l17282 lab=BLB0}
N -40 21560 -60 21560 {}
C {lab_pin.sym} -60 21560 0 0 {name=l17283 lab=WL108}
N 40 21640 60 21640 {}
C {lab_pin.sym} 60 21640 0 0 {name=l17284 lab=VDD}
N 40 21560 60 21560 {}
C {lab_pin.sym} 60 21560 0 0 {name=l17285 lab=VSS}
C {bitcell_6t.sym} 200 21600 0 0 {name=Xr108c1}
N 160 21640 140 21640 {}
C {lab_pin.sym} 140 21640 0 0 {name=l17286 lab=BL1}
N 160 21600 140 21600 {}
C {lab_pin.sym} 140 21600 0 0 {name=l17287 lab=BLB1}
N 160 21560 140 21560 {}
C {lab_pin.sym} 140 21560 0 0 {name=l17288 lab=WL108}
N 240 21640 260 21640 {}
C {lab_pin.sym} 260 21640 0 0 {name=l17289 lab=VDD}
N 240 21560 260 21560 {}
C {lab_pin.sym} 260 21560 0 0 {name=l17290 lab=VSS}
C {bitcell_6t.sym} 400 21600 0 0 {name=Xr108c2}
N 360 21640 340 21640 {}
C {lab_pin.sym} 340 21640 0 0 {name=l17291 lab=BL2}
N 360 21600 340 21600 {}
C {lab_pin.sym} 340 21600 0 0 {name=l17292 lab=BLB2}
N 360 21560 340 21560 {}
C {lab_pin.sym} 340 21560 0 0 {name=l17293 lab=WL108}
N 440 21640 460 21640 {}
C {lab_pin.sym} 460 21640 0 0 {name=l17294 lab=VDD}
N 440 21560 460 21560 {}
C {lab_pin.sym} 460 21560 0 0 {name=l17295 lab=VSS}
C {bitcell_6t.sym} 600 21600 0 0 {name=Xr108c3}
N 560 21640 540 21640 {}
C {lab_pin.sym} 540 21640 0 0 {name=l17296 lab=BL3}
N 560 21600 540 21600 {}
C {lab_pin.sym} 540 21600 0 0 {name=l17297 lab=BLB3}
N 560 21560 540 21560 {}
C {lab_pin.sym} 540 21560 0 0 {name=l17298 lab=WL108}
N 640 21640 660 21640 {}
C {lab_pin.sym} 660 21640 0 0 {name=l17299 lab=VDD}
N 640 21560 660 21560 {}
C {lab_pin.sym} 660 21560 0 0 {name=l17300 lab=VSS}
C {bitcell_6t.sym} 800 21600 0 0 {name=Xr108c4}
N 760 21640 740 21640 {}
C {lab_pin.sym} 740 21640 0 0 {name=l17301 lab=BL4}
N 760 21600 740 21600 {}
C {lab_pin.sym} 740 21600 0 0 {name=l17302 lab=BLB4}
N 760 21560 740 21560 {}
C {lab_pin.sym} 740 21560 0 0 {name=l17303 lab=WL108}
N 840 21640 860 21640 {}
C {lab_pin.sym} 860 21640 0 0 {name=l17304 lab=VDD}
N 840 21560 860 21560 {}
C {lab_pin.sym} 860 21560 0 0 {name=l17305 lab=VSS}
C {bitcell_6t.sym} 1000 21600 0 0 {name=Xr108c5}
N 960 21640 940 21640 {}
C {lab_pin.sym} 940 21640 0 0 {name=l17306 lab=BL5}
N 960 21600 940 21600 {}
C {lab_pin.sym} 940 21600 0 0 {name=l17307 lab=BLB5}
N 960 21560 940 21560 {}
C {lab_pin.sym} 940 21560 0 0 {name=l17308 lab=WL108}
N 1040 21640 1060 21640 {}
C {lab_pin.sym} 1060 21640 0 0 {name=l17309 lab=VDD}
N 1040 21560 1060 21560 {}
C {lab_pin.sym} 1060 21560 0 0 {name=l17310 lab=VSS}
C {bitcell_6t.sym} 1200 21600 0 0 {name=Xr108c6}
N 1160 21640 1140 21640 {}
C {lab_pin.sym} 1140 21640 0 0 {name=l17311 lab=BL6}
N 1160 21600 1140 21600 {}
C {lab_pin.sym} 1140 21600 0 0 {name=l17312 lab=BLB6}
N 1160 21560 1140 21560 {}
C {lab_pin.sym} 1140 21560 0 0 {name=l17313 lab=WL108}
N 1240 21640 1260 21640 {}
C {lab_pin.sym} 1260 21640 0 0 {name=l17314 lab=VDD}
N 1240 21560 1260 21560 {}
C {lab_pin.sym} 1260 21560 0 0 {name=l17315 lab=VSS}
C {bitcell_6t.sym} 1400 21600 0 0 {name=Xr108c7}
N 1360 21640 1340 21640 {}
C {lab_pin.sym} 1340 21640 0 0 {name=l17316 lab=BL7}
N 1360 21600 1340 21600 {}
C {lab_pin.sym} 1340 21600 0 0 {name=l17317 lab=BLB7}
N 1360 21560 1340 21560 {}
C {lab_pin.sym} 1340 21560 0 0 {name=l17318 lab=WL108}
N 1440 21640 1460 21640 {}
C {lab_pin.sym} 1460 21640 0 0 {name=l17319 lab=VDD}
N 1440 21560 1460 21560 {}
C {lab_pin.sym} 1460 21560 0 0 {name=l17320 lab=VSS}
C {bitcell_6t.sym} 1600 21600 0 0 {name=Xr108c8}
N 1560 21640 1540 21640 {}
C {lab_pin.sym} 1540 21640 0 0 {name=l17321 lab=BL8}
N 1560 21600 1540 21600 {}
C {lab_pin.sym} 1540 21600 0 0 {name=l17322 lab=BLB8}
N 1560 21560 1540 21560 {}
C {lab_pin.sym} 1540 21560 0 0 {name=l17323 lab=WL108}
N 1640 21640 1660 21640 {}
C {lab_pin.sym} 1660 21640 0 0 {name=l17324 lab=VDD}
N 1640 21560 1660 21560 {}
C {lab_pin.sym} 1660 21560 0 0 {name=l17325 lab=VSS}
C {bitcell_6t.sym} 1800 21600 0 0 {name=Xr108c9}
N 1760 21640 1740 21640 {}
C {lab_pin.sym} 1740 21640 0 0 {name=l17326 lab=BL9}
N 1760 21600 1740 21600 {}
C {lab_pin.sym} 1740 21600 0 0 {name=l17327 lab=BLB9}
N 1760 21560 1740 21560 {}
C {lab_pin.sym} 1740 21560 0 0 {name=l17328 lab=WL108}
N 1840 21640 1860 21640 {}
C {lab_pin.sym} 1860 21640 0 0 {name=l17329 lab=VDD}
N 1840 21560 1860 21560 {}
C {lab_pin.sym} 1860 21560 0 0 {name=l17330 lab=VSS}
C {bitcell_6t.sym} 2000 21600 0 0 {name=Xr108c10}
N 1960 21640 1940 21640 {}
C {lab_pin.sym} 1940 21640 0 0 {name=l17331 lab=BL10}
N 1960 21600 1940 21600 {}
C {lab_pin.sym} 1940 21600 0 0 {name=l17332 lab=BLB10}
N 1960 21560 1940 21560 {}
C {lab_pin.sym} 1940 21560 0 0 {name=l17333 lab=WL108}
N 2040 21640 2060 21640 {}
C {lab_pin.sym} 2060 21640 0 0 {name=l17334 lab=VDD}
N 2040 21560 2060 21560 {}
C {lab_pin.sym} 2060 21560 0 0 {name=l17335 lab=VSS}
C {bitcell_6t.sym} 2200 21600 0 0 {name=Xr108c11}
N 2160 21640 2140 21640 {}
C {lab_pin.sym} 2140 21640 0 0 {name=l17336 lab=BL11}
N 2160 21600 2140 21600 {}
C {lab_pin.sym} 2140 21600 0 0 {name=l17337 lab=BLB11}
N 2160 21560 2140 21560 {}
C {lab_pin.sym} 2140 21560 0 0 {name=l17338 lab=WL108}
N 2240 21640 2260 21640 {}
C {lab_pin.sym} 2260 21640 0 0 {name=l17339 lab=VDD}
N 2240 21560 2260 21560 {}
C {lab_pin.sym} 2260 21560 0 0 {name=l17340 lab=VSS}
C {bitcell_6t.sym} 2400 21600 0 0 {name=Xr108c12}
N 2360 21640 2340 21640 {}
C {lab_pin.sym} 2340 21640 0 0 {name=l17341 lab=BL12}
N 2360 21600 2340 21600 {}
C {lab_pin.sym} 2340 21600 0 0 {name=l17342 lab=BLB12}
N 2360 21560 2340 21560 {}
C {lab_pin.sym} 2340 21560 0 0 {name=l17343 lab=WL108}
N 2440 21640 2460 21640 {}
C {lab_pin.sym} 2460 21640 0 0 {name=l17344 lab=VDD}
N 2440 21560 2460 21560 {}
C {lab_pin.sym} 2460 21560 0 0 {name=l17345 lab=VSS}
C {bitcell_6t.sym} 2600 21600 0 0 {name=Xr108c13}
N 2560 21640 2540 21640 {}
C {lab_pin.sym} 2540 21640 0 0 {name=l17346 lab=BL13}
N 2560 21600 2540 21600 {}
C {lab_pin.sym} 2540 21600 0 0 {name=l17347 lab=BLB13}
N 2560 21560 2540 21560 {}
C {lab_pin.sym} 2540 21560 0 0 {name=l17348 lab=WL108}
N 2640 21640 2660 21640 {}
C {lab_pin.sym} 2660 21640 0 0 {name=l17349 lab=VDD}
N 2640 21560 2660 21560 {}
C {lab_pin.sym} 2660 21560 0 0 {name=l17350 lab=VSS}
C {bitcell_6t.sym} 2800 21600 0 0 {name=Xr108c14}
N 2760 21640 2740 21640 {}
C {lab_pin.sym} 2740 21640 0 0 {name=l17351 lab=BL14}
N 2760 21600 2740 21600 {}
C {lab_pin.sym} 2740 21600 0 0 {name=l17352 lab=BLB14}
N 2760 21560 2740 21560 {}
C {lab_pin.sym} 2740 21560 0 0 {name=l17353 lab=WL108}
N 2840 21640 2860 21640 {}
C {lab_pin.sym} 2860 21640 0 0 {name=l17354 lab=VDD}
N 2840 21560 2860 21560 {}
C {lab_pin.sym} 2860 21560 0 0 {name=l17355 lab=VSS}
C {bitcell_6t.sym} 3000 21600 0 0 {name=Xr108c15}
N 2960 21640 2940 21640 {}
C {lab_pin.sym} 2940 21640 0 0 {name=l17356 lab=BL15}
N 2960 21600 2940 21600 {}
C {lab_pin.sym} 2940 21600 0 0 {name=l17357 lab=BLB15}
N 2960 21560 2940 21560 {}
C {lab_pin.sym} 2940 21560 0 0 {name=l17358 lab=WL108}
N 3040 21640 3060 21640 {}
C {lab_pin.sym} 3060 21640 0 0 {name=l17359 lab=VDD}
N 3040 21560 3060 21560 {}
C {lab_pin.sym} 3060 21560 0 0 {name=l17360 lab=VSS}
C {bitcell_6t.sym} 3200 21600 0 0 {name=Xr108c16}
N 3160 21640 3140 21640 {}
C {lab_pin.sym} 3140 21640 0 0 {name=l17361 lab=BL16}
N 3160 21600 3140 21600 {}
C {lab_pin.sym} 3140 21600 0 0 {name=l17362 lab=BLB16}
N 3160 21560 3140 21560 {}
C {lab_pin.sym} 3140 21560 0 0 {name=l17363 lab=WL108}
N 3240 21640 3260 21640 {}
C {lab_pin.sym} 3260 21640 0 0 {name=l17364 lab=VDD}
N 3240 21560 3260 21560 {}
C {lab_pin.sym} 3260 21560 0 0 {name=l17365 lab=VSS}
C {bitcell_6t.sym} 3400 21600 0 0 {name=Xr108c17}
N 3360 21640 3340 21640 {}
C {lab_pin.sym} 3340 21640 0 0 {name=l17366 lab=BL17}
N 3360 21600 3340 21600 {}
C {lab_pin.sym} 3340 21600 0 0 {name=l17367 lab=BLB17}
N 3360 21560 3340 21560 {}
C {lab_pin.sym} 3340 21560 0 0 {name=l17368 lab=WL108}
N 3440 21640 3460 21640 {}
C {lab_pin.sym} 3460 21640 0 0 {name=l17369 lab=VDD}
N 3440 21560 3460 21560 {}
C {lab_pin.sym} 3460 21560 0 0 {name=l17370 lab=VSS}
C {bitcell_6t.sym} 3600 21600 0 0 {name=Xr108c18}
N 3560 21640 3540 21640 {}
C {lab_pin.sym} 3540 21640 0 0 {name=l17371 lab=BL18}
N 3560 21600 3540 21600 {}
C {lab_pin.sym} 3540 21600 0 0 {name=l17372 lab=BLB18}
N 3560 21560 3540 21560 {}
C {lab_pin.sym} 3540 21560 0 0 {name=l17373 lab=WL108}
N 3640 21640 3660 21640 {}
C {lab_pin.sym} 3660 21640 0 0 {name=l17374 lab=VDD}
N 3640 21560 3660 21560 {}
C {lab_pin.sym} 3660 21560 0 0 {name=l17375 lab=VSS}
C {bitcell_6t.sym} 3800 21600 0 0 {name=Xr108c19}
N 3760 21640 3740 21640 {}
C {lab_pin.sym} 3740 21640 0 0 {name=l17376 lab=BL19}
N 3760 21600 3740 21600 {}
C {lab_pin.sym} 3740 21600 0 0 {name=l17377 lab=BLB19}
N 3760 21560 3740 21560 {}
C {lab_pin.sym} 3740 21560 0 0 {name=l17378 lab=WL108}
N 3840 21640 3860 21640 {}
C {lab_pin.sym} 3860 21640 0 0 {name=l17379 lab=VDD}
N 3840 21560 3860 21560 {}
C {lab_pin.sym} 3860 21560 0 0 {name=l17380 lab=VSS}
C {bitcell_6t.sym} 4000 21600 0 0 {name=Xr108c20}
N 3960 21640 3940 21640 {}
C {lab_pin.sym} 3940 21640 0 0 {name=l17381 lab=BL20}
N 3960 21600 3940 21600 {}
C {lab_pin.sym} 3940 21600 0 0 {name=l17382 lab=BLB20}
N 3960 21560 3940 21560 {}
C {lab_pin.sym} 3940 21560 0 0 {name=l17383 lab=WL108}
N 4040 21640 4060 21640 {}
C {lab_pin.sym} 4060 21640 0 0 {name=l17384 lab=VDD}
N 4040 21560 4060 21560 {}
C {lab_pin.sym} 4060 21560 0 0 {name=l17385 lab=VSS}
C {bitcell_6t.sym} 4200 21600 0 0 {name=Xr108c21}
N 4160 21640 4140 21640 {}
C {lab_pin.sym} 4140 21640 0 0 {name=l17386 lab=BL21}
N 4160 21600 4140 21600 {}
C {lab_pin.sym} 4140 21600 0 0 {name=l17387 lab=BLB21}
N 4160 21560 4140 21560 {}
C {lab_pin.sym} 4140 21560 0 0 {name=l17388 lab=WL108}
N 4240 21640 4260 21640 {}
C {lab_pin.sym} 4260 21640 0 0 {name=l17389 lab=VDD}
N 4240 21560 4260 21560 {}
C {lab_pin.sym} 4260 21560 0 0 {name=l17390 lab=VSS}
C {bitcell_6t.sym} 4400 21600 0 0 {name=Xr108c22}
N 4360 21640 4340 21640 {}
C {lab_pin.sym} 4340 21640 0 0 {name=l17391 lab=BL22}
N 4360 21600 4340 21600 {}
C {lab_pin.sym} 4340 21600 0 0 {name=l17392 lab=BLB22}
N 4360 21560 4340 21560 {}
C {lab_pin.sym} 4340 21560 0 0 {name=l17393 lab=WL108}
N 4440 21640 4460 21640 {}
C {lab_pin.sym} 4460 21640 0 0 {name=l17394 lab=VDD}
N 4440 21560 4460 21560 {}
C {lab_pin.sym} 4460 21560 0 0 {name=l17395 lab=VSS}
C {bitcell_6t.sym} 4600 21600 0 0 {name=Xr108c23}
N 4560 21640 4540 21640 {}
C {lab_pin.sym} 4540 21640 0 0 {name=l17396 lab=BL23}
N 4560 21600 4540 21600 {}
C {lab_pin.sym} 4540 21600 0 0 {name=l17397 lab=BLB23}
N 4560 21560 4540 21560 {}
C {lab_pin.sym} 4540 21560 0 0 {name=l17398 lab=WL108}
N 4640 21640 4660 21640 {}
C {lab_pin.sym} 4660 21640 0 0 {name=l17399 lab=VDD}
N 4640 21560 4660 21560 {}
C {lab_pin.sym} 4660 21560 0 0 {name=l17400 lab=VSS}
C {bitcell_6t.sym} 4800 21600 0 0 {name=Xr108c24}
N 4760 21640 4740 21640 {}
C {lab_pin.sym} 4740 21640 0 0 {name=l17401 lab=BL24}
N 4760 21600 4740 21600 {}
C {lab_pin.sym} 4740 21600 0 0 {name=l17402 lab=BLB24}
N 4760 21560 4740 21560 {}
C {lab_pin.sym} 4740 21560 0 0 {name=l17403 lab=WL108}
N 4840 21640 4860 21640 {}
C {lab_pin.sym} 4860 21640 0 0 {name=l17404 lab=VDD}
N 4840 21560 4860 21560 {}
C {lab_pin.sym} 4860 21560 0 0 {name=l17405 lab=VSS}
C {bitcell_6t.sym} 5000 21600 0 0 {name=Xr108c25}
N 4960 21640 4940 21640 {}
C {lab_pin.sym} 4940 21640 0 0 {name=l17406 lab=BL25}
N 4960 21600 4940 21600 {}
C {lab_pin.sym} 4940 21600 0 0 {name=l17407 lab=BLB25}
N 4960 21560 4940 21560 {}
C {lab_pin.sym} 4940 21560 0 0 {name=l17408 lab=WL108}
N 5040 21640 5060 21640 {}
C {lab_pin.sym} 5060 21640 0 0 {name=l17409 lab=VDD}
N 5040 21560 5060 21560 {}
C {lab_pin.sym} 5060 21560 0 0 {name=l17410 lab=VSS}
C {bitcell_6t.sym} 5200 21600 0 0 {name=Xr108c26}
N 5160 21640 5140 21640 {}
C {lab_pin.sym} 5140 21640 0 0 {name=l17411 lab=BL26}
N 5160 21600 5140 21600 {}
C {lab_pin.sym} 5140 21600 0 0 {name=l17412 lab=BLB26}
N 5160 21560 5140 21560 {}
C {lab_pin.sym} 5140 21560 0 0 {name=l17413 lab=WL108}
N 5240 21640 5260 21640 {}
C {lab_pin.sym} 5260 21640 0 0 {name=l17414 lab=VDD}
N 5240 21560 5260 21560 {}
C {lab_pin.sym} 5260 21560 0 0 {name=l17415 lab=VSS}
C {bitcell_6t.sym} 5400 21600 0 0 {name=Xr108c27}
N 5360 21640 5340 21640 {}
C {lab_pin.sym} 5340 21640 0 0 {name=l17416 lab=BL27}
N 5360 21600 5340 21600 {}
C {lab_pin.sym} 5340 21600 0 0 {name=l17417 lab=BLB27}
N 5360 21560 5340 21560 {}
C {lab_pin.sym} 5340 21560 0 0 {name=l17418 lab=WL108}
N 5440 21640 5460 21640 {}
C {lab_pin.sym} 5460 21640 0 0 {name=l17419 lab=VDD}
N 5440 21560 5460 21560 {}
C {lab_pin.sym} 5460 21560 0 0 {name=l17420 lab=VSS}
C {bitcell_6t.sym} 5600 21600 0 0 {name=Xr108c28}
N 5560 21640 5540 21640 {}
C {lab_pin.sym} 5540 21640 0 0 {name=l17421 lab=BL28}
N 5560 21600 5540 21600 {}
C {lab_pin.sym} 5540 21600 0 0 {name=l17422 lab=BLB28}
N 5560 21560 5540 21560 {}
C {lab_pin.sym} 5540 21560 0 0 {name=l17423 lab=WL108}
N 5640 21640 5660 21640 {}
C {lab_pin.sym} 5660 21640 0 0 {name=l17424 lab=VDD}
N 5640 21560 5660 21560 {}
C {lab_pin.sym} 5660 21560 0 0 {name=l17425 lab=VSS}
C {bitcell_6t.sym} 5800 21600 0 0 {name=Xr108c29}
N 5760 21640 5740 21640 {}
C {lab_pin.sym} 5740 21640 0 0 {name=l17426 lab=BL29}
N 5760 21600 5740 21600 {}
C {lab_pin.sym} 5740 21600 0 0 {name=l17427 lab=BLB29}
N 5760 21560 5740 21560 {}
C {lab_pin.sym} 5740 21560 0 0 {name=l17428 lab=WL108}
N 5840 21640 5860 21640 {}
C {lab_pin.sym} 5860 21640 0 0 {name=l17429 lab=VDD}
N 5840 21560 5860 21560 {}
C {lab_pin.sym} 5860 21560 0 0 {name=l17430 lab=VSS}
C {bitcell_6t.sym} 6000 21600 0 0 {name=Xr108c30}
N 5960 21640 5940 21640 {}
C {lab_pin.sym} 5940 21640 0 0 {name=l17431 lab=BL30}
N 5960 21600 5940 21600 {}
C {lab_pin.sym} 5940 21600 0 0 {name=l17432 lab=BLB30}
N 5960 21560 5940 21560 {}
C {lab_pin.sym} 5940 21560 0 0 {name=l17433 lab=WL108}
N 6040 21640 6060 21640 {}
C {lab_pin.sym} 6060 21640 0 0 {name=l17434 lab=VDD}
N 6040 21560 6060 21560 {}
C {lab_pin.sym} 6060 21560 0 0 {name=l17435 lab=VSS}
C {bitcell_6t.sym} 6200 21600 0 0 {name=Xr108c31}
N 6160 21640 6140 21640 {}
C {lab_pin.sym} 6140 21640 0 0 {name=l17436 lab=BL31}
N 6160 21600 6140 21600 {}
C {lab_pin.sym} 6140 21600 0 0 {name=l17437 lab=BLB31}
N 6160 21560 6140 21560 {}
C {lab_pin.sym} 6140 21560 0 0 {name=l17438 lab=WL108}
N 6240 21640 6260 21640 {}
C {lab_pin.sym} 6260 21640 0 0 {name=l17439 lab=VDD}
N 6240 21560 6260 21560 {}
C {lab_pin.sym} 6260 21560 0 0 {name=l17440 lab=VSS}
C {bitcell_6t.sym} 0 21800 0 0 {name=Xr109c0}
N -40 21840 -60 21840 {}
C {lab_pin.sym} -60 21840 0 0 {name=l17441 lab=BL0}
N -40 21800 -60 21800 {}
C {lab_pin.sym} -60 21800 0 0 {name=l17442 lab=BLB0}
N -40 21760 -60 21760 {}
C {lab_pin.sym} -60 21760 0 0 {name=l17443 lab=WL109}
N 40 21840 60 21840 {}
C {lab_pin.sym} 60 21840 0 0 {name=l17444 lab=VDD}
N 40 21760 60 21760 {}
C {lab_pin.sym} 60 21760 0 0 {name=l17445 lab=VSS}
C {bitcell_6t.sym} 200 21800 0 0 {name=Xr109c1}
N 160 21840 140 21840 {}
C {lab_pin.sym} 140 21840 0 0 {name=l17446 lab=BL1}
N 160 21800 140 21800 {}
C {lab_pin.sym} 140 21800 0 0 {name=l17447 lab=BLB1}
N 160 21760 140 21760 {}
C {lab_pin.sym} 140 21760 0 0 {name=l17448 lab=WL109}
N 240 21840 260 21840 {}
C {lab_pin.sym} 260 21840 0 0 {name=l17449 lab=VDD}
N 240 21760 260 21760 {}
C {lab_pin.sym} 260 21760 0 0 {name=l17450 lab=VSS}
C {bitcell_6t.sym} 400 21800 0 0 {name=Xr109c2}
N 360 21840 340 21840 {}
C {lab_pin.sym} 340 21840 0 0 {name=l17451 lab=BL2}
N 360 21800 340 21800 {}
C {lab_pin.sym} 340 21800 0 0 {name=l17452 lab=BLB2}
N 360 21760 340 21760 {}
C {lab_pin.sym} 340 21760 0 0 {name=l17453 lab=WL109}
N 440 21840 460 21840 {}
C {lab_pin.sym} 460 21840 0 0 {name=l17454 lab=VDD}
N 440 21760 460 21760 {}
C {lab_pin.sym} 460 21760 0 0 {name=l17455 lab=VSS}
C {bitcell_6t.sym} 600 21800 0 0 {name=Xr109c3}
N 560 21840 540 21840 {}
C {lab_pin.sym} 540 21840 0 0 {name=l17456 lab=BL3}
N 560 21800 540 21800 {}
C {lab_pin.sym} 540 21800 0 0 {name=l17457 lab=BLB3}
N 560 21760 540 21760 {}
C {lab_pin.sym} 540 21760 0 0 {name=l17458 lab=WL109}
N 640 21840 660 21840 {}
C {lab_pin.sym} 660 21840 0 0 {name=l17459 lab=VDD}
N 640 21760 660 21760 {}
C {lab_pin.sym} 660 21760 0 0 {name=l17460 lab=VSS}
C {bitcell_6t.sym} 800 21800 0 0 {name=Xr109c4}
N 760 21840 740 21840 {}
C {lab_pin.sym} 740 21840 0 0 {name=l17461 lab=BL4}
N 760 21800 740 21800 {}
C {lab_pin.sym} 740 21800 0 0 {name=l17462 lab=BLB4}
N 760 21760 740 21760 {}
C {lab_pin.sym} 740 21760 0 0 {name=l17463 lab=WL109}
N 840 21840 860 21840 {}
C {lab_pin.sym} 860 21840 0 0 {name=l17464 lab=VDD}
N 840 21760 860 21760 {}
C {lab_pin.sym} 860 21760 0 0 {name=l17465 lab=VSS}
C {bitcell_6t.sym} 1000 21800 0 0 {name=Xr109c5}
N 960 21840 940 21840 {}
C {lab_pin.sym} 940 21840 0 0 {name=l17466 lab=BL5}
N 960 21800 940 21800 {}
C {lab_pin.sym} 940 21800 0 0 {name=l17467 lab=BLB5}
N 960 21760 940 21760 {}
C {lab_pin.sym} 940 21760 0 0 {name=l17468 lab=WL109}
N 1040 21840 1060 21840 {}
C {lab_pin.sym} 1060 21840 0 0 {name=l17469 lab=VDD}
N 1040 21760 1060 21760 {}
C {lab_pin.sym} 1060 21760 0 0 {name=l17470 lab=VSS}
C {bitcell_6t.sym} 1200 21800 0 0 {name=Xr109c6}
N 1160 21840 1140 21840 {}
C {lab_pin.sym} 1140 21840 0 0 {name=l17471 lab=BL6}
N 1160 21800 1140 21800 {}
C {lab_pin.sym} 1140 21800 0 0 {name=l17472 lab=BLB6}
N 1160 21760 1140 21760 {}
C {lab_pin.sym} 1140 21760 0 0 {name=l17473 lab=WL109}
N 1240 21840 1260 21840 {}
C {lab_pin.sym} 1260 21840 0 0 {name=l17474 lab=VDD}
N 1240 21760 1260 21760 {}
C {lab_pin.sym} 1260 21760 0 0 {name=l17475 lab=VSS}
C {bitcell_6t.sym} 1400 21800 0 0 {name=Xr109c7}
N 1360 21840 1340 21840 {}
C {lab_pin.sym} 1340 21840 0 0 {name=l17476 lab=BL7}
N 1360 21800 1340 21800 {}
C {lab_pin.sym} 1340 21800 0 0 {name=l17477 lab=BLB7}
N 1360 21760 1340 21760 {}
C {lab_pin.sym} 1340 21760 0 0 {name=l17478 lab=WL109}
N 1440 21840 1460 21840 {}
C {lab_pin.sym} 1460 21840 0 0 {name=l17479 lab=VDD}
N 1440 21760 1460 21760 {}
C {lab_pin.sym} 1460 21760 0 0 {name=l17480 lab=VSS}
C {bitcell_6t.sym} 1600 21800 0 0 {name=Xr109c8}
N 1560 21840 1540 21840 {}
C {lab_pin.sym} 1540 21840 0 0 {name=l17481 lab=BL8}
N 1560 21800 1540 21800 {}
C {lab_pin.sym} 1540 21800 0 0 {name=l17482 lab=BLB8}
N 1560 21760 1540 21760 {}
C {lab_pin.sym} 1540 21760 0 0 {name=l17483 lab=WL109}
N 1640 21840 1660 21840 {}
C {lab_pin.sym} 1660 21840 0 0 {name=l17484 lab=VDD}
N 1640 21760 1660 21760 {}
C {lab_pin.sym} 1660 21760 0 0 {name=l17485 lab=VSS}
C {bitcell_6t.sym} 1800 21800 0 0 {name=Xr109c9}
N 1760 21840 1740 21840 {}
C {lab_pin.sym} 1740 21840 0 0 {name=l17486 lab=BL9}
N 1760 21800 1740 21800 {}
C {lab_pin.sym} 1740 21800 0 0 {name=l17487 lab=BLB9}
N 1760 21760 1740 21760 {}
C {lab_pin.sym} 1740 21760 0 0 {name=l17488 lab=WL109}
N 1840 21840 1860 21840 {}
C {lab_pin.sym} 1860 21840 0 0 {name=l17489 lab=VDD}
N 1840 21760 1860 21760 {}
C {lab_pin.sym} 1860 21760 0 0 {name=l17490 lab=VSS}
C {bitcell_6t.sym} 2000 21800 0 0 {name=Xr109c10}
N 1960 21840 1940 21840 {}
C {lab_pin.sym} 1940 21840 0 0 {name=l17491 lab=BL10}
N 1960 21800 1940 21800 {}
C {lab_pin.sym} 1940 21800 0 0 {name=l17492 lab=BLB10}
N 1960 21760 1940 21760 {}
C {lab_pin.sym} 1940 21760 0 0 {name=l17493 lab=WL109}
N 2040 21840 2060 21840 {}
C {lab_pin.sym} 2060 21840 0 0 {name=l17494 lab=VDD}
N 2040 21760 2060 21760 {}
C {lab_pin.sym} 2060 21760 0 0 {name=l17495 lab=VSS}
C {bitcell_6t.sym} 2200 21800 0 0 {name=Xr109c11}
N 2160 21840 2140 21840 {}
C {lab_pin.sym} 2140 21840 0 0 {name=l17496 lab=BL11}
N 2160 21800 2140 21800 {}
C {lab_pin.sym} 2140 21800 0 0 {name=l17497 lab=BLB11}
N 2160 21760 2140 21760 {}
C {lab_pin.sym} 2140 21760 0 0 {name=l17498 lab=WL109}
N 2240 21840 2260 21840 {}
C {lab_pin.sym} 2260 21840 0 0 {name=l17499 lab=VDD}
N 2240 21760 2260 21760 {}
C {lab_pin.sym} 2260 21760 0 0 {name=l17500 lab=VSS}
C {bitcell_6t.sym} 2400 21800 0 0 {name=Xr109c12}
N 2360 21840 2340 21840 {}
C {lab_pin.sym} 2340 21840 0 0 {name=l17501 lab=BL12}
N 2360 21800 2340 21800 {}
C {lab_pin.sym} 2340 21800 0 0 {name=l17502 lab=BLB12}
N 2360 21760 2340 21760 {}
C {lab_pin.sym} 2340 21760 0 0 {name=l17503 lab=WL109}
N 2440 21840 2460 21840 {}
C {lab_pin.sym} 2460 21840 0 0 {name=l17504 lab=VDD}
N 2440 21760 2460 21760 {}
C {lab_pin.sym} 2460 21760 0 0 {name=l17505 lab=VSS}
C {bitcell_6t.sym} 2600 21800 0 0 {name=Xr109c13}
N 2560 21840 2540 21840 {}
C {lab_pin.sym} 2540 21840 0 0 {name=l17506 lab=BL13}
N 2560 21800 2540 21800 {}
C {lab_pin.sym} 2540 21800 0 0 {name=l17507 lab=BLB13}
N 2560 21760 2540 21760 {}
C {lab_pin.sym} 2540 21760 0 0 {name=l17508 lab=WL109}
N 2640 21840 2660 21840 {}
C {lab_pin.sym} 2660 21840 0 0 {name=l17509 lab=VDD}
N 2640 21760 2660 21760 {}
C {lab_pin.sym} 2660 21760 0 0 {name=l17510 lab=VSS}
C {bitcell_6t.sym} 2800 21800 0 0 {name=Xr109c14}
N 2760 21840 2740 21840 {}
C {lab_pin.sym} 2740 21840 0 0 {name=l17511 lab=BL14}
N 2760 21800 2740 21800 {}
C {lab_pin.sym} 2740 21800 0 0 {name=l17512 lab=BLB14}
N 2760 21760 2740 21760 {}
C {lab_pin.sym} 2740 21760 0 0 {name=l17513 lab=WL109}
N 2840 21840 2860 21840 {}
C {lab_pin.sym} 2860 21840 0 0 {name=l17514 lab=VDD}
N 2840 21760 2860 21760 {}
C {lab_pin.sym} 2860 21760 0 0 {name=l17515 lab=VSS}
C {bitcell_6t.sym} 3000 21800 0 0 {name=Xr109c15}
N 2960 21840 2940 21840 {}
C {lab_pin.sym} 2940 21840 0 0 {name=l17516 lab=BL15}
N 2960 21800 2940 21800 {}
C {lab_pin.sym} 2940 21800 0 0 {name=l17517 lab=BLB15}
N 2960 21760 2940 21760 {}
C {lab_pin.sym} 2940 21760 0 0 {name=l17518 lab=WL109}
N 3040 21840 3060 21840 {}
C {lab_pin.sym} 3060 21840 0 0 {name=l17519 lab=VDD}
N 3040 21760 3060 21760 {}
C {lab_pin.sym} 3060 21760 0 0 {name=l17520 lab=VSS}
C {bitcell_6t.sym} 3200 21800 0 0 {name=Xr109c16}
N 3160 21840 3140 21840 {}
C {lab_pin.sym} 3140 21840 0 0 {name=l17521 lab=BL16}
N 3160 21800 3140 21800 {}
C {lab_pin.sym} 3140 21800 0 0 {name=l17522 lab=BLB16}
N 3160 21760 3140 21760 {}
C {lab_pin.sym} 3140 21760 0 0 {name=l17523 lab=WL109}
N 3240 21840 3260 21840 {}
C {lab_pin.sym} 3260 21840 0 0 {name=l17524 lab=VDD}
N 3240 21760 3260 21760 {}
C {lab_pin.sym} 3260 21760 0 0 {name=l17525 lab=VSS}
C {bitcell_6t.sym} 3400 21800 0 0 {name=Xr109c17}
N 3360 21840 3340 21840 {}
C {lab_pin.sym} 3340 21840 0 0 {name=l17526 lab=BL17}
N 3360 21800 3340 21800 {}
C {lab_pin.sym} 3340 21800 0 0 {name=l17527 lab=BLB17}
N 3360 21760 3340 21760 {}
C {lab_pin.sym} 3340 21760 0 0 {name=l17528 lab=WL109}
N 3440 21840 3460 21840 {}
C {lab_pin.sym} 3460 21840 0 0 {name=l17529 lab=VDD}
N 3440 21760 3460 21760 {}
C {lab_pin.sym} 3460 21760 0 0 {name=l17530 lab=VSS}
C {bitcell_6t.sym} 3600 21800 0 0 {name=Xr109c18}
N 3560 21840 3540 21840 {}
C {lab_pin.sym} 3540 21840 0 0 {name=l17531 lab=BL18}
N 3560 21800 3540 21800 {}
C {lab_pin.sym} 3540 21800 0 0 {name=l17532 lab=BLB18}
N 3560 21760 3540 21760 {}
C {lab_pin.sym} 3540 21760 0 0 {name=l17533 lab=WL109}
N 3640 21840 3660 21840 {}
C {lab_pin.sym} 3660 21840 0 0 {name=l17534 lab=VDD}
N 3640 21760 3660 21760 {}
C {lab_pin.sym} 3660 21760 0 0 {name=l17535 lab=VSS}
C {bitcell_6t.sym} 3800 21800 0 0 {name=Xr109c19}
N 3760 21840 3740 21840 {}
C {lab_pin.sym} 3740 21840 0 0 {name=l17536 lab=BL19}
N 3760 21800 3740 21800 {}
C {lab_pin.sym} 3740 21800 0 0 {name=l17537 lab=BLB19}
N 3760 21760 3740 21760 {}
C {lab_pin.sym} 3740 21760 0 0 {name=l17538 lab=WL109}
N 3840 21840 3860 21840 {}
C {lab_pin.sym} 3860 21840 0 0 {name=l17539 lab=VDD}
N 3840 21760 3860 21760 {}
C {lab_pin.sym} 3860 21760 0 0 {name=l17540 lab=VSS}
C {bitcell_6t.sym} 4000 21800 0 0 {name=Xr109c20}
N 3960 21840 3940 21840 {}
C {lab_pin.sym} 3940 21840 0 0 {name=l17541 lab=BL20}
N 3960 21800 3940 21800 {}
C {lab_pin.sym} 3940 21800 0 0 {name=l17542 lab=BLB20}
N 3960 21760 3940 21760 {}
C {lab_pin.sym} 3940 21760 0 0 {name=l17543 lab=WL109}
N 4040 21840 4060 21840 {}
C {lab_pin.sym} 4060 21840 0 0 {name=l17544 lab=VDD}
N 4040 21760 4060 21760 {}
C {lab_pin.sym} 4060 21760 0 0 {name=l17545 lab=VSS}
C {bitcell_6t.sym} 4200 21800 0 0 {name=Xr109c21}
N 4160 21840 4140 21840 {}
C {lab_pin.sym} 4140 21840 0 0 {name=l17546 lab=BL21}
N 4160 21800 4140 21800 {}
C {lab_pin.sym} 4140 21800 0 0 {name=l17547 lab=BLB21}
N 4160 21760 4140 21760 {}
C {lab_pin.sym} 4140 21760 0 0 {name=l17548 lab=WL109}
N 4240 21840 4260 21840 {}
C {lab_pin.sym} 4260 21840 0 0 {name=l17549 lab=VDD}
N 4240 21760 4260 21760 {}
C {lab_pin.sym} 4260 21760 0 0 {name=l17550 lab=VSS}
C {bitcell_6t.sym} 4400 21800 0 0 {name=Xr109c22}
N 4360 21840 4340 21840 {}
C {lab_pin.sym} 4340 21840 0 0 {name=l17551 lab=BL22}
N 4360 21800 4340 21800 {}
C {lab_pin.sym} 4340 21800 0 0 {name=l17552 lab=BLB22}
N 4360 21760 4340 21760 {}
C {lab_pin.sym} 4340 21760 0 0 {name=l17553 lab=WL109}
N 4440 21840 4460 21840 {}
C {lab_pin.sym} 4460 21840 0 0 {name=l17554 lab=VDD}
N 4440 21760 4460 21760 {}
C {lab_pin.sym} 4460 21760 0 0 {name=l17555 lab=VSS}
C {bitcell_6t.sym} 4600 21800 0 0 {name=Xr109c23}
N 4560 21840 4540 21840 {}
C {lab_pin.sym} 4540 21840 0 0 {name=l17556 lab=BL23}
N 4560 21800 4540 21800 {}
C {lab_pin.sym} 4540 21800 0 0 {name=l17557 lab=BLB23}
N 4560 21760 4540 21760 {}
C {lab_pin.sym} 4540 21760 0 0 {name=l17558 lab=WL109}
N 4640 21840 4660 21840 {}
C {lab_pin.sym} 4660 21840 0 0 {name=l17559 lab=VDD}
N 4640 21760 4660 21760 {}
C {lab_pin.sym} 4660 21760 0 0 {name=l17560 lab=VSS}
C {bitcell_6t.sym} 4800 21800 0 0 {name=Xr109c24}
N 4760 21840 4740 21840 {}
C {lab_pin.sym} 4740 21840 0 0 {name=l17561 lab=BL24}
N 4760 21800 4740 21800 {}
C {lab_pin.sym} 4740 21800 0 0 {name=l17562 lab=BLB24}
N 4760 21760 4740 21760 {}
C {lab_pin.sym} 4740 21760 0 0 {name=l17563 lab=WL109}
N 4840 21840 4860 21840 {}
C {lab_pin.sym} 4860 21840 0 0 {name=l17564 lab=VDD}
N 4840 21760 4860 21760 {}
C {lab_pin.sym} 4860 21760 0 0 {name=l17565 lab=VSS}
C {bitcell_6t.sym} 5000 21800 0 0 {name=Xr109c25}
N 4960 21840 4940 21840 {}
C {lab_pin.sym} 4940 21840 0 0 {name=l17566 lab=BL25}
N 4960 21800 4940 21800 {}
C {lab_pin.sym} 4940 21800 0 0 {name=l17567 lab=BLB25}
N 4960 21760 4940 21760 {}
C {lab_pin.sym} 4940 21760 0 0 {name=l17568 lab=WL109}
N 5040 21840 5060 21840 {}
C {lab_pin.sym} 5060 21840 0 0 {name=l17569 lab=VDD}
N 5040 21760 5060 21760 {}
C {lab_pin.sym} 5060 21760 0 0 {name=l17570 lab=VSS}
C {bitcell_6t.sym} 5200 21800 0 0 {name=Xr109c26}
N 5160 21840 5140 21840 {}
C {lab_pin.sym} 5140 21840 0 0 {name=l17571 lab=BL26}
N 5160 21800 5140 21800 {}
C {lab_pin.sym} 5140 21800 0 0 {name=l17572 lab=BLB26}
N 5160 21760 5140 21760 {}
C {lab_pin.sym} 5140 21760 0 0 {name=l17573 lab=WL109}
N 5240 21840 5260 21840 {}
C {lab_pin.sym} 5260 21840 0 0 {name=l17574 lab=VDD}
N 5240 21760 5260 21760 {}
C {lab_pin.sym} 5260 21760 0 0 {name=l17575 lab=VSS}
C {bitcell_6t.sym} 5400 21800 0 0 {name=Xr109c27}
N 5360 21840 5340 21840 {}
C {lab_pin.sym} 5340 21840 0 0 {name=l17576 lab=BL27}
N 5360 21800 5340 21800 {}
C {lab_pin.sym} 5340 21800 0 0 {name=l17577 lab=BLB27}
N 5360 21760 5340 21760 {}
C {lab_pin.sym} 5340 21760 0 0 {name=l17578 lab=WL109}
N 5440 21840 5460 21840 {}
C {lab_pin.sym} 5460 21840 0 0 {name=l17579 lab=VDD}
N 5440 21760 5460 21760 {}
C {lab_pin.sym} 5460 21760 0 0 {name=l17580 lab=VSS}
C {bitcell_6t.sym} 5600 21800 0 0 {name=Xr109c28}
N 5560 21840 5540 21840 {}
C {lab_pin.sym} 5540 21840 0 0 {name=l17581 lab=BL28}
N 5560 21800 5540 21800 {}
C {lab_pin.sym} 5540 21800 0 0 {name=l17582 lab=BLB28}
N 5560 21760 5540 21760 {}
C {lab_pin.sym} 5540 21760 0 0 {name=l17583 lab=WL109}
N 5640 21840 5660 21840 {}
C {lab_pin.sym} 5660 21840 0 0 {name=l17584 lab=VDD}
N 5640 21760 5660 21760 {}
C {lab_pin.sym} 5660 21760 0 0 {name=l17585 lab=VSS}
C {bitcell_6t.sym} 5800 21800 0 0 {name=Xr109c29}
N 5760 21840 5740 21840 {}
C {lab_pin.sym} 5740 21840 0 0 {name=l17586 lab=BL29}
N 5760 21800 5740 21800 {}
C {lab_pin.sym} 5740 21800 0 0 {name=l17587 lab=BLB29}
N 5760 21760 5740 21760 {}
C {lab_pin.sym} 5740 21760 0 0 {name=l17588 lab=WL109}
N 5840 21840 5860 21840 {}
C {lab_pin.sym} 5860 21840 0 0 {name=l17589 lab=VDD}
N 5840 21760 5860 21760 {}
C {lab_pin.sym} 5860 21760 0 0 {name=l17590 lab=VSS}
C {bitcell_6t.sym} 6000 21800 0 0 {name=Xr109c30}
N 5960 21840 5940 21840 {}
C {lab_pin.sym} 5940 21840 0 0 {name=l17591 lab=BL30}
N 5960 21800 5940 21800 {}
C {lab_pin.sym} 5940 21800 0 0 {name=l17592 lab=BLB30}
N 5960 21760 5940 21760 {}
C {lab_pin.sym} 5940 21760 0 0 {name=l17593 lab=WL109}
N 6040 21840 6060 21840 {}
C {lab_pin.sym} 6060 21840 0 0 {name=l17594 lab=VDD}
N 6040 21760 6060 21760 {}
C {lab_pin.sym} 6060 21760 0 0 {name=l17595 lab=VSS}
C {bitcell_6t.sym} 6200 21800 0 0 {name=Xr109c31}
N 6160 21840 6140 21840 {}
C {lab_pin.sym} 6140 21840 0 0 {name=l17596 lab=BL31}
N 6160 21800 6140 21800 {}
C {lab_pin.sym} 6140 21800 0 0 {name=l17597 lab=BLB31}
N 6160 21760 6140 21760 {}
C {lab_pin.sym} 6140 21760 0 0 {name=l17598 lab=WL109}
N 6240 21840 6260 21840 {}
C {lab_pin.sym} 6260 21840 0 0 {name=l17599 lab=VDD}
N 6240 21760 6260 21760 {}
C {lab_pin.sym} 6260 21760 0 0 {name=l17600 lab=VSS}
C {bitcell_6t.sym} 0 22000 0 0 {name=Xr110c0}
N -40 22040 -60 22040 {}
C {lab_pin.sym} -60 22040 0 0 {name=l17601 lab=BL0}
N -40 22000 -60 22000 {}
C {lab_pin.sym} -60 22000 0 0 {name=l17602 lab=BLB0}
N -40 21960 -60 21960 {}
C {lab_pin.sym} -60 21960 0 0 {name=l17603 lab=WL110}
N 40 22040 60 22040 {}
C {lab_pin.sym} 60 22040 0 0 {name=l17604 lab=VDD}
N 40 21960 60 21960 {}
C {lab_pin.sym} 60 21960 0 0 {name=l17605 lab=VSS}
C {bitcell_6t.sym} 200 22000 0 0 {name=Xr110c1}
N 160 22040 140 22040 {}
C {lab_pin.sym} 140 22040 0 0 {name=l17606 lab=BL1}
N 160 22000 140 22000 {}
C {lab_pin.sym} 140 22000 0 0 {name=l17607 lab=BLB1}
N 160 21960 140 21960 {}
C {lab_pin.sym} 140 21960 0 0 {name=l17608 lab=WL110}
N 240 22040 260 22040 {}
C {lab_pin.sym} 260 22040 0 0 {name=l17609 lab=VDD}
N 240 21960 260 21960 {}
C {lab_pin.sym} 260 21960 0 0 {name=l17610 lab=VSS}
C {bitcell_6t.sym} 400 22000 0 0 {name=Xr110c2}
N 360 22040 340 22040 {}
C {lab_pin.sym} 340 22040 0 0 {name=l17611 lab=BL2}
N 360 22000 340 22000 {}
C {lab_pin.sym} 340 22000 0 0 {name=l17612 lab=BLB2}
N 360 21960 340 21960 {}
C {lab_pin.sym} 340 21960 0 0 {name=l17613 lab=WL110}
N 440 22040 460 22040 {}
C {lab_pin.sym} 460 22040 0 0 {name=l17614 lab=VDD}
N 440 21960 460 21960 {}
C {lab_pin.sym} 460 21960 0 0 {name=l17615 lab=VSS}
C {bitcell_6t.sym} 600 22000 0 0 {name=Xr110c3}
N 560 22040 540 22040 {}
C {lab_pin.sym} 540 22040 0 0 {name=l17616 lab=BL3}
N 560 22000 540 22000 {}
C {lab_pin.sym} 540 22000 0 0 {name=l17617 lab=BLB3}
N 560 21960 540 21960 {}
C {lab_pin.sym} 540 21960 0 0 {name=l17618 lab=WL110}
N 640 22040 660 22040 {}
C {lab_pin.sym} 660 22040 0 0 {name=l17619 lab=VDD}
N 640 21960 660 21960 {}
C {lab_pin.sym} 660 21960 0 0 {name=l17620 lab=VSS}
C {bitcell_6t.sym} 800 22000 0 0 {name=Xr110c4}
N 760 22040 740 22040 {}
C {lab_pin.sym} 740 22040 0 0 {name=l17621 lab=BL4}
N 760 22000 740 22000 {}
C {lab_pin.sym} 740 22000 0 0 {name=l17622 lab=BLB4}
N 760 21960 740 21960 {}
C {lab_pin.sym} 740 21960 0 0 {name=l17623 lab=WL110}
N 840 22040 860 22040 {}
C {lab_pin.sym} 860 22040 0 0 {name=l17624 lab=VDD}
N 840 21960 860 21960 {}
C {lab_pin.sym} 860 21960 0 0 {name=l17625 lab=VSS}
C {bitcell_6t.sym} 1000 22000 0 0 {name=Xr110c5}
N 960 22040 940 22040 {}
C {lab_pin.sym} 940 22040 0 0 {name=l17626 lab=BL5}
N 960 22000 940 22000 {}
C {lab_pin.sym} 940 22000 0 0 {name=l17627 lab=BLB5}
N 960 21960 940 21960 {}
C {lab_pin.sym} 940 21960 0 0 {name=l17628 lab=WL110}
N 1040 22040 1060 22040 {}
C {lab_pin.sym} 1060 22040 0 0 {name=l17629 lab=VDD}
N 1040 21960 1060 21960 {}
C {lab_pin.sym} 1060 21960 0 0 {name=l17630 lab=VSS}
C {bitcell_6t.sym} 1200 22000 0 0 {name=Xr110c6}
N 1160 22040 1140 22040 {}
C {lab_pin.sym} 1140 22040 0 0 {name=l17631 lab=BL6}
N 1160 22000 1140 22000 {}
C {lab_pin.sym} 1140 22000 0 0 {name=l17632 lab=BLB6}
N 1160 21960 1140 21960 {}
C {lab_pin.sym} 1140 21960 0 0 {name=l17633 lab=WL110}
N 1240 22040 1260 22040 {}
C {lab_pin.sym} 1260 22040 0 0 {name=l17634 lab=VDD}
N 1240 21960 1260 21960 {}
C {lab_pin.sym} 1260 21960 0 0 {name=l17635 lab=VSS}
C {bitcell_6t.sym} 1400 22000 0 0 {name=Xr110c7}
N 1360 22040 1340 22040 {}
C {lab_pin.sym} 1340 22040 0 0 {name=l17636 lab=BL7}
N 1360 22000 1340 22000 {}
C {lab_pin.sym} 1340 22000 0 0 {name=l17637 lab=BLB7}
N 1360 21960 1340 21960 {}
C {lab_pin.sym} 1340 21960 0 0 {name=l17638 lab=WL110}
N 1440 22040 1460 22040 {}
C {lab_pin.sym} 1460 22040 0 0 {name=l17639 lab=VDD}
N 1440 21960 1460 21960 {}
C {lab_pin.sym} 1460 21960 0 0 {name=l17640 lab=VSS}
C {bitcell_6t.sym} 1600 22000 0 0 {name=Xr110c8}
N 1560 22040 1540 22040 {}
C {lab_pin.sym} 1540 22040 0 0 {name=l17641 lab=BL8}
N 1560 22000 1540 22000 {}
C {lab_pin.sym} 1540 22000 0 0 {name=l17642 lab=BLB8}
N 1560 21960 1540 21960 {}
C {lab_pin.sym} 1540 21960 0 0 {name=l17643 lab=WL110}
N 1640 22040 1660 22040 {}
C {lab_pin.sym} 1660 22040 0 0 {name=l17644 lab=VDD}
N 1640 21960 1660 21960 {}
C {lab_pin.sym} 1660 21960 0 0 {name=l17645 lab=VSS}
C {bitcell_6t.sym} 1800 22000 0 0 {name=Xr110c9}
N 1760 22040 1740 22040 {}
C {lab_pin.sym} 1740 22040 0 0 {name=l17646 lab=BL9}
N 1760 22000 1740 22000 {}
C {lab_pin.sym} 1740 22000 0 0 {name=l17647 lab=BLB9}
N 1760 21960 1740 21960 {}
C {lab_pin.sym} 1740 21960 0 0 {name=l17648 lab=WL110}
N 1840 22040 1860 22040 {}
C {lab_pin.sym} 1860 22040 0 0 {name=l17649 lab=VDD}
N 1840 21960 1860 21960 {}
C {lab_pin.sym} 1860 21960 0 0 {name=l17650 lab=VSS}
C {bitcell_6t.sym} 2000 22000 0 0 {name=Xr110c10}
N 1960 22040 1940 22040 {}
C {lab_pin.sym} 1940 22040 0 0 {name=l17651 lab=BL10}
N 1960 22000 1940 22000 {}
C {lab_pin.sym} 1940 22000 0 0 {name=l17652 lab=BLB10}
N 1960 21960 1940 21960 {}
C {lab_pin.sym} 1940 21960 0 0 {name=l17653 lab=WL110}
N 2040 22040 2060 22040 {}
C {lab_pin.sym} 2060 22040 0 0 {name=l17654 lab=VDD}
N 2040 21960 2060 21960 {}
C {lab_pin.sym} 2060 21960 0 0 {name=l17655 lab=VSS}
C {bitcell_6t.sym} 2200 22000 0 0 {name=Xr110c11}
N 2160 22040 2140 22040 {}
C {lab_pin.sym} 2140 22040 0 0 {name=l17656 lab=BL11}
N 2160 22000 2140 22000 {}
C {lab_pin.sym} 2140 22000 0 0 {name=l17657 lab=BLB11}
N 2160 21960 2140 21960 {}
C {lab_pin.sym} 2140 21960 0 0 {name=l17658 lab=WL110}
N 2240 22040 2260 22040 {}
C {lab_pin.sym} 2260 22040 0 0 {name=l17659 lab=VDD}
N 2240 21960 2260 21960 {}
C {lab_pin.sym} 2260 21960 0 0 {name=l17660 lab=VSS}
C {bitcell_6t.sym} 2400 22000 0 0 {name=Xr110c12}
N 2360 22040 2340 22040 {}
C {lab_pin.sym} 2340 22040 0 0 {name=l17661 lab=BL12}
N 2360 22000 2340 22000 {}
C {lab_pin.sym} 2340 22000 0 0 {name=l17662 lab=BLB12}
N 2360 21960 2340 21960 {}
C {lab_pin.sym} 2340 21960 0 0 {name=l17663 lab=WL110}
N 2440 22040 2460 22040 {}
C {lab_pin.sym} 2460 22040 0 0 {name=l17664 lab=VDD}
N 2440 21960 2460 21960 {}
C {lab_pin.sym} 2460 21960 0 0 {name=l17665 lab=VSS}
C {bitcell_6t.sym} 2600 22000 0 0 {name=Xr110c13}
N 2560 22040 2540 22040 {}
C {lab_pin.sym} 2540 22040 0 0 {name=l17666 lab=BL13}
N 2560 22000 2540 22000 {}
C {lab_pin.sym} 2540 22000 0 0 {name=l17667 lab=BLB13}
N 2560 21960 2540 21960 {}
C {lab_pin.sym} 2540 21960 0 0 {name=l17668 lab=WL110}
N 2640 22040 2660 22040 {}
C {lab_pin.sym} 2660 22040 0 0 {name=l17669 lab=VDD}
N 2640 21960 2660 21960 {}
C {lab_pin.sym} 2660 21960 0 0 {name=l17670 lab=VSS}
C {bitcell_6t.sym} 2800 22000 0 0 {name=Xr110c14}
N 2760 22040 2740 22040 {}
C {lab_pin.sym} 2740 22040 0 0 {name=l17671 lab=BL14}
N 2760 22000 2740 22000 {}
C {lab_pin.sym} 2740 22000 0 0 {name=l17672 lab=BLB14}
N 2760 21960 2740 21960 {}
C {lab_pin.sym} 2740 21960 0 0 {name=l17673 lab=WL110}
N 2840 22040 2860 22040 {}
C {lab_pin.sym} 2860 22040 0 0 {name=l17674 lab=VDD}
N 2840 21960 2860 21960 {}
C {lab_pin.sym} 2860 21960 0 0 {name=l17675 lab=VSS}
C {bitcell_6t.sym} 3000 22000 0 0 {name=Xr110c15}
N 2960 22040 2940 22040 {}
C {lab_pin.sym} 2940 22040 0 0 {name=l17676 lab=BL15}
N 2960 22000 2940 22000 {}
C {lab_pin.sym} 2940 22000 0 0 {name=l17677 lab=BLB15}
N 2960 21960 2940 21960 {}
C {lab_pin.sym} 2940 21960 0 0 {name=l17678 lab=WL110}
N 3040 22040 3060 22040 {}
C {lab_pin.sym} 3060 22040 0 0 {name=l17679 lab=VDD}
N 3040 21960 3060 21960 {}
C {lab_pin.sym} 3060 21960 0 0 {name=l17680 lab=VSS}
C {bitcell_6t.sym} 3200 22000 0 0 {name=Xr110c16}
N 3160 22040 3140 22040 {}
C {lab_pin.sym} 3140 22040 0 0 {name=l17681 lab=BL16}
N 3160 22000 3140 22000 {}
C {lab_pin.sym} 3140 22000 0 0 {name=l17682 lab=BLB16}
N 3160 21960 3140 21960 {}
C {lab_pin.sym} 3140 21960 0 0 {name=l17683 lab=WL110}
N 3240 22040 3260 22040 {}
C {lab_pin.sym} 3260 22040 0 0 {name=l17684 lab=VDD}
N 3240 21960 3260 21960 {}
C {lab_pin.sym} 3260 21960 0 0 {name=l17685 lab=VSS}
C {bitcell_6t.sym} 3400 22000 0 0 {name=Xr110c17}
N 3360 22040 3340 22040 {}
C {lab_pin.sym} 3340 22040 0 0 {name=l17686 lab=BL17}
N 3360 22000 3340 22000 {}
C {lab_pin.sym} 3340 22000 0 0 {name=l17687 lab=BLB17}
N 3360 21960 3340 21960 {}
C {lab_pin.sym} 3340 21960 0 0 {name=l17688 lab=WL110}
N 3440 22040 3460 22040 {}
C {lab_pin.sym} 3460 22040 0 0 {name=l17689 lab=VDD}
N 3440 21960 3460 21960 {}
C {lab_pin.sym} 3460 21960 0 0 {name=l17690 lab=VSS}
C {bitcell_6t.sym} 3600 22000 0 0 {name=Xr110c18}
N 3560 22040 3540 22040 {}
C {lab_pin.sym} 3540 22040 0 0 {name=l17691 lab=BL18}
N 3560 22000 3540 22000 {}
C {lab_pin.sym} 3540 22000 0 0 {name=l17692 lab=BLB18}
N 3560 21960 3540 21960 {}
C {lab_pin.sym} 3540 21960 0 0 {name=l17693 lab=WL110}
N 3640 22040 3660 22040 {}
C {lab_pin.sym} 3660 22040 0 0 {name=l17694 lab=VDD}
N 3640 21960 3660 21960 {}
C {lab_pin.sym} 3660 21960 0 0 {name=l17695 lab=VSS}
C {bitcell_6t.sym} 3800 22000 0 0 {name=Xr110c19}
N 3760 22040 3740 22040 {}
C {lab_pin.sym} 3740 22040 0 0 {name=l17696 lab=BL19}
N 3760 22000 3740 22000 {}
C {lab_pin.sym} 3740 22000 0 0 {name=l17697 lab=BLB19}
N 3760 21960 3740 21960 {}
C {lab_pin.sym} 3740 21960 0 0 {name=l17698 lab=WL110}
N 3840 22040 3860 22040 {}
C {lab_pin.sym} 3860 22040 0 0 {name=l17699 lab=VDD}
N 3840 21960 3860 21960 {}
C {lab_pin.sym} 3860 21960 0 0 {name=l17700 lab=VSS}
C {bitcell_6t.sym} 4000 22000 0 0 {name=Xr110c20}
N 3960 22040 3940 22040 {}
C {lab_pin.sym} 3940 22040 0 0 {name=l17701 lab=BL20}
N 3960 22000 3940 22000 {}
C {lab_pin.sym} 3940 22000 0 0 {name=l17702 lab=BLB20}
N 3960 21960 3940 21960 {}
C {lab_pin.sym} 3940 21960 0 0 {name=l17703 lab=WL110}
N 4040 22040 4060 22040 {}
C {lab_pin.sym} 4060 22040 0 0 {name=l17704 lab=VDD}
N 4040 21960 4060 21960 {}
C {lab_pin.sym} 4060 21960 0 0 {name=l17705 lab=VSS}
C {bitcell_6t.sym} 4200 22000 0 0 {name=Xr110c21}
N 4160 22040 4140 22040 {}
C {lab_pin.sym} 4140 22040 0 0 {name=l17706 lab=BL21}
N 4160 22000 4140 22000 {}
C {lab_pin.sym} 4140 22000 0 0 {name=l17707 lab=BLB21}
N 4160 21960 4140 21960 {}
C {lab_pin.sym} 4140 21960 0 0 {name=l17708 lab=WL110}
N 4240 22040 4260 22040 {}
C {lab_pin.sym} 4260 22040 0 0 {name=l17709 lab=VDD}
N 4240 21960 4260 21960 {}
C {lab_pin.sym} 4260 21960 0 0 {name=l17710 lab=VSS}
C {bitcell_6t.sym} 4400 22000 0 0 {name=Xr110c22}
N 4360 22040 4340 22040 {}
C {lab_pin.sym} 4340 22040 0 0 {name=l17711 lab=BL22}
N 4360 22000 4340 22000 {}
C {lab_pin.sym} 4340 22000 0 0 {name=l17712 lab=BLB22}
N 4360 21960 4340 21960 {}
C {lab_pin.sym} 4340 21960 0 0 {name=l17713 lab=WL110}
N 4440 22040 4460 22040 {}
C {lab_pin.sym} 4460 22040 0 0 {name=l17714 lab=VDD}
N 4440 21960 4460 21960 {}
C {lab_pin.sym} 4460 21960 0 0 {name=l17715 lab=VSS}
C {bitcell_6t.sym} 4600 22000 0 0 {name=Xr110c23}
N 4560 22040 4540 22040 {}
C {lab_pin.sym} 4540 22040 0 0 {name=l17716 lab=BL23}
N 4560 22000 4540 22000 {}
C {lab_pin.sym} 4540 22000 0 0 {name=l17717 lab=BLB23}
N 4560 21960 4540 21960 {}
C {lab_pin.sym} 4540 21960 0 0 {name=l17718 lab=WL110}
N 4640 22040 4660 22040 {}
C {lab_pin.sym} 4660 22040 0 0 {name=l17719 lab=VDD}
N 4640 21960 4660 21960 {}
C {lab_pin.sym} 4660 21960 0 0 {name=l17720 lab=VSS}
C {bitcell_6t.sym} 4800 22000 0 0 {name=Xr110c24}
N 4760 22040 4740 22040 {}
C {lab_pin.sym} 4740 22040 0 0 {name=l17721 lab=BL24}
N 4760 22000 4740 22000 {}
C {lab_pin.sym} 4740 22000 0 0 {name=l17722 lab=BLB24}
N 4760 21960 4740 21960 {}
C {lab_pin.sym} 4740 21960 0 0 {name=l17723 lab=WL110}
N 4840 22040 4860 22040 {}
C {lab_pin.sym} 4860 22040 0 0 {name=l17724 lab=VDD}
N 4840 21960 4860 21960 {}
C {lab_pin.sym} 4860 21960 0 0 {name=l17725 lab=VSS}
C {bitcell_6t.sym} 5000 22000 0 0 {name=Xr110c25}
N 4960 22040 4940 22040 {}
C {lab_pin.sym} 4940 22040 0 0 {name=l17726 lab=BL25}
N 4960 22000 4940 22000 {}
C {lab_pin.sym} 4940 22000 0 0 {name=l17727 lab=BLB25}
N 4960 21960 4940 21960 {}
C {lab_pin.sym} 4940 21960 0 0 {name=l17728 lab=WL110}
N 5040 22040 5060 22040 {}
C {lab_pin.sym} 5060 22040 0 0 {name=l17729 lab=VDD}
N 5040 21960 5060 21960 {}
C {lab_pin.sym} 5060 21960 0 0 {name=l17730 lab=VSS}
C {bitcell_6t.sym} 5200 22000 0 0 {name=Xr110c26}
N 5160 22040 5140 22040 {}
C {lab_pin.sym} 5140 22040 0 0 {name=l17731 lab=BL26}
N 5160 22000 5140 22000 {}
C {lab_pin.sym} 5140 22000 0 0 {name=l17732 lab=BLB26}
N 5160 21960 5140 21960 {}
C {lab_pin.sym} 5140 21960 0 0 {name=l17733 lab=WL110}
N 5240 22040 5260 22040 {}
C {lab_pin.sym} 5260 22040 0 0 {name=l17734 lab=VDD}
N 5240 21960 5260 21960 {}
C {lab_pin.sym} 5260 21960 0 0 {name=l17735 lab=VSS}
C {bitcell_6t.sym} 5400 22000 0 0 {name=Xr110c27}
N 5360 22040 5340 22040 {}
C {lab_pin.sym} 5340 22040 0 0 {name=l17736 lab=BL27}
N 5360 22000 5340 22000 {}
C {lab_pin.sym} 5340 22000 0 0 {name=l17737 lab=BLB27}
N 5360 21960 5340 21960 {}
C {lab_pin.sym} 5340 21960 0 0 {name=l17738 lab=WL110}
N 5440 22040 5460 22040 {}
C {lab_pin.sym} 5460 22040 0 0 {name=l17739 lab=VDD}
N 5440 21960 5460 21960 {}
C {lab_pin.sym} 5460 21960 0 0 {name=l17740 lab=VSS}
C {bitcell_6t.sym} 5600 22000 0 0 {name=Xr110c28}
N 5560 22040 5540 22040 {}
C {lab_pin.sym} 5540 22040 0 0 {name=l17741 lab=BL28}
N 5560 22000 5540 22000 {}
C {lab_pin.sym} 5540 22000 0 0 {name=l17742 lab=BLB28}
N 5560 21960 5540 21960 {}
C {lab_pin.sym} 5540 21960 0 0 {name=l17743 lab=WL110}
N 5640 22040 5660 22040 {}
C {lab_pin.sym} 5660 22040 0 0 {name=l17744 lab=VDD}
N 5640 21960 5660 21960 {}
C {lab_pin.sym} 5660 21960 0 0 {name=l17745 lab=VSS}
C {bitcell_6t.sym} 5800 22000 0 0 {name=Xr110c29}
N 5760 22040 5740 22040 {}
C {lab_pin.sym} 5740 22040 0 0 {name=l17746 lab=BL29}
N 5760 22000 5740 22000 {}
C {lab_pin.sym} 5740 22000 0 0 {name=l17747 lab=BLB29}
N 5760 21960 5740 21960 {}
C {lab_pin.sym} 5740 21960 0 0 {name=l17748 lab=WL110}
N 5840 22040 5860 22040 {}
C {lab_pin.sym} 5860 22040 0 0 {name=l17749 lab=VDD}
N 5840 21960 5860 21960 {}
C {lab_pin.sym} 5860 21960 0 0 {name=l17750 lab=VSS}
C {bitcell_6t.sym} 6000 22000 0 0 {name=Xr110c30}
N 5960 22040 5940 22040 {}
C {lab_pin.sym} 5940 22040 0 0 {name=l17751 lab=BL30}
N 5960 22000 5940 22000 {}
C {lab_pin.sym} 5940 22000 0 0 {name=l17752 lab=BLB30}
N 5960 21960 5940 21960 {}
C {lab_pin.sym} 5940 21960 0 0 {name=l17753 lab=WL110}
N 6040 22040 6060 22040 {}
C {lab_pin.sym} 6060 22040 0 0 {name=l17754 lab=VDD}
N 6040 21960 6060 21960 {}
C {lab_pin.sym} 6060 21960 0 0 {name=l17755 lab=VSS}
C {bitcell_6t.sym} 6200 22000 0 0 {name=Xr110c31}
N 6160 22040 6140 22040 {}
C {lab_pin.sym} 6140 22040 0 0 {name=l17756 lab=BL31}
N 6160 22000 6140 22000 {}
C {lab_pin.sym} 6140 22000 0 0 {name=l17757 lab=BLB31}
N 6160 21960 6140 21960 {}
C {lab_pin.sym} 6140 21960 0 0 {name=l17758 lab=WL110}
N 6240 22040 6260 22040 {}
C {lab_pin.sym} 6260 22040 0 0 {name=l17759 lab=VDD}
N 6240 21960 6260 21960 {}
C {lab_pin.sym} 6260 21960 0 0 {name=l17760 lab=VSS}
C {bitcell_6t.sym} 0 22200 0 0 {name=Xr111c0}
N -40 22240 -60 22240 {}
C {lab_pin.sym} -60 22240 0 0 {name=l17761 lab=BL0}
N -40 22200 -60 22200 {}
C {lab_pin.sym} -60 22200 0 0 {name=l17762 lab=BLB0}
N -40 22160 -60 22160 {}
C {lab_pin.sym} -60 22160 0 0 {name=l17763 lab=WL111}
N 40 22240 60 22240 {}
C {lab_pin.sym} 60 22240 0 0 {name=l17764 lab=VDD}
N 40 22160 60 22160 {}
C {lab_pin.sym} 60 22160 0 0 {name=l17765 lab=VSS}
C {bitcell_6t.sym} 200 22200 0 0 {name=Xr111c1}
N 160 22240 140 22240 {}
C {lab_pin.sym} 140 22240 0 0 {name=l17766 lab=BL1}
N 160 22200 140 22200 {}
C {lab_pin.sym} 140 22200 0 0 {name=l17767 lab=BLB1}
N 160 22160 140 22160 {}
C {lab_pin.sym} 140 22160 0 0 {name=l17768 lab=WL111}
N 240 22240 260 22240 {}
C {lab_pin.sym} 260 22240 0 0 {name=l17769 lab=VDD}
N 240 22160 260 22160 {}
C {lab_pin.sym} 260 22160 0 0 {name=l17770 lab=VSS}
C {bitcell_6t.sym} 400 22200 0 0 {name=Xr111c2}
N 360 22240 340 22240 {}
C {lab_pin.sym} 340 22240 0 0 {name=l17771 lab=BL2}
N 360 22200 340 22200 {}
C {lab_pin.sym} 340 22200 0 0 {name=l17772 lab=BLB2}
N 360 22160 340 22160 {}
C {lab_pin.sym} 340 22160 0 0 {name=l17773 lab=WL111}
N 440 22240 460 22240 {}
C {lab_pin.sym} 460 22240 0 0 {name=l17774 lab=VDD}
N 440 22160 460 22160 {}
C {lab_pin.sym} 460 22160 0 0 {name=l17775 lab=VSS}
C {bitcell_6t.sym} 600 22200 0 0 {name=Xr111c3}
N 560 22240 540 22240 {}
C {lab_pin.sym} 540 22240 0 0 {name=l17776 lab=BL3}
N 560 22200 540 22200 {}
C {lab_pin.sym} 540 22200 0 0 {name=l17777 lab=BLB3}
N 560 22160 540 22160 {}
C {lab_pin.sym} 540 22160 0 0 {name=l17778 lab=WL111}
N 640 22240 660 22240 {}
C {lab_pin.sym} 660 22240 0 0 {name=l17779 lab=VDD}
N 640 22160 660 22160 {}
C {lab_pin.sym} 660 22160 0 0 {name=l17780 lab=VSS}
C {bitcell_6t.sym} 800 22200 0 0 {name=Xr111c4}
N 760 22240 740 22240 {}
C {lab_pin.sym} 740 22240 0 0 {name=l17781 lab=BL4}
N 760 22200 740 22200 {}
C {lab_pin.sym} 740 22200 0 0 {name=l17782 lab=BLB4}
N 760 22160 740 22160 {}
C {lab_pin.sym} 740 22160 0 0 {name=l17783 lab=WL111}
N 840 22240 860 22240 {}
C {lab_pin.sym} 860 22240 0 0 {name=l17784 lab=VDD}
N 840 22160 860 22160 {}
C {lab_pin.sym} 860 22160 0 0 {name=l17785 lab=VSS}
C {bitcell_6t.sym} 1000 22200 0 0 {name=Xr111c5}
N 960 22240 940 22240 {}
C {lab_pin.sym} 940 22240 0 0 {name=l17786 lab=BL5}
N 960 22200 940 22200 {}
C {lab_pin.sym} 940 22200 0 0 {name=l17787 lab=BLB5}
N 960 22160 940 22160 {}
C {lab_pin.sym} 940 22160 0 0 {name=l17788 lab=WL111}
N 1040 22240 1060 22240 {}
C {lab_pin.sym} 1060 22240 0 0 {name=l17789 lab=VDD}
N 1040 22160 1060 22160 {}
C {lab_pin.sym} 1060 22160 0 0 {name=l17790 lab=VSS}
C {bitcell_6t.sym} 1200 22200 0 0 {name=Xr111c6}
N 1160 22240 1140 22240 {}
C {lab_pin.sym} 1140 22240 0 0 {name=l17791 lab=BL6}
N 1160 22200 1140 22200 {}
C {lab_pin.sym} 1140 22200 0 0 {name=l17792 lab=BLB6}
N 1160 22160 1140 22160 {}
C {lab_pin.sym} 1140 22160 0 0 {name=l17793 lab=WL111}
N 1240 22240 1260 22240 {}
C {lab_pin.sym} 1260 22240 0 0 {name=l17794 lab=VDD}
N 1240 22160 1260 22160 {}
C {lab_pin.sym} 1260 22160 0 0 {name=l17795 lab=VSS}
C {bitcell_6t.sym} 1400 22200 0 0 {name=Xr111c7}
N 1360 22240 1340 22240 {}
C {lab_pin.sym} 1340 22240 0 0 {name=l17796 lab=BL7}
N 1360 22200 1340 22200 {}
C {lab_pin.sym} 1340 22200 0 0 {name=l17797 lab=BLB7}
N 1360 22160 1340 22160 {}
C {lab_pin.sym} 1340 22160 0 0 {name=l17798 lab=WL111}
N 1440 22240 1460 22240 {}
C {lab_pin.sym} 1460 22240 0 0 {name=l17799 lab=VDD}
N 1440 22160 1460 22160 {}
C {lab_pin.sym} 1460 22160 0 0 {name=l17800 lab=VSS}
C {bitcell_6t.sym} 1600 22200 0 0 {name=Xr111c8}
N 1560 22240 1540 22240 {}
C {lab_pin.sym} 1540 22240 0 0 {name=l17801 lab=BL8}
N 1560 22200 1540 22200 {}
C {lab_pin.sym} 1540 22200 0 0 {name=l17802 lab=BLB8}
N 1560 22160 1540 22160 {}
C {lab_pin.sym} 1540 22160 0 0 {name=l17803 lab=WL111}
N 1640 22240 1660 22240 {}
C {lab_pin.sym} 1660 22240 0 0 {name=l17804 lab=VDD}
N 1640 22160 1660 22160 {}
C {lab_pin.sym} 1660 22160 0 0 {name=l17805 lab=VSS}
C {bitcell_6t.sym} 1800 22200 0 0 {name=Xr111c9}
N 1760 22240 1740 22240 {}
C {lab_pin.sym} 1740 22240 0 0 {name=l17806 lab=BL9}
N 1760 22200 1740 22200 {}
C {lab_pin.sym} 1740 22200 0 0 {name=l17807 lab=BLB9}
N 1760 22160 1740 22160 {}
C {lab_pin.sym} 1740 22160 0 0 {name=l17808 lab=WL111}
N 1840 22240 1860 22240 {}
C {lab_pin.sym} 1860 22240 0 0 {name=l17809 lab=VDD}
N 1840 22160 1860 22160 {}
C {lab_pin.sym} 1860 22160 0 0 {name=l17810 lab=VSS}
C {bitcell_6t.sym} 2000 22200 0 0 {name=Xr111c10}
N 1960 22240 1940 22240 {}
C {lab_pin.sym} 1940 22240 0 0 {name=l17811 lab=BL10}
N 1960 22200 1940 22200 {}
C {lab_pin.sym} 1940 22200 0 0 {name=l17812 lab=BLB10}
N 1960 22160 1940 22160 {}
C {lab_pin.sym} 1940 22160 0 0 {name=l17813 lab=WL111}
N 2040 22240 2060 22240 {}
C {lab_pin.sym} 2060 22240 0 0 {name=l17814 lab=VDD}
N 2040 22160 2060 22160 {}
C {lab_pin.sym} 2060 22160 0 0 {name=l17815 lab=VSS}
C {bitcell_6t.sym} 2200 22200 0 0 {name=Xr111c11}
N 2160 22240 2140 22240 {}
C {lab_pin.sym} 2140 22240 0 0 {name=l17816 lab=BL11}
N 2160 22200 2140 22200 {}
C {lab_pin.sym} 2140 22200 0 0 {name=l17817 lab=BLB11}
N 2160 22160 2140 22160 {}
C {lab_pin.sym} 2140 22160 0 0 {name=l17818 lab=WL111}
N 2240 22240 2260 22240 {}
C {lab_pin.sym} 2260 22240 0 0 {name=l17819 lab=VDD}
N 2240 22160 2260 22160 {}
C {lab_pin.sym} 2260 22160 0 0 {name=l17820 lab=VSS}
C {bitcell_6t.sym} 2400 22200 0 0 {name=Xr111c12}
N 2360 22240 2340 22240 {}
C {lab_pin.sym} 2340 22240 0 0 {name=l17821 lab=BL12}
N 2360 22200 2340 22200 {}
C {lab_pin.sym} 2340 22200 0 0 {name=l17822 lab=BLB12}
N 2360 22160 2340 22160 {}
C {lab_pin.sym} 2340 22160 0 0 {name=l17823 lab=WL111}
N 2440 22240 2460 22240 {}
C {lab_pin.sym} 2460 22240 0 0 {name=l17824 lab=VDD}
N 2440 22160 2460 22160 {}
C {lab_pin.sym} 2460 22160 0 0 {name=l17825 lab=VSS}
C {bitcell_6t.sym} 2600 22200 0 0 {name=Xr111c13}
N 2560 22240 2540 22240 {}
C {lab_pin.sym} 2540 22240 0 0 {name=l17826 lab=BL13}
N 2560 22200 2540 22200 {}
C {lab_pin.sym} 2540 22200 0 0 {name=l17827 lab=BLB13}
N 2560 22160 2540 22160 {}
C {lab_pin.sym} 2540 22160 0 0 {name=l17828 lab=WL111}
N 2640 22240 2660 22240 {}
C {lab_pin.sym} 2660 22240 0 0 {name=l17829 lab=VDD}
N 2640 22160 2660 22160 {}
C {lab_pin.sym} 2660 22160 0 0 {name=l17830 lab=VSS}
C {bitcell_6t.sym} 2800 22200 0 0 {name=Xr111c14}
N 2760 22240 2740 22240 {}
C {lab_pin.sym} 2740 22240 0 0 {name=l17831 lab=BL14}
N 2760 22200 2740 22200 {}
C {lab_pin.sym} 2740 22200 0 0 {name=l17832 lab=BLB14}
N 2760 22160 2740 22160 {}
C {lab_pin.sym} 2740 22160 0 0 {name=l17833 lab=WL111}
N 2840 22240 2860 22240 {}
C {lab_pin.sym} 2860 22240 0 0 {name=l17834 lab=VDD}
N 2840 22160 2860 22160 {}
C {lab_pin.sym} 2860 22160 0 0 {name=l17835 lab=VSS}
C {bitcell_6t.sym} 3000 22200 0 0 {name=Xr111c15}
N 2960 22240 2940 22240 {}
C {lab_pin.sym} 2940 22240 0 0 {name=l17836 lab=BL15}
N 2960 22200 2940 22200 {}
C {lab_pin.sym} 2940 22200 0 0 {name=l17837 lab=BLB15}
N 2960 22160 2940 22160 {}
C {lab_pin.sym} 2940 22160 0 0 {name=l17838 lab=WL111}
N 3040 22240 3060 22240 {}
C {lab_pin.sym} 3060 22240 0 0 {name=l17839 lab=VDD}
N 3040 22160 3060 22160 {}
C {lab_pin.sym} 3060 22160 0 0 {name=l17840 lab=VSS}
C {bitcell_6t.sym} 3200 22200 0 0 {name=Xr111c16}
N 3160 22240 3140 22240 {}
C {lab_pin.sym} 3140 22240 0 0 {name=l17841 lab=BL16}
N 3160 22200 3140 22200 {}
C {lab_pin.sym} 3140 22200 0 0 {name=l17842 lab=BLB16}
N 3160 22160 3140 22160 {}
C {lab_pin.sym} 3140 22160 0 0 {name=l17843 lab=WL111}
N 3240 22240 3260 22240 {}
C {lab_pin.sym} 3260 22240 0 0 {name=l17844 lab=VDD}
N 3240 22160 3260 22160 {}
C {lab_pin.sym} 3260 22160 0 0 {name=l17845 lab=VSS}
C {bitcell_6t.sym} 3400 22200 0 0 {name=Xr111c17}
N 3360 22240 3340 22240 {}
C {lab_pin.sym} 3340 22240 0 0 {name=l17846 lab=BL17}
N 3360 22200 3340 22200 {}
C {lab_pin.sym} 3340 22200 0 0 {name=l17847 lab=BLB17}
N 3360 22160 3340 22160 {}
C {lab_pin.sym} 3340 22160 0 0 {name=l17848 lab=WL111}
N 3440 22240 3460 22240 {}
C {lab_pin.sym} 3460 22240 0 0 {name=l17849 lab=VDD}
N 3440 22160 3460 22160 {}
C {lab_pin.sym} 3460 22160 0 0 {name=l17850 lab=VSS}
C {bitcell_6t.sym} 3600 22200 0 0 {name=Xr111c18}
N 3560 22240 3540 22240 {}
C {lab_pin.sym} 3540 22240 0 0 {name=l17851 lab=BL18}
N 3560 22200 3540 22200 {}
C {lab_pin.sym} 3540 22200 0 0 {name=l17852 lab=BLB18}
N 3560 22160 3540 22160 {}
C {lab_pin.sym} 3540 22160 0 0 {name=l17853 lab=WL111}
N 3640 22240 3660 22240 {}
C {lab_pin.sym} 3660 22240 0 0 {name=l17854 lab=VDD}
N 3640 22160 3660 22160 {}
C {lab_pin.sym} 3660 22160 0 0 {name=l17855 lab=VSS}
C {bitcell_6t.sym} 3800 22200 0 0 {name=Xr111c19}
N 3760 22240 3740 22240 {}
C {lab_pin.sym} 3740 22240 0 0 {name=l17856 lab=BL19}
N 3760 22200 3740 22200 {}
C {lab_pin.sym} 3740 22200 0 0 {name=l17857 lab=BLB19}
N 3760 22160 3740 22160 {}
C {lab_pin.sym} 3740 22160 0 0 {name=l17858 lab=WL111}
N 3840 22240 3860 22240 {}
C {lab_pin.sym} 3860 22240 0 0 {name=l17859 lab=VDD}
N 3840 22160 3860 22160 {}
C {lab_pin.sym} 3860 22160 0 0 {name=l17860 lab=VSS}
C {bitcell_6t.sym} 4000 22200 0 0 {name=Xr111c20}
N 3960 22240 3940 22240 {}
C {lab_pin.sym} 3940 22240 0 0 {name=l17861 lab=BL20}
N 3960 22200 3940 22200 {}
C {lab_pin.sym} 3940 22200 0 0 {name=l17862 lab=BLB20}
N 3960 22160 3940 22160 {}
C {lab_pin.sym} 3940 22160 0 0 {name=l17863 lab=WL111}
N 4040 22240 4060 22240 {}
C {lab_pin.sym} 4060 22240 0 0 {name=l17864 lab=VDD}
N 4040 22160 4060 22160 {}
C {lab_pin.sym} 4060 22160 0 0 {name=l17865 lab=VSS}
C {bitcell_6t.sym} 4200 22200 0 0 {name=Xr111c21}
N 4160 22240 4140 22240 {}
C {lab_pin.sym} 4140 22240 0 0 {name=l17866 lab=BL21}
N 4160 22200 4140 22200 {}
C {lab_pin.sym} 4140 22200 0 0 {name=l17867 lab=BLB21}
N 4160 22160 4140 22160 {}
C {lab_pin.sym} 4140 22160 0 0 {name=l17868 lab=WL111}
N 4240 22240 4260 22240 {}
C {lab_pin.sym} 4260 22240 0 0 {name=l17869 lab=VDD}
N 4240 22160 4260 22160 {}
C {lab_pin.sym} 4260 22160 0 0 {name=l17870 lab=VSS}
C {bitcell_6t.sym} 4400 22200 0 0 {name=Xr111c22}
N 4360 22240 4340 22240 {}
C {lab_pin.sym} 4340 22240 0 0 {name=l17871 lab=BL22}
N 4360 22200 4340 22200 {}
C {lab_pin.sym} 4340 22200 0 0 {name=l17872 lab=BLB22}
N 4360 22160 4340 22160 {}
C {lab_pin.sym} 4340 22160 0 0 {name=l17873 lab=WL111}
N 4440 22240 4460 22240 {}
C {lab_pin.sym} 4460 22240 0 0 {name=l17874 lab=VDD}
N 4440 22160 4460 22160 {}
C {lab_pin.sym} 4460 22160 0 0 {name=l17875 lab=VSS}
C {bitcell_6t.sym} 4600 22200 0 0 {name=Xr111c23}
N 4560 22240 4540 22240 {}
C {lab_pin.sym} 4540 22240 0 0 {name=l17876 lab=BL23}
N 4560 22200 4540 22200 {}
C {lab_pin.sym} 4540 22200 0 0 {name=l17877 lab=BLB23}
N 4560 22160 4540 22160 {}
C {lab_pin.sym} 4540 22160 0 0 {name=l17878 lab=WL111}
N 4640 22240 4660 22240 {}
C {lab_pin.sym} 4660 22240 0 0 {name=l17879 lab=VDD}
N 4640 22160 4660 22160 {}
C {lab_pin.sym} 4660 22160 0 0 {name=l17880 lab=VSS}
C {bitcell_6t.sym} 4800 22200 0 0 {name=Xr111c24}
N 4760 22240 4740 22240 {}
C {lab_pin.sym} 4740 22240 0 0 {name=l17881 lab=BL24}
N 4760 22200 4740 22200 {}
C {lab_pin.sym} 4740 22200 0 0 {name=l17882 lab=BLB24}
N 4760 22160 4740 22160 {}
C {lab_pin.sym} 4740 22160 0 0 {name=l17883 lab=WL111}
N 4840 22240 4860 22240 {}
C {lab_pin.sym} 4860 22240 0 0 {name=l17884 lab=VDD}
N 4840 22160 4860 22160 {}
C {lab_pin.sym} 4860 22160 0 0 {name=l17885 lab=VSS}
C {bitcell_6t.sym} 5000 22200 0 0 {name=Xr111c25}
N 4960 22240 4940 22240 {}
C {lab_pin.sym} 4940 22240 0 0 {name=l17886 lab=BL25}
N 4960 22200 4940 22200 {}
C {lab_pin.sym} 4940 22200 0 0 {name=l17887 lab=BLB25}
N 4960 22160 4940 22160 {}
C {lab_pin.sym} 4940 22160 0 0 {name=l17888 lab=WL111}
N 5040 22240 5060 22240 {}
C {lab_pin.sym} 5060 22240 0 0 {name=l17889 lab=VDD}
N 5040 22160 5060 22160 {}
C {lab_pin.sym} 5060 22160 0 0 {name=l17890 lab=VSS}
C {bitcell_6t.sym} 5200 22200 0 0 {name=Xr111c26}
N 5160 22240 5140 22240 {}
C {lab_pin.sym} 5140 22240 0 0 {name=l17891 lab=BL26}
N 5160 22200 5140 22200 {}
C {lab_pin.sym} 5140 22200 0 0 {name=l17892 lab=BLB26}
N 5160 22160 5140 22160 {}
C {lab_pin.sym} 5140 22160 0 0 {name=l17893 lab=WL111}
N 5240 22240 5260 22240 {}
C {lab_pin.sym} 5260 22240 0 0 {name=l17894 lab=VDD}
N 5240 22160 5260 22160 {}
C {lab_pin.sym} 5260 22160 0 0 {name=l17895 lab=VSS}
C {bitcell_6t.sym} 5400 22200 0 0 {name=Xr111c27}
N 5360 22240 5340 22240 {}
C {lab_pin.sym} 5340 22240 0 0 {name=l17896 lab=BL27}
N 5360 22200 5340 22200 {}
C {lab_pin.sym} 5340 22200 0 0 {name=l17897 lab=BLB27}
N 5360 22160 5340 22160 {}
C {lab_pin.sym} 5340 22160 0 0 {name=l17898 lab=WL111}
N 5440 22240 5460 22240 {}
C {lab_pin.sym} 5460 22240 0 0 {name=l17899 lab=VDD}
N 5440 22160 5460 22160 {}
C {lab_pin.sym} 5460 22160 0 0 {name=l17900 lab=VSS}
C {bitcell_6t.sym} 5600 22200 0 0 {name=Xr111c28}
N 5560 22240 5540 22240 {}
C {lab_pin.sym} 5540 22240 0 0 {name=l17901 lab=BL28}
N 5560 22200 5540 22200 {}
C {lab_pin.sym} 5540 22200 0 0 {name=l17902 lab=BLB28}
N 5560 22160 5540 22160 {}
C {lab_pin.sym} 5540 22160 0 0 {name=l17903 lab=WL111}
N 5640 22240 5660 22240 {}
C {lab_pin.sym} 5660 22240 0 0 {name=l17904 lab=VDD}
N 5640 22160 5660 22160 {}
C {lab_pin.sym} 5660 22160 0 0 {name=l17905 lab=VSS}
C {bitcell_6t.sym} 5800 22200 0 0 {name=Xr111c29}
N 5760 22240 5740 22240 {}
C {lab_pin.sym} 5740 22240 0 0 {name=l17906 lab=BL29}
N 5760 22200 5740 22200 {}
C {lab_pin.sym} 5740 22200 0 0 {name=l17907 lab=BLB29}
N 5760 22160 5740 22160 {}
C {lab_pin.sym} 5740 22160 0 0 {name=l17908 lab=WL111}
N 5840 22240 5860 22240 {}
C {lab_pin.sym} 5860 22240 0 0 {name=l17909 lab=VDD}
N 5840 22160 5860 22160 {}
C {lab_pin.sym} 5860 22160 0 0 {name=l17910 lab=VSS}
C {bitcell_6t.sym} 6000 22200 0 0 {name=Xr111c30}
N 5960 22240 5940 22240 {}
C {lab_pin.sym} 5940 22240 0 0 {name=l17911 lab=BL30}
N 5960 22200 5940 22200 {}
C {lab_pin.sym} 5940 22200 0 0 {name=l17912 lab=BLB30}
N 5960 22160 5940 22160 {}
C {lab_pin.sym} 5940 22160 0 0 {name=l17913 lab=WL111}
N 6040 22240 6060 22240 {}
C {lab_pin.sym} 6060 22240 0 0 {name=l17914 lab=VDD}
N 6040 22160 6060 22160 {}
C {lab_pin.sym} 6060 22160 0 0 {name=l17915 lab=VSS}
C {bitcell_6t.sym} 6200 22200 0 0 {name=Xr111c31}
N 6160 22240 6140 22240 {}
C {lab_pin.sym} 6140 22240 0 0 {name=l17916 lab=BL31}
N 6160 22200 6140 22200 {}
C {lab_pin.sym} 6140 22200 0 0 {name=l17917 lab=BLB31}
N 6160 22160 6140 22160 {}
C {lab_pin.sym} 6140 22160 0 0 {name=l17918 lab=WL111}
N 6240 22240 6260 22240 {}
C {lab_pin.sym} 6260 22240 0 0 {name=l17919 lab=VDD}
N 6240 22160 6260 22160 {}
C {lab_pin.sym} 6260 22160 0 0 {name=l17920 lab=VSS}
C {bitcell_6t.sym} 0 22400 0 0 {name=Xr112c0}
N -40 22440 -60 22440 {}
C {lab_pin.sym} -60 22440 0 0 {name=l17921 lab=BL0}
N -40 22400 -60 22400 {}
C {lab_pin.sym} -60 22400 0 0 {name=l17922 lab=BLB0}
N -40 22360 -60 22360 {}
C {lab_pin.sym} -60 22360 0 0 {name=l17923 lab=WL112}
N 40 22440 60 22440 {}
C {lab_pin.sym} 60 22440 0 0 {name=l17924 lab=VDD}
N 40 22360 60 22360 {}
C {lab_pin.sym} 60 22360 0 0 {name=l17925 lab=VSS}
C {bitcell_6t.sym} 200 22400 0 0 {name=Xr112c1}
N 160 22440 140 22440 {}
C {lab_pin.sym} 140 22440 0 0 {name=l17926 lab=BL1}
N 160 22400 140 22400 {}
C {lab_pin.sym} 140 22400 0 0 {name=l17927 lab=BLB1}
N 160 22360 140 22360 {}
C {lab_pin.sym} 140 22360 0 0 {name=l17928 lab=WL112}
N 240 22440 260 22440 {}
C {lab_pin.sym} 260 22440 0 0 {name=l17929 lab=VDD}
N 240 22360 260 22360 {}
C {lab_pin.sym} 260 22360 0 0 {name=l17930 lab=VSS}
C {bitcell_6t.sym} 400 22400 0 0 {name=Xr112c2}
N 360 22440 340 22440 {}
C {lab_pin.sym} 340 22440 0 0 {name=l17931 lab=BL2}
N 360 22400 340 22400 {}
C {lab_pin.sym} 340 22400 0 0 {name=l17932 lab=BLB2}
N 360 22360 340 22360 {}
C {lab_pin.sym} 340 22360 0 0 {name=l17933 lab=WL112}
N 440 22440 460 22440 {}
C {lab_pin.sym} 460 22440 0 0 {name=l17934 lab=VDD}
N 440 22360 460 22360 {}
C {lab_pin.sym} 460 22360 0 0 {name=l17935 lab=VSS}
C {bitcell_6t.sym} 600 22400 0 0 {name=Xr112c3}
N 560 22440 540 22440 {}
C {lab_pin.sym} 540 22440 0 0 {name=l17936 lab=BL3}
N 560 22400 540 22400 {}
C {lab_pin.sym} 540 22400 0 0 {name=l17937 lab=BLB3}
N 560 22360 540 22360 {}
C {lab_pin.sym} 540 22360 0 0 {name=l17938 lab=WL112}
N 640 22440 660 22440 {}
C {lab_pin.sym} 660 22440 0 0 {name=l17939 lab=VDD}
N 640 22360 660 22360 {}
C {lab_pin.sym} 660 22360 0 0 {name=l17940 lab=VSS}
C {bitcell_6t.sym} 800 22400 0 0 {name=Xr112c4}
N 760 22440 740 22440 {}
C {lab_pin.sym} 740 22440 0 0 {name=l17941 lab=BL4}
N 760 22400 740 22400 {}
C {lab_pin.sym} 740 22400 0 0 {name=l17942 lab=BLB4}
N 760 22360 740 22360 {}
C {lab_pin.sym} 740 22360 0 0 {name=l17943 lab=WL112}
N 840 22440 860 22440 {}
C {lab_pin.sym} 860 22440 0 0 {name=l17944 lab=VDD}
N 840 22360 860 22360 {}
C {lab_pin.sym} 860 22360 0 0 {name=l17945 lab=VSS}
C {bitcell_6t.sym} 1000 22400 0 0 {name=Xr112c5}
N 960 22440 940 22440 {}
C {lab_pin.sym} 940 22440 0 0 {name=l17946 lab=BL5}
N 960 22400 940 22400 {}
C {lab_pin.sym} 940 22400 0 0 {name=l17947 lab=BLB5}
N 960 22360 940 22360 {}
C {lab_pin.sym} 940 22360 0 0 {name=l17948 lab=WL112}
N 1040 22440 1060 22440 {}
C {lab_pin.sym} 1060 22440 0 0 {name=l17949 lab=VDD}
N 1040 22360 1060 22360 {}
C {lab_pin.sym} 1060 22360 0 0 {name=l17950 lab=VSS}
C {bitcell_6t.sym} 1200 22400 0 0 {name=Xr112c6}
N 1160 22440 1140 22440 {}
C {lab_pin.sym} 1140 22440 0 0 {name=l17951 lab=BL6}
N 1160 22400 1140 22400 {}
C {lab_pin.sym} 1140 22400 0 0 {name=l17952 lab=BLB6}
N 1160 22360 1140 22360 {}
C {lab_pin.sym} 1140 22360 0 0 {name=l17953 lab=WL112}
N 1240 22440 1260 22440 {}
C {lab_pin.sym} 1260 22440 0 0 {name=l17954 lab=VDD}
N 1240 22360 1260 22360 {}
C {lab_pin.sym} 1260 22360 0 0 {name=l17955 lab=VSS}
C {bitcell_6t.sym} 1400 22400 0 0 {name=Xr112c7}
N 1360 22440 1340 22440 {}
C {lab_pin.sym} 1340 22440 0 0 {name=l17956 lab=BL7}
N 1360 22400 1340 22400 {}
C {lab_pin.sym} 1340 22400 0 0 {name=l17957 lab=BLB7}
N 1360 22360 1340 22360 {}
C {lab_pin.sym} 1340 22360 0 0 {name=l17958 lab=WL112}
N 1440 22440 1460 22440 {}
C {lab_pin.sym} 1460 22440 0 0 {name=l17959 lab=VDD}
N 1440 22360 1460 22360 {}
C {lab_pin.sym} 1460 22360 0 0 {name=l17960 lab=VSS}
C {bitcell_6t.sym} 1600 22400 0 0 {name=Xr112c8}
N 1560 22440 1540 22440 {}
C {lab_pin.sym} 1540 22440 0 0 {name=l17961 lab=BL8}
N 1560 22400 1540 22400 {}
C {lab_pin.sym} 1540 22400 0 0 {name=l17962 lab=BLB8}
N 1560 22360 1540 22360 {}
C {lab_pin.sym} 1540 22360 0 0 {name=l17963 lab=WL112}
N 1640 22440 1660 22440 {}
C {lab_pin.sym} 1660 22440 0 0 {name=l17964 lab=VDD}
N 1640 22360 1660 22360 {}
C {lab_pin.sym} 1660 22360 0 0 {name=l17965 lab=VSS}
C {bitcell_6t.sym} 1800 22400 0 0 {name=Xr112c9}
N 1760 22440 1740 22440 {}
C {lab_pin.sym} 1740 22440 0 0 {name=l17966 lab=BL9}
N 1760 22400 1740 22400 {}
C {lab_pin.sym} 1740 22400 0 0 {name=l17967 lab=BLB9}
N 1760 22360 1740 22360 {}
C {lab_pin.sym} 1740 22360 0 0 {name=l17968 lab=WL112}
N 1840 22440 1860 22440 {}
C {lab_pin.sym} 1860 22440 0 0 {name=l17969 lab=VDD}
N 1840 22360 1860 22360 {}
C {lab_pin.sym} 1860 22360 0 0 {name=l17970 lab=VSS}
C {bitcell_6t.sym} 2000 22400 0 0 {name=Xr112c10}
N 1960 22440 1940 22440 {}
C {lab_pin.sym} 1940 22440 0 0 {name=l17971 lab=BL10}
N 1960 22400 1940 22400 {}
C {lab_pin.sym} 1940 22400 0 0 {name=l17972 lab=BLB10}
N 1960 22360 1940 22360 {}
C {lab_pin.sym} 1940 22360 0 0 {name=l17973 lab=WL112}
N 2040 22440 2060 22440 {}
C {lab_pin.sym} 2060 22440 0 0 {name=l17974 lab=VDD}
N 2040 22360 2060 22360 {}
C {lab_pin.sym} 2060 22360 0 0 {name=l17975 lab=VSS}
C {bitcell_6t.sym} 2200 22400 0 0 {name=Xr112c11}
N 2160 22440 2140 22440 {}
C {lab_pin.sym} 2140 22440 0 0 {name=l17976 lab=BL11}
N 2160 22400 2140 22400 {}
C {lab_pin.sym} 2140 22400 0 0 {name=l17977 lab=BLB11}
N 2160 22360 2140 22360 {}
C {lab_pin.sym} 2140 22360 0 0 {name=l17978 lab=WL112}
N 2240 22440 2260 22440 {}
C {lab_pin.sym} 2260 22440 0 0 {name=l17979 lab=VDD}
N 2240 22360 2260 22360 {}
C {lab_pin.sym} 2260 22360 0 0 {name=l17980 lab=VSS}
C {bitcell_6t.sym} 2400 22400 0 0 {name=Xr112c12}
N 2360 22440 2340 22440 {}
C {lab_pin.sym} 2340 22440 0 0 {name=l17981 lab=BL12}
N 2360 22400 2340 22400 {}
C {lab_pin.sym} 2340 22400 0 0 {name=l17982 lab=BLB12}
N 2360 22360 2340 22360 {}
C {lab_pin.sym} 2340 22360 0 0 {name=l17983 lab=WL112}
N 2440 22440 2460 22440 {}
C {lab_pin.sym} 2460 22440 0 0 {name=l17984 lab=VDD}
N 2440 22360 2460 22360 {}
C {lab_pin.sym} 2460 22360 0 0 {name=l17985 lab=VSS}
C {bitcell_6t.sym} 2600 22400 0 0 {name=Xr112c13}
N 2560 22440 2540 22440 {}
C {lab_pin.sym} 2540 22440 0 0 {name=l17986 lab=BL13}
N 2560 22400 2540 22400 {}
C {lab_pin.sym} 2540 22400 0 0 {name=l17987 lab=BLB13}
N 2560 22360 2540 22360 {}
C {lab_pin.sym} 2540 22360 0 0 {name=l17988 lab=WL112}
N 2640 22440 2660 22440 {}
C {lab_pin.sym} 2660 22440 0 0 {name=l17989 lab=VDD}
N 2640 22360 2660 22360 {}
C {lab_pin.sym} 2660 22360 0 0 {name=l17990 lab=VSS}
C {bitcell_6t.sym} 2800 22400 0 0 {name=Xr112c14}
N 2760 22440 2740 22440 {}
C {lab_pin.sym} 2740 22440 0 0 {name=l17991 lab=BL14}
N 2760 22400 2740 22400 {}
C {lab_pin.sym} 2740 22400 0 0 {name=l17992 lab=BLB14}
N 2760 22360 2740 22360 {}
C {lab_pin.sym} 2740 22360 0 0 {name=l17993 lab=WL112}
N 2840 22440 2860 22440 {}
C {lab_pin.sym} 2860 22440 0 0 {name=l17994 lab=VDD}
N 2840 22360 2860 22360 {}
C {lab_pin.sym} 2860 22360 0 0 {name=l17995 lab=VSS}
C {bitcell_6t.sym} 3000 22400 0 0 {name=Xr112c15}
N 2960 22440 2940 22440 {}
C {lab_pin.sym} 2940 22440 0 0 {name=l17996 lab=BL15}
N 2960 22400 2940 22400 {}
C {lab_pin.sym} 2940 22400 0 0 {name=l17997 lab=BLB15}
N 2960 22360 2940 22360 {}
C {lab_pin.sym} 2940 22360 0 0 {name=l17998 lab=WL112}
N 3040 22440 3060 22440 {}
C {lab_pin.sym} 3060 22440 0 0 {name=l17999 lab=VDD}
N 3040 22360 3060 22360 {}
C {lab_pin.sym} 3060 22360 0 0 {name=l18000 lab=VSS}
C {bitcell_6t.sym} 3200 22400 0 0 {name=Xr112c16}
N 3160 22440 3140 22440 {}
C {lab_pin.sym} 3140 22440 0 0 {name=l18001 lab=BL16}
N 3160 22400 3140 22400 {}
C {lab_pin.sym} 3140 22400 0 0 {name=l18002 lab=BLB16}
N 3160 22360 3140 22360 {}
C {lab_pin.sym} 3140 22360 0 0 {name=l18003 lab=WL112}
N 3240 22440 3260 22440 {}
C {lab_pin.sym} 3260 22440 0 0 {name=l18004 lab=VDD}
N 3240 22360 3260 22360 {}
C {lab_pin.sym} 3260 22360 0 0 {name=l18005 lab=VSS}
C {bitcell_6t.sym} 3400 22400 0 0 {name=Xr112c17}
N 3360 22440 3340 22440 {}
C {lab_pin.sym} 3340 22440 0 0 {name=l18006 lab=BL17}
N 3360 22400 3340 22400 {}
C {lab_pin.sym} 3340 22400 0 0 {name=l18007 lab=BLB17}
N 3360 22360 3340 22360 {}
C {lab_pin.sym} 3340 22360 0 0 {name=l18008 lab=WL112}
N 3440 22440 3460 22440 {}
C {lab_pin.sym} 3460 22440 0 0 {name=l18009 lab=VDD}
N 3440 22360 3460 22360 {}
C {lab_pin.sym} 3460 22360 0 0 {name=l18010 lab=VSS}
C {bitcell_6t.sym} 3600 22400 0 0 {name=Xr112c18}
N 3560 22440 3540 22440 {}
C {lab_pin.sym} 3540 22440 0 0 {name=l18011 lab=BL18}
N 3560 22400 3540 22400 {}
C {lab_pin.sym} 3540 22400 0 0 {name=l18012 lab=BLB18}
N 3560 22360 3540 22360 {}
C {lab_pin.sym} 3540 22360 0 0 {name=l18013 lab=WL112}
N 3640 22440 3660 22440 {}
C {lab_pin.sym} 3660 22440 0 0 {name=l18014 lab=VDD}
N 3640 22360 3660 22360 {}
C {lab_pin.sym} 3660 22360 0 0 {name=l18015 lab=VSS}
C {bitcell_6t.sym} 3800 22400 0 0 {name=Xr112c19}
N 3760 22440 3740 22440 {}
C {lab_pin.sym} 3740 22440 0 0 {name=l18016 lab=BL19}
N 3760 22400 3740 22400 {}
C {lab_pin.sym} 3740 22400 0 0 {name=l18017 lab=BLB19}
N 3760 22360 3740 22360 {}
C {lab_pin.sym} 3740 22360 0 0 {name=l18018 lab=WL112}
N 3840 22440 3860 22440 {}
C {lab_pin.sym} 3860 22440 0 0 {name=l18019 lab=VDD}
N 3840 22360 3860 22360 {}
C {lab_pin.sym} 3860 22360 0 0 {name=l18020 lab=VSS}
C {bitcell_6t.sym} 4000 22400 0 0 {name=Xr112c20}
N 3960 22440 3940 22440 {}
C {lab_pin.sym} 3940 22440 0 0 {name=l18021 lab=BL20}
N 3960 22400 3940 22400 {}
C {lab_pin.sym} 3940 22400 0 0 {name=l18022 lab=BLB20}
N 3960 22360 3940 22360 {}
C {lab_pin.sym} 3940 22360 0 0 {name=l18023 lab=WL112}
N 4040 22440 4060 22440 {}
C {lab_pin.sym} 4060 22440 0 0 {name=l18024 lab=VDD}
N 4040 22360 4060 22360 {}
C {lab_pin.sym} 4060 22360 0 0 {name=l18025 lab=VSS}
C {bitcell_6t.sym} 4200 22400 0 0 {name=Xr112c21}
N 4160 22440 4140 22440 {}
C {lab_pin.sym} 4140 22440 0 0 {name=l18026 lab=BL21}
N 4160 22400 4140 22400 {}
C {lab_pin.sym} 4140 22400 0 0 {name=l18027 lab=BLB21}
N 4160 22360 4140 22360 {}
C {lab_pin.sym} 4140 22360 0 0 {name=l18028 lab=WL112}
N 4240 22440 4260 22440 {}
C {lab_pin.sym} 4260 22440 0 0 {name=l18029 lab=VDD}
N 4240 22360 4260 22360 {}
C {lab_pin.sym} 4260 22360 0 0 {name=l18030 lab=VSS}
C {bitcell_6t.sym} 4400 22400 0 0 {name=Xr112c22}
N 4360 22440 4340 22440 {}
C {lab_pin.sym} 4340 22440 0 0 {name=l18031 lab=BL22}
N 4360 22400 4340 22400 {}
C {lab_pin.sym} 4340 22400 0 0 {name=l18032 lab=BLB22}
N 4360 22360 4340 22360 {}
C {lab_pin.sym} 4340 22360 0 0 {name=l18033 lab=WL112}
N 4440 22440 4460 22440 {}
C {lab_pin.sym} 4460 22440 0 0 {name=l18034 lab=VDD}
N 4440 22360 4460 22360 {}
C {lab_pin.sym} 4460 22360 0 0 {name=l18035 lab=VSS}
C {bitcell_6t.sym} 4600 22400 0 0 {name=Xr112c23}
N 4560 22440 4540 22440 {}
C {lab_pin.sym} 4540 22440 0 0 {name=l18036 lab=BL23}
N 4560 22400 4540 22400 {}
C {lab_pin.sym} 4540 22400 0 0 {name=l18037 lab=BLB23}
N 4560 22360 4540 22360 {}
C {lab_pin.sym} 4540 22360 0 0 {name=l18038 lab=WL112}
N 4640 22440 4660 22440 {}
C {lab_pin.sym} 4660 22440 0 0 {name=l18039 lab=VDD}
N 4640 22360 4660 22360 {}
C {lab_pin.sym} 4660 22360 0 0 {name=l18040 lab=VSS}
C {bitcell_6t.sym} 4800 22400 0 0 {name=Xr112c24}
N 4760 22440 4740 22440 {}
C {lab_pin.sym} 4740 22440 0 0 {name=l18041 lab=BL24}
N 4760 22400 4740 22400 {}
C {lab_pin.sym} 4740 22400 0 0 {name=l18042 lab=BLB24}
N 4760 22360 4740 22360 {}
C {lab_pin.sym} 4740 22360 0 0 {name=l18043 lab=WL112}
N 4840 22440 4860 22440 {}
C {lab_pin.sym} 4860 22440 0 0 {name=l18044 lab=VDD}
N 4840 22360 4860 22360 {}
C {lab_pin.sym} 4860 22360 0 0 {name=l18045 lab=VSS}
C {bitcell_6t.sym} 5000 22400 0 0 {name=Xr112c25}
N 4960 22440 4940 22440 {}
C {lab_pin.sym} 4940 22440 0 0 {name=l18046 lab=BL25}
N 4960 22400 4940 22400 {}
C {lab_pin.sym} 4940 22400 0 0 {name=l18047 lab=BLB25}
N 4960 22360 4940 22360 {}
C {lab_pin.sym} 4940 22360 0 0 {name=l18048 lab=WL112}
N 5040 22440 5060 22440 {}
C {lab_pin.sym} 5060 22440 0 0 {name=l18049 lab=VDD}
N 5040 22360 5060 22360 {}
C {lab_pin.sym} 5060 22360 0 0 {name=l18050 lab=VSS}
C {bitcell_6t.sym} 5200 22400 0 0 {name=Xr112c26}
N 5160 22440 5140 22440 {}
C {lab_pin.sym} 5140 22440 0 0 {name=l18051 lab=BL26}
N 5160 22400 5140 22400 {}
C {lab_pin.sym} 5140 22400 0 0 {name=l18052 lab=BLB26}
N 5160 22360 5140 22360 {}
C {lab_pin.sym} 5140 22360 0 0 {name=l18053 lab=WL112}
N 5240 22440 5260 22440 {}
C {lab_pin.sym} 5260 22440 0 0 {name=l18054 lab=VDD}
N 5240 22360 5260 22360 {}
C {lab_pin.sym} 5260 22360 0 0 {name=l18055 lab=VSS}
C {bitcell_6t.sym} 5400 22400 0 0 {name=Xr112c27}
N 5360 22440 5340 22440 {}
C {lab_pin.sym} 5340 22440 0 0 {name=l18056 lab=BL27}
N 5360 22400 5340 22400 {}
C {lab_pin.sym} 5340 22400 0 0 {name=l18057 lab=BLB27}
N 5360 22360 5340 22360 {}
C {lab_pin.sym} 5340 22360 0 0 {name=l18058 lab=WL112}
N 5440 22440 5460 22440 {}
C {lab_pin.sym} 5460 22440 0 0 {name=l18059 lab=VDD}
N 5440 22360 5460 22360 {}
C {lab_pin.sym} 5460 22360 0 0 {name=l18060 lab=VSS}
C {bitcell_6t.sym} 5600 22400 0 0 {name=Xr112c28}
N 5560 22440 5540 22440 {}
C {lab_pin.sym} 5540 22440 0 0 {name=l18061 lab=BL28}
N 5560 22400 5540 22400 {}
C {lab_pin.sym} 5540 22400 0 0 {name=l18062 lab=BLB28}
N 5560 22360 5540 22360 {}
C {lab_pin.sym} 5540 22360 0 0 {name=l18063 lab=WL112}
N 5640 22440 5660 22440 {}
C {lab_pin.sym} 5660 22440 0 0 {name=l18064 lab=VDD}
N 5640 22360 5660 22360 {}
C {lab_pin.sym} 5660 22360 0 0 {name=l18065 lab=VSS}
C {bitcell_6t.sym} 5800 22400 0 0 {name=Xr112c29}
N 5760 22440 5740 22440 {}
C {lab_pin.sym} 5740 22440 0 0 {name=l18066 lab=BL29}
N 5760 22400 5740 22400 {}
C {lab_pin.sym} 5740 22400 0 0 {name=l18067 lab=BLB29}
N 5760 22360 5740 22360 {}
C {lab_pin.sym} 5740 22360 0 0 {name=l18068 lab=WL112}
N 5840 22440 5860 22440 {}
C {lab_pin.sym} 5860 22440 0 0 {name=l18069 lab=VDD}
N 5840 22360 5860 22360 {}
C {lab_pin.sym} 5860 22360 0 0 {name=l18070 lab=VSS}
C {bitcell_6t.sym} 6000 22400 0 0 {name=Xr112c30}
N 5960 22440 5940 22440 {}
C {lab_pin.sym} 5940 22440 0 0 {name=l18071 lab=BL30}
N 5960 22400 5940 22400 {}
C {lab_pin.sym} 5940 22400 0 0 {name=l18072 lab=BLB30}
N 5960 22360 5940 22360 {}
C {lab_pin.sym} 5940 22360 0 0 {name=l18073 lab=WL112}
N 6040 22440 6060 22440 {}
C {lab_pin.sym} 6060 22440 0 0 {name=l18074 lab=VDD}
N 6040 22360 6060 22360 {}
C {lab_pin.sym} 6060 22360 0 0 {name=l18075 lab=VSS}
C {bitcell_6t.sym} 6200 22400 0 0 {name=Xr112c31}
N 6160 22440 6140 22440 {}
C {lab_pin.sym} 6140 22440 0 0 {name=l18076 lab=BL31}
N 6160 22400 6140 22400 {}
C {lab_pin.sym} 6140 22400 0 0 {name=l18077 lab=BLB31}
N 6160 22360 6140 22360 {}
C {lab_pin.sym} 6140 22360 0 0 {name=l18078 lab=WL112}
N 6240 22440 6260 22440 {}
C {lab_pin.sym} 6260 22440 0 0 {name=l18079 lab=VDD}
N 6240 22360 6260 22360 {}
C {lab_pin.sym} 6260 22360 0 0 {name=l18080 lab=VSS}
C {bitcell_6t.sym} 0 22600 0 0 {name=Xr113c0}
N -40 22640 -60 22640 {}
C {lab_pin.sym} -60 22640 0 0 {name=l18081 lab=BL0}
N -40 22600 -60 22600 {}
C {lab_pin.sym} -60 22600 0 0 {name=l18082 lab=BLB0}
N -40 22560 -60 22560 {}
C {lab_pin.sym} -60 22560 0 0 {name=l18083 lab=WL113}
N 40 22640 60 22640 {}
C {lab_pin.sym} 60 22640 0 0 {name=l18084 lab=VDD}
N 40 22560 60 22560 {}
C {lab_pin.sym} 60 22560 0 0 {name=l18085 lab=VSS}
C {bitcell_6t.sym} 200 22600 0 0 {name=Xr113c1}
N 160 22640 140 22640 {}
C {lab_pin.sym} 140 22640 0 0 {name=l18086 lab=BL1}
N 160 22600 140 22600 {}
C {lab_pin.sym} 140 22600 0 0 {name=l18087 lab=BLB1}
N 160 22560 140 22560 {}
C {lab_pin.sym} 140 22560 0 0 {name=l18088 lab=WL113}
N 240 22640 260 22640 {}
C {lab_pin.sym} 260 22640 0 0 {name=l18089 lab=VDD}
N 240 22560 260 22560 {}
C {lab_pin.sym} 260 22560 0 0 {name=l18090 lab=VSS}
C {bitcell_6t.sym} 400 22600 0 0 {name=Xr113c2}
N 360 22640 340 22640 {}
C {lab_pin.sym} 340 22640 0 0 {name=l18091 lab=BL2}
N 360 22600 340 22600 {}
C {lab_pin.sym} 340 22600 0 0 {name=l18092 lab=BLB2}
N 360 22560 340 22560 {}
C {lab_pin.sym} 340 22560 0 0 {name=l18093 lab=WL113}
N 440 22640 460 22640 {}
C {lab_pin.sym} 460 22640 0 0 {name=l18094 lab=VDD}
N 440 22560 460 22560 {}
C {lab_pin.sym} 460 22560 0 0 {name=l18095 lab=VSS}
C {bitcell_6t.sym} 600 22600 0 0 {name=Xr113c3}
N 560 22640 540 22640 {}
C {lab_pin.sym} 540 22640 0 0 {name=l18096 lab=BL3}
N 560 22600 540 22600 {}
C {lab_pin.sym} 540 22600 0 0 {name=l18097 lab=BLB3}
N 560 22560 540 22560 {}
C {lab_pin.sym} 540 22560 0 0 {name=l18098 lab=WL113}
N 640 22640 660 22640 {}
C {lab_pin.sym} 660 22640 0 0 {name=l18099 lab=VDD}
N 640 22560 660 22560 {}
C {lab_pin.sym} 660 22560 0 0 {name=l18100 lab=VSS}
C {bitcell_6t.sym} 800 22600 0 0 {name=Xr113c4}
N 760 22640 740 22640 {}
C {lab_pin.sym} 740 22640 0 0 {name=l18101 lab=BL4}
N 760 22600 740 22600 {}
C {lab_pin.sym} 740 22600 0 0 {name=l18102 lab=BLB4}
N 760 22560 740 22560 {}
C {lab_pin.sym} 740 22560 0 0 {name=l18103 lab=WL113}
N 840 22640 860 22640 {}
C {lab_pin.sym} 860 22640 0 0 {name=l18104 lab=VDD}
N 840 22560 860 22560 {}
C {lab_pin.sym} 860 22560 0 0 {name=l18105 lab=VSS}
C {bitcell_6t.sym} 1000 22600 0 0 {name=Xr113c5}
N 960 22640 940 22640 {}
C {lab_pin.sym} 940 22640 0 0 {name=l18106 lab=BL5}
N 960 22600 940 22600 {}
C {lab_pin.sym} 940 22600 0 0 {name=l18107 lab=BLB5}
N 960 22560 940 22560 {}
C {lab_pin.sym} 940 22560 0 0 {name=l18108 lab=WL113}
N 1040 22640 1060 22640 {}
C {lab_pin.sym} 1060 22640 0 0 {name=l18109 lab=VDD}
N 1040 22560 1060 22560 {}
C {lab_pin.sym} 1060 22560 0 0 {name=l18110 lab=VSS}
C {bitcell_6t.sym} 1200 22600 0 0 {name=Xr113c6}
N 1160 22640 1140 22640 {}
C {lab_pin.sym} 1140 22640 0 0 {name=l18111 lab=BL6}
N 1160 22600 1140 22600 {}
C {lab_pin.sym} 1140 22600 0 0 {name=l18112 lab=BLB6}
N 1160 22560 1140 22560 {}
C {lab_pin.sym} 1140 22560 0 0 {name=l18113 lab=WL113}
N 1240 22640 1260 22640 {}
C {lab_pin.sym} 1260 22640 0 0 {name=l18114 lab=VDD}
N 1240 22560 1260 22560 {}
C {lab_pin.sym} 1260 22560 0 0 {name=l18115 lab=VSS}
C {bitcell_6t.sym} 1400 22600 0 0 {name=Xr113c7}
N 1360 22640 1340 22640 {}
C {lab_pin.sym} 1340 22640 0 0 {name=l18116 lab=BL7}
N 1360 22600 1340 22600 {}
C {lab_pin.sym} 1340 22600 0 0 {name=l18117 lab=BLB7}
N 1360 22560 1340 22560 {}
C {lab_pin.sym} 1340 22560 0 0 {name=l18118 lab=WL113}
N 1440 22640 1460 22640 {}
C {lab_pin.sym} 1460 22640 0 0 {name=l18119 lab=VDD}
N 1440 22560 1460 22560 {}
C {lab_pin.sym} 1460 22560 0 0 {name=l18120 lab=VSS}
C {bitcell_6t.sym} 1600 22600 0 0 {name=Xr113c8}
N 1560 22640 1540 22640 {}
C {lab_pin.sym} 1540 22640 0 0 {name=l18121 lab=BL8}
N 1560 22600 1540 22600 {}
C {lab_pin.sym} 1540 22600 0 0 {name=l18122 lab=BLB8}
N 1560 22560 1540 22560 {}
C {lab_pin.sym} 1540 22560 0 0 {name=l18123 lab=WL113}
N 1640 22640 1660 22640 {}
C {lab_pin.sym} 1660 22640 0 0 {name=l18124 lab=VDD}
N 1640 22560 1660 22560 {}
C {lab_pin.sym} 1660 22560 0 0 {name=l18125 lab=VSS}
C {bitcell_6t.sym} 1800 22600 0 0 {name=Xr113c9}
N 1760 22640 1740 22640 {}
C {lab_pin.sym} 1740 22640 0 0 {name=l18126 lab=BL9}
N 1760 22600 1740 22600 {}
C {lab_pin.sym} 1740 22600 0 0 {name=l18127 lab=BLB9}
N 1760 22560 1740 22560 {}
C {lab_pin.sym} 1740 22560 0 0 {name=l18128 lab=WL113}
N 1840 22640 1860 22640 {}
C {lab_pin.sym} 1860 22640 0 0 {name=l18129 lab=VDD}
N 1840 22560 1860 22560 {}
C {lab_pin.sym} 1860 22560 0 0 {name=l18130 lab=VSS}
C {bitcell_6t.sym} 2000 22600 0 0 {name=Xr113c10}
N 1960 22640 1940 22640 {}
C {lab_pin.sym} 1940 22640 0 0 {name=l18131 lab=BL10}
N 1960 22600 1940 22600 {}
C {lab_pin.sym} 1940 22600 0 0 {name=l18132 lab=BLB10}
N 1960 22560 1940 22560 {}
C {lab_pin.sym} 1940 22560 0 0 {name=l18133 lab=WL113}
N 2040 22640 2060 22640 {}
C {lab_pin.sym} 2060 22640 0 0 {name=l18134 lab=VDD}
N 2040 22560 2060 22560 {}
C {lab_pin.sym} 2060 22560 0 0 {name=l18135 lab=VSS}
C {bitcell_6t.sym} 2200 22600 0 0 {name=Xr113c11}
N 2160 22640 2140 22640 {}
C {lab_pin.sym} 2140 22640 0 0 {name=l18136 lab=BL11}
N 2160 22600 2140 22600 {}
C {lab_pin.sym} 2140 22600 0 0 {name=l18137 lab=BLB11}
N 2160 22560 2140 22560 {}
C {lab_pin.sym} 2140 22560 0 0 {name=l18138 lab=WL113}
N 2240 22640 2260 22640 {}
C {lab_pin.sym} 2260 22640 0 0 {name=l18139 lab=VDD}
N 2240 22560 2260 22560 {}
C {lab_pin.sym} 2260 22560 0 0 {name=l18140 lab=VSS}
C {bitcell_6t.sym} 2400 22600 0 0 {name=Xr113c12}
N 2360 22640 2340 22640 {}
C {lab_pin.sym} 2340 22640 0 0 {name=l18141 lab=BL12}
N 2360 22600 2340 22600 {}
C {lab_pin.sym} 2340 22600 0 0 {name=l18142 lab=BLB12}
N 2360 22560 2340 22560 {}
C {lab_pin.sym} 2340 22560 0 0 {name=l18143 lab=WL113}
N 2440 22640 2460 22640 {}
C {lab_pin.sym} 2460 22640 0 0 {name=l18144 lab=VDD}
N 2440 22560 2460 22560 {}
C {lab_pin.sym} 2460 22560 0 0 {name=l18145 lab=VSS}
C {bitcell_6t.sym} 2600 22600 0 0 {name=Xr113c13}
N 2560 22640 2540 22640 {}
C {lab_pin.sym} 2540 22640 0 0 {name=l18146 lab=BL13}
N 2560 22600 2540 22600 {}
C {lab_pin.sym} 2540 22600 0 0 {name=l18147 lab=BLB13}
N 2560 22560 2540 22560 {}
C {lab_pin.sym} 2540 22560 0 0 {name=l18148 lab=WL113}
N 2640 22640 2660 22640 {}
C {lab_pin.sym} 2660 22640 0 0 {name=l18149 lab=VDD}
N 2640 22560 2660 22560 {}
C {lab_pin.sym} 2660 22560 0 0 {name=l18150 lab=VSS}
C {bitcell_6t.sym} 2800 22600 0 0 {name=Xr113c14}
N 2760 22640 2740 22640 {}
C {lab_pin.sym} 2740 22640 0 0 {name=l18151 lab=BL14}
N 2760 22600 2740 22600 {}
C {lab_pin.sym} 2740 22600 0 0 {name=l18152 lab=BLB14}
N 2760 22560 2740 22560 {}
C {lab_pin.sym} 2740 22560 0 0 {name=l18153 lab=WL113}
N 2840 22640 2860 22640 {}
C {lab_pin.sym} 2860 22640 0 0 {name=l18154 lab=VDD}
N 2840 22560 2860 22560 {}
C {lab_pin.sym} 2860 22560 0 0 {name=l18155 lab=VSS}
C {bitcell_6t.sym} 3000 22600 0 0 {name=Xr113c15}
N 2960 22640 2940 22640 {}
C {lab_pin.sym} 2940 22640 0 0 {name=l18156 lab=BL15}
N 2960 22600 2940 22600 {}
C {lab_pin.sym} 2940 22600 0 0 {name=l18157 lab=BLB15}
N 2960 22560 2940 22560 {}
C {lab_pin.sym} 2940 22560 0 0 {name=l18158 lab=WL113}
N 3040 22640 3060 22640 {}
C {lab_pin.sym} 3060 22640 0 0 {name=l18159 lab=VDD}
N 3040 22560 3060 22560 {}
C {lab_pin.sym} 3060 22560 0 0 {name=l18160 lab=VSS}
C {bitcell_6t.sym} 3200 22600 0 0 {name=Xr113c16}
N 3160 22640 3140 22640 {}
C {lab_pin.sym} 3140 22640 0 0 {name=l18161 lab=BL16}
N 3160 22600 3140 22600 {}
C {lab_pin.sym} 3140 22600 0 0 {name=l18162 lab=BLB16}
N 3160 22560 3140 22560 {}
C {lab_pin.sym} 3140 22560 0 0 {name=l18163 lab=WL113}
N 3240 22640 3260 22640 {}
C {lab_pin.sym} 3260 22640 0 0 {name=l18164 lab=VDD}
N 3240 22560 3260 22560 {}
C {lab_pin.sym} 3260 22560 0 0 {name=l18165 lab=VSS}
C {bitcell_6t.sym} 3400 22600 0 0 {name=Xr113c17}
N 3360 22640 3340 22640 {}
C {lab_pin.sym} 3340 22640 0 0 {name=l18166 lab=BL17}
N 3360 22600 3340 22600 {}
C {lab_pin.sym} 3340 22600 0 0 {name=l18167 lab=BLB17}
N 3360 22560 3340 22560 {}
C {lab_pin.sym} 3340 22560 0 0 {name=l18168 lab=WL113}
N 3440 22640 3460 22640 {}
C {lab_pin.sym} 3460 22640 0 0 {name=l18169 lab=VDD}
N 3440 22560 3460 22560 {}
C {lab_pin.sym} 3460 22560 0 0 {name=l18170 lab=VSS}
C {bitcell_6t.sym} 3600 22600 0 0 {name=Xr113c18}
N 3560 22640 3540 22640 {}
C {lab_pin.sym} 3540 22640 0 0 {name=l18171 lab=BL18}
N 3560 22600 3540 22600 {}
C {lab_pin.sym} 3540 22600 0 0 {name=l18172 lab=BLB18}
N 3560 22560 3540 22560 {}
C {lab_pin.sym} 3540 22560 0 0 {name=l18173 lab=WL113}
N 3640 22640 3660 22640 {}
C {lab_pin.sym} 3660 22640 0 0 {name=l18174 lab=VDD}
N 3640 22560 3660 22560 {}
C {lab_pin.sym} 3660 22560 0 0 {name=l18175 lab=VSS}
C {bitcell_6t.sym} 3800 22600 0 0 {name=Xr113c19}
N 3760 22640 3740 22640 {}
C {lab_pin.sym} 3740 22640 0 0 {name=l18176 lab=BL19}
N 3760 22600 3740 22600 {}
C {lab_pin.sym} 3740 22600 0 0 {name=l18177 lab=BLB19}
N 3760 22560 3740 22560 {}
C {lab_pin.sym} 3740 22560 0 0 {name=l18178 lab=WL113}
N 3840 22640 3860 22640 {}
C {lab_pin.sym} 3860 22640 0 0 {name=l18179 lab=VDD}
N 3840 22560 3860 22560 {}
C {lab_pin.sym} 3860 22560 0 0 {name=l18180 lab=VSS}
C {bitcell_6t.sym} 4000 22600 0 0 {name=Xr113c20}
N 3960 22640 3940 22640 {}
C {lab_pin.sym} 3940 22640 0 0 {name=l18181 lab=BL20}
N 3960 22600 3940 22600 {}
C {lab_pin.sym} 3940 22600 0 0 {name=l18182 lab=BLB20}
N 3960 22560 3940 22560 {}
C {lab_pin.sym} 3940 22560 0 0 {name=l18183 lab=WL113}
N 4040 22640 4060 22640 {}
C {lab_pin.sym} 4060 22640 0 0 {name=l18184 lab=VDD}
N 4040 22560 4060 22560 {}
C {lab_pin.sym} 4060 22560 0 0 {name=l18185 lab=VSS}
C {bitcell_6t.sym} 4200 22600 0 0 {name=Xr113c21}
N 4160 22640 4140 22640 {}
C {lab_pin.sym} 4140 22640 0 0 {name=l18186 lab=BL21}
N 4160 22600 4140 22600 {}
C {lab_pin.sym} 4140 22600 0 0 {name=l18187 lab=BLB21}
N 4160 22560 4140 22560 {}
C {lab_pin.sym} 4140 22560 0 0 {name=l18188 lab=WL113}
N 4240 22640 4260 22640 {}
C {lab_pin.sym} 4260 22640 0 0 {name=l18189 lab=VDD}
N 4240 22560 4260 22560 {}
C {lab_pin.sym} 4260 22560 0 0 {name=l18190 lab=VSS}
C {bitcell_6t.sym} 4400 22600 0 0 {name=Xr113c22}
N 4360 22640 4340 22640 {}
C {lab_pin.sym} 4340 22640 0 0 {name=l18191 lab=BL22}
N 4360 22600 4340 22600 {}
C {lab_pin.sym} 4340 22600 0 0 {name=l18192 lab=BLB22}
N 4360 22560 4340 22560 {}
C {lab_pin.sym} 4340 22560 0 0 {name=l18193 lab=WL113}
N 4440 22640 4460 22640 {}
C {lab_pin.sym} 4460 22640 0 0 {name=l18194 lab=VDD}
N 4440 22560 4460 22560 {}
C {lab_pin.sym} 4460 22560 0 0 {name=l18195 lab=VSS}
C {bitcell_6t.sym} 4600 22600 0 0 {name=Xr113c23}
N 4560 22640 4540 22640 {}
C {lab_pin.sym} 4540 22640 0 0 {name=l18196 lab=BL23}
N 4560 22600 4540 22600 {}
C {lab_pin.sym} 4540 22600 0 0 {name=l18197 lab=BLB23}
N 4560 22560 4540 22560 {}
C {lab_pin.sym} 4540 22560 0 0 {name=l18198 lab=WL113}
N 4640 22640 4660 22640 {}
C {lab_pin.sym} 4660 22640 0 0 {name=l18199 lab=VDD}
N 4640 22560 4660 22560 {}
C {lab_pin.sym} 4660 22560 0 0 {name=l18200 lab=VSS}
C {bitcell_6t.sym} 4800 22600 0 0 {name=Xr113c24}
N 4760 22640 4740 22640 {}
C {lab_pin.sym} 4740 22640 0 0 {name=l18201 lab=BL24}
N 4760 22600 4740 22600 {}
C {lab_pin.sym} 4740 22600 0 0 {name=l18202 lab=BLB24}
N 4760 22560 4740 22560 {}
C {lab_pin.sym} 4740 22560 0 0 {name=l18203 lab=WL113}
N 4840 22640 4860 22640 {}
C {lab_pin.sym} 4860 22640 0 0 {name=l18204 lab=VDD}
N 4840 22560 4860 22560 {}
C {lab_pin.sym} 4860 22560 0 0 {name=l18205 lab=VSS}
C {bitcell_6t.sym} 5000 22600 0 0 {name=Xr113c25}
N 4960 22640 4940 22640 {}
C {lab_pin.sym} 4940 22640 0 0 {name=l18206 lab=BL25}
N 4960 22600 4940 22600 {}
C {lab_pin.sym} 4940 22600 0 0 {name=l18207 lab=BLB25}
N 4960 22560 4940 22560 {}
C {lab_pin.sym} 4940 22560 0 0 {name=l18208 lab=WL113}
N 5040 22640 5060 22640 {}
C {lab_pin.sym} 5060 22640 0 0 {name=l18209 lab=VDD}
N 5040 22560 5060 22560 {}
C {lab_pin.sym} 5060 22560 0 0 {name=l18210 lab=VSS}
C {bitcell_6t.sym} 5200 22600 0 0 {name=Xr113c26}
N 5160 22640 5140 22640 {}
C {lab_pin.sym} 5140 22640 0 0 {name=l18211 lab=BL26}
N 5160 22600 5140 22600 {}
C {lab_pin.sym} 5140 22600 0 0 {name=l18212 lab=BLB26}
N 5160 22560 5140 22560 {}
C {lab_pin.sym} 5140 22560 0 0 {name=l18213 lab=WL113}
N 5240 22640 5260 22640 {}
C {lab_pin.sym} 5260 22640 0 0 {name=l18214 lab=VDD}
N 5240 22560 5260 22560 {}
C {lab_pin.sym} 5260 22560 0 0 {name=l18215 lab=VSS}
C {bitcell_6t.sym} 5400 22600 0 0 {name=Xr113c27}
N 5360 22640 5340 22640 {}
C {lab_pin.sym} 5340 22640 0 0 {name=l18216 lab=BL27}
N 5360 22600 5340 22600 {}
C {lab_pin.sym} 5340 22600 0 0 {name=l18217 lab=BLB27}
N 5360 22560 5340 22560 {}
C {lab_pin.sym} 5340 22560 0 0 {name=l18218 lab=WL113}
N 5440 22640 5460 22640 {}
C {lab_pin.sym} 5460 22640 0 0 {name=l18219 lab=VDD}
N 5440 22560 5460 22560 {}
C {lab_pin.sym} 5460 22560 0 0 {name=l18220 lab=VSS}
C {bitcell_6t.sym} 5600 22600 0 0 {name=Xr113c28}
N 5560 22640 5540 22640 {}
C {lab_pin.sym} 5540 22640 0 0 {name=l18221 lab=BL28}
N 5560 22600 5540 22600 {}
C {lab_pin.sym} 5540 22600 0 0 {name=l18222 lab=BLB28}
N 5560 22560 5540 22560 {}
C {lab_pin.sym} 5540 22560 0 0 {name=l18223 lab=WL113}
N 5640 22640 5660 22640 {}
C {lab_pin.sym} 5660 22640 0 0 {name=l18224 lab=VDD}
N 5640 22560 5660 22560 {}
C {lab_pin.sym} 5660 22560 0 0 {name=l18225 lab=VSS}
C {bitcell_6t.sym} 5800 22600 0 0 {name=Xr113c29}
N 5760 22640 5740 22640 {}
C {lab_pin.sym} 5740 22640 0 0 {name=l18226 lab=BL29}
N 5760 22600 5740 22600 {}
C {lab_pin.sym} 5740 22600 0 0 {name=l18227 lab=BLB29}
N 5760 22560 5740 22560 {}
C {lab_pin.sym} 5740 22560 0 0 {name=l18228 lab=WL113}
N 5840 22640 5860 22640 {}
C {lab_pin.sym} 5860 22640 0 0 {name=l18229 lab=VDD}
N 5840 22560 5860 22560 {}
C {lab_pin.sym} 5860 22560 0 0 {name=l18230 lab=VSS}
C {bitcell_6t.sym} 6000 22600 0 0 {name=Xr113c30}
N 5960 22640 5940 22640 {}
C {lab_pin.sym} 5940 22640 0 0 {name=l18231 lab=BL30}
N 5960 22600 5940 22600 {}
C {lab_pin.sym} 5940 22600 0 0 {name=l18232 lab=BLB30}
N 5960 22560 5940 22560 {}
C {lab_pin.sym} 5940 22560 0 0 {name=l18233 lab=WL113}
N 6040 22640 6060 22640 {}
C {lab_pin.sym} 6060 22640 0 0 {name=l18234 lab=VDD}
N 6040 22560 6060 22560 {}
C {lab_pin.sym} 6060 22560 0 0 {name=l18235 lab=VSS}
C {bitcell_6t.sym} 6200 22600 0 0 {name=Xr113c31}
N 6160 22640 6140 22640 {}
C {lab_pin.sym} 6140 22640 0 0 {name=l18236 lab=BL31}
N 6160 22600 6140 22600 {}
C {lab_pin.sym} 6140 22600 0 0 {name=l18237 lab=BLB31}
N 6160 22560 6140 22560 {}
C {lab_pin.sym} 6140 22560 0 0 {name=l18238 lab=WL113}
N 6240 22640 6260 22640 {}
C {lab_pin.sym} 6260 22640 0 0 {name=l18239 lab=VDD}
N 6240 22560 6260 22560 {}
C {lab_pin.sym} 6260 22560 0 0 {name=l18240 lab=VSS}
C {bitcell_6t.sym} 0 22800 0 0 {name=Xr114c0}
N -40 22840 -60 22840 {}
C {lab_pin.sym} -60 22840 0 0 {name=l18241 lab=BL0}
N -40 22800 -60 22800 {}
C {lab_pin.sym} -60 22800 0 0 {name=l18242 lab=BLB0}
