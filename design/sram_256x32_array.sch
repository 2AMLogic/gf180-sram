C {bitcell_6t.sym} 1000 39400 0 0 {name=Xr197c5}
N 960 39440 940 39440 {}
C {lab_pin.sym} 940 39440 0 0 {name=l31546 lab=BL5}
N 960 39400 940 39400 {}
C {lab_pin.sym} 940 39400 0 0 {name=l31547 lab=BLB5}
N 960 39360 940 39360 {}
C {lab_pin.sym} 940 39360 0 0 {name=l31548 lab=WL197}
N 1040 39440 1060 39440 {}
C {lab_pin.sym} 1060 39440 0 0 {name=l31549 lab=VDD}
N 1040 39360 1060 39360 {}
C {lab_pin.sym} 1060 39360 0 0 {name=l31550 lab=VSS}
C {bitcell_6t.sym} 1200 39400 0 0 {name=Xr197c6}
N 1160 39440 1140 39440 {}
C {lab_pin.sym} 1140 39440 0 0 {name=l31551 lab=BL6}
N 1160 39400 1140 39400 {}
C {lab_pin.sym} 1140 39400 0 0 {name=l31552 lab=BLB6}
N 1160 39360 1140 39360 {}
C {lab_pin.sym} 1140 39360 0 0 {name=l31553 lab=WL197}
N 1240 39440 1260 39440 {}
C {lab_pin.sym} 1260 39440 0 0 {name=l31554 lab=VDD}
N 1240 39360 1260 39360 {}
C {lab_pin.sym} 1260 39360 0 0 {name=l31555 lab=VSS}
C {bitcell_6t.sym} 1400 39400 0 0 {name=Xr197c7}
N 1360 39440 1340 39440 {}
C {lab_pin.sym} 1340 39440 0 0 {name=l31556 lab=BL7}
N 1360 39400 1340 39400 {}
C {lab_pin.sym} 1340 39400 0 0 {name=l31557 lab=BLB7}
N 1360 39360 1340 39360 {}
C {lab_pin.sym} 1340 39360 0 0 {name=l31558 lab=WL197}
N 1440 39440 1460 39440 {}
C {lab_pin.sym} 1460 39440 0 0 {name=l31559 lab=VDD}
N 1440 39360 1460 39360 {}
C {lab_pin.sym} 1460 39360 0 0 {name=l31560 lab=VSS}
C {bitcell_6t.sym} 1600 39400 0 0 {name=Xr197c8}
N 1560 39440 1540 39440 {}
C {lab_pin.sym} 1540 39440 0 0 {name=l31561 lab=BL8}
N 1560 39400 1540 39400 {}
C {lab_pin.sym} 1540 39400 0 0 {name=l31562 lab=BLB8}
N 1560 39360 1540 39360 {}
C {lab_pin.sym} 1540 39360 0 0 {name=l31563 lab=WL197}
N 1640 39440 1660 39440 {}
C {lab_pin.sym} 1660 39440 0 0 {name=l31564 lab=VDD}
N 1640 39360 1660 39360 {}
C {lab_pin.sym} 1660 39360 0 0 {name=l31565 lab=VSS}
C {bitcell_6t.sym} 1800 39400 0 0 {name=Xr197c9}
N 1760 39440 1740 39440 {}
C {lab_pin.sym} 1740 39440 0 0 {name=l31566 lab=BL9}
N 1760 39400 1740 39400 {}
C {lab_pin.sym} 1740 39400 0 0 {name=l31567 lab=BLB9}
N 1760 39360 1740 39360 {}
C {lab_pin.sym} 1740 39360 0 0 {name=l31568 lab=WL197}
N 1840 39440 1860 39440 {}
C {lab_pin.sym} 1860 39440 0 0 {name=l31569 lab=VDD}
N 1840 39360 1860 39360 {}
C {lab_pin.sym} 1860 39360 0 0 {name=l31570 lab=VSS}
C {bitcell_6t.sym} 2000 39400 0 0 {name=Xr197c10}
N 1960 39440 1940 39440 {}
C {lab_pin.sym} 1940 39440 0 0 {name=l31571 lab=BL10}
N 1960 39400 1940 39400 {}
C {lab_pin.sym} 1940 39400 0 0 {name=l31572 lab=BLB10}
N 1960 39360 1940 39360 {}
C {lab_pin.sym} 1940 39360 0 0 {name=l31573 lab=WL197}
N 2040 39440 2060 39440 {}
C {lab_pin.sym} 2060 39440 0 0 {name=l31574 lab=VDD}
N 2040 39360 2060 39360 {}
C {lab_pin.sym} 2060 39360 0 0 {name=l31575 lab=VSS}
C {bitcell_6t.sym} 2200 39400 0 0 {name=Xr197c11}
N 2160 39440 2140 39440 {}
C {lab_pin.sym} 2140 39440 0 0 {name=l31576 lab=BL11}
N 2160 39400 2140 39400 {}
C {lab_pin.sym} 2140 39400 0 0 {name=l31577 lab=BLB11}
N 2160 39360 2140 39360 {}
C {lab_pin.sym} 2140 39360 0 0 {name=l31578 lab=WL197}
N 2240 39440 2260 39440 {}
C {lab_pin.sym} 2260 39440 0 0 {name=l31579 lab=VDD}
N 2240 39360 2260 39360 {}
C {lab_pin.sym} 2260 39360 0 0 {name=l31580 lab=VSS}
C {bitcell_6t.sym} 2400 39400 0 0 {name=Xr197c12}
N 2360 39440 2340 39440 {}
C {lab_pin.sym} 2340 39440 0 0 {name=l31581 lab=BL12}
N 2360 39400 2340 39400 {}
C {lab_pin.sym} 2340 39400 0 0 {name=l31582 lab=BLB12}
N 2360 39360 2340 39360 {}
C {lab_pin.sym} 2340 39360 0 0 {name=l31583 lab=WL197}
N 2440 39440 2460 39440 {}
C {lab_pin.sym} 2460 39440 0 0 {name=l31584 lab=VDD}
N 2440 39360 2460 39360 {}
C {lab_pin.sym} 2460 39360 0 0 {name=l31585 lab=VSS}
C {bitcell_6t.sym} 2600 39400 0 0 {name=Xr197c13}
N 2560 39440 2540 39440 {}
C {lab_pin.sym} 2540 39440 0 0 {name=l31586 lab=BL13}
N 2560 39400 2540 39400 {}
C {lab_pin.sym} 2540 39400 0 0 {name=l31587 lab=BLB13}
N 2560 39360 2540 39360 {}
C {lab_pin.sym} 2540 39360 0 0 {name=l31588 lab=WL197}
N 2640 39440 2660 39440 {}
C {lab_pin.sym} 2660 39440 0 0 {name=l31589 lab=VDD}
N 2640 39360 2660 39360 {}
C {lab_pin.sym} 2660 39360 0 0 {name=l31590 lab=VSS}
C {bitcell_6t.sym} 2800 39400 0 0 {name=Xr197c14}
N 2760 39440 2740 39440 {}
C {lab_pin.sym} 2740 39440 0 0 {name=l31591 lab=BL14}
N 2760 39400 2740 39400 {}
C {lab_pin.sym} 2740 39400 0 0 {name=l31592 lab=BLB14}
N 2760 39360 2740 39360 {}
C {lab_pin.sym} 2740 39360 0 0 {name=l31593 lab=WL197}
N 2840 39440 2860 39440 {}
C {lab_pin.sym} 2860 39440 0 0 {name=l31594 lab=VDD}
N 2840 39360 2860 39360 {}
C {lab_pin.sym} 2860 39360 0 0 {name=l31595 lab=VSS}
C {bitcell_6t.sym} 3000 39400 0 0 {name=Xr197c15}
N 2960 39440 2940 39440 {}
C {lab_pin.sym} 2940 39440 0 0 {name=l31596 lab=BL15}
N 2960 39400 2940 39400 {}
C {lab_pin.sym} 2940 39400 0 0 {name=l31597 lab=BLB15}
N 2960 39360 2940 39360 {}
C {lab_pin.sym} 2940 39360 0 0 {name=l31598 lab=WL197}
N 3040 39440 3060 39440 {}
C {lab_pin.sym} 3060 39440 0 0 {name=l31599 lab=VDD}
N 3040 39360 3060 39360 {}
C {lab_pin.sym} 3060 39360 0 0 {name=l31600 lab=VSS}
C {bitcell_6t.sym} 3200 39400 0 0 {name=Xr197c16}
N 3160 39440 3140 39440 {}
C {lab_pin.sym} 3140 39440 0 0 {name=l31601 lab=BL16}
N 3160 39400 3140 39400 {}
C {lab_pin.sym} 3140 39400 0 0 {name=l31602 lab=BLB16}
N 3160 39360 3140 39360 {}
C {lab_pin.sym} 3140 39360 0 0 {name=l31603 lab=WL197}
N 3240 39440 3260 39440 {}
C {lab_pin.sym} 3260 39440 0 0 {name=l31604 lab=VDD}
N 3240 39360 3260 39360 {}
C {lab_pin.sym} 3260 39360 0 0 {name=l31605 lab=VSS}
C {bitcell_6t.sym} 3400 39400 0 0 {name=Xr197c17}
N 3360 39440 3340 39440 {}
C {lab_pin.sym} 3340 39440 0 0 {name=l31606 lab=BL17}
N 3360 39400 3340 39400 {}
C {lab_pin.sym} 3340 39400 0 0 {name=l31607 lab=BLB17}
N 3360 39360 3340 39360 {}
C {lab_pin.sym} 3340 39360 0 0 {name=l31608 lab=WL197}
N 3440 39440 3460 39440 {}
C {lab_pin.sym} 3460 39440 0 0 {name=l31609 lab=VDD}
N 3440 39360 3460 39360 {}
C {lab_pin.sym} 3460 39360 0 0 {name=l31610 lab=VSS}
C {bitcell_6t.sym} 3600 39400 0 0 {name=Xr197c18}
N 3560 39440 3540 39440 {}
C {lab_pin.sym} 3540 39440 0 0 {name=l31611 lab=BL18}
N 3560 39400 3540 39400 {}
C {lab_pin.sym} 3540 39400 0 0 {name=l31612 lab=BLB18}
N 3560 39360 3540 39360 {}
C {lab_pin.sym} 3540 39360 0 0 {name=l31613 lab=WL197}
N 3640 39440 3660 39440 {}
C {lab_pin.sym} 3660 39440 0 0 {name=l31614 lab=VDD}
N 3640 39360 3660 39360 {}
C {lab_pin.sym} 3660 39360 0 0 {name=l31615 lab=VSS}
C {bitcell_6t.sym} 3800 39400 0 0 {name=Xr197c19}
N 3760 39440 3740 39440 {}
C {lab_pin.sym} 3740 39440 0 0 {name=l31616 lab=BL19}
N 3760 39400 3740 39400 {}
C {lab_pin.sym} 3740 39400 0 0 {name=l31617 lab=BLB19}
N 3760 39360 3740 39360 {}
C {lab_pin.sym} 3740 39360 0 0 {name=l31618 lab=WL197}
N 3840 39440 3860 39440 {}
C {lab_pin.sym} 3860 39440 0 0 {name=l31619 lab=VDD}
N 3840 39360 3860 39360 {}
C {lab_pin.sym} 3860 39360 0 0 {name=l31620 lab=VSS}
C {bitcell_6t.sym} 4000 39400 0 0 {name=Xr197c20}
N 3960 39440 3940 39440 {}
C {lab_pin.sym} 3940 39440 0 0 {name=l31621 lab=BL20}
N 3960 39400 3940 39400 {}
C {lab_pin.sym} 3940 39400 0 0 {name=l31622 lab=BLB20}
N 3960 39360 3940 39360 {}
C {lab_pin.sym} 3940 39360 0 0 {name=l31623 lab=WL197}
N 4040 39440 4060 39440 {}
C {lab_pin.sym} 4060 39440 0 0 {name=l31624 lab=VDD}
N 4040 39360 4060 39360 {}
C {lab_pin.sym} 4060 39360 0 0 {name=l31625 lab=VSS}
C {bitcell_6t.sym} 4200 39400 0 0 {name=Xr197c21}
N 4160 39440 4140 39440 {}
C {lab_pin.sym} 4140 39440 0 0 {name=l31626 lab=BL21}
N 4160 39400 4140 39400 {}
C {lab_pin.sym} 4140 39400 0 0 {name=l31627 lab=BLB21}
N 4160 39360 4140 39360 {}
C {lab_pin.sym} 4140 39360 0 0 {name=l31628 lab=WL197}
N 4240 39440 4260 39440 {}
C {lab_pin.sym} 4260 39440 0 0 {name=l31629 lab=VDD}
N 4240 39360 4260 39360 {}
C {lab_pin.sym} 4260 39360 0 0 {name=l31630 lab=VSS}
C {bitcell_6t.sym} 4400 39400 0 0 {name=Xr197c22}
N 4360 39440 4340 39440 {}
C {lab_pin.sym} 4340 39440 0 0 {name=l31631 lab=BL22}
N 4360 39400 4340 39400 {}
C {lab_pin.sym} 4340 39400 0 0 {name=l31632 lab=BLB22}
N 4360 39360 4340 39360 {}
C {lab_pin.sym} 4340 39360 0 0 {name=l31633 lab=WL197}
N 4440 39440 4460 39440 {}
C {lab_pin.sym} 4460 39440 0 0 {name=l31634 lab=VDD}
N 4440 39360 4460 39360 {}
C {lab_pin.sym} 4460 39360 0 0 {name=l31635 lab=VSS}
C {bitcell_6t.sym} 4600 39400 0 0 {name=Xr197c23}
N 4560 39440 4540 39440 {}
C {lab_pin.sym} 4540 39440 0 0 {name=l31636 lab=BL23}
N 4560 39400 4540 39400 {}
C {lab_pin.sym} 4540 39400 0 0 {name=l31637 lab=BLB23}
N 4560 39360 4540 39360 {}
C {lab_pin.sym} 4540 39360 0 0 {name=l31638 lab=WL197}
N 4640 39440 4660 39440 {}
C {lab_pin.sym} 4660 39440 0 0 {name=l31639 lab=VDD}
N 4640 39360 4660 39360 {}
C {lab_pin.sym} 4660 39360 0 0 {name=l31640 lab=VSS}
C {bitcell_6t.sym} 4800 39400 0 0 {name=Xr197c24}
N 4760 39440 4740 39440 {}
C {lab_pin.sym} 4740 39440 0 0 {name=l31641 lab=BL24}
N 4760 39400 4740 39400 {}
C {lab_pin.sym} 4740 39400 0 0 {name=l31642 lab=BLB24}
N 4760 39360 4740 39360 {}
C {lab_pin.sym} 4740 39360 0 0 {name=l31643 lab=WL197}
N 4840 39440 4860 39440 {}
C {lab_pin.sym} 4860 39440 0 0 {name=l31644 lab=VDD}
N 4840 39360 4860 39360 {}
C {lab_pin.sym} 4860 39360 0 0 {name=l31645 lab=VSS}
C {bitcell_6t.sym} 5000 39400 0 0 {name=Xr197c25}
N 4960 39440 4940 39440 {}
C {lab_pin.sym} 4940 39440 0 0 {name=l31646 lab=BL25}
N 4960 39400 4940 39400 {}
C {lab_pin.sym} 4940 39400 0 0 {name=l31647 lab=BLB25}
N 4960 39360 4940 39360 {}
C {lab_pin.sym} 4940 39360 0 0 {name=l31648 lab=WL197}
N 5040 39440 5060 39440 {}
C {lab_pin.sym} 5060 39440 0 0 {name=l31649 lab=VDD}
N 5040 39360 5060 39360 {}
C {lab_pin.sym} 5060 39360 0 0 {name=l31650 lab=VSS}
C {bitcell_6t.sym} 5200 39400 0 0 {name=Xr197c26}
N 5160 39440 5140 39440 {}
C {lab_pin.sym} 5140 39440 0 0 {name=l31651 lab=BL26}
N 5160 39400 5140 39400 {}
C {lab_pin.sym} 5140 39400 0 0 {name=l31652 lab=BLB26}
N 5160 39360 5140 39360 {}
C {lab_pin.sym} 5140 39360 0 0 {name=l31653 lab=WL197}
N 5240 39440 5260 39440 {}
C {lab_pin.sym} 5260 39440 0 0 {name=l31654 lab=VDD}
N 5240 39360 5260 39360 {}
C {lab_pin.sym} 5260 39360 0 0 {name=l31655 lab=VSS}
C {bitcell_6t.sym} 5400 39400 0 0 {name=Xr197c27}
N 5360 39440 5340 39440 {}
C {lab_pin.sym} 5340 39440 0 0 {name=l31656 lab=BL27}
N 5360 39400 5340 39400 {}
C {lab_pin.sym} 5340 39400 0 0 {name=l31657 lab=BLB27}
N 5360 39360 5340 39360 {}
C {lab_pin.sym} 5340 39360 0 0 {name=l31658 lab=WL197}
N 5440 39440 5460 39440 {}
C {lab_pin.sym} 5460 39440 0 0 {name=l31659 lab=VDD}
N 5440 39360 5460 39360 {}
C {lab_pin.sym} 5460 39360 0 0 {name=l31660 lab=VSS}
C {bitcell_6t.sym} 5600 39400 0 0 {name=Xr197c28}
N 5560 39440 5540 39440 {}
C {lab_pin.sym} 5540 39440 0 0 {name=l31661 lab=BL28}
N 5560 39400 5540 39400 {}
C {lab_pin.sym} 5540 39400 0 0 {name=l31662 lab=BLB28}
N 5560 39360 5540 39360 {}
C {lab_pin.sym} 5540 39360 0 0 {name=l31663 lab=WL197}
N 5640 39440 5660 39440 {}
C {lab_pin.sym} 5660 39440 0 0 {name=l31664 lab=VDD}
N 5640 39360 5660 39360 {}
C {lab_pin.sym} 5660 39360 0 0 {name=l31665 lab=VSS}
C {bitcell_6t.sym} 5800 39400 0 0 {name=Xr197c29}
N 5760 39440 5740 39440 {}
C {lab_pin.sym} 5740 39440 0 0 {name=l31666 lab=BL29}
N 5760 39400 5740 39400 {}
C {lab_pin.sym} 5740 39400 0 0 {name=l31667 lab=BLB29}
N 5760 39360 5740 39360 {}
C {lab_pin.sym} 5740 39360 0 0 {name=l31668 lab=WL197}
N 5840 39440 5860 39440 {}
C {lab_pin.sym} 5860 39440 0 0 {name=l31669 lab=VDD}
N 5840 39360 5860 39360 {}
C {lab_pin.sym} 5860 39360 0 0 {name=l31670 lab=VSS}
C {bitcell_6t.sym} 6000 39400 0 0 {name=Xr197c30}
N 5960 39440 5940 39440 {}
C {lab_pin.sym} 5940 39440 0 0 {name=l31671 lab=BL30}
N 5960 39400 5940 39400 {}
C {lab_pin.sym} 5940 39400 0 0 {name=l31672 lab=BLB30}
N 5960 39360 5940 39360 {}
C {lab_pin.sym} 5940 39360 0 0 {name=l31673 lab=WL197}
N 6040 39440 6060 39440 {}
C {lab_pin.sym} 6060 39440 0 0 {name=l31674 lab=VDD}
N 6040 39360 6060 39360 {}
C {lab_pin.sym} 6060 39360 0 0 {name=l31675 lab=VSS}
C {bitcell_6t.sym} 6200 39400 0 0 {name=Xr197c31}
N 6160 39440 6140 39440 {}
C {lab_pin.sym} 6140 39440 0 0 {name=l31676 lab=BL31}
N 6160 39400 6140 39400 {}
C {lab_pin.sym} 6140 39400 0 0 {name=l31677 lab=BLB31}
N 6160 39360 6140 39360 {}
C {lab_pin.sym} 6140 39360 0 0 {name=l31678 lab=WL197}
N 6240 39440 6260 39440 {}
C {lab_pin.sym} 6260 39440 0 0 {name=l31679 lab=VDD}
N 6240 39360 6260 39360 {}
C {lab_pin.sym} 6260 39360 0 0 {name=l31680 lab=VSS}
C {bitcell_6t.sym} 0 39600 0 0 {name=Xr198c0}
N -40 39640 -60 39640 {}
C {lab_pin.sym} -60 39640 0 0 {name=l31681 lab=BL0}
N -40 39600 -60 39600 {}
C {lab_pin.sym} -60 39600 0 0 {name=l31682 lab=BLB0}
N -40 39560 -60 39560 {}
C {lab_pin.sym} -60 39560 0 0 {name=l31683 lab=WL198}
N 40 39640 60 39640 {}
C {lab_pin.sym} 60 39640 0 0 {name=l31684 lab=VDD}
N 40 39560 60 39560 {}
C {lab_pin.sym} 60 39560 0 0 {name=l31685 lab=VSS}
C {bitcell_6t.sym} 200 39600 0 0 {name=Xr198c1}
N 160 39640 140 39640 {}
C {lab_pin.sym} 140 39640 0 0 {name=l31686 lab=BL1}
N 160 39600 140 39600 {}
C {lab_pin.sym} 140 39600 0 0 {name=l31687 lab=BLB1}
N 160 39560 140 39560 {}
C {lab_pin.sym} 140 39560 0 0 {name=l31688 lab=WL198}
N 240 39640 260 39640 {}
C {lab_pin.sym} 260 39640 0 0 {name=l31689 lab=VDD}
N 240 39560 260 39560 {}
C {lab_pin.sym} 260 39560 0 0 {name=l31690 lab=VSS}
C {bitcell_6t.sym} 400 39600 0 0 {name=Xr198c2}
N 360 39640 340 39640 {}
C {lab_pin.sym} 340 39640 0 0 {name=l31691 lab=BL2}
N 360 39600 340 39600 {}
C {lab_pin.sym} 340 39600 0 0 {name=l31692 lab=BLB2}
N 360 39560 340 39560 {}
C {lab_pin.sym} 340 39560 0 0 {name=l31693 lab=WL198}
N 440 39640 460 39640 {}
C {lab_pin.sym} 460 39640 0 0 {name=l31694 lab=VDD}
N 440 39560 460 39560 {}
C {lab_pin.sym} 460 39560 0 0 {name=l31695 lab=VSS}
C {bitcell_6t.sym} 600 39600 0 0 {name=Xr198c3}
N 560 39640 540 39640 {}
C {lab_pin.sym} 540 39640 0 0 {name=l31696 lab=BL3}
N 560 39600 540 39600 {}
C {lab_pin.sym} 540 39600 0 0 {name=l31697 lab=BLB3}
N 560 39560 540 39560 {}
C {lab_pin.sym} 540 39560 0 0 {name=l31698 lab=WL198}
N 640 39640 660 39640 {}
C {lab_pin.sym} 660 39640 0 0 {name=l31699 lab=VDD}
N 640 39560 660 39560 {}
C {lab_pin.sym} 660 39560 0 0 {name=l31700 lab=VSS}
C {bitcell_6t.sym} 800 39600 0 0 {name=Xr198c4}
N 760 39640 740 39640 {}
C {lab_pin.sym} 740 39640 0 0 {name=l31701 lab=BL4}
N 760 39600 740 39600 {}
C {lab_pin.sym} 740 39600 0 0 {name=l31702 lab=BLB4}
N 760 39560 740 39560 {}
C {lab_pin.sym} 740 39560 0 0 {name=l31703 lab=WL198}
N 840 39640 860 39640 {}
C {lab_pin.sym} 860 39640 0 0 {name=l31704 lab=VDD}
N 840 39560 860 39560 {}
C {lab_pin.sym} 860 39560 0 0 {name=l31705 lab=VSS}
C {bitcell_6t.sym} 1000 39600 0 0 {name=Xr198c5}
N 960 39640 940 39640 {}
C {lab_pin.sym} 940 39640 0 0 {name=l31706 lab=BL5}
N 960 39600 940 39600 {}
C {lab_pin.sym} 940 39600 0 0 {name=l31707 lab=BLB5}
N 960 39560 940 39560 {}
C {lab_pin.sym} 940 39560 0 0 {name=l31708 lab=WL198}
N 1040 39640 1060 39640 {}
C {lab_pin.sym} 1060 39640 0 0 {name=l31709 lab=VDD}
N 1040 39560 1060 39560 {}
C {lab_pin.sym} 1060 39560 0 0 {name=l31710 lab=VSS}
C {bitcell_6t.sym} 1200 39600 0 0 {name=Xr198c6}
N 1160 39640 1140 39640 {}
C {lab_pin.sym} 1140 39640 0 0 {name=l31711 lab=BL6}
N 1160 39600 1140 39600 {}
C {lab_pin.sym} 1140 39600 0 0 {name=l31712 lab=BLB6}
N 1160 39560 1140 39560 {}
C {lab_pin.sym} 1140 39560 0 0 {name=l31713 lab=WL198}
N 1240 39640 1260 39640 {}
C {lab_pin.sym} 1260 39640 0 0 {name=l31714 lab=VDD}
N 1240 39560 1260 39560 {}
C {lab_pin.sym} 1260 39560 0 0 {name=l31715 lab=VSS}
C {bitcell_6t.sym} 1400 39600 0 0 {name=Xr198c7}
N 1360 39640 1340 39640 {}
C {lab_pin.sym} 1340 39640 0 0 {name=l31716 lab=BL7}
N 1360 39600 1340 39600 {}
C {lab_pin.sym} 1340 39600 0 0 {name=l31717 lab=BLB7}
N 1360 39560 1340 39560 {}
C {lab_pin.sym} 1340 39560 0 0 {name=l31718 lab=WL198}
N 1440 39640 1460 39640 {}
C {lab_pin.sym} 1460 39640 0 0 {name=l31719 lab=VDD}
N 1440 39560 1460 39560 {}
C {lab_pin.sym} 1460 39560 0 0 {name=l31720 lab=VSS}
C {bitcell_6t.sym} 1600 39600 0 0 {name=Xr198c8}
N 1560 39640 1540 39640 {}
C {lab_pin.sym} 1540 39640 0 0 {name=l31721 lab=BL8}
N 1560 39600 1540 39600 {}
C {lab_pin.sym} 1540 39600 0 0 {name=l31722 lab=BLB8}
N 1560 39560 1540 39560 {}
C {lab_pin.sym} 1540 39560 0 0 {name=l31723 lab=WL198}
N 1640 39640 1660 39640 {}
C {lab_pin.sym} 1660 39640 0 0 {name=l31724 lab=VDD}
N 1640 39560 1660 39560 {}
C {lab_pin.sym} 1660 39560 0 0 {name=l31725 lab=VSS}
C {bitcell_6t.sym} 1800 39600 0 0 {name=Xr198c9}
N 1760 39640 1740 39640 {}
C {lab_pin.sym} 1740 39640 0 0 {name=l31726 lab=BL9}
N 1760 39600 1740 39600 {}
C {lab_pin.sym} 1740 39600 0 0 {name=l31727 lab=BLB9}
N 1760 39560 1740 39560 {}
C {lab_pin.sym} 1740 39560 0 0 {name=l31728 lab=WL198}
N 1840 39640 1860 39640 {}
C {lab_pin.sym} 1860 39640 0 0 {name=l31729 lab=VDD}
N 1840 39560 1860 39560 {}
C {lab_pin.sym} 1860 39560 0 0 {name=l31730 lab=VSS}
C {bitcell_6t.sym} 2000 39600 0 0 {name=Xr198c10}
N 1960 39640 1940 39640 {}
C {lab_pin.sym} 1940 39640 0 0 {name=l31731 lab=BL10}
N 1960 39600 1940 39600 {}
C {lab_pin.sym} 1940 39600 0 0 {name=l31732 lab=BLB10}
N 1960 39560 1940 39560 {}
C {lab_pin.sym} 1940 39560 0 0 {name=l31733 lab=WL198}
N 2040 39640 2060 39640 {}
C {lab_pin.sym} 2060 39640 0 0 {name=l31734 lab=VDD}
N 2040 39560 2060 39560 {}
C {lab_pin.sym} 2060 39560 0 0 {name=l31735 lab=VSS}
C {bitcell_6t.sym} 2200 39600 0 0 {name=Xr198c11}
N 2160 39640 2140 39640 {}
C {lab_pin.sym} 2140 39640 0 0 {name=l31736 lab=BL11}
N 2160 39600 2140 39600 {}
C {lab_pin.sym} 2140 39600 0 0 {name=l31737 lab=BLB11}
N 2160 39560 2140 39560 {}
C {lab_pin.sym} 2140 39560 0 0 {name=l31738 lab=WL198}
N 2240 39640 2260 39640 {}
C {lab_pin.sym} 2260 39640 0 0 {name=l31739 lab=VDD}
N 2240 39560 2260 39560 {}
C {lab_pin.sym} 2260 39560 0 0 {name=l31740 lab=VSS}
C {bitcell_6t.sym} 2400 39600 0 0 {name=Xr198c12}
N 2360 39640 2340 39640 {}
C {lab_pin.sym} 2340 39640 0 0 {name=l31741 lab=BL12}
N 2360 39600 2340 39600 {}
C {lab_pin.sym} 2340 39600 0 0 {name=l31742 lab=BLB12}
N 2360 39560 2340 39560 {}
C {lab_pin.sym} 2340 39560 0 0 {name=l31743 lab=WL198}
N 2440 39640 2460 39640 {}
C {lab_pin.sym} 2460 39640 0 0 {name=l31744 lab=VDD}
N 2440 39560 2460 39560 {}
C {lab_pin.sym} 2460 39560 0 0 {name=l31745 lab=VSS}
C {bitcell_6t.sym} 2600 39600 0 0 {name=Xr198c13}
N 2560 39640 2540 39640 {}
C {lab_pin.sym} 2540 39640 0 0 {name=l31746 lab=BL13}
N 2560 39600 2540 39600 {}
C {lab_pin.sym} 2540 39600 0 0 {name=l31747 lab=BLB13}
N 2560 39560 2540 39560 {}
C {lab_pin.sym} 2540 39560 0 0 {name=l31748 lab=WL198}
N 2640 39640 2660 39640 {}
C {lab_pin.sym} 2660 39640 0 0 {name=l31749 lab=VDD}
N 2640 39560 2660 39560 {}
C {lab_pin.sym} 2660 39560 0 0 {name=l31750 lab=VSS}
C {bitcell_6t.sym} 2800 39600 0 0 {name=Xr198c14}
N 2760 39640 2740 39640 {}
C {lab_pin.sym} 2740 39640 0 0 {name=l31751 lab=BL14}
N 2760 39600 2740 39600 {}
C {lab_pin.sym} 2740 39600 0 0 {name=l31752 lab=BLB14}
N 2760 39560 2740 39560 {}
C {lab_pin.sym} 2740 39560 0 0 {name=l31753 lab=WL198}
N 2840 39640 2860 39640 {}
C {lab_pin.sym} 2860 39640 0 0 {name=l31754 lab=VDD}
N 2840 39560 2860 39560 {}
C {lab_pin.sym} 2860 39560 0 0 {name=l31755 lab=VSS}
C {bitcell_6t.sym} 3000 39600 0 0 {name=Xr198c15}
N 2960 39640 2940 39640 {}
C {lab_pin.sym} 2940 39640 0 0 {name=l31756 lab=BL15}
N 2960 39600 2940 39600 {}
C {lab_pin.sym} 2940 39600 0 0 {name=l31757 lab=BLB15}
N 2960 39560 2940 39560 {}
C {lab_pin.sym} 2940 39560 0 0 {name=l31758 lab=WL198}
N 3040 39640 3060 39640 {}
C {lab_pin.sym} 3060 39640 0 0 {name=l31759 lab=VDD}
N 3040 39560 3060 39560 {}
C {lab_pin.sym} 3060 39560 0 0 {name=l31760 lab=VSS}
C {bitcell_6t.sym} 3200 39600 0 0 {name=Xr198c16}
N 3160 39640 3140 39640 {}
C {lab_pin.sym} 3140 39640 0 0 {name=l31761 lab=BL16}
N 3160 39600 3140 39600 {}
C {lab_pin.sym} 3140 39600 0 0 {name=l31762 lab=BLB16}
N 3160 39560 3140 39560 {}
C {lab_pin.sym} 3140 39560 0 0 {name=l31763 lab=WL198}
N 3240 39640 3260 39640 {}
C {lab_pin.sym} 3260 39640 0 0 {name=l31764 lab=VDD}
N 3240 39560 3260 39560 {}
C {lab_pin.sym} 3260 39560 0 0 {name=l31765 lab=VSS}
C {bitcell_6t.sym} 3400 39600 0 0 {name=Xr198c17}
N 3360 39640 3340 39640 {}
C {lab_pin.sym} 3340 39640 0 0 {name=l31766 lab=BL17}
N 3360 39600 3340 39600 {}
C {lab_pin.sym} 3340 39600 0 0 {name=l31767 lab=BLB17}
N 3360 39560 3340 39560 {}
C {lab_pin.sym} 3340 39560 0 0 {name=l31768 lab=WL198}
N 3440 39640 3460 39640 {}
C {lab_pin.sym} 3460 39640 0 0 {name=l31769 lab=VDD}
N 3440 39560 3460 39560 {}
C {lab_pin.sym} 3460 39560 0 0 {name=l31770 lab=VSS}
C {bitcell_6t.sym} 3600 39600 0 0 {name=Xr198c18}
N 3560 39640 3540 39640 {}
C {lab_pin.sym} 3540 39640 0 0 {name=l31771 lab=BL18}
N 3560 39600 3540 39600 {}
C {lab_pin.sym} 3540 39600 0 0 {name=l31772 lab=BLB18}
N 3560 39560 3540 39560 {}
C {lab_pin.sym} 3540 39560 0 0 {name=l31773 lab=WL198}
N 3640 39640 3660 39640 {}
C {lab_pin.sym} 3660 39640 0 0 {name=l31774 lab=VDD}
N 3640 39560 3660 39560 {}
C {lab_pin.sym} 3660 39560 0 0 {name=l31775 lab=VSS}
C {bitcell_6t.sym} 3800 39600 0 0 {name=Xr198c19}
N 3760 39640 3740 39640 {}
C {lab_pin.sym} 3740 39640 0 0 {name=l31776 lab=BL19}
N 3760 39600 3740 39600 {}
C {lab_pin.sym} 3740 39600 0 0 {name=l31777 lab=BLB19}
N 3760 39560 3740 39560 {}
C {lab_pin.sym} 3740 39560 0 0 {name=l31778 lab=WL198}
N 3840 39640 3860 39640 {}
C {lab_pin.sym} 3860 39640 0 0 {name=l31779 lab=VDD}
N 3840 39560 3860 39560 {}
C {lab_pin.sym} 3860 39560 0 0 {name=l31780 lab=VSS}
C {bitcell_6t.sym} 4000 39600 0 0 {name=Xr198c20}
N 3960 39640 3940 39640 {}
C {lab_pin.sym} 3940 39640 0 0 {name=l31781 lab=BL20}
N 3960 39600 3940 39600 {}
C {lab_pin.sym} 3940 39600 0 0 {name=l31782 lab=BLB20}
N 3960 39560 3940 39560 {}
C {lab_pin.sym} 3940 39560 0 0 {name=l31783 lab=WL198}
N 4040 39640 4060 39640 {}
C {lab_pin.sym} 4060 39640 0 0 {name=l31784 lab=VDD}
N 4040 39560 4060 39560 {}
C {lab_pin.sym} 4060 39560 0 0 {name=l31785 lab=VSS}
C {bitcell_6t.sym} 4200 39600 0 0 {name=Xr198c21}
N 4160 39640 4140 39640 {}
C {lab_pin.sym} 4140 39640 0 0 {name=l31786 lab=BL21}
N 4160 39600 4140 39600 {}
C {lab_pin.sym} 4140 39600 0 0 {name=l31787 lab=BLB21}
N 4160 39560 4140 39560 {}
C {lab_pin.sym} 4140 39560 0 0 {name=l31788 lab=WL198}
N 4240 39640 4260 39640 {}
C {lab_pin.sym} 4260 39640 0 0 {name=l31789 lab=VDD}
N 4240 39560 4260 39560 {}
C {lab_pin.sym} 4260 39560 0 0 {name=l31790 lab=VSS}
C {bitcell_6t.sym} 4400 39600 0 0 {name=Xr198c22}
N 4360 39640 4340 39640 {}
C {lab_pin.sym} 4340 39640 0 0 {name=l31791 lab=BL22}
N 4360 39600 4340 39600 {}
C {lab_pin.sym} 4340 39600 0 0 {name=l31792 lab=BLB22}
N 4360 39560 4340 39560 {}
C {lab_pin.sym} 4340 39560 0 0 {name=l31793 lab=WL198}
N 4440 39640 4460 39640 {}
C {lab_pin.sym} 4460 39640 0 0 {name=l31794 lab=VDD}
N 4440 39560 4460 39560 {}
C {lab_pin.sym} 4460 39560 0 0 {name=l31795 lab=VSS}
C {bitcell_6t.sym} 4600 39600 0 0 {name=Xr198c23}
N 4560 39640 4540 39640 {}
C {lab_pin.sym} 4540 39640 0 0 {name=l31796 lab=BL23}
N 4560 39600 4540 39600 {}
C {lab_pin.sym} 4540 39600 0 0 {name=l31797 lab=BLB23}
N 4560 39560 4540 39560 {}
C {lab_pin.sym} 4540 39560 0 0 {name=l31798 lab=WL198}
N 4640 39640 4660 39640 {}
C {lab_pin.sym} 4660 39640 0 0 {name=l31799 lab=VDD}
N 4640 39560 4660 39560 {}
C {lab_pin.sym} 4660 39560 0 0 {name=l31800 lab=VSS}
C {bitcell_6t.sym} 4800 39600 0 0 {name=Xr198c24}
N 4760 39640 4740 39640 {}
C {lab_pin.sym} 4740 39640 0 0 {name=l31801 lab=BL24}
N 4760 39600 4740 39600 {}
C {lab_pin.sym} 4740 39600 0 0 {name=l31802 lab=BLB24}
N 4760 39560 4740 39560 {}
C {lab_pin.sym} 4740 39560 0 0 {name=l31803 lab=WL198}
N 4840 39640 4860 39640 {}
C {lab_pin.sym} 4860 39640 0 0 {name=l31804 lab=VDD}
N 4840 39560 4860 39560 {}
C {lab_pin.sym} 4860 39560 0 0 {name=l31805 lab=VSS}
C {bitcell_6t.sym} 5000 39600 0 0 {name=Xr198c25}
N 4960 39640 4940 39640 {}
C {lab_pin.sym} 4940 39640 0 0 {name=l31806 lab=BL25}
N 4960 39600 4940 39600 {}
C {lab_pin.sym} 4940 39600 0 0 {name=l31807 lab=BLB25}
N 4960 39560 4940 39560 {}
C {lab_pin.sym} 4940 39560 0 0 {name=l31808 lab=WL198}
N 5040 39640 5060 39640 {}
C {lab_pin.sym} 5060 39640 0 0 {name=l31809 lab=VDD}
N 5040 39560 5060 39560 {}
C {lab_pin.sym} 5060 39560 0 0 {name=l31810 lab=VSS}
C {bitcell_6t.sym} 5200 39600 0 0 {name=Xr198c26}
N 5160 39640 5140 39640 {}
C {lab_pin.sym} 5140 39640 0 0 {name=l31811 lab=BL26}
N 5160 39600 5140 39600 {}
C {lab_pin.sym} 5140 39600 0 0 {name=l31812 lab=BLB26}
N 5160 39560 5140 39560 {}
C {lab_pin.sym} 5140 39560 0 0 {name=l31813 lab=WL198}
N 5240 39640 5260 39640 {}
C {lab_pin.sym} 5260 39640 0 0 {name=l31814 lab=VDD}
N 5240 39560 5260 39560 {}
C {lab_pin.sym} 5260 39560 0 0 {name=l31815 lab=VSS}
C {bitcell_6t.sym} 5400 39600 0 0 {name=Xr198c27}
N 5360 39640 5340 39640 {}
C {lab_pin.sym} 5340 39640 0 0 {name=l31816 lab=BL27}
N 5360 39600 5340 39600 {}
C {lab_pin.sym} 5340 39600 0 0 {name=l31817 lab=BLB27}
N 5360 39560 5340 39560 {}
C {lab_pin.sym} 5340 39560 0 0 {name=l31818 lab=WL198}
N 5440 39640 5460 39640 {}
C {lab_pin.sym} 5460 39640 0 0 {name=l31819 lab=VDD}
N 5440 39560 5460 39560 {}
C {lab_pin.sym} 5460 39560 0 0 {name=l31820 lab=VSS}
C {bitcell_6t.sym} 5600 39600 0 0 {name=Xr198c28}
N 5560 39640 5540 39640 {}
C {lab_pin.sym} 5540 39640 0 0 {name=l31821 lab=BL28}
N 5560 39600 5540 39600 {}
C {lab_pin.sym} 5540 39600 0 0 {name=l31822 lab=BLB28}
N 5560 39560 5540 39560 {}
C {lab_pin.sym} 5540 39560 0 0 {name=l31823 lab=WL198}
N 5640 39640 5660 39640 {}
C {lab_pin.sym} 5660 39640 0 0 {name=l31824 lab=VDD}
N 5640 39560 5660 39560 {}
C {lab_pin.sym} 5660 39560 0 0 {name=l31825 lab=VSS}
C {bitcell_6t.sym} 5800 39600 0 0 {name=Xr198c29}
N 5760 39640 5740 39640 {}
C {lab_pin.sym} 5740 39640 0 0 {name=l31826 lab=BL29}
N 5760 39600 5740 39600 {}
C {lab_pin.sym} 5740 39600 0 0 {name=l31827 lab=BLB29}
N 5760 39560 5740 39560 {}
C {lab_pin.sym} 5740 39560 0 0 {name=l31828 lab=WL198}
N 5840 39640 5860 39640 {}
C {lab_pin.sym} 5860 39640 0 0 {name=l31829 lab=VDD}
N 5840 39560 5860 39560 {}
C {lab_pin.sym} 5860 39560 0 0 {name=l31830 lab=VSS}
C {bitcell_6t.sym} 6000 39600 0 0 {name=Xr198c30}
N 5960 39640 5940 39640 {}
C {lab_pin.sym} 5940 39640 0 0 {name=l31831 lab=BL30}
N 5960 39600 5940 39600 {}
C {lab_pin.sym} 5940 39600 0 0 {name=l31832 lab=BLB30}
N 5960 39560 5940 39560 {}
C {lab_pin.sym} 5940 39560 0 0 {name=l31833 lab=WL198}
N 6040 39640 6060 39640 {}
C {lab_pin.sym} 6060 39640 0 0 {name=l31834 lab=VDD}
N 6040 39560 6060 39560 {}
C {lab_pin.sym} 6060 39560 0 0 {name=l31835 lab=VSS}
C {bitcell_6t.sym} 6200 39600 0 0 {name=Xr198c31}
N 6160 39640 6140 39640 {}
C {lab_pin.sym} 6140 39640 0 0 {name=l31836 lab=BL31}
N 6160 39600 6140 39600 {}
C {lab_pin.sym} 6140 39600 0 0 {name=l31837 lab=BLB31}
N 6160 39560 6140 39560 {}
C {lab_pin.sym} 6140 39560 0 0 {name=l31838 lab=WL198}
N 6240 39640 6260 39640 {}
C {lab_pin.sym} 6260 39640 0 0 {name=l31839 lab=VDD}
N 6240 39560 6260 39560 {}
C {lab_pin.sym} 6260 39560 0 0 {name=l31840 lab=VSS}
C {bitcell_6t.sym} 0 39800 0 0 {name=Xr199c0}
N -40 39840 -60 39840 {}
C {lab_pin.sym} -60 39840 0 0 {name=l31841 lab=BL0}
N -40 39800 -60 39800 {}
C {lab_pin.sym} -60 39800 0 0 {name=l31842 lab=BLB0}
N -40 39760 -60 39760 {}
C {lab_pin.sym} -60 39760 0 0 {name=l31843 lab=WL199}
N 40 39840 60 39840 {}
C {lab_pin.sym} 60 39840 0 0 {name=l31844 lab=VDD}
N 40 39760 60 39760 {}
C {lab_pin.sym} 60 39760 0 0 {name=l31845 lab=VSS}
C {bitcell_6t.sym} 200 39800 0 0 {name=Xr199c1}
N 160 39840 140 39840 {}
C {lab_pin.sym} 140 39840 0 0 {name=l31846 lab=BL1}
N 160 39800 140 39800 {}
C {lab_pin.sym} 140 39800 0 0 {name=l31847 lab=BLB1}
N 160 39760 140 39760 {}
C {lab_pin.sym} 140 39760 0 0 {name=l31848 lab=WL199}
N 240 39840 260 39840 {}
C {lab_pin.sym} 260 39840 0 0 {name=l31849 lab=VDD}
N 240 39760 260 39760 {}
C {lab_pin.sym} 260 39760 0 0 {name=l31850 lab=VSS}
C {bitcell_6t.sym} 400 39800 0 0 {name=Xr199c2}
N 360 39840 340 39840 {}
C {lab_pin.sym} 340 39840 0 0 {name=l31851 lab=BL2}
N 360 39800 340 39800 {}
C {lab_pin.sym} 340 39800 0 0 {name=l31852 lab=BLB2}
N 360 39760 340 39760 {}
C {lab_pin.sym} 340 39760 0 0 {name=l31853 lab=WL199}
N 440 39840 460 39840 {}
C {lab_pin.sym} 460 39840 0 0 {name=l31854 lab=VDD}
N 440 39760 460 39760 {}
C {lab_pin.sym} 460 39760 0 0 {name=l31855 lab=VSS}
C {bitcell_6t.sym} 600 39800 0 0 {name=Xr199c3}
N 560 39840 540 39840 {}
C {lab_pin.sym} 540 39840 0 0 {name=l31856 lab=BL3}
N 560 39800 540 39800 {}
C {lab_pin.sym} 540 39800 0 0 {name=l31857 lab=BLB3}
N 560 39760 540 39760 {}
C {lab_pin.sym} 540 39760 0 0 {name=l31858 lab=WL199}
N 640 39840 660 39840 {}
C {lab_pin.sym} 660 39840 0 0 {name=l31859 lab=VDD}
N 640 39760 660 39760 {}
C {lab_pin.sym} 660 39760 0 0 {name=l31860 lab=VSS}
C {bitcell_6t.sym} 800 39800 0 0 {name=Xr199c4}
N 760 39840 740 39840 {}
C {lab_pin.sym} 740 39840 0 0 {name=l31861 lab=BL4}
N 760 39800 740 39800 {}
C {lab_pin.sym} 740 39800 0 0 {name=l31862 lab=BLB4}
N 760 39760 740 39760 {}
C {lab_pin.sym} 740 39760 0 0 {name=l31863 lab=WL199}
N 840 39840 860 39840 {}
C {lab_pin.sym} 860 39840 0 0 {name=l31864 lab=VDD}
N 840 39760 860 39760 {}
C {lab_pin.sym} 860 39760 0 0 {name=l31865 lab=VSS}
C {bitcell_6t.sym} 1000 39800 0 0 {name=Xr199c5}
N 960 39840 940 39840 {}
C {lab_pin.sym} 940 39840 0 0 {name=l31866 lab=BL5}
N 960 39800 940 39800 {}
C {lab_pin.sym} 940 39800 0 0 {name=l31867 lab=BLB5}
N 960 39760 940 39760 {}
C {lab_pin.sym} 940 39760 0 0 {name=l31868 lab=WL199}
N 1040 39840 1060 39840 {}
C {lab_pin.sym} 1060 39840 0 0 {name=l31869 lab=VDD}
N 1040 39760 1060 39760 {}
C {lab_pin.sym} 1060 39760 0 0 {name=l31870 lab=VSS}
C {bitcell_6t.sym} 1200 39800 0 0 {name=Xr199c6}
N 1160 39840 1140 39840 {}
C {lab_pin.sym} 1140 39840 0 0 {name=l31871 lab=BL6}
N 1160 39800 1140 39800 {}
C {lab_pin.sym} 1140 39800 0 0 {name=l31872 lab=BLB6}
N 1160 39760 1140 39760 {}
C {lab_pin.sym} 1140 39760 0 0 {name=l31873 lab=WL199}
N 1240 39840 1260 39840 {}
C {lab_pin.sym} 1260 39840 0 0 {name=l31874 lab=VDD}
N 1240 39760 1260 39760 {}
C {lab_pin.sym} 1260 39760 0 0 {name=l31875 lab=VSS}
C {bitcell_6t.sym} 1400 39800 0 0 {name=Xr199c7}
N 1360 39840 1340 39840 {}
C {lab_pin.sym} 1340 39840 0 0 {name=l31876 lab=BL7}
N 1360 39800 1340 39800 {}
C {lab_pin.sym} 1340 39800 0 0 {name=l31877 lab=BLB7}
N 1360 39760 1340 39760 {}
C {lab_pin.sym} 1340 39760 0 0 {name=l31878 lab=WL199}
N 1440 39840 1460 39840 {}
C {lab_pin.sym} 1460 39840 0 0 {name=l31879 lab=VDD}
N 1440 39760 1460 39760 {}
C {lab_pin.sym} 1460 39760 0 0 {name=l31880 lab=VSS}
C {bitcell_6t.sym} 1600 39800 0 0 {name=Xr199c8}
N 1560 39840 1540 39840 {}
C {lab_pin.sym} 1540 39840 0 0 {name=l31881 lab=BL8}
N 1560 39800 1540 39800 {}
C {lab_pin.sym} 1540 39800 0 0 {name=l31882 lab=BLB8}
N 1560 39760 1540 39760 {}
C {lab_pin.sym} 1540 39760 0 0 {name=l31883 lab=WL199}
N 1640 39840 1660 39840 {}
C {lab_pin.sym} 1660 39840 0 0 {name=l31884 lab=VDD}
N 1640 39760 1660 39760 {}
C {lab_pin.sym} 1660 39760 0 0 {name=l31885 lab=VSS}
C {bitcell_6t.sym} 1800 39800 0 0 {name=Xr199c9}
N 1760 39840 1740 39840 {}
C {lab_pin.sym} 1740 39840 0 0 {name=l31886 lab=BL9}
N 1760 39800 1740 39800 {}
C {lab_pin.sym} 1740 39800 0 0 {name=l31887 lab=BLB9}
N 1760 39760 1740 39760 {}
C {lab_pin.sym} 1740 39760 0 0 {name=l31888 lab=WL199}
N 1840 39840 1860 39840 {}
C {lab_pin.sym} 1860 39840 0 0 {name=l31889 lab=VDD}
N 1840 39760 1860 39760 {}
C {lab_pin.sym} 1860 39760 0 0 {name=l31890 lab=VSS}
C {bitcell_6t.sym} 2000 39800 0 0 {name=Xr199c10}
N 1960 39840 1940 39840 {}
C {lab_pin.sym} 1940 39840 0 0 {name=l31891 lab=BL10}
N 1960 39800 1940 39800 {}
C {lab_pin.sym} 1940 39800 0 0 {name=l31892 lab=BLB10}
N 1960 39760 1940 39760 {}
C {lab_pin.sym} 1940 39760 0 0 {name=l31893 lab=WL199}
N 2040 39840 2060 39840 {}
C {lab_pin.sym} 2060 39840 0 0 {name=l31894 lab=VDD}
N 2040 39760 2060 39760 {}
C {lab_pin.sym} 2060 39760 0 0 {name=l31895 lab=VSS}
C {bitcell_6t.sym} 2200 39800 0 0 {name=Xr199c11}
N 2160 39840 2140 39840 {}
C {lab_pin.sym} 2140 39840 0 0 {name=l31896 lab=BL11}
N 2160 39800 2140 39800 {}
C {lab_pin.sym} 2140 39800 0 0 {name=l31897 lab=BLB11}
N 2160 39760 2140 39760 {}
C {lab_pin.sym} 2140 39760 0 0 {name=l31898 lab=WL199}
N 2240 39840 2260 39840 {}
C {lab_pin.sym} 2260 39840 0 0 {name=l31899 lab=VDD}
N 2240 39760 2260 39760 {}
C {lab_pin.sym} 2260 39760 0 0 {name=l31900 lab=VSS}
C {bitcell_6t.sym} 2400 39800 0 0 {name=Xr199c12}
N 2360 39840 2340 39840 {}
C {lab_pin.sym} 2340 39840 0 0 {name=l31901 lab=BL12}
N 2360 39800 2340 39800 {}
C {lab_pin.sym} 2340 39800 0 0 {name=l31902 lab=BLB12}
N 2360 39760 2340 39760 {}
C {lab_pin.sym} 2340 39760 0 0 {name=l31903 lab=WL199}
N 2440 39840 2460 39840 {}
C {lab_pin.sym} 2460 39840 0 0 {name=l31904 lab=VDD}
N 2440 39760 2460 39760 {}
C {lab_pin.sym} 2460 39760 0 0 {name=l31905 lab=VSS}
C {bitcell_6t.sym} 2600 39800 0 0 {name=Xr199c13}
N 2560 39840 2540 39840 {}
C {lab_pin.sym} 2540 39840 0 0 {name=l31906 lab=BL13}
N 2560 39800 2540 39800 {}
C {lab_pin.sym} 2540 39800 0 0 {name=l31907 lab=BLB13}
N 2560 39760 2540 39760 {}
C {lab_pin.sym} 2540 39760 0 0 {name=l31908 lab=WL199}
N 2640 39840 2660 39840 {}
C {lab_pin.sym} 2660 39840 0 0 {name=l31909 lab=VDD}
N 2640 39760 2660 39760 {}
C {lab_pin.sym} 2660 39760 0 0 {name=l31910 lab=VSS}
C {bitcell_6t.sym} 2800 39800 0 0 {name=Xr199c14}
N 2760 39840 2740 39840 {}
C {lab_pin.sym} 2740 39840 0 0 {name=l31911 lab=BL14}
N 2760 39800 2740 39800 {}
C {lab_pin.sym} 2740 39800 0 0 {name=l31912 lab=BLB14}
N 2760 39760 2740 39760 {}
C {lab_pin.sym} 2740 39760 0 0 {name=l31913 lab=WL199}
N 2840 39840 2860 39840 {}
C {lab_pin.sym} 2860 39840 0 0 {name=l31914 lab=VDD}
N 2840 39760 2860 39760 {}
C {lab_pin.sym} 2860 39760 0 0 {name=l31915 lab=VSS}
C {bitcell_6t.sym} 3000 39800 0 0 {name=Xr199c15}
N 2960 39840 2940 39840 {}
C {lab_pin.sym} 2940 39840 0 0 {name=l31916 lab=BL15}
N 2960 39800 2940 39800 {}
C {lab_pin.sym} 2940 39800 0 0 {name=l31917 lab=BLB15}
N 2960 39760 2940 39760 {}
C {lab_pin.sym} 2940 39760 0 0 {name=l31918 lab=WL199}
N 3040 39840 3060 39840 {}
C {lab_pin.sym} 3060 39840 0 0 {name=l31919 lab=VDD}
N 3040 39760 3060 39760 {}
C {lab_pin.sym} 3060 39760 0 0 {name=l31920 lab=VSS}
C {bitcell_6t.sym} 3200 39800 0 0 {name=Xr199c16}
N 3160 39840 3140 39840 {}
C {lab_pin.sym} 3140 39840 0 0 {name=l31921 lab=BL16}
N 3160 39800 3140 39800 {}
C {lab_pin.sym} 3140 39800 0 0 {name=l31922 lab=BLB16}
N 3160 39760 3140 39760 {}
C {lab_pin.sym} 3140 39760 0 0 {name=l31923 lab=WL199}
N 3240 39840 3260 39840 {}
C {lab_pin.sym} 3260 39840 0 0 {name=l31924 lab=VDD}
N 3240 39760 3260 39760 {}
C {lab_pin.sym} 3260 39760 0 0 {name=l31925 lab=VSS}
C {bitcell_6t.sym} 3400 39800 0 0 {name=Xr199c17}
N 3360 39840 3340 39840 {}
C {lab_pin.sym} 3340 39840 0 0 {name=l31926 lab=BL17}
N 3360 39800 3340 39800 {}
C {lab_pin.sym} 3340 39800 0 0 {name=l31927 lab=BLB17}
N 3360 39760 3340 39760 {}
C {lab_pin.sym} 3340 39760 0 0 {name=l31928 lab=WL199}
N 3440 39840 3460 39840 {}
C {lab_pin.sym} 3460 39840 0 0 {name=l31929 lab=VDD}
N 3440 39760 3460 39760 {}
C {lab_pin.sym} 3460 39760 0 0 {name=l31930 lab=VSS}
C {bitcell_6t.sym} 3600 39800 0 0 {name=Xr199c18}
N 3560 39840 3540 39840 {}
C {lab_pin.sym} 3540 39840 0 0 {name=l31931 lab=BL18}
N 3560 39800 3540 39800 {}
C {lab_pin.sym} 3540 39800 0 0 {name=l31932 lab=BLB18}
N 3560 39760 3540 39760 {}
C {lab_pin.sym} 3540 39760 0 0 {name=l31933 lab=WL199}
N 3640 39840 3660 39840 {}
C {lab_pin.sym} 3660 39840 0 0 {name=l31934 lab=VDD}
N 3640 39760 3660 39760 {}
C {lab_pin.sym} 3660 39760 0 0 {name=l31935 lab=VSS}
C {bitcell_6t.sym} 3800 39800 0 0 {name=Xr199c19}
N 3760 39840 3740 39840 {}
C {lab_pin.sym} 3740 39840 0 0 {name=l31936 lab=BL19}
N 3760 39800 3740 39800 {}
C {lab_pin.sym} 3740 39800 0 0 {name=l31937 lab=BLB19}
N 3760 39760 3740 39760 {}
C {lab_pin.sym} 3740 39760 0 0 {name=l31938 lab=WL199}
N 3840 39840 3860 39840 {}
C {lab_pin.sym} 3860 39840 0 0 {name=l31939 lab=VDD}
N 3840 39760 3860 39760 {}
C {lab_pin.sym} 3860 39760 0 0 {name=l31940 lab=VSS}
C {bitcell_6t.sym} 4000 39800 0 0 {name=Xr199c20}
N 3960 39840 3940 39840 {}
C {lab_pin.sym} 3940 39840 0 0 {name=l31941 lab=BL20}
N 3960 39800 3940 39800 {}
C {lab_pin.sym} 3940 39800 0 0 {name=l31942 lab=BLB20}
N 3960 39760 3940 39760 {}
C {lab_pin.sym} 3940 39760 0 0 {name=l31943 lab=WL199}
N 4040 39840 4060 39840 {}
C {lab_pin.sym} 4060 39840 0 0 {name=l31944 lab=VDD}
N 4040 39760 4060 39760 {}
C {lab_pin.sym} 4060 39760 0 0 {name=l31945 lab=VSS}
C {bitcell_6t.sym} 4200 39800 0 0 {name=Xr199c21}
N 4160 39840 4140 39840 {}
C {lab_pin.sym} 4140 39840 0 0 {name=l31946 lab=BL21}
N 4160 39800 4140 39800 {}
C {lab_pin.sym} 4140 39800 0 0 {name=l31947 lab=BLB21}
N 4160 39760 4140 39760 {}
C {lab_pin.sym} 4140 39760 0 0 {name=l31948 lab=WL199}
N 4240 39840 4260 39840 {}
C {lab_pin.sym} 4260 39840 0 0 {name=l31949 lab=VDD}
N 4240 39760 4260 39760 {}
C {lab_pin.sym} 4260 39760 0 0 {name=l31950 lab=VSS}
C {bitcell_6t.sym} 4400 39800 0 0 {name=Xr199c22}
N 4360 39840 4340 39840 {}
C {lab_pin.sym} 4340 39840 0 0 {name=l31951 lab=BL22}
N 4360 39800 4340 39800 {}
C {lab_pin.sym} 4340 39800 0 0 {name=l31952 lab=BLB22}
N 4360 39760 4340 39760 {}
C {lab_pin.sym} 4340 39760 0 0 {name=l31953 lab=WL199}
N 4440 39840 4460 39840 {}
C {lab_pin.sym} 4460 39840 0 0 {name=l31954 lab=VDD}
N 4440 39760 4460 39760 {}
C {lab_pin.sym} 4460 39760 0 0 {name=l31955 lab=VSS}
C {bitcell_6t.sym} 4600 39800 0 0 {name=Xr199c23}
N 4560 39840 4540 39840 {}
C {lab_pin.sym} 4540 39840 0 0 {name=l31956 lab=BL23}
N 4560 39800 4540 39800 {}
C {lab_pin.sym} 4540 39800 0 0 {name=l31957 lab=BLB23}
N 4560 39760 4540 39760 {}
C {lab_pin.sym} 4540 39760 0 0 {name=l31958 lab=WL199}
N 4640 39840 4660 39840 {}
C {lab_pin.sym} 4660 39840 0 0 {name=l31959 lab=VDD}
N 4640 39760 4660 39760 {}
C {lab_pin.sym} 4660 39760 0 0 {name=l31960 lab=VSS}
C {bitcell_6t.sym} 4800 39800 0 0 {name=Xr199c24}
N 4760 39840 4740 39840 {}
C {lab_pin.sym} 4740 39840 0 0 {name=l31961 lab=BL24}
N 4760 39800 4740 39800 {}
C {lab_pin.sym} 4740 39800 0 0 {name=l31962 lab=BLB24}
N 4760 39760 4740 39760 {}
C {lab_pin.sym} 4740 39760 0 0 {name=l31963 lab=WL199}
N 4840 39840 4860 39840 {}
C {lab_pin.sym} 4860 39840 0 0 {name=l31964 lab=VDD}
N 4840 39760 4860 39760 {}
C {lab_pin.sym} 4860 39760 0 0 {name=l31965 lab=VSS}
C {bitcell_6t.sym} 5000 39800 0 0 {name=Xr199c25}
N 4960 39840 4940 39840 {}
C {lab_pin.sym} 4940 39840 0 0 {name=l31966 lab=BL25}
N 4960 39800 4940 39800 {}
C {lab_pin.sym} 4940 39800 0 0 {name=l31967 lab=BLB25}
N 4960 39760 4940 39760 {}
C {lab_pin.sym} 4940 39760 0 0 {name=l31968 lab=WL199}
N 5040 39840 5060 39840 {}
C {lab_pin.sym} 5060 39840 0 0 {name=l31969 lab=VDD}
N 5040 39760 5060 39760 {}
C {lab_pin.sym} 5060 39760 0 0 {name=l31970 lab=VSS}
C {bitcell_6t.sym} 5200 39800 0 0 {name=Xr199c26}
N 5160 39840 5140 39840 {}
C {lab_pin.sym} 5140 39840 0 0 {name=l31971 lab=BL26}
N 5160 39800 5140 39800 {}
C {lab_pin.sym} 5140 39800 0 0 {name=l31972 lab=BLB26}
N 5160 39760 5140 39760 {}
C {lab_pin.sym} 5140 39760 0 0 {name=l31973 lab=WL199}
N 5240 39840 5260 39840 {}
C {lab_pin.sym} 5260 39840 0 0 {name=l31974 lab=VDD}
N 5240 39760 5260 39760 {}
C {lab_pin.sym} 5260 39760 0 0 {name=l31975 lab=VSS}
C {bitcell_6t.sym} 5400 39800 0 0 {name=Xr199c27}
N 5360 39840 5340 39840 {}
C {lab_pin.sym} 5340 39840 0 0 {name=l31976 lab=BL27}
N 5360 39800 5340 39800 {}
C {lab_pin.sym} 5340 39800 0 0 {name=l31977 lab=BLB27}
N 5360 39760 5340 39760 {}
C {lab_pin.sym} 5340 39760 0 0 {name=l31978 lab=WL199}
N 5440 39840 5460 39840 {}
C {lab_pin.sym} 5460 39840 0 0 {name=l31979 lab=VDD}
N 5440 39760 5460 39760 {}
C {lab_pin.sym} 5460 39760 0 0 {name=l31980 lab=VSS}
C {bitcell_6t.sym} 5600 39800 0 0 {name=Xr199c28}
N 5560 39840 5540 39840 {}
C {lab_pin.sym} 5540 39840 0 0 {name=l31981 lab=BL28}
N 5560 39800 5540 39800 {}
C {lab_pin.sym} 5540 39800 0 0 {name=l31982 lab=BLB28}
N 5560 39760 5540 39760 {}
C {lab_pin.sym} 5540 39760 0 0 {name=l31983 lab=WL199}
N 5640 39840 5660 39840 {}
C {lab_pin.sym} 5660 39840 0 0 {name=l31984 lab=VDD}
N 5640 39760 5660 39760 {}
C {lab_pin.sym} 5660 39760 0 0 {name=l31985 lab=VSS}
C {bitcell_6t.sym} 5800 39800 0 0 {name=Xr199c29}
N 5760 39840 5740 39840 {}
C {lab_pin.sym} 5740 39840 0 0 {name=l31986 lab=BL29}
N 5760 39800 5740 39800 {}
C {lab_pin.sym} 5740 39800 0 0 {name=l31987 lab=BLB29}
N 5760 39760 5740 39760 {}
C {lab_pin.sym} 5740 39760 0 0 {name=l31988 lab=WL199}
N 5840 39840 5860 39840 {}
C {lab_pin.sym} 5860 39840 0 0 {name=l31989 lab=VDD}
N 5840 39760 5860 39760 {}
C {lab_pin.sym} 5860 39760 0 0 {name=l31990 lab=VSS}
C {bitcell_6t.sym} 6000 39800 0 0 {name=Xr199c30}
N 5960 39840 5940 39840 {}
C {lab_pin.sym} 5940 39840 0 0 {name=l31991 lab=BL30}
N 5960 39800 5940 39800 {}
C {lab_pin.sym} 5940 39800 0 0 {name=l31992 lab=BLB30}
N 5960 39760 5940 39760 {}
C {lab_pin.sym} 5940 39760 0 0 {name=l31993 lab=WL199}
N 6040 39840 6060 39840 {}
C {lab_pin.sym} 6060 39840 0 0 {name=l31994 lab=VDD}
N 6040 39760 6060 39760 {}
C {lab_pin.sym} 6060 39760 0 0 {name=l31995 lab=VSS}
C {bitcell_6t.sym} 6200 39800 0 0 {name=Xr199c31}
N 6160 39840 6140 39840 {}
C {lab_pin.sym} 6140 39840 0 0 {name=l31996 lab=BL31}
N 6160 39800 6140 39800 {}
C {lab_pin.sym} 6140 39800 0 0 {name=l31997 lab=BLB31}
N 6160 39760 6140 39760 {}
C {lab_pin.sym} 6140 39760 0 0 {name=l31998 lab=WL199}
N 6240 39840 6260 39840 {}
C {lab_pin.sym} 6260 39840 0 0 {name=l31999 lab=VDD}
N 6240 39760 6260 39760 {}
C {lab_pin.sym} 6260 39760 0 0 {name=l32000 lab=VSS}
C {bitcell_6t.sym} 0 40000 0 0 {name=Xr200c0}
N -40 40040 -60 40040 {}
C {lab_pin.sym} -60 40040 0 0 {name=l32001 lab=BL0}
N -40 40000 -60 40000 {}
C {lab_pin.sym} -60 40000 0 0 {name=l32002 lab=BLB0}
N -40 39960 -60 39960 {}
C {lab_pin.sym} -60 39960 0 0 {name=l32003 lab=WL200}
N 40 40040 60 40040 {}
C {lab_pin.sym} 60 40040 0 0 {name=l32004 lab=VDD}
N 40 39960 60 39960 {}
C {lab_pin.sym} 60 39960 0 0 {name=l32005 lab=VSS}
C {bitcell_6t.sym} 200 40000 0 0 {name=Xr200c1}
N 160 40040 140 40040 {}
C {lab_pin.sym} 140 40040 0 0 {name=l32006 lab=BL1}
N 160 40000 140 40000 {}
C {lab_pin.sym} 140 40000 0 0 {name=l32007 lab=BLB1}
N 160 39960 140 39960 {}
C {lab_pin.sym} 140 39960 0 0 {name=l32008 lab=WL200}
N 240 40040 260 40040 {}
C {lab_pin.sym} 260 40040 0 0 {name=l32009 lab=VDD}
N 240 39960 260 39960 {}
C {lab_pin.sym} 260 39960 0 0 {name=l32010 lab=VSS}
C {bitcell_6t.sym} 400 40000 0 0 {name=Xr200c2}
N 360 40040 340 40040 {}
C {lab_pin.sym} 340 40040 0 0 {name=l32011 lab=BL2}
N 360 40000 340 40000 {}
C {lab_pin.sym} 340 40000 0 0 {name=l32012 lab=BLB2}
N 360 39960 340 39960 {}
C {lab_pin.sym} 340 39960 0 0 {name=l32013 lab=WL200}
N 440 40040 460 40040 {}
C {lab_pin.sym} 460 40040 0 0 {name=l32014 lab=VDD}
N 440 39960 460 39960 {}
C {lab_pin.sym} 460 39960 0 0 {name=l32015 lab=VSS}
C {bitcell_6t.sym} 600 40000 0 0 {name=Xr200c3}
N 560 40040 540 40040 {}
C {lab_pin.sym} 540 40040 0 0 {name=l32016 lab=BL3}
N 560 40000 540 40000 {}
C {lab_pin.sym} 540 40000 0 0 {name=l32017 lab=BLB3}
N 560 39960 540 39960 {}
C {lab_pin.sym} 540 39960 0 0 {name=l32018 lab=WL200}
N 640 40040 660 40040 {}
C {lab_pin.sym} 660 40040 0 0 {name=l32019 lab=VDD}
N 640 39960 660 39960 {}
C {lab_pin.sym} 660 39960 0 0 {name=l32020 lab=VSS}
C {bitcell_6t.sym} 800 40000 0 0 {name=Xr200c4}
N 760 40040 740 40040 {}
C {lab_pin.sym} 740 40040 0 0 {name=l32021 lab=BL4}
N 760 40000 740 40000 {}
C {lab_pin.sym} 740 40000 0 0 {name=l32022 lab=BLB4}
N 760 39960 740 39960 {}
C {lab_pin.sym} 740 39960 0 0 {name=l32023 lab=WL200}
N 840 40040 860 40040 {}
C {lab_pin.sym} 860 40040 0 0 {name=l32024 lab=VDD}
N 840 39960 860 39960 {}
C {lab_pin.sym} 860 39960 0 0 {name=l32025 lab=VSS}
C {bitcell_6t.sym} 1000 40000 0 0 {name=Xr200c5}
N 960 40040 940 40040 {}
C {lab_pin.sym} 940 40040 0 0 {name=l32026 lab=BL5}
N 960 40000 940 40000 {}
C {lab_pin.sym} 940 40000 0 0 {name=l32027 lab=BLB5}
N 960 39960 940 39960 {}
C {lab_pin.sym} 940 39960 0 0 {name=l32028 lab=WL200}
N 1040 40040 1060 40040 {}
C {lab_pin.sym} 1060 40040 0 0 {name=l32029 lab=VDD}
N 1040 39960 1060 39960 {}
C {lab_pin.sym} 1060 39960 0 0 {name=l32030 lab=VSS}
C {bitcell_6t.sym} 1200 40000 0 0 {name=Xr200c6}
N 1160 40040 1140 40040 {}
C {lab_pin.sym} 1140 40040 0 0 {name=l32031 lab=BL6}
N 1160 40000 1140 40000 {}
C {lab_pin.sym} 1140 40000 0 0 {name=l32032 lab=BLB6}
N 1160 39960 1140 39960 {}
C {lab_pin.sym} 1140 39960 0 0 {name=l32033 lab=WL200}
N 1240 40040 1260 40040 {}
C {lab_pin.sym} 1260 40040 0 0 {name=l32034 lab=VDD}
N 1240 39960 1260 39960 {}
C {lab_pin.sym} 1260 39960 0 0 {name=l32035 lab=VSS}
C {bitcell_6t.sym} 1400 40000 0 0 {name=Xr200c7}
N 1360 40040 1340 40040 {}
C {lab_pin.sym} 1340 40040 0 0 {name=l32036 lab=BL7}
N 1360 40000 1340 40000 {}
C {lab_pin.sym} 1340 40000 0 0 {name=l32037 lab=BLB7}
N 1360 39960 1340 39960 {}
C {lab_pin.sym} 1340 39960 0 0 {name=l32038 lab=WL200}
N 1440 40040 1460 40040 {}
C {lab_pin.sym} 1460 40040 0 0 {name=l32039 lab=VDD}
N 1440 39960 1460 39960 {}
C {lab_pin.sym} 1460 39960 0 0 {name=l32040 lab=VSS}
C {bitcell_6t.sym} 1600 40000 0 0 {name=Xr200c8}
N 1560 40040 1540 40040 {}
C {lab_pin.sym} 1540 40040 0 0 {name=l32041 lab=BL8}
N 1560 40000 1540 40000 {}
C {lab_pin.sym} 1540 40000 0 0 {name=l32042 lab=BLB8}
N 1560 39960 1540 39960 {}
C {lab_pin.sym} 1540 39960 0 0 {name=l32043 lab=WL200}
N 1640 40040 1660 40040 {}
C {lab_pin.sym} 1660 40040 0 0 {name=l32044 lab=VDD}
N 1640 39960 1660 39960 {}
C {lab_pin.sym} 1660 39960 0 0 {name=l32045 lab=VSS}
C {bitcell_6t.sym} 1800 40000 0 0 {name=Xr200c9}
N 1760 40040 1740 40040 {}
C {lab_pin.sym} 1740 40040 0 0 {name=l32046 lab=BL9}
N 1760 40000 1740 40000 {}
C {lab_pin.sym} 1740 40000 0 0 {name=l32047 lab=BLB9}
N 1760 39960 1740 39960 {}
C {lab_pin.sym} 1740 39960 0 0 {name=l32048 lab=WL200}
N 1840 40040 1860 40040 {}
C {lab_pin.sym} 1860 40040 0 0 {name=l32049 lab=VDD}
N 1840 39960 1860 39960 {}
C {lab_pin.sym} 1860 39960 0 0 {name=l32050 lab=VSS}
C {bitcell_6t.sym} 2000 40000 0 0 {name=Xr200c10}
N 1960 40040 1940 40040 {}
C {lab_pin.sym} 1940 40040 0 0 {name=l32051 lab=BL10}
N 1960 40000 1940 40000 {}
C {lab_pin.sym} 1940 40000 0 0 {name=l32052 lab=BLB10}
N 1960 39960 1940 39960 {}
C {lab_pin.sym} 1940 39960 0 0 {name=l32053 lab=WL200}
N 2040 40040 2060 40040 {}
C {lab_pin.sym} 2060 40040 0 0 {name=l32054 lab=VDD}
N 2040 39960 2060 39960 {}
C {lab_pin.sym} 2060 39960 0 0 {name=l32055 lab=VSS}
C {bitcell_6t.sym} 2200 40000 0 0 {name=Xr200c11}
N 2160 40040 2140 40040 {}
C {lab_pin.sym} 2140 40040 0 0 {name=l32056 lab=BL11}
N 2160 40000 2140 40000 {}
C {lab_pin.sym} 2140 40000 0 0 {name=l32057 lab=BLB11}
N 2160 39960 2140 39960 {}
C {lab_pin.sym} 2140 39960 0 0 {name=l32058 lab=WL200}
N 2240 40040 2260 40040 {}
C {lab_pin.sym} 2260 40040 0 0 {name=l32059 lab=VDD}
N 2240 39960 2260 39960 {}
C {lab_pin.sym} 2260 39960 0 0 {name=l32060 lab=VSS}
C {bitcell_6t.sym} 2400 40000 0 0 {name=Xr200c12}
N 2360 40040 2340 40040 {}
C {lab_pin.sym} 2340 40040 0 0 {name=l32061 lab=BL12}
N 2360 40000 2340 40000 {}
C {lab_pin.sym} 2340 40000 0 0 {name=l32062 lab=BLB12}
N 2360 39960 2340 39960 {}
C {lab_pin.sym} 2340 39960 0 0 {name=l32063 lab=WL200}
N 2440 40040 2460 40040 {}
C {lab_pin.sym} 2460 40040 0 0 {name=l32064 lab=VDD}
N 2440 39960 2460 39960 {}
C {lab_pin.sym} 2460 39960 0 0 {name=l32065 lab=VSS}
C {bitcell_6t.sym} 2600 40000 0 0 {name=Xr200c13}
N 2560 40040 2540 40040 {}
C {lab_pin.sym} 2540 40040 0 0 {name=l32066 lab=BL13}
N 2560 40000 2540 40000 {}
C {lab_pin.sym} 2540 40000 0 0 {name=l32067 lab=BLB13}
N 2560 39960 2540 39960 {}
C {lab_pin.sym} 2540 39960 0 0 {name=l32068 lab=WL200}
N 2640 40040 2660 40040 {}
C {lab_pin.sym} 2660 40040 0 0 {name=l32069 lab=VDD}
N 2640 39960 2660 39960 {}
C {lab_pin.sym} 2660 39960 0 0 {name=l32070 lab=VSS}
C {bitcell_6t.sym} 2800 40000 0 0 {name=Xr200c14}
N 2760 40040 2740 40040 {}
C {lab_pin.sym} 2740 40040 0 0 {name=l32071 lab=BL14}
N 2760 40000 2740 40000 {}
C {lab_pin.sym} 2740 40000 0 0 {name=l32072 lab=BLB14}
N 2760 39960 2740 39960 {}
C {lab_pin.sym} 2740 39960 0 0 {name=l32073 lab=WL200}
N 2840 40040 2860 40040 {}
C {lab_pin.sym} 2860 40040 0 0 {name=l32074 lab=VDD}
N 2840 39960 2860 39960 {}
C {lab_pin.sym} 2860 39960 0 0 {name=l32075 lab=VSS}
C {bitcell_6t.sym} 3000 40000 0 0 {name=Xr200c15}
N 2960 40040 2940 40040 {}
C {lab_pin.sym} 2940 40040 0 0 {name=l32076 lab=BL15}
N 2960 40000 2940 40000 {}
C {lab_pin.sym} 2940 40000 0 0 {name=l32077 lab=BLB15}
N 2960 39960 2940 39960 {}
C {lab_pin.sym} 2940 39960 0 0 {name=l32078 lab=WL200}
N 3040 40040 3060 40040 {}
C {lab_pin.sym} 3060 40040 0 0 {name=l32079 lab=VDD}
N 3040 39960 3060 39960 {}
C {lab_pin.sym} 3060 39960 0 0 {name=l32080 lab=VSS}
C {bitcell_6t.sym} 3200 40000 0 0 {name=Xr200c16}
N 3160 40040 3140 40040 {}
C {lab_pin.sym} 3140 40040 0 0 {name=l32081 lab=BL16}
N 3160 40000 3140 40000 {}
C {lab_pin.sym} 3140 40000 0 0 {name=l32082 lab=BLB16}
N 3160 39960 3140 39960 {}
C {lab_pin.sym} 3140 39960 0 0 {name=l32083 lab=WL200}
N 3240 40040 3260 40040 {}
C {lab_pin.sym} 3260 40040 0 0 {name=l32084 lab=VDD}
N 3240 39960 3260 39960 {}
C {lab_pin.sym} 3260 39960 0 0 {name=l32085 lab=VSS}
C {bitcell_6t.sym} 3400 40000 0 0 {name=Xr200c17}
N 3360 40040 3340 40040 {}
C {lab_pin.sym} 3340 40040 0 0 {name=l32086 lab=BL17}
N 3360 40000 3340 40000 {}
C {lab_pin.sym} 3340 40000 0 0 {name=l32087 lab=BLB17}
N 3360 39960 3340 39960 {}
C {lab_pin.sym} 3340 39960 0 0 {name=l32088 lab=WL200}
N 3440 40040 3460 40040 {}
C {lab_pin.sym} 3460 40040 0 0 {name=l32089 lab=VDD}
N 3440 39960 3460 39960 {}
C {lab_pin.sym} 3460 39960 0 0 {name=l32090 lab=VSS}
C {bitcell_6t.sym} 3600 40000 0 0 {name=Xr200c18}
N 3560 40040 3540 40040 {}
C {lab_pin.sym} 3540 40040 0 0 {name=l32091 lab=BL18}
N 3560 40000 3540 40000 {}
C {lab_pin.sym} 3540 40000 0 0 {name=l32092 lab=BLB18}
N 3560 39960 3540 39960 {}
C {lab_pin.sym} 3540 39960 0 0 {name=l32093 lab=WL200}
N 3640 40040 3660 40040 {}
C {lab_pin.sym} 3660 40040 0 0 {name=l32094 lab=VDD}
N 3640 39960 3660 39960 {}
C {lab_pin.sym} 3660 39960 0 0 {name=l32095 lab=VSS}
C {bitcell_6t.sym} 3800 40000 0 0 {name=Xr200c19}
N 3760 40040 3740 40040 {}
C {lab_pin.sym} 3740 40040 0 0 {name=l32096 lab=BL19}
N 3760 40000 3740 40000 {}
C {lab_pin.sym} 3740 40000 0 0 {name=l32097 lab=BLB19}
N 3760 39960 3740 39960 {}
C {lab_pin.sym} 3740 39960 0 0 {name=l32098 lab=WL200}
N 3840 40040 3860 40040 {}
C {lab_pin.sym} 3860 40040 0 0 {name=l32099 lab=VDD}
N 3840 39960 3860 39960 {}
C {lab_pin.sym} 3860 39960 0 0 {name=l32100 lab=VSS}
C {bitcell_6t.sym} 4000 40000 0 0 {name=Xr200c20}
N 3960 40040 3940 40040 {}
C {lab_pin.sym} 3940 40040 0 0 {name=l32101 lab=BL20}
N 3960 40000 3940 40000 {}
C {lab_pin.sym} 3940 40000 0 0 {name=l32102 lab=BLB20}
N 3960 39960 3940 39960 {}
C {lab_pin.sym} 3940 39960 0 0 {name=l32103 lab=WL200}
N 4040 40040 4060 40040 {}
C {lab_pin.sym} 4060 40040 0 0 {name=l32104 lab=VDD}
N 4040 39960 4060 39960 {}
C {lab_pin.sym} 4060 39960 0 0 {name=l32105 lab=VSS}
C {bitcell_6t.sym} 4200 40000 0 0 {name=Xr200c21}
N 4160 40040 4140 40040 {}
C {lab_pin.sym} 4140 40040 0 0 {name=l32106 lab=BL21}
N 4160 40000 4140 40000 {}
C {lab_pin.sym} 4140 40000 0 0 {name=l32107 lab=BLB21}
N 4160 39960 4140 39960 {}
C {lab_pin.sym} 4140 39960 0 0 {name=l32108 lab=WL200}
N 4240 40040 4260 40040 {}
C {lab_pin.sym} 4260 40040 0 0 {name=l32109 lab=VDD}
N 4240 39960 4260 39960 {}
C {lab_pin.sym} 4260 39960 0 0 {name=l32110 lab=VSS}
C {bitcell_6t.sym} 4400 40000 0 0 {name=Xr200c22}
N 4360 40040 4340 40040 {}
C {lab_pin.sym} 4340 40040 0 0 {name=l32111 lab=BL22}
N 4360 40000 4340 40000 {}
C {lab_pin.sym} 4340 40000 0 0 {name=l32112 lab=BLB22}
N 4360 39960 4340 39960 {}
C {lab_pin.sym} 4340 39960 0 0 {name=l32113 lab=WL200}
N 4440 40040 4460 40040 {}
C {lab_pin.sym} 4460 40040 0 0 {name=l32114 lab=VDD}
N 4440 39960 4460 39960 {}
C {lab_pin.sym} 4460 39960 0 0 {name=l32115 lab=VSS}
C {bitcell_6t.sym} 4600 40000 0 0 {name=Xr200c23}
N 4560 40040 4540 40040 {}
C {lab_pin.sym} 4540 40040 0 0 {name=l32116 lab=BL23}
N 4560 40000 4540 40000 {}
C {lab_pin.sym} 4540 40000 0 0 {name=l32117 lab=BLB23}
N 4560 39960 4540 39960 {}
C {lab_pin.sym} 4540 39960 0 0 {name=l32118 lab=WL200}
N 4640 40040 4660 40040 {}
C {lab_pin.sym} 4660 40040 0 0 {name=l32119 lab=VDD}
N 4640 39960 4660 39960 {}
C {lab_pin.sym} 4660 39960 0 0 {name=l32120 lab=VSS}
C {bitcell_6t.sym} 4800 40000 0 0 {name=Xr200c24}
N 4760 40040 4740 40040 {}
C {lab_pin.sym} 4740 40040 0 0 {name=l32121 lab=BL24}
N 4760 40000 4740 40000 {}
C {lab_pin.sym} 4740 40000 0 0 {name=l32122 lab=BLB24}
N 4760 39960 4740 39960 {}
C {lab_pin.sym} 4740 39960 0 0 {name=l32123 lab=WL200}
N 4840 40040 4860 40040 {}
C {lab_pin.sym} 4860 40040 0 0 {name=l32124 lab=VDD}
N 4840 39960 4860 39960 {}
C {lab_pin.sym} 4860 39960 0 0 {name=l32125 lab=VSS}
C {bitcell_6t.sym} 5000 40000 0 0 {name=Xr200c25}
N 4960 40040 4940 40040 {}
C {lab_pin.sym} 4940 40040 0 0 {name=l32126 lab=BL25}
N 4960 40000 4940 40000 {}
C {lab_pin.sym} 4940 40000 0 0 {name=l32127 lab=BLB25}
N 4960 39960 4940 39960 {}
C {lab_pin.sym} 4940 39960 0 0 {name=l32128 lab=WL200}
N 5040 40040 5060 40040 {}
C {lab_pin.sym} 5060 40040 0 0 {name=l32129 lab=VDD}
N 5040 39960 5060 39960 {}
C {lab_pin.sym} 5060 39960 0 0 {name=l32130 lab=VSS}
C {bitcell_6t.sym} 5200 40000 0 0 {name=Xr200c26}
N 5160 40040 5140 40040 {}
C {lab_pin.sym} 5140 40040 0 0 {name=l32131 lab=BL26}
N 5160 40000 5140 40000 {}
C {lab_pin.sym} 5140 40000 0 0 {name=l32132 lab=BLB26}
N 5160 39960 5140 39960 {}
C {lab_pin.sym} 5140 39960 0 0 {name=l32133 lab=WL200}
N 5240 40040 5260 40040 {}
C {lab_pin.sym} 5260 40040 0 0 {name=l32134 lab=VDD}
N 5240 39960 5260 39960 {}
C {lab_pin.sym} 5260 39960 0 0 {name=l32135 lab=VSS}
C {bitcell_6t.sym} 5400 40000 0 0 {name=Xr200c27}
N 5360 40040 5340 40040 {}
C {lab_pin.sym} 5340 40040 0 0 {name=l32136 lab=BL27}
N 5360 40000 5340 40000 {}
C {lab_pin.sym} 5340 40000 0 0 {name=l32137 lab=BLB27}
N 5360 39960 5340 39960 {}
C {lab_pin.sym} 5340 39960 0 0 {name=l32138 lab=WL200}
N 5440 40040 5460 40040 {}
C {lab_pin.sym} 5460 40040 0 0 {name=l32139 lab=VDD}
N 5440 39960 5460 39960 {}
C {lab_pin.sym} 5460 39960 0 0 {name=l32140 lab=VSS}
C {bitcell_6t.sym} 5600 40000 0 0 {name=Xr200c28}
N 5560 40040 5540 40040 {}
C {lab_pin.sym} 5540 40040 0 0 {name=l32141 lab=BL28}
N 5560 40000 5540 40000 {}
C {lab_pin.sym} 5540 40000 0 0 {name=l32142 lab=BLB28}
N 5560 39960 5540 39960 {}
C {lab_pin.sym} 5540 39960 0 0 {name=l32143 lab=WL200}
N 5640 40040 5660 40040 {}
C {lab_pin.sym} 5660 40040 0 0 {name=l32144 lab=VDD}
N 5640 39960 5660 39960 {}
C {lab_pin.sym} 5660 39960 0 0 {name=l32145 lab=VSS}
C {bitcell_6t.sym} 5800 40000 0 0 {name=Xr200c29}
N 5760 40040 5740 40040 {}
C {lab_pin.sym} 5740 40040 0 0 {name=l32146 lab=BL29}
N 5760 40000 5740 40000 {}
C {lab_pin.sym} 5740 40000 0 0 {name=l32147 lab=BLB29}
N 5760 39960 5740 39960 {}
C {lab_pin.sym} 5740 39960 0 0 {name=l32148 lab=WL200}
N 5840 40040 5860 40040 {}
C {lab_pin.sym} 5860 40040 0 0 {name=l32149 lab=VDD}
N 5840 39960 5860 39960 {}
C {lab_pin.sym} 5860 39960 0 0 {name=l32150 lab=VSS}
C {bitcell_6t.sym} 6000 40000 0 0 {name=Xr200c30}
N 5960 40040 5940 40040 {}
C {lab_pin.sym} 5940 40040 0 0 {name=l32151 lab=BL30}
N 5960 40000 5940 40000 {}
C {lab_pin.sym} 5940 40000 0 0 {name=l32152 lab=BLB30}
N 5960 39960 5940 39960 {}
C {lab_pin.sym} 5940 39960 0 0 {name=l32153 lab=WL200}
N 6040 40040 6060 40040 {}
C {lab_pin.sym} 6060 40040 0 0 {name=l32154 lab=VDD}
N 6040 39960 6060 39960 {}
C {lab_pin.sym} 6060 39960 0 0 {name=l32155 lab=VSS}
C {bitcell_6t.sym} 6200 40000 0 0 {name=Xr200c31}
N 6160 40040 6140 40040 {}
C {lab_pin.sym} 6140 40040 0 0 {name=l32156 lab=BL31}
N 6160 40000 6140 40000 {}
C {lab_pin.sym} 6140 40000 0 0 {name=l32157 lab=BLB31}
N 6160 39960 6140 39960 {}
C {lab_pin.sym} 6140 39960 0 0 {name=l32158 lab=WL200}
N 6240 40040 6260 40040 {}
C {lab_pin.sym} 6260 40040 0 0 {name=l32159 lab=VDD}
N 6240 39960 6260 39960 {}
C {lab_pin.sym} 6260 39960 0 0 {name=l32160 lab=VSS}
C {bitcell_6t.sym} 0 40200 0 0 {name=Xr201c0}
N -40 40240 -60 40240 {}
C {lab_pin.sym} -60 40240 0 0 {name=l32161 lab=BL0}
N -40 40200 -60 40200 {}
C {lab_pin.sym} -60 40200 0 0 {name=l32162 lab=BLB0}
N -40 40160 -60 40160 {}
C {lab_pin.sym} -60 40160 0 0 {name=l32163 lab=WL201}
N 40 40240 60 40240 {}
C {lab_pin.sym} 60 40240 0 0 {name=l32164 lab=VDD}
N 40 40160 60 40160 {}
C {lab_pin.sym} 60 40160 0 0 {name=l32165 lab=VSS}
C {bitcell_6t.sym} 200 40200 0 0 {name=Xr201c1}
N 160 40240 140 40240 {}
C {lab_pin.sym} 140 40240 0 0 {name=l32166 lab=BL1}
N 160 40200 140 40200 {}
C {lab_pin.sym} 140 40200 0 0 {name=l32167 lab=BLB1}
N 160 40160 140 40160 {}
C {lab_pin.sym} 140 40160 0 0 {name=l32168 lab=WL201}
N 240 40240 260 40240 {}
C {lab_pin.sym} 260 40240 0 0 {name=l32169 lab=VDD}
N 240 40160 260 40160 {}
C {lab_pin.sym} 260 40160 0 0 {name=l32170 lab=VSS}
C {bitcell_6t.sym} 400 40200 0 0 {name=Xr201c2}
N 360 40240 340 40240 {}
C {lab_pin.sym} 340 40240 0 0 {name=l32171 lab=BL2}
N 360 40200 340 40200 {}
C {lab_pin.sym} 340 40200 0 0 {name=l32172 lab=BLB2}
N 360 40160 340 40160 {}
C {lab_pin.sym} 340 40160 0 0 {name=l32173 lab=WL201}
N 440 40240 460 40240 {}
C {lab_pin.sym} 460 40240 0 0 {name=l32174 lab=VDD}
N 440 40160 460 40160 {}
C {lab_pin.sym} 460 40160 0 0 {name=l32175 lab=VSS}
C {bitcell_6t.sym} 600 40200 0 0 {name=Xr201c3}
N 560 40240 540 40240 {}
C {lab_pin.sym} 540 40240 0 0 {name=l32176 lab=BL3}
N 560 40200 540 40200 {}
C {lab_pin.sym} 540 40200 0 0 {name=l32177 lab=BLB3}
N 560 40160 540 40160 {}
C {lab_pin.sym} 540 40160 0 0 {name=l32178 lab=WL201}
N 640 40240 660 40240 {}
C {lab_pin.sym} 660 40240 0 0 {name=l32179 lab=VDD}
N 640 40160 660 40160 {}
C {lab_pin.sym} 660 40160 0 0 {name=l32180 lab=VSS}
C {bitcell_6t.sym} 800 40200 0 0 {name=Xr201c4}
N 760 40240 740 40240 {}
C {lab_pin.sym} 740 40240 0 0 {name=l32181 lab=BL4}
N 760 40200 740 40200 {}
C {lab_pin.sym} 740 40200 0 0 {name=l32182 lab=BLB4}
N 760 40160 740 40160 {}
C {lab_pin.sym} 740 40160 0 0 {name=l32183 lab=WL201}
N 840 40240 860 40240 {}
C {lab_pin.sym} 860 40240 0 0 {name=l32184 lab=VDD}
N 840 40160 860 40160 {}
C {lab_pin.sym} 860 40160 0 0 {name=l32185 lab=VSS}
C {bitcell_6t.sym} 1000 40200 0 0 {name=Xr201c5}
N 960 40240 940 40240 {}
C {lab_pin.sym} 940 40240 0 0 {name=l32186 lab=BL5}
N 960 40200 940 40200 {}
C {lab_pin.sym} 940 40200 0 0 {name=l32187 lab=BLB5}
N 960 40160 940 40160 {}
C {lab_pin.sym} 940 40160 0 0 {name=l32188 lab=WL201}
N 1040 40240 1060 40240 {}
C {lab_pin.sym} 1060 40240 0 0 {name=l32189 lab=VDD}
N 1040 40160 1060 40160 {}
C {lab_pin.sym} 1060 40160 0 0 {name=l32190 lab=VSS}
C {bitcell_6t.sym} 1200 40200 0 0 {name=Xr201c6}
N 1160 40240 1140 40240 {}
C {lab_pin.sym} 1140 40240 0 0 {name=l32191 lab=BL6}
N 1160 40200 1140 40200 {}
C {lab_pin.sym} 1140 40200 0 0 {name=l32192 lab=BLB6}
N 1160 40160 1140 40160 {}
C {lab_pin.sym} 1140 40160 0 0 {name=l32193 lab=WL201}
N 1240 40240 1260 40240 {}
C {lab_pin.sym} 1260 40240 0 0 {name=l32194 lab=VDD}
N 1240 40160 1260 40160 {}
C {lab_pin.sym} 1260 40160 0 0 {name=l32195 lab=VSS}
C {bitcell_6t.sym} 1400 40200 0 0 {name=Xr201c7}
N 1360 40240 1340 40240 {}
C {lab_pin.sym} 1340 40240 0 0 {name=l32196 lab=BL7}
N 1360 40200 1340 40200 {}
C {lab_pin.sym} 1340 40200 0 0 {name=l32197 lab=BLB7}
N 1360 40160 1340 40160 {}
C {lab_pin.sym} 1340 40160 0 0 {name=l32198 lab=WL201}
N 1440 40240 1460 40240 {}
C {lab_pin.sym} 1460 40240 0 0 {name=l32199 lab=VDD}
N 1440 40160 1460 40160 {}
C {lab_pin.sym} 1460 40160 0 0 {name=l32200 lab=VSS}
C {bitcell_6t.sym} 1600 40200 0 0 {name=Xr201c8}
N 1560 40240 1540 40240 {}
C {lab_pin.sym} 1540 40240 0 0 {name=l32201 lab=BL8}
N 1560 40200 1540 40200 {}
C {lab_pin.sym} 1540 40200 0 0 {name=l32202 lab=BLB8}
N 1560 40160 1540 40160 {}
C {lab_pin.sym} 1540 40160 0 0 {name=l32203 lab=WL201}
N 1640 40240 1660 40240 {}
C {lab_pin.sym} 1660 40240 0 0 {name=l32204 lab=VDD}
N 1640 40160 1660 40160 {}
C {lab_pin.sym} 1660 40160 0 0 {name=l32205 lab=VSS}
C {bitcell_6t.sym} 1800 40200 0 0 {name=Xr201c9}
N 1760 40240 1740 40240 {}
C {lab_pin.sym} 1740 40240 0 0 {name=l32206 lab=BL9}
N 1760 40200 1740 40200 {}
C {lab_pin.sym} 1740 40200 0 0 {name=l32207 lab=BLB9}
N 1760 40160 1740 40160 {}
C {lab_pin.sym} 1740 40160 0 0 {name=l32208 lab=WL201}
N 1840 40240 1860 40240 {}
C {lab_pin.sym} 1860 40240 0 0 {name=l32209 lab=VDD}
N 1840 40160 1860 40160 {}
C {lab_pin.sym} 1860 40160 0 0 {name=l32210 lab=VSS}
C {bitcell_6t.sym} 2000 40200 0 0 {name=Xr201c10}
N 1960 40240 1940 40240 {}
C {lab_pin.sym} 1940 40240 0 0 {name=l32211 lab=BL10}
N 1960 40200 1940 40200 {}
C {lab_pin.sym} 1940 40200 0 0 {name=l32212 lab=BLB10}
N 1960 40160 1940 40160 {}
C {lab_pin.sym} 1940 40160 0 0 {name=l32213 lab=WL201}
N 2040 40240 2060 40240 {}
C {lab_pin.sym} 2060 40240 0 0 {name=l32214 lab=VDD}
N 2040 40160 2060 40160 {}
C {lab_pin.sym} 2060 40160 0 0 {name=l32215 lab=VSS}
C {bitcell_6t.sym} 2200 40200 0 0 {name=Xr201c11}
N 2160 40240 2140 40240 {}
C {lab_pin.sym} 2140 40240 0 0 {name=l32216 lab=BL11}
N 2160 40200 2140 40200 {}
C {lab_pin.sym} 2140 40200 0 0 {name=l32217 lab=BLB11}
N 2160 40160 2140 40160 {}
C {lab_pin.sym} 2140 40160 0 0 {name=l32218 lab=WL201}
N 2240 40240 2260 40240 {}
C {lab_pin.sym} 2260 40240 0 0 {name=l32219 lab=VDD}
N 2240 40160 2260 40160 {}
C {lab_pin.sym} 2260 40160 0 0 {name=l32220 lab=VSS}
C {bitcell_6t.sym} 2400 40200 0 0 {name=Xr201c12}
N 2360 40240 2340 40240 {}
C {lab_pin.sym} 2340 40240 0 0 {name=l32221 lab=BL12}
N 2360 40200 2340 40200 {}
C {lab_pin.sym} 2340 40200 0 0 {name=l32222 lab=BLB12}
N 2360 40160 2340 40160 {}
C {lab_pin.sym} 2340 40160 0 0 {name=l32223 lab=WL201}
N 2440 40240 2460 40240 {}
C {lab_pin.sym} 2460 40240 0 0 {name=l32224 lab=VDD}
N 2440 40160 2460 40160 {}
C {lab_pin.sym} 2460 40160 0 0 {name=l32225 lab=VSS}
C {bitcell_6t.sym} 2600 40200 0 0 {name=Xr201c13}
N 2560 40240 2540 40240 {}
C {lab_pin.sym} 2540 40240 0 0 {name=l32226 lab=BL13}
N 2560 40200 2540 40200 {}
C {lab_pin.sym} 2540 40200 0 0 {name=l32227 lab=BLB13}
N 2560 40160 2540 40160 {}
C {lab_pin.sym} 2540 40160 0 0 {name=l32228 lab=WL201}
N 2640 40240 2660 40240 {}
C {lab_pin.sym} 2660 40240 0 0 {name=l32229 lab=VDD}
N 2640 40160 2660 40160 {}
C {lab_pin.sym} 2660 40160 0 0 {name=l32230 lab=VSS}
C {bitcell_6t.sym} 2800 40200 0 0 {name=Xr201c14}
N 2760 40240 2740 40240 {}
C {lab_pin.sym} 2740 40240 0 0 {name=l32231 lab=BL14}
N 2760 40200 2740 40200 {}
C {lab_pin.sym} 2740 40200 0 0 {name=l32232 lab=BLB14}
N 2760 40160 2740 40160 {}
C {lab_pin.sym} 2740 40160 0 0 {name=l32233 lab=WL201}
N 2840 40240 2860 40240 {}
C {lab_pin.sym} 2860 40240 0 0 {name=l32234 lab=VDD}
N 2840 40160 2860 40160 {}
C {lab_pin.sym} 2860 40160 0 0 {name=l32235 lab=VSS}
C {bitcell_6t.sym} 3000 40200 0 0 {name=Xr201c15}
N 2960 40240 2940 40240 {}
C {lab_pin.sym} 2940 40240 0 0 {name=l32236 lab=BL15}
N 2960 40200 2940 40200 {}
C {lab_pin.sym} 2940 40200 0 0 {name=l32237 lab=BLB15}
N 2960 40160 2940 40160 {}
C {lab_pin.sym} 2940 40160 0 0 {name=l32238 lab=WL201}
N 3040 40240 3060 40240 {}
C {lab_pin.sym} 3060 40240 0 0 {name=l32239 lab=VDD}
N 3040 40160 3060 40160 {}
C {lab_pin.sym} 3060 40160 0 0 {name=l32240 lab=VSS}
C {bitcell_6t.sym} 3200 40200 0 0 {name=Xr201c16}
N 3160 40240 3140 40240 {}
C {lab_pin.sym} 3140 40240 0 0 {name=l32241 lab=BL16}
N 3160 40200 3140 40200 {}
C {lab_pin.sym} 3140 40200 0 0 {name=l32242 lab=BLB16}
N 3160 40160 3140 40160 {}
C {lab_pin.sym} 3140 40160 0 0 {name=l32243 lab=WL201}
N 3240 40240 3260 40240 {}
C {lab_pin.sym} 3260 40240 0 0 {name=l32244 lab=VDD}
N 3240 40160 3260 40160 {}
C {lab_pin.sym} 3260 40160 0 0 {name=l32245 lab=VSS}
C {bitcell_6t.sym} 3400 40200 0 0 {name=Xr201c17}
N 3360 40240 3340 40240 {}
C {lab_pin.sym} 3340 40240 0 0 {name=l32246 lab=BL17}
N 3360 40200 3340 40200 {}
C {lab_pin.sym} 3340 40200 0 0 {name=l32247 lab=BLB17}
N 3360 40160 3340 40160 {}
C {lab_pin.sym} 3340 40160 0 0 {name=l32248 lab=WL201}
N 3440 40240 3460 40240 {}
C {lab_pin.sym} 3460 40240 0 0 {name=l32249 lab=VDD}
N 3440 40160 3460 40160 {}
C {lab_pin.sym} 3460 40160 0 0 {name=l32250 lab=VSS}
C {bitcell_6t.sym} 3600 40200 0 0 {name=Xr201c18}
N 3560 40240 3540 40240 {}
C {lab_pin.sym} 3540 40240 0 0 {name=l32251 lab=BL18}
N 3560 40200 3540 40200 {}
C {lab_pin.sym} 3540 40200 0 0 {name=l32252 lab=BLB18}
N 3560 40160 3540 40160 {}
C {lab_pin.sym} 3540 40160 0 0 {name=l32253 lab=WL201}
N 3640 40240 3660 40240 {}
C {lab_pin.sym} 3660 40240 0 0 {name=l32254 lab=VDD}
N 3640 40160 3660 40160 {}
C {lab_pin.sym} 3660 40160 0 0 {name=l32255 lab=VSS}
C {bitcell_6t.sym} 3800 40200 0 0 {name=Xr201c19}
N 3760 40240 3740 40240 {}
C {lab_pin.sym} 3740 40240 0 0 {name=l32256 lab=BL19}
N 3760 40200 3740 40200 {}
C {lab_pin.sym} 3740 40200 0 0 {name=l32257 lab=BLB19}
N 3760 40160 3740 40160 {}
C {lab_pin.sym} 3740 40160 0 0 {name=l32258 lab=WL201}
N 3840 40240 3860 40240 {}
C {lab_pin.sym} 3860 40240 0 0 {name=l32259 lab=VDD}
N 3840 40160 3860 40160 {}
C {lab_pin.sym} 3860 40160 0 0 {name=l32260 lab=VSS}
C {bitcell_6t.sym} 4000 40200 0 0 {name=Xr201c20}
N 3960 40240 3940 40240 {}
C {lab_pin.sym} 3940 40240 0 0 {name=l32261 lab=BL20}
N 3960 40200 3940 40200 {}
C {lab_pin.sym} 3940 40200 0 0 {name=l32262 lab=BLB20}
N 3960 40160 3940 40160 {}
C {lab_pin.sym} 3940 40160 0 0 {name=l32263 lab=WL201}
N 4040 40240 4060 40240 {}
C {lab_pin.sym} 4060 40240 0 0 {name=l32264 lab=VDD}
N 4040 40160 4060 40160 {}
C {lab_pin.sym} 4060 40160 0 0 {name=l32265 lab=VSS}
C {bitcell_6t.sym} 4200 40200 0 0 {name=Xr201c21}
N 4160 40240 4140 40240 {}
C {lab_pin.sym} 4140 40240 0 0 {name=l32266 lab=BL21}
N 4160 40200 4140 40200 {}
C {lab_pin.sym} 4140 40200 0 0 {name=l32267 lab=BLB21}
N 4160 40160 4140 40160 {}
C {lab_pin.sym} 4140 40160 0 0 {name=l32268 lab=WL201}
N 4240 40240 4260 40240 {}
C {lab_pin.sym} 4260 40240 0 0 {name=l32269 lab=VDD}
N 4240 40160 4260 40160 {}
C {lab_pin.sym} 4260 40160 0 0 {name=l32270 lab=VSS}
C {bitcell_6t.sym} 4400 40200 0 0 {name=Xr201c22}
N 4360 40240 4340 40240 {}
C {lab_pin.sym} 4340 40240 0 0 {name=l32271 lab=BL22}
N 4360 40200 4340 40200 {}
C {lab_pin.sym} 4340 40200 0 0 {name=l32272 lab=BLB22}
N 4360 40160 4340 40160 {}
C {lab_pin.sym} 4340 40160 0 0 {name=l32273 lab=WL201}
N 4440 40240 4460 40240 {}
C {lab_pin.sym} 4460 40240 0 0 {name=l32274 lab=VDD}
N 4440 40160 4460 40160 {}
C {lab_pin.sym} 4460 40160 0 0 {name=l32275 lab=VSS}
C {bitcell_6t.sym} 4600 40200 0 0 {name=Xr201c23}
N 4560 40240 4540 40240 {}
C {lab_pin.sym} 4540 40240 0 0 {name=l32276 lab=BL23}
N 4560 40200 4540 40200 {}
C {lab_pin.sym} 4540 40200 0 0 {name=l32277 lab=BLB23}
N 4560 40160 4540 40160 {}
C {lab_pin.sym} 4540 40160 0 0 {name=l32278 lab=WL201}
N 4640 40240 4660 40240 {}
C {lab_pin.sym} 4660 40240 0 0 {name=l32279 lab=VDD}
N 4640 40160 4660 40160 {}
C {lab_pin.sym} 4660 40160 0 0 {name=l32280 lab=VSS}
C {bitcell_6t.sym} 4800 40200 0 0 {name=Xr201c24}
N 4760 40240 4740 40240 {}
C {lab_pin.sym} 4740 40240 0 0 {name=l32281 lab=BL24}
N 4760 40200 4740 40200 {}
C {lab_pin.sym} 4740 40200 0 0 {name=l32282 lab=BLB24}
N 4760 40160 4740 40160 {}
C {lab_pin.sym} 4740 40160 0 0 {name=l32283 lab=WL201}
N 4840 40240 4860 40240 {}
C {lab_pin.sym} 4860 40240 0 0 {name=l32284 lab=VDD}
N 4840 40160 4860 40160 {}
C {lab_pin.sym} 4860 40160 0 0 {name=l32285 lab=VSS}
C {bitcell_6t.sym} 5000 40200 0 0 {name=Xr201c25}
N 4960 40240 4940 40240 {}
C {lab_pin.sym} 4940 40240 0 0 {name=l32286 lab=BL25}
N 4960 40200 4940 40200 {}
C {lab_pin.sym} 4940 40200 0 0 {name=l32287 lab=BLB25}
N 4960 40160 4940 40160 {}
C {lab_pin.sym} 4940 40160 0 0 {name=l32288 lab=WL201}
N 5040 40240 5060 40240 {}
C {lab_pin.sym} 5060 40240 0 0 {name=l32289 lab=VDD}
N 5040 40160 5060 40160 {}
C {lab_pin.sym} 5060 40160 0 0 {name=l32290 lab=VSS}
C {bitcell_6t.sym} 5200 40200 0 0 {name=Xr201c26}
N 5160 40240 5140 40240 {}
C {lab_pin.sym} 5140 40240 0 0 {name=l32291 lab=BL26}
N 5160 40200 5140 40200 {}
C {lab_pin.sym} 5140 40200 0 0 {name=l32292 lab=BLB26}
N 5160 40160 5140 40160 {}
C {lab_pin.sym} 5140 40160 0 0 {name=l32293 lab=WL201}
N 5240 40240 5260 40240 {}
C {lab_pin.sym} 5260 40240 0 0 {name=l32294 lab=VDD}
N 5240 40160 5260 40160 {}
C {lab_pin.sym} 5260 40160 0 0 {name=l32295 lab=VSS}
C {bitcell_6t.sym} 5400 40200 0 0 {name=Xr201c27}
N 5360 40240 5340 40240 {}
C {lab_pin.sym} 5340 40240 0 0 {name=l32296 lab=BL27}
N 5360 40200 5340 40200 {}
C {lab_pin.sym} 5340 40200 0 0 {name=l32297 lab=BLB27}
N 5360 40160 5340 40160 {}
C {lab_pin.sym} 5340 40160 0 0 {name=l32298 lab=WL201}
N 5440 40240 5460 40240 {}
C {lab_pin.sym} 5460 40240 0 0 {name=l32299 lab=VDD}
N 5440 40160 5460 40160 {}
C {lab_pin.sym} 5460 40160 0 0 {name=l32300 lab=VSS}
C {bitcell_6t.sym} 5600 40200 0 0 {name=Xr201c28}
N 5560 40240 5540 40240 {}
C {lab_pin.sym} 5540 40240 0 0 {name=l32301 lab=BL28}
N 5560 40200 5540 40200 {}
C {lab_pin.sym} 5540 40200 0 0 {name=l32302 lab=BLB28}
N 5560 40160 5540 40160 {}
C {lab_pin.sym} 5540 40160 0 0 {name=l32303 lab=WL201}
N 5640 40240 5660 40240 {}
C {lab_pin.sym} 5660 40240 0 0 {name=l32304 lab=VDD}
N 5640 40160 5660 40160 {}
C {lab_pin.sym} 5660 40160 0 0 {name=l32305 lab=VSS}
C {bitcell_6t.sym} 5800 40200 0 0 {name=Xr201c29}
N 5760 40240 5740 40240 {}
C {lab_pin.sym} 5740 40240 0 0 {name=l32306 lab=BL29}
N 5760 40200 5740 40200 {}
C {lab_pin.sym} 5740 40200 0 0 {name=l32307 lab=BLB29}
N 5760 40160 5740 40160 {}
C {lab_pin.sym} 5740 40160 0 0 {name=l32308 lab=WL201}
N 5840 40240 5860 40240 {}
C {lab_pin.sym} 5860 40240 0 0 {name=l32309 lab=VDD}
N 5840 40160 5860 40160 {}
C {lab_pin.sym} 5860 40160 0 0 {name=l32310 lab=VSS}
C {bitcell_6t.sym} 6000 40200 0 0 {name=Xr201c30}
N 5960 40240 5940 40240 {}
C {lab_pin.sym} 5940 40240 0 0 {name=l32311 lab=BL30}
N 5960 40200 5940 40200 {}
C {lab_pin.sym} 5940 40200 0 0 {name=l32312 lab=BLB30}
N 5960 40160 5940 40160 {}
C {lab_pin.sym} 5940 40160 0 0 {name=l32313 lab=WL201}
N 6040 40240 6060 40240 {}
C {lab_pin.sym} 6060 40240 0 0 {name=l32314 lab=VDD}
N 6040 40160 6060 40160 {}
C {lab_pin.sym} 6060 40160 0 0 {name=l32315 lab=VSS}
C {bitcell_6t.sym} 6200 40200 0 0 {name=Xr201c31}
N 6160 40240 6140 40240 {}
C {lab_pin.sym} 6140 40240 0 0 {name=l32316 lab=BL31}
N 6160 40200 6140 40200 {}
C {lab_pin.sym} 6140 40200 0 0 {name=l32317 lab=BLB31}
N 6160 40160 6140 40160 {}
C {lab_pin.sym} 6140 40160 0 0 {name=l32318 lab=WL201}
N 6240 40240 6260 40240 {}
C {lab_pin.sym} 6260 40240 0 0 {name=l32319 lab=VDD}
N 6240 40160 6260 40160 {}
C {lab_pin.sym} 6260 40160 0 0 {name=l32320 lab=VSS}
C {bitcell_6t.sym} 0 40400 0 0 {name=Xr202c0}
N -40 40440 -60 40440 {}
C {lab_pin.sym} -60 40440 0 0 {name=l32321 lab=BL0}
N -40 40400 -60 40400 {}
C {lab_pin.sym} -60 40400 0 0 {name=l32322 lab=BLB0}
N -40 40360 -60 40360 {}
C {lab_pin.sym} -60 40360 0 0 {name=l32323 lab=WL202}
N 40 40440 60 40440 {}
C {lab_pin.sym} 60 40440 0 0 {name=l32324 lab=VDD}
N 40 40360 60 40360 {}
C {lab_pin.sym} 60 40360 0 0 {name=l32325 lab=VSS}
C {bitcell_6t.sym} 200 40400 0 0 {name=Xr202c1}
N 160 40440 140 40440 {}
C {lab_pin.sym} 140 40440 0 0 {name=l32326 lab=BL1}
N 160 40400 140 40400 {}
C {lab_pin.sym} 140 40400 0 0 {name=l32327 lab=BLB1}
N 160 40360 140 40360 {}
C {lab_pin.sym} 140 40360 0 0 {name=l32328 lab=WL202}
N 240 40440 260 40440 {}
C {lab_pin.sym} 260 40440 0 0 {name=l32329 lab=VDD}
N 240 40360 260 40360 {}
C {lab_pin.sym} 260 40360 0 0 {name=l32330 lab=VSS}
C {bitcell_6t.sym} 400 40400 0 0 {name=Xr202c2}
N 360 40440 340 40440 {}
C {lab_pin.sym} 340 40440 0 0 {name=l32331 lab=BL2}
N 360 40400 340 40400 {}
C {lab_pin.sym} 340 40400 0 0 {name=l32332 lab=BLB2}
N 360 40360 340 40360 {}
C {lab_pin.sym} 340 40360 0 0 {name=l32333 lab=WL202}
N 440 40440 460 40440 {}
C {lab_pin.sym} 460 40440 0 0 {name=l32334 lab=VDD}
N 440 40360 460 40360 {}
C {lab_pin.sym} 460 40360 0 0 {name=l32335 lab=VSS}
C {bitcell_6t.sym} 600 40400 0 0 {name=Xr202c3}
N 560 40440 540 40440 {}
C {lab_pin.sym} 540 40440 0 0 {name=l32336 lab=BL3}
N 560 40400 540 40400 {}
C {lab_pin.sym} 540 40400 0 0 {name=l32337 lab=BLB3}
N 560 40360 540 40360 {}
C {lab_pin.sym} 540 40360 0 0 {name=l32338 lab=WL202}
N 640 40440 660 40440 {}
C {lab_pin.sym} 660 40440 0 0 {name=l32339 lab=VDD}
N 640 40360 660 40360 {}
C {lab_pin.sym} 660 40360 0 0 {name=l32340 lab=VSS}
C {bitcell_6t.sym} 800 40400 0 0 {name=Xr202c4}
N 760 40440 740 40440 {}
C {lab_pin.sym} 740 40440 0 0 {name=l32341 lab=BL4}
N 760 40400 740 40400 {}
C {lab_pin.sym} 740 40400 0 0 {name=l32342 lab=BLB4}
N 760 40360 740 40360 {}
C {lab_pin.sym} 740 40360 0 0 {name=l32343 lab=WL202}
N 840 40440 860 40440 {}
C {lab_pin.sym} 860 40440 0 0 {name=l32344 lab=VDD}
N 840 40360 860 40360 {}
C {lab_pin.sym} 860 40360 0 0 {name=l32345 lab=VSS}
C {bitcell_6t.sym} 1000 40400 0 0 {name=Xr202c5}
N 960 40440 940 40440 {}
C {lab_pin.sym} 940 40440 0 0 {name=l32346 lab=BL5}
N 960 40400 940 40400 {}
C {lab_pin.sym} 940 40400 0 0 {name=l32347 lab=BLB5}
N 960 40360 940 40360 {}
C {lab_pin.sym} 940 40360 0 0 {name=l32348 lab=WL202}
N 1040 40440 1060 40440 {}
C {lab_pin.sym} 1060 40440 0 0 {name=l32349 lab=VDD}
N 1040 40360 1060 40360 {}
C {lab_pin.sym} 1060 40360 0 0 {name=l32350 lab=VSS}
C {bitcell_6t.sym} 1200 40400 0 0 {name=Xr202c6}
N 1160 40440 1140 40440 {}
C {lab_pin.sym} 1140 40440 0 0 {name=l32351 lab=BL6}
N 1160 40400 1140 40400 {}
C {lab_pin.sym} 1140 40400 0 0 {name=l32352 lab=BLB6}
N 1160 40360 1140 40360 {}
C {lab_pin.sym} 1140 40360 0 0 {name=l32353 lab=WL202}
N 1240 40440 1260 40440 {}
C {lab_pin.sym} 1260 40440 0 0 {name=l32354 lab=VDD}
N 1240 40360 1260 40360 {}
C {lab_pin.sym} 1260 40360 0 0 {name=l32355 lab=VSS}
C {bitcell_6t.sym} 1400 40400 0 0 {name=Xr202c7}
N 1360 40440 1340 40440 {}
C {lab_pin.sym} 1340 40440 0 0 {name=l32356 lab=BL7}
N 1360 40400 1340 40400 {}
C {lab_pin.sym} 1340 40400 0 0 {name=l32357 lab=BLB7}
N 1360 40360 1340 40360 {}
C {lab_pin.sym} 1340 40360 0 0 {name=l32358 lab=WL202}
N 1440 40440 1460 40440 {}
C {lab_pin.sym} 1460 40440 0 0 {name=l32359 lab=VDD}
N 1440 40360 1460 40360 {}
C {lab_pin.sym} 1460 40360 0 0 {name=l32360 lab=VSS}
C {bitcell_6t.sym} 1600 40400 0 0 {name=Xr202c8}
N 1560 40440 1540 40440 {}
C {lab_pin.sym} 1540 40440 0 0 {name=l32361 lab=BL8}
N 1560 40400 1540 40400 {}
C {lab_pin.sym} 1540 40400 0 0 {name=l32362 lab=BLB8}
N 1560 40360 1540 40360 {}
C {lab_pin.sym} 1540 40360 0 0 {name=l32363 lab=WL202}
N 1640 40440 1660 40440 {}
C {lab_pin.sym} 1660 40440 0 0 {name=l32364 lab=VDD}
N 1640 40360 1660 40360 {}
C {lab_pin.sym} 1660 40360 0 0 {name=l32365 lab=VSS}
C {bitcell_6t.sym} 1800 40400 0 0 {name=Xr202c9}
N 1760 40440 1740 40440 {}
C {lab_pin.sym} 1740 40440 0 0 {name=l32366 lab=BL9}
N 1760 40400 1740 40400 {}
C {lab_pin.sym} 1740 40400 0 0 {name=l32367 lab=BLB9}
N 1760 40360 1740 40360 {}
C {lab_pin.sym} 1740 40360 0 0 {name=l32368 lab=WL202}
N 1840 40440 1860 40440 {}
C {lab_pin.sym} 1860 40440 0 0 {name=l32369 lab=VDD}
N 1840 40360 1860 40360 {}
C {lab_pin.sym} 1860 40360 0 0 {name=l32370 lab=VSS}
C {bitcell_6t.sym} 2000 40400 0 0 {name=Xr202c10}
N 1960 40440 1940 40440 {}
C {lab_pin.sym} 1940 40440 0 0 {name=l32371 lab=BL10}
N 1960 40400 1940 40400 {}
C {lab_pin.sym} 1940 40400 0 0 {name=l32372 lab=BLB10}
N 1960 40360 1940 40360 {}
C {lab_pin.sym} 1940 40360 0 0 {name=l32373 lab=WL202}
N 2040 40440 2060 40440 {}
C {lab_pin.sym} 2060 40440 0 0 {name=l32374 lab=VDD}
N 2040 40360 2060 40360 {}
C {lab_pin.sym} 2060 40360 0 0 {name=l32375 lab=VSS}
C {bitcell_6t.sym} 2200 40400 0 0 {name=Xr202c11}
N 2160 40440 2140 40440 {}
C {lab_pin.sym} 2140 40440 0 0 {name=l32376 lab=BL11}
N 2160 40400 2140 40400 {}
C {lab_pin.sym} 2140 40400 0 0 {name=l32377 lab=BLB11}
N 2160 40360 2140 40360 {}
C {lab_pin.sym} 2140 40360 0 0 {name=l32378 lab=WL202}
N 2240 40440 2260 40440 {}
C {lab_pin.sym} 2260 40440 0 0 {name=l32379 lab=VDD}
N 2240 40360 2260 40360 {}
C {lab_pin.sym} 2260 40360 0 0 {name=l32380 lab=VSS}
C {bitcell_6t.sym} 2400 40400 0 0 {name=Xr202c12}
N 2360 40440 2340 40440 {}
C {lab_pin.sym} 2340 40440 0 0 {name=l32381 lab=BL12}
N 2360 40400 2340 40400 {}
C {lab_pin.sym} 2340 40400 0 0 {name=l32382 lab=BLB12}
N 2360 40360 2340 40360 {}
C {lab_pin.sym} 2340 40360 0 0 {name=l32383 lab=WL202}
N 2440 40440 2460 40440 {}
C {lab_pin.sym} 2460 40440 0 0 {name=l32384 lab=VDD}
N 2440 40360 2460 40360 {}
C {lab_pin.sym} 2460 40360 0 0 {name=l32385 lab=VSS}
C {bitcell_6t.sym} 2600 40400 0 0 {name=Xr202c13}
N 2560 40440 2540 40440 {}
C {lab_pin.sym} 2540 40440 0 0 {name=l32386 lab=BL13}
N 2560 40400 2540 40400 {}
C {lab_pin.sym} 2540 40400 0 0 {name=l32387 lab=BLB13}
N 2560 40360 2540 40360 {}
C {lab_pin.sym} 2540 40360 0 0 {name=l32388 lab=WL202}
N 2640 40440 2660 40440 {}
C {lab_pin.sym} 2660 40440 0 0 {name=l32389 lab=VDD}
N 2640 40360 2660 40360 {}
C {lab_pin.sym} 2660 40360 0 0 {name=l32390 lab=VSS}
C {bitcell_6t.sym} 2800 40400 0 0 {name=Xr202c14}
N 2760 40440 2740 40440 {}
C {lab_pin.sym} 2740 40440 0 0 {name=l32391 lab=BL14}
N 2760 40400 2740 40400 {}
C {lab_pin.sym} 2740 40400 0 0 {name=l32392 lab=BLB14}
N 2760 40360 2740 40360 {}
C {lab_pin.sym} 2740 40360 0 0 {name=l32393 lab=WL202}
N 2840 40440 2860 40440 {}
C {lab_pin.sym} 2860 40440 0 0 {name=l32394 lab=VDD}
N 2840 40360 2860 40360 {}
C {lab_pin.sym} 2860 40360 0 0 {name=l32395 lab=VSS}
C {bitcell_6t.sym} 3000 40400 0 0 {name=Xr202c15}
N 2960 40440 2940 40440 {}
C {lab_pin.sym} 2940 40440 0 0 {name=l32396 lab=BL15}
N 2960 40400 2940 40400 {}
C {lab_pin.sym} 2940 40400 0 0 {name=l32397 lab=BLB15}
N 2960 40360 2940 40360 {}
C {lab_pin.sym} 2940 40360 0 0 {name=l32398 lab=WL202}
N 3040 40440 3060 40440 {}
C {lab_pin.sym} 3060 40440 0 0 {name=l32399 lab=VDD}
N 3040 40360 3060 40360 {}
C {lab_pin.sym} 3060 40360 0 0 {name=l32400 lab=VSS}
C {bitcell_6t.sym} 3200 40400 0 0 {name=Xr202c16}
N 3160 40440 3140 40440 {}
C {lab_pin.sym} 3140 40440 0 0 {name=l32401 lab=BL16}
N 3160 40400 3140 40400 {}
C {lab_pin.sym} 3140 40400 0 0 {name=l32402 lab=BLB16}
N 3160 40360 3140 40360 {}
C {lab_pin.sym} 3140 40360 0 0 {name=l32403 lab=WL202}
N 3240 40440 3260 40440 {}
C {lab_pin.sym} 3260 40440 0 0 {name=l32404 lab=VDD}
N 3240 40360 3260 40360 {}
C {lab_pin.sym} 3260 40360 0 0 {name=l32405 lab=VSS}
C {bitcell_6t.sym} 3400 40400 0 0 {name=Xr202c17}
N 3360 40440 3340 40440 {}
C {lab_pin.sym} 3340 40440 0 0 {name=l32406 lab=BL17}
N 3360 40400 3340 40400 {}
C {lab_pin.sym} 3340 40400 0 0 {name=l32407 lab=BLB17}
N 3360 40360 3340 40360 {}
C {lab_pin.sym} 3340 40360 0 0 {name=l32408 lab=WL202}
N 3440 40440 3460 40440 {}
C {lab_pin.sym} 3460 40440 0 0 {name=l32409 lab=VDD}
N 3440 40360 3460 40360 {}
C {lab_pin.sym} 3460 40360 0 0 {name=l32410 lab=VSS}
C {bitcell_6t.sym} 3600 40400 0 0 {name=Xr202c18}
N 3560 40440 3540 40440 {}
C {lab_pin.sym} 3540 40440 0 0 {name=l32411 lab=BL18}
N 3560 40400 3540 40400 {}
C {lab_pin.sym} 3540 40400 0 0 {name=l32412 lab=BLB18}
N 3560 40360 3540 40360 {}
C {lab_pin.sym} 3540 40360 0 0 {name=l32413 lab=WL202}
N 3640 40440 3660 40440 {}
C {lab_pin.sym} 3660 40440 0 0 {name=l32414 lab=VDD}
N 3640 40360 3660 40360 {}
C {lab_pin.sym} 3660 40360 0 0 {name=l32415 lab=VSS}
C {bitcell_6t.sym} 3800 40400 0 0 {name=Xr202c19}
N 3760 40440 3740 40440 {}
C {lab_pin.sym} 3740 40440 0 0 {name=l32416 lab=BL19}
N 3760 40400 3740 40400 {}
C {lab_pin.sym} 3740 40400 0 0 {name=l32417 lab=BLB19}
N 3760 40360 3740 40360 {}
C {lab_pin.sym} 3740 40360 0 0 {name=l32418 lab=WL202}
N 3840 40440 3860 40440 {}
C {lab_pin.sym} 3860 40440 0 0 {name=l32419 lab=VDD}
N 3840 40360 3860 40360 {}
C {lab_pin.sym} 3860 40360 0 0 {name=l32420 lab=VSS}
C {bitcell_6t.sym} 4000 40400 0 0 {name=Xr202c20}
N 3960 40440 3940 40440 {}
C {lab_pin.sym} 3940 40440 0 0 {name=l32421 lab=BL20}
N 3960 40400 3940 40400 {}
C {lab_pin.sym} 3940 40400 0 0 {name=l32422 lab=BLB20}
N 3960 40360 3940 40360 {}
C {lab_pin.sym} 3940 40360 0 0 {name=l32423 lab=WL202}
N 4040 40440 4060 40440 {}
C {lab_pin.sym} 4060 40440 0 0 {name=l32424 lab=VDD}
N 4040 40360 4060 40360 {}
C {lab_pin.sym} 4060 40360 0 0 {name=l32425 lab=VSS}
C {bitcell_6t.sym} 4200 40400 0 0 {name=Xr202c21}
N 4160 40440 4140 40440 {}
C {lab_pin.sym} 4140 40440 0 0 {name=l32426 lab=BL21}
N 4160 40400 4140 40400 {}
C {lab_pin.sym} 4140 40400 0 0 {name=l32427 lab=BLB21}
N 4160 40360 4140 40360 {}
C {lab_pin.sym} 4140 40360 0 0 {name=l32428 lab=WL202}
N 4240 40440 4260 40440 {}
C {lab_pin.sym} 4260 40440 0 0 {name=l32429 lab=VDD}
N 4240 40360 4260 40360 {}
C {lab_pin.sym} 4260 40360 0 0 {name=l32430 lab=VSS}
C {bitcell_6t.sym} 4400 40400 0 0 {name=Xr202c22}
N 4360 40440 4340 40440 {}
C {lab_pin.sym} 4340 40440 0 0 {name=l32431 lab=BL22}
N 4360 40400 4340 40400 {}
C {lab_pin.sym} 4340 40400 0 0 {name=l32432 lab=BLB22}
N 4360 40360 4340 40360 {}
C {lab_pin.sym} 4340 40360 0 0 {name=l32433 lab=WL202}
N 4440 40440 4460 40440 {}
C {lab_pin.sym} 4460 40440 0 0 {name=l32434 lab=VDD}
N 4440 40360 4460 40360 {}
C {lab_pin.sym} 4460 40360 0 0 {name=l32435 lab=VSS}
C {bitcell_6t.sym} 4600 40400 0 0 {name=Xr202c23}
N 4560 40440 4540 40440 {}
C {lab_pin.sym} 4540 40440 0 0 {name=l32436 lab=BL23}
N 4560 40400 4540 40400 {}
C {lab_pin.sym} 4540 40400 0 0 {name=l32437 lab=BLB23}
N 4560 40360 4540 40360 {}
C {lab_pin.sym} 4540 40360 0 0 {name=l32438 lab=WL202}
N 4640 40440 4660 40440 {}
C {lab_pin.sym} 4660 40440 0 0 {name=l32439 lab=VDD}
N 4640 40360 4660 40360 {}
C {lab_pin.sym} 4660 40360 0 0 {name=l32440 lab=VSS}
C {bitcell_6t.sym} 4800 40400 0 0 {name=Xr202c24}
N 4760 40440 4740 40440 {}
C {lab_pin.sym} 4740 40440 0 0 {name=l32441 lab=BL24}
N 4760 40400 4740 40400 {}
C {lab_pin.sym} 4740 40400 0 0 {name=l32442 lab=BLB24}
N 4760 40360 4740 40360 {}
C {lab_pin.sym} 4740 40360 0 0 {name=l32443 lab=WL202}
N 4840 40440 4860 40440 {}
C {lab_pin.sym} 4860 40440 0 0 {name=l32444 lab=VDD}
N 4840 40360 4860 40360 {}
C {lab_pin.sym} 4860 40360 0 0 {name=l32445 lab=VSS}
C {bitcell_6t.sym} 5000 40400 0 0 {name=Xr202c25}
N 4960 40440 4940 40440 {}
C {lab_pin.sym} 4940 40440 0 0 {name=l32446 lab=BL25}
N 4960 40400 4940 40400 {}
C {lab_pin.sym} 4940 40400 0 0 {name=l32447 lab=BLB25}
N 4960 40360 4940 40360 {}
C {lab_pin.sym} 4940 40360 0 0 {name=l32448 lab=WL202}
N 5040 40440 5060 40440 {}
C {lab_pin.sym} 5060 40440 0 0 {name=l32449 lab=VDD}
N 5040 40360 5060 40360 {}
C {lab_pin.sym} 5060 40360 0 0 {name=l32450 lab=VSS}
C {bitcell_6t.sym} 5200 40400 0 0 {name=Xr202c26}
N 5160 40440 5140 40440 {}
C {lab_pin.sym} 5140 40440 0 0 {name=l32451 lab=BL26}
N 5160 40400 5140 40400 {}
C {lab_pin.sym} 5140 40400 0 0 {name=l32452 lab=BLB26}
N 5160 40360 5140 40360 {}
C {lab_pin.sym} 5140 40360 0 0 {name=l32453 lab=WL202}
N 5240 40440 5260 40440 {}
C {lab_pin.sym} 5260 40440 0 0 {name=l32454 lab=VDD}
N 5240 40360 5260 40360 {}
C {lab_pin.sym} 5260 40360 0 0 {name=l32455 lab=VSS}
C {bitcell_6t.sym} 5400 40400 0 0 {name=Xr202c27}
N 5360 40440 5340 40440 {}
C {lab_pin.sym} 5340 40440 0 0 {name=l32456 lab=BL27}
N 5360 40400 5340 40400 {}
C {lab_pin.sym} 5340 40400 0 0 {name=l32457 lab=BLB27}
N 5360 40360 5340 40360 {}
C {lab_pin.sym} 5340 40360 0 0 {name=l32458 lab=WL202}
N 5440 40440 5460 40440 {}
C {lab_pin.sym} 5460 40440 0 0 {name=l32459 lab=VDD}
N 5440 40360 5460 40360 {}
C {lab_pin.sym} 5460 40360 0 0 {name=l32460 lab=VSS}
C {bitcell_6t.sym} 5600 40400 0 0 {name=Xr202c28}
N 5560 40440 5540 40440 {}
C {lab_pin.sym} 5540 40440 0 0 {name=l32461 lab=BL28}
N 5560 40400 5540 40400 {}
C {lab_pin.sym} 5540 40400 0 0 {name=l32462 lab=BLB28}
N 5560 40360 5540 40360 {}
C {lab_pin.sym} 5540 40360 0 0 {name=l32463 lab=WL202}
N 5640 40440 5660 40440 {}
C {lab_pin.sym} 5660 40440 0 0 {name=l32464 lab=VDD}
N 5640 40360 5660 40360 {}
C {lab_pin.sym} 5660 40360 0 0 {name=l32465 lab=VSS}
C {bitcell_6t.sym} 5800 40400 0 0 {name=Xr202c29}
N 5760 40440 5740 40440 {}
C {lab_pin.sym} 5740 40440 0 0 {name=l32466 lab=BL29}
N 5760 40400 5740 40400 {}
C {lab_pin.sym} 5740 40400 0 0 {name=l32467 lab=BLB29}
N 5760 40360 5740 40360 {}
C {lab_pin.sym} 5740 40360 0 0 {name=l32468 lab=WL202}
N 5840 40440 5860 40440 {}
C {lab_pin.sym} 5860 40440 0 0 {name=l32469 lab=VDD}
N 5840 40360 5860 40360 {}
C {lab_pin.sym} 5860 40360 0 0 {name=l32470 lab=VSS}
C {bitcell_6t.sym} 6000 40400 0 0 {name=Xr202c30}
N 5960 40440 5940 40440 {}
C {lab_pin.sym} 5940 40440 0 0 {name=l32471 lab=BL30}
N 5960 40400 5940 40400 {}
C {lab_pin.sym} 5940 40400 0 0 {name=l32472 lab=BLB30}
N 5960 40360 5940 40360 {}
C {lab_pin.sym} 5940 40360 0 0 {name=l32473 lab=WL202}
N 6040 40440 6060 40440 {}
C {lab_pin.sym} 6060 40440 0 0 {name=l32474 lab=VDD}
N 6040 40360 6060 40360 {}
C {lab_pin.sym} 6060 40360 0 0 {name=l32475 lab=VSS}
C {bitcell_6t.sym} 6200 40400 0 0 {name=Xr202c31}
N 6160 40440 6140 40440 {}
C {lab_pin.sym} 6140 40440 0 0 {name=l32476 lab=BL31}
N 6160 40400 6140 40400 {}
C {lab_pin.sym} 6140 40400 0 0 {name=l32477 lab=BLB31}
N 6160 40360 6140 40360 {}
C {lab_pin.sym} 6140 40360 0 0 {name=l32478 lab=WL202}
N 6240 40440 6260 40440 {}
C {lab_pin.sym} 6260 40440 0 0 {name=l32479 lab=VDD}
N 6240 40360 6260 40360 {}
C {lab_pin.sym} 6260 40360 0 0 {name=l32480 lab=VSS}
C {bitcell_6t.sym} 0 40600 0 0 {name=Xr203c0}
N -40 40640 -60 40640 {}
C {lab_pin.sym} -60 40640 0 0 {name=l32481 lab=BL0}
N -40 40600 -60 40600 {}
C {lab_pin.sym} -60 40600 0 0 {name=l32482 lab=BLB0}
N -40 40560 -60 40560 {}
C {lab_pin.sym} -60 40560 0 0 {name=l32483 lab=WL203}
N 40 40640 60 40640 {}
C {lab_pin.sym} 60 40640 0 0 {name=l32484 lab=VDD}
N 40 40560 60 40560 {}
C {lab_pin.sym} 60 40560 0 0 {name=l32485 lab=VSS}
C {bitcell_6t.sym} 200 40600 0 0 {name=Xr203c1}
N 160 40640 140 40640 {}
C {lab_pin.sym} 140 40640 0 0 {name=l32486 lab=BL1}
N 160 40600 140 40600 {}
C {lab_pin.sym} 140 40600 0 0 {name=l32487 lab=BLB1}
N 160 40560 140 40560 {}
C {lab_pin.sym} 140 40560 0 0 {name=l32488 lab=WL203}
N 240 40640 260 40640 {}
C {lab_pin.sym} 260 40640 0 0 {name=l32489 lab=VDD}
N 240 40560 260 40560 {}
C {lab_pin.sym} 260 40560 0 0 {name=l32490 lab=VSS}
C {bitcell_6t.sym} 400 40600 0 0 {name=Xr203c2}
N 360 40640 340 40640 {}
C {lab_pin.sym} 340 40640 0 0 {name=l32491 lab=BL2}
N 360 40600 340 40600 {}
C {lab_pin.sym} 340 40600 0 0 {name=l32492 lab=BLB2}
N 360 40560 340 40560 {}
C {lab_pin.sym} 340 40560 0 0 {name=l32493 lab=WL203}
N 440 40640 460 40640 {}
C {lab_pin.sym} 460 40640 0 0 {name=l32494 lab=VDD}
N 440 40560 460 40560 {}
C {lab_pin.sym} 460 40560 0 0 {name=l32495 lab=VSS}
C {bitcell_6t.sym} 600 40600 0 0 {name=Xr203c3}
N 560 40640 540 40640 {}
C {lab_pin.sym} 540 40640 0 0 {name=l32496 lab=BL3}
N 560 40600 540 40600 {}
C {lab_pin.sym} 540 40600 0 0 {name=l32497 lab=BLB3}
N 560 40560 540 40560 {}
C {lab_pin.sym} 540 40560 0 0 {name=l32498 lab=WL203}
N 640 40640 660 40640 {}
C {lab_pin.sym} 660 40640 0 0 {name=l32499 lab=VDD}
N 640 40560 660 40560 {}
C {lab_pin.sym} 660 40560 0 0 {name=l32500 lab=VSS}
C {bitcell_6t.sym} 800 40600 0 0 {name=Xr203c4}
N 760 40640 740 40640 {}
C {lab_pin.sym} 740 40640 0 0 {name=l32501 lab=BL4}
N 760 40600 740 40600 {}
C {lab_pin.sym} 740 40600 0 0 {name=l32502 lab=BLB4}
N 760 40560 740 40560 {}
C {lab_pin.sym} 740 40560 0 0 {name=l32503 lab=WL203}
N 840 40640 860 40640 {}
C {lab_pin.sym} 860 40640 0 0 {name=l32504 lab=VDD}
N 840 40560 860 40560 {}
C {lab_pin.sym} 860 40560 0 0 {name=l32505 lab=VSS}
C {bitcell_6t.sym} 1000 40600 0 0 {name=Xr203c5}
N 960 40640 940 40640 {}
C {lab_pin.sym} 940 40640 0 0 {name=l32506 lab=BL5}
N 960 40600 940 40600 {}
C {lab_pin.sym} 940 40600 0 0 {name=l32507 lab=BLB5}
N 960 40560 940 40560 {}
C {lab_pin.sym} 940 40560 0 0 {name=l32508 lab=WL203}
N 1040 40640 1060 40640 {}
C {lab_pin.sym} 1060 40640 0 0 {name=l32509 lab=VDD}
N 1040 40560 1060 40560 {}
C {lab_pin.sym} 1060 40560 0 0 {name=l32510 lab=VSS}
C {bitcell_6t.sym} 1200 40600 0 0 {name=Xr203c6}
N 1160 40640 1140 40640 {}
C {lab_pin.sym} 1140 40640 0 0 {name=l32511 lab=BL6}
N 1160 40600 1140 40600 {}
C {lab_pin.sym} 1140 40600 0 0 {name=l32512 lab=BLB6}
N 1160 40560 1140 40560 {}
C {lab_pin.sym} 1140 40560 0 0 {name=l32513 lab=WL203}
N 1240 40640 1260 40640 {}
C {lab_pin.sym} 1260 40640 0 0 {name=l32514 lab=VDD}
N 1240 40560 1260 40560 {}
C {lab_pin.sym} 1260 40560 0 0 {name=l32515 lab=VSS}
C {bitcell_6t.sym} 1400 40600 0 0 {name=Xr203c7}
N 1360 40640 1340 40640 {}
C {lab_pin.sym} 1340 40640 0 0 {name=l32516 lab=BL7}
N 1360 40600 1340 40600 {}
C {lab_pin.sym} 1340 40600 0 0 {name=l32517 lab=BLB7}
N 1360 40560 1340 40560 {}
C {lab_pin.sym} 1340 40560 0 0 {name=l32518 lab=WL203}
N 1440 40640 1460 40640 {}
C {lab_pin.sym} 1460 40640 0 0 {name=l32519 lab=VDD}
N 1440 40560 1460 40560 {}
C {lab_pin.sym} 1460 40560 0 0 {name=l32520 lab=VSS}
C {bitcell_6t.sym} 1600 40600 0 0 {name=Xr203c8}
N 1560 40640 1540 40640 {}
C {lab_pin.sym} 1540 40640 0 0 {name=l32521 lab=BL8}
N 1560 40600 1540 40600 {}
C {lab_pin.sym} 1540 40600 0 0 {name=l32522 lab=BLB8}
N 1560 40560 1540 40560 {}
C {lab_pin.sym} 1540 40560 0 0 {name=l32523 lab=WL203}
N 1640 40640 1660 40640 {}
C {lab_pin.sym} 1660 40640 0 0 {name=l32524 lab=VDD}
N 1640 40560 1660 40560 {}
C {lab_pin.sym} 1660 40560 0 0 {name=l32525 lab=VSS}
C {bitcell_6t.sym} 1800 40600 0 0 {name=Xr203c9}
N 1760 40640 1740 40640 {}
C {lab_pin.sym} 1740 40640 0 0 {name=l32526 lab=BL9}
N 1760 40600 1740 40600 {}
C {lab_pin.sym} 1740 40600 0 0 {name=l32527 lab=BLB9}
N 1760 40560 1740 40560 {}
C {lab_pin.sym} 1740 40560 0 0 {name=l32528 lab=WL203}
N 1840 40640 1860 40640 {}
C {lab_pin.sym} 1860 40640 0 0 {name=l32529 lab=VDD}
N 1840 40560 1860 40560 {}
C {lab_pin.sym} 1860 40560 0 0 {name=l32530 lab=VSS}
C {bitcell_6t.sym} 2000 40600 0 0 {name=Xr203c10}
N 1960 40640 1940 40640 {}
C {lab_pin.sym} 1940 40640 0 0 {name=l32531 lab=BL10}
N 1960 40600 1940 40600 {}
C {lab_pin.sym} 1940 40600 0 0 {name=l32532 lab=BLB10}
N 1960 40560 1940 40560 {}
C {lab_pin.sym} 1940 40560 0 0 {name=l32533 lab=WL203}
N 2040 40640 2060 40640 {}
C {lab_pin.sym} 2060 40640 0 0 {name=l32534 lab=VDD}
N 2040 40560 2060 40560 {}
C {lab_pin.sym} 2060 40560 0 0 {name=l32535 lab=VSS}
C {bitcell_6t.sym} 2200 40600 0 0 {name=Xr203c11}
N 2160 40640 2140 40640 {}
C {lab_pin.sym} 2140 40640 0 0 {name=l32536 lab=BL11}
N 2160 40600 2140 40600 {}
C {lab_pin.sym} 2140 40600 0 0 {name=l32537 lab=BLB11}
N 2160 40560 2140 40560 {}
C {lab_pin.sym} 2140 40560 0 0 {name=l32538 lab=WL203}
N 2240 40640 2260 40640 {}
C {lab_pin.sym} 2260 40640 0 0 {name=l32539 lab=VDD}
N 2240 40560 2260 40560 {}
C {lab_pin.sym} 2260 40560 0 0 {name=l32540 lab=VSS}
C {bitcell_6t.sym} 2400 40600 0 0 {name=Xr203c12}
N 2360 40640 2340 40640 {}
C {lab_pin.sym} 2340 40640 0 0 {name=l32541 lab=BL12}
N 2360 40600 2340 40600 {}
C {lab_pin.sym} 2340 40600 0 0 {name=l32542 lab=BLB12}
N 2360 40560 2340 40560 {}
C {lab_pin.sym} 2340 40560 0 0 {name=l32543 lab=WL203}
N 2440 40640 2460 40640 {}
C {lab_pin.sym} 2460 40640 0 0 {name=l32544 lab=VDD}
N 2440 40560 2460 40560 {}
C {lab_pin.sym} 2460 40560 0 0 {name=l32545 lab=VSS}
C {bitcell_6t.sym} 2600 40600 0 0 {name=Xr203c13}
N 2560 40640 2540 40640 {}
C {lab_pin.sym} 2540 40640 0 0 {name=l32546 lab=BL13}
N 2560 40600 2540 40600 {}
C {lab_pin.sym} 2540 40600 0 0 {name=l32547 lab=BLB13}
N 2560 40560 2540 40560 {}
C {lab_pin.sym} 2540 40560 0 0 {name=l32548 lab=WL203}
N 2640 40640 2660 40640 {}
C {lab_pin.sym} 2660 40640 0 0 {name=l32549 lab=VDD}
N 2640 40560 2660 40560 {}
C {lab_pin.sym} 2660 40560 0 0 {name=l32550 lab=VSS}
C {bitcell_6t.sym} 2800 40600 0 0 {name=Xr203c14}
N 2760 40640 2740 40640 {}
C {lab_pin.sym} 2740 40640 0 0 {name=l32551 lab=BL14}
N 2760 40600 2740 40600 {}
C {lab_pin.sym} 2740 40600 0 0 {name=l32552 lab=BLB14}
N 2760 40560 2740 40560 {}
C {lab_pin.sym} 2740 40560 0 0 {name=l32553 lab=WL203}
N 2840 40640 2860 40640 {}
C {lab_pin.sym} 2860 40640 0 0 {name=l32554 lab=VDD}
N 2840 40560 2860 40560 {}
C {lab_pin.sym} 2860 40560 0 0 {name=l32555 lab=VSS}
C {bitcell_6t.sym} 3000 40600 0 0 {name=Xr203c15}
N 2960 40640 2940 40640 {}
C {lab_pin.sym} 2940 40640 0 0 {name=l32556 lab=BL15}
N 2960 40600 2940 40600 {}
C {lab_pin.sym} 2940 40600 0 0 {name=l32557 lab=BLB15}
N 2960 40560 2940 40560 {}
C {lab_pin.sym} 2940 40560 0 0 {name=l32558 lab=WL203}
N 3040 40640 3060 40640 {}
C {lab_pin.sym} 3060 40640 0 0 {name=l32559 lab=VDD}
N 3040 40560 3060 40560 {}
C {lab_pin.sym} 3060 40560 0 0 {name=l32560 lab=VSS}
C {bitcell_6t.sym} 3200 40600 0 0 {name=Xr203c16}
N 3160 40640 3140 40640 {}
C {lab_pin.sym} 3140 40640 0 0 {name=l32561 lab=BL16}
N 3160 40600 3140 40600 {}
C {lab_pin.sym} 3140 40600 0 0 {name=l32562 lab=BLB16}
N 3160 40560 3140 40560 {}
C {lab_pin.sym} 3140 40560 0 0 {name=l32563 lab=WL203}
N 3240 40640 3260 40640 {}
C {lab_pin.sym} 3260 40640 0 0 {name=l32564 lab=VDD}
N 3240 40560 3260 40560 {}
C {lab_pin.sym} 3260 40560 0 0 {name=l32565 lab=VSS}
C {bitcell_6t.sym} 3400 40600 0 0 {name=Xr203c17}
N 3360 40640 3340 40640 {}
C {lab_pin.sym} 3340 40640 0 0 {name=l32566 lab=BL17}
N 3360 40600 3340 40600 {}
C {lab_pin.sym} 3340 40600 0 0 {name=l32567 lab=BLB17}
N 3360 40560 3340 40560 {}
C {lab_pin.sym} 3340 40560 0 0 {name=l32568 lab=WL203}
N 3440 40640 3460 40640 {}
C {lab_pin.sym} 3460 40640 0 0 {name=l32569 lab=VDD}
N 3440 40560 3460 40560 {}
C {lab_pin.sym} 3460 40560 0 0 {name=l32570 lab=VSS}
C {bitcell_6t.sym} 3600 40600 0 0 {name=Xr203c18}
N 3560 40640 3540 40640 {}
C {lab_pin.sym} 3540 40640 0 0 {name=l32571 lab=BL18}
N 3560 40600 3540 40600 {}
C {lab_pin.sym} 3540 40600 0 0 {name=l32572 lab=BLB18}
N 3560 40560 3540 40560 {}
C {lab_pin.sym} 3540 40560 0 0 {name=l32573 lab=WL203}
N 3640 40640 3660 40640 {}
C {lab_pin.sym} 3660 40640 0 0 {name=l32574 lab=VDD}
N 3640 40560 3660 40560 {}
C {lab_pin.sym} 3660 40560 0 0 {name=l32575 lab=VSS}
C {bitcell_6t.sym} 3800 40600 0 0 {name=Xr203c19}
N 3760 40640 3740 40640 {}
C {lab_pin.sym} 3740 40640 0 0 {name=l32576 lab=BL19}
N 3760 40600 3740 40600 {}
C {lab_pin.sym} 3740 40600 0 0 {name=l32577 lab=BLB19}
N 3760 40560 3740 40560 {}
C {lab_pin.sym} 3740 40560 0 0 {name=l32578 lab=WL203}
N 3840 40640 3860 40640 {}
C {lab_pin.sym} 3860 40640 0 0 {name=l32579 lab=VDD}
N 3840 40560 3860 40560 {}
C {lab_pin.sym} 3860 40560 0 0 {name=l32580 lab=VSS}
C {bitcell_6t.sym} 4000 40600 0 0 {name=Xr203c20}
N 3960 40640 3940 40640 {}
C {lab_pin.sym} 3940 40640 0 0 {name=l32581 lab=BL20}
N 3960 40600 3940 40600 {}
C {lab_pin.sym} 3940 40600 0 0 {name=l32582 lab=BLB20}
N 3960 40560 3940 40560 {}
C {lab_pin.sym} 3940 40560 0 0 {name=l32583 lab=WL203}
N 4040 40640 4060 40640 {}
C {lab_pin.sym} 4060 40640 0 0 {name=l32584 lab=VDD}
N 4040 40560 4060 40560 {}
C {lab_pin.sym} 4060 40560 0 0 {name=l32585 lab=VSS}
C {bitcell_6t.sym} 4200 40600 0 0 {name=Xr203c21}
N 4160 40640 4140 40640 {}
C {lab_pin.sym} 4140 40640 0 0 {name=l32586 lab=BL21}
N 4160 40600 4140 40600 {}
C {lab_pin.sym} 4140 40600 0 0 {name=l32587 lab=BLB21}
N 4160 40560 4140 40560 {}
C {lab_pin.sym} 4140 40560 0 0 {name=l32588 lab=WL203}
N 4240 40640 4260 40640 {}
C {lab_pin.sym} 4260 40640 0 0 {name=l32589 lab=VDD}
N 4240 40560 4260 40560 {}
C {lab_pin.sym} 4260 40560 0 0 {name=l32590 lab=VSS}
C {bitcell_6t.sym} 4400 40600 0 0 {name=Xr203c22}
N 4360 40640 4340 40640 {}
C {lab_pin.sym} 4340 40640 0 0 {name=l32591 lab=BL22}
N 4360 40600 4340 40600 {}
C {lab_pin.sym} 4340 40600 0 0 {name=l32592 lab=BLB22}
N 4360 40560 4340 40560 {}
C {lab_pin.sym} 4340 40560 0 0 {name=l32593 lab=WL203}
N 4440 40640 4460 40640 {}
C {lab_pin.sym} 4460 40640 0 0 {name=l32594 lab=VDD}
N 4440 40560 4460 40560 {}
C {lab_pin.sym} 4460 40560 0 0 {name=l32595 lab=VSS}
C {bitcell_6t.sym} 4600 40600 0 0 {name=Xr203c23}
N 4560 40640 4540 40640 {}
C {lab_pin.sym} 4540 40640 0 0 {name=l32596 lab=BL23}
N 4560 40600 4540 40600 {}
C {lab_pin.sym} 4540 40600 0 0 {name=l32597 lab=BLB23}
N 4560 40560 4540 40560 {}
C {lab_pin.sym} 4540 40560 0 0 {name=l32598 lab=WL203}
N 4640 40640 4660 40640 {}
C {lab_pin.sym} 4660 40640 0 0 {name=l32599 lab=VDD}
N 4640 40560 4660 40560 {}
C {lab_pin.sym} 4660 40560 0 0 {name=l32600 lab=VSS}
C {bitcell_6t.sym} 4800 40600 0 0 {name=Xr203c24}
N 4760 40640 4740 40640 {}
C {lab_pin.sym} 4740 40640 0 0 {name=l32601 lab=BL24}
N 4760 40600 4740 40600 {}
C {lab_pin.sym} 4740 40600 0 0 {name=l32602 lab=BLB24}
N 4760 40560 4740 40560 {}
C {lab_pin.sym} 4740 40560 0 0 {name=l32603 lab=WL203}
N 4840 40640 4860 40640 {}
C {lab_pin.sym} 4860 40640 0 0 {name=l32604 lab=VDD}
N 4840 40560 4860 40560 {}
C {lab_pin.sym} 4860 40560 0 0 {name=l32605 lab=VSS}
C {bitcell_6t.sym} 5000 40600 0 0 {name=Xr203c25}
N 4960 40640 4940 40640 {}
C {lab_pin.sym} 4940 40640 0 0 {name=l32606 lab=BL25}
N 4960 40600 4940 40600 {}
C {lab_pin.sym} 4940 40600 0 0 {name=l32607 lab=BLB25}
N 4960 40560 4940 40560 {}
C {lab_pin.sym} 4940 40560 0 0 {name=l32608 lab=WL203}
N 5040 40640 5060 40640 {}
C {lab_pin.sym} 5060 40640 0 0 {name=l32609 lab=VDD}
N 5040 40560 5060 40560 {}
C {lab_pin.sym} 5060 40560 0 0 {name=l32610 lab=VSS}
C {bitcell_6t.sym} 5200 40600 0 0 {name=Xr203c26}
N 5160 40640 5140 40640 {}
C {lab_pin.sym} 5140 40640 0 0 {name=l32611 lab=BL26}
N 5160 40600 5140 40600 {}
C {lab_pin.sym} 5140 40600 0 0 {name=l32612 lab=BLB26}
N 5160 40560 5140 40560 {}
C {lab_pin.sym} 5140 40560 0 0 {name=l32613 lab=WL203}
N 5240 40640 5260 40640 {}
C {lab_pin.sym} 5260 40640 0 0 {name=l32614 lab=VDD}
N 5240 40560 5260 40560 {}
C {lab_pin.sym} 5260 40560 0 0 {name=l32615 lab=VSS}
C {bitcell_6t.sym} 5400 40600 0 0 {name=Xr203c27}
N 5360 40640 5340 40640 {}
C {lab_pin.sym} 5340 40640 0 0 {name=l32616 lab=BL27}
N 5360 40600 5340 40600 {}
C {lab_pin.sym} 5340 40600 0 0 {name=l32617 lab=BLB27}
N 5360 40560 5340 40560 {}
C {lab_pin.sym} 5340 40560 0 0 {name=l32618 lab=WL203}
N 5440 40640 5460 40640 {}
C {lab_pin.sym} 5460 40640 0 0 {name=l32619 lab=VDD}
N 5440 40560 5460 40560 {}
C {lab_pin.sym} 5460 40560 0 0 {name=l32620 lab=VSS}
C {bitcell_6t.sym} 5600 40600 0 0 {name=Xr203c28}
N 5560 40640 5540 40640 {}
C {lab_pin.sym} 5540 40640 0 0 {name=l32621 lab=BL28}
N 5560 40600 5540 40600 {}
C {lab_pin.sym} 5540 40600 0 0 {name=l32622 lab=BLB28}
N 5560 40560 5540 40560 {}
C {lab_pin.sym} 5540 40560 0 0 {name=l32623 lab=WL203}
N 5640 40640 5660 40640 {}
C {lab_pin.sym} 5660 40640 0 0 {name=l32624 lab=VDD}
N 5640 40560 5660 40560 {}
C {lab_pin.sym} 5660 40560 0 0 {name=l32625 lab=VSS}
C {bitcell_6t.sym} 5800 40600 0 0 {name=Xr203c29}
N 5760 40640 5740 40640 {}
C {lab_pin.sym} 5740 40640 0 0 {name=l32626 lab=BL29}
N 5760 40600 5740 40600 {}
C {lab_pin.sym} 5740 40600 0 0 {name=l32627 lab=BLB29}
N 5760 40560 5740 40560 {}
C {lab_pin.sym} 5740 40560 0 0 {name=l32628 lab=WL203}
N 5840 40640 5860 40640 {}
C {lab_pin.sym} 5860 40640 0 0 {name=l32629 lab=VDD}
N 5840 40560 5860 40560 {}
C {lab_pin.sym} 5860 40560 0 0 {name=l32630 lab=VSS}
C {bitcell_6t.sym} 6000 40600 0 0 {name=Xr203c30}
N 5960 40640 5940 40640 {}
C {lab_pin.sym} 5940 40640 0 0 {name=l32631 lab=BL30}
N 5960 40600 5940 40600 {}
C {lab_pin.sym} 5940 40600 0 0 {name=l32632 lab=BLB30}
N 5960 40560 5940 40560 {}
C {lab_pin.sym} 5940 40560 0 0 {name=l32633 lab=WL203}
N 6040 40640 6060 40640 {}
C {lab_pin.sym} 6060 40640 0 0 {name=l32634 lab=VDD}
N 6040 40560 6060 40560 {}
C {lab_pin.sym} 6060 40560 0 0 {name=l32635 lab=VSS}
C {bitcell_6t.sym} 6200 40600 0 0 {name=Xr203c31}
N 6160 40640 6140 40640 {}
C {lab_pin.sym} 6140 40640 0 0 {name=l32636 lab=BL31}
N 6160 40600 6140 40600 {}
C {lab_pin.sym} 6140 40600 0 0 {name=l32637 lab=BLB31}
N 6160 40560 6140 40560 {}
C {lab_pin.sym} 6140 40560 0 0 {name=l32638 lab=WL203}
N 6240 40640 6260 40640 {}
C {lab_pin.sym} 6260 40640 0 0 {name=l32639 lab=VDD}
N 6240 40560 6260 40560 {}
C {lab_pin.sym} 6260 40560 0 0 {name=l32640 lab=VSS}
C {bitcell_6t.sym} 0 40800 0 0 {name=Xr204c0}
N -40 40840 -60 40840 {}
C {lab_pin.sym} -60 40840 0 0 {name=l32641 lab=BL0}
N -40 40800 -60 40800 {}
C {lab_pin.sym} -60 40800 0 0 {name=l32642 lab=BLB0}
N -40 40760 -60 40760 {}
C {lab_pin.sym} -60 40760 0 0 {name=l32643 lab=WL204}
N 40 40840 60 40840 {}
C {lab_pin.sym} 60 40840 0 0 {name=l32644 lab=VDD}
N 40 40760 60 40760 {}
C {lab_pin.sym} 60 40760 0 0 {name=l32645 lab=VSS}
C {bitcell_6t.sym} 200 40800 0 0 {name=Xr204c1}
N 160 40840 140 40840 {}
C {lab_pin.sym} 140 40840 0 0 {name=l32646 lab=BL1}
N 160 40800 140 40800 {}
C {lab_pin.sym} 140 40800 0 0 {name=l32647 lab=BLB1}
N 160 40760 140 40760 {}
C {lab_pin.sym} 140 40760 0 0 {name=l32648 lab=WL204}
N 240 40840 260 40840 {}
C {lab_pin.sym} 260 40840 0 0 {name=l32649 lab=VDD}
N 240 40760 260 40760 {}
C {lab_pin.sym} 260 40760 0 0 {name=l32650 lab=VSS}
C {bitcell_6t.sym} 400 40800 0 0 {name=Xr204c2}
N 360 40840 340 40840 {}
C {lab_pin.sym} 340 40840 0 0 {name=l32651 lab=BL2}
N 360 40800 340 40800 {}
C {lab_pin.sym} 340 40800 0 0 {name=l32652 lab=BLB2}
N 360 40760 340 40760 {}
C {lab_pin.sym} 340 40760 0 0 {name=l32653 lab=WL204}
N 440 40840 460 40840 {}
C {lab_pin.sym} 460 40840 0 0 {name=l32654 lab=VDD}
N 440 40760 460 40760 {}
C {lab_pin.sym} 460 40760 0 0 {name=l32655 lab=VSS}
C {bitcell_6t.sym} 600 40800 0 0 {name=Xr204c3}
N 560 40840 540 40840 {}
C {lab_pin.sym} 540 40840 0 0 {name=l32656 lab=BL3}
N 560 40800 540 40800 {}
C {lab_pin.sym} 540 40800 0 0 {name=l32657 lab=BLB3}
N 560 40760 540 40760 {}
C {lab_pin.sym} 540 40760 0 0 {name=l32658 lab=WL204}
N 640 40840 660 40840 {}
C {lab_pin.sym} 660 40840 0 0 {name=l32659 lab=VDD}
N 640 40760 660 40760 {}
C {lab_pin.sym} 660 40760 0 0 {name=l32660 lab=VSS}
C {bitcell_6t.sym} 800 40800 0 0 {name=Xr204c4}
N 760 40840 740 40840 {}
C {lab_pin.sym} 740 40840 0 0 {name=l32661 lab=BL4}
N 760 40800 740 40800 {}
C {lab_pin.sym} 740 40800 0 0 {name=l32662 lab=BLB4}
N 760 40760 740 40760 {}
C {lab_pin.sym} 740 40760 0 0 {name=l32663 lab=WL204}
N 840 40840 860 40840 {}
C {lab_pin.sym} 860 40840 0 0 {name=l32664 lab=VDD}
N 840 40760 860 40760 {}
C {lab_pin.sym} 860 40760 0 0 {name=l32665 lab=VSS}
C {bitcell_6t.sym} 1000 40800 0 0 {name=Xr204c5}
N 960 40840 940 40840 {}
C {lab_pin.sym} 940 40840 0 0 {name=l32666 lab=BL5}
N 960 40800 940 40800 {}
C {lab_pin.sym} 940 40800 0 0 {name=l32667 lab=BLB5}
N 960 40760 940 40760 {}
C {lab_pin.sym} 940 40760 0 0 {name=l32668 lab=WL204}
N 1040 40840 1060 40840 {}
C {lab_pin.sym} 1060 40840 0 0 {name=l32669 lab=VDD}
N 1040 40760 1060 40760 {}
C {lab_pin.sym} 1060 40760 0 0 {name=l32670 lab=VSS}
C {bitcell_6t.sym} 1200 40800 0 0 {name=Xr204c6}
N 1160 40840 1140 40840 {}
C {lab_pin.sym} 1140 40840 0 0 {name=l32671 lab=BL6}
N 1160 40800 1140 40800 {}
C {lab_pin.sym} 1140 40800 0 0 {name=l32672 lab=BLB6}
N 1160 40760 1140 40760 {}
C {lab_pin.sym} 1140 40760 0 0 {name=l32673 lab=WL204}
N 1240 40840 1260 40840 {}
C {lab_pin.sym} 1260 40840 0 0 {name=l32674 lab=VDD}
N 1240 40760 1260 40760 {}
C {lab_pin.sym} 1260 40760 0 0 {name=l32675 lab=VSS}
C {bitcell_6t.sym} 1400 40800 0 0 {name=Xr204c7}
N 1360 40840 1340 40840 {}
C {lab_pin.sym} 1340 40840 0 0 {name=l32676 lab=BL7}
N 1360 40800 1340 40800 {}
C {lab_pin.sym} 1340 40800 0 0 {name=l32677 lab=BLB7}
N 1360 40760 1340 40760 {}
C {lab_pin.sym} 1340 40760 0 0 {name=l32678 lab=WL204}
N 1440 40840 1460 40840 {}
C {lab_pin.sym} 1460 40840 0 0 {name=l32679 lab=VDD}
N 1440 40760 1460 40760 {}
C {lab_pin.sym} 1460 40760 0 0 {name=l32680 lab=VSS}
C {bitcell_6t.sym} 1600 40800 0 0 {name=Xr204c8}
N 1560 40840 1540 40840 {}
C {lab_pin.sym} 1540 40840 0 0 {name=l32681 lab=BL8}
N 1560 40800 1540 40800 {}
C {lab_pin.sym} 1540 40800 0 0 {name=l32682 lab=BLB8}
N 1560 40760 1540 40760 {}
C {lab_pin.sym} 1540 40760 0 0 {name=l32683 lab=WL204}
N 1640 40840 1660 40840 {}
C {lab_pin.sym} 1660 40840 0 0 {name=l32684 lab=VDD}
N 1640 40760 1660 40760 {}
C {lab_pin.sym} 1660 40760 0 0 {name=l32685 lab=VSS}
C {bitcell_6t.sym} 1800 40800 0 0 {name=Xr204c9}
N 1760 40840 1740 40840 {}
C {lab_pin.sym} 1740 40840 0 0 {name=l32686 lab=BL9}
N 1760 40800 1740 40800 {}
C {lab_pin.sym} 1740 40800 0 0 {name=l32687 lab=BLB9}
N 1760 40760 1740 40760 {}
C {lab_pin.sym} 1740 40760 0 0 {name=l32688 lab=WL204}
N 1840 40840 1860 40840 {}
C {lab_pin.sym} 1860 40840 0 0 {name=l32689 lab=VDD}
N 1840 40760 1860 40760 {}
C {lab_pin.sym} 1860 40760 0 0 {name=l32690 lab=VSS}
C {bitcell_6t.sym} 2000 40800 0 0 {name=Xr204c10}
N 1960 40840 1940 40840 {}
C {lab_pin.sym} 1940 40840 0 0 {name=l32691 lab=BL10}
N 1960 40800 1940 40800 {}
C {lab_pin.sym} 1940 40800 0 0 {name=l32692 lab=BLB10}
N 1960 40760 1940 40760 {}
C {lab_pin.sym} 1940 40760 0 0 {name=l32693 lab=WL204}
N 2040 40840 2060 40840 {}
C {lab_pin.sym} 2060 40840 0 0 {name=l32694 lab=VDD}
N 2040 40760 2060 40760 {}
C {lab_pin.sym} 2060 40760 0 0 {name=l32695 lab=VSS}
C {bitcell_6t.sym} 2200 40800 0 0 {name=Xr204c11}
N 2160 40840 2140 40840 {}
C {lab_pin.sym} 2140 40840 0 0 {name=l32696 lab=BL11}
N 2160 40800 2140 40800 {}
C {lab_pin.sym} 2140 40800 0 0 {name=l32697 lab=BLB11}
N 2160 40760 2140 40760 {}
C {lab_pin.sym} 2140 40760 0 0 {name=l32698 lab=WL204}
N 2240 40840 2260 40840 {}
C {lab_pin.sym} 2260 40840 0 0 {name=l32699 lab=VDD}
N 2240 40760 2260 40760 {}
C {lab_pin.sym} 2260 40760 0 0 {name=l32700 lab=VSS}
C {bitcell_6t.sym} 2400 40800 0 0 {name=Xr204c12}
N 2360 40840 2340 40840 {}
C {lab_pin.sym} 2340 40840 0 0 {name=l32701 lab=BL12}
N 2360 40800 2340 40800 {}
C {lab_pin.sym} 2340 40800 0 0 {name=l32702 lab=BLB12}
N 2360 40760 2340 40760 {}
C {lab_pin.sym} 2340 40760 0 0 {name=l32703 lab=WL204}
N 2440 40840 2460 40840 {}
C {lab_pin.sym} 2460 40840 0 0 {name=l32704 lab=VDD}
N 2440 40760 2460 40760 {}
C {lab_pin.sym} 2460 40760 0 0 {name=l32705 lab=VSS}
C {bitcell_6t.sym} 2600 40800 0 0 {name=Xr204c13}
N 2560 40840 2540 40840 {}
C {lab_pin.sym} 2540 40840 0 0 {name=l32706 lab=BL13}
N 2560 40800 2540 40800 {}
C {lab_pin.sym} 2540 40800 0 0 {name=l32707 lab=BLB13}
N 2560 40760 2540 40760 {}
C {lab_pin.sym} 2540 40760 0 0 {name=l32708 lab=WL204}
N 2640 40840 2660 40840 {}
C {lab_pin.sym} 2660 40840 0 0 {name=l32709 lab=VDD}
N 2640 40760 2660 40760 {}
C {lab_pin.sym} 2660 40760 0 0 {name=l32710 lab=VSS}
C {bitcell_6t.sym} 2800 40800 0 0 {name=Xr204c14}
N 2760 40840 2740 40840 {}
C {lab_pin.sym} 2740 40840 0 0 {name=l32711 lab=BL14}
N 2760 40800 2740 40800 {}
C {lab_pin.sym} 2740 40800 0 0 {name=l32712 lab=BLB14}
N 2760 40760 2740 40760 {}
C {lab_pin.sym} 2740 40760 0 0 {name=l32713 lab=WL204}
N 2840 40840 2860 40840 {}
C {lab_pin.sym} 2860 40840 0 0 {name=l32714 lab=VDD}
N 2840 40760 2860 40760 {}
C {lab_pin.sym} 2860 40760 0 0 {name=l32715 lab=VSS}
C {bitcell_6t.sym} 3000 40800 0 0 {name=Xr204c15}
N 2960 40840 2940 40840 {}
C {lab_pin.sym} 2940 40840 0 0 {name=l32716 lab=BL15}
N 2960 40800 2940 40800 {}
C {lab_pin.sym} 2940 40800 0 0 {name=l32717 lab=BLB15}
N 2960 40760 2940 40760 {}
C {lab_pin.sym} 2940 40760 0 0 {name=l32718 lab=WL204}
N 3040 40840 3060 40840 {}
C {lab_pin.sym} 3060 40840 0 0 {name=l32719 lab=VDD}
N 3040 40760 3060 40760 {}
C {lab_pin.sym} 3060 40760 0 0 {name=l32720 lab=VSS}
C {bitcell_6t.sym} 3200 40800 0 0 {name=Xr204c16}
N 3160 40840 3140 40840 {}
C {lab_pin.sym} 3140 40840 0 0 {name=l32721 lab=BL16}
N 3160 40800 3140 40800 {}
C {lab_pin.sym} 3140 40800 0 0 {name=l32722 lab=BLB16}
N 3160 40760 3140 40760 {}
C {lab_pin.sym} 3140 40760 0 0 {name=l32723 lab=WL204}
N 3240 40840 3260 40840 {}
C {lab_pin.sym} 3260 40840 0 0 {name=l32724 lab=VDD}
N 3240 40760 3260 40760 {}
C {lab_pin.sym} 3260 40760 0 0 {name=l32725 lab=VSS}
C {bitcell_6t.sym} 3400 40800 0 0 {name=Xr204c17}
N 3360 40840 3340 40840 {}
C {lab_pin.sym} 3340 40840 0 0 {name=l32726 lab=BL17}
N 3360 40800 3340 40800 {}
C {lab_pin.sym} 3340 40800 0 0 {name=l32727 lab=BLB17}
N 3360 40760 3340 40760 {}
C {lab_pin.sym} 3340 40760 0 0 {name=l32728 lab=WL204}
N 3440 40840 3460 40840 {}
C {lab_pin.sym} 3460 40840 0 0 {name=l32729 lab=VDD}
N 3440 40760 3460 40760 {}
C {lab_pin.sym} 3460 40760 0 0 {name=l32730 lab=VSS}
C {bitcell_6t.sym} 3600 40800 0 0 {name=Xr204c18}
N 3560 40840 3540 40840 {}
C {lab_pin.sym} 3540 40840 0 0 {name=l32731 lab=BL18}
N 3560 40800 3540 40800 {}
C {lab_pin.sym} 3540 40800 0 0 {name=l32732 lab=BLB18}
N 3560 40760 3540 40760 {}
C {lab_pin.sym} 3540 40760 0 0 {name=l32733 lab=WL204}
N 3640 40840 3660 40840 {}
C {lab_pin.sym} 3660 40840 0 0 {name=l32734 lab=VDD}
N 3640 40760 3660 40760 {}
C {lab_pin.sym} 3660 40760 0 0 {name=l32735 lab=VSS}
C {bitcell_6t.sym} 3800 40800 0 0 {name=Xr204c19}
N 3760 40840 3740 40840 {}
C {lab_pin.sym} 3740 40840 0 0 {name=l32736 lab=BL19}
N 3760 40800 3740 40800 {}
C {lab_pin.sym} 3740 40800 0 0 {name=l32737 lab=BLB19}
N 3760 40760 3740 40760 {}
C {lab_pin.sym} 3740 40760 0 0 {name=l32738 lab=WL204}
N 3840 40840 3860 40840 {}
C {lab_pin.sym} 3860 40840 0 0 {name=l32739 lab=VDD}
N 3840 40760 3860 40760 {}
C {lab_pin.sym} 3860 40760 0 0 {name=l32740 lab=VSS}
C {bitcell_6t.sym} 4000 40800 0 0 {name=Xr204c20}
N 3960 40840 3940 40840 {}
C {lab_pin.sym} 3940 40840 0 0 {name=l32741 lab=BL20}
N 3960 40800 3940 40800 {}
C {lab_pin.sym} 3940 40800 0 0 {name=l32742 lab=BLB20}
N 3960 40760 3940 40760 {}
C {lab_pin.sym} 3940 40760 0 0 {name=l32743 lab=WL204}
N 4040 40840 4060 40840 {}
C {lab_pin.sym} 4060 40840 0 0 {name=l32744 lab=VDD}
N 4040 40760 4060 40760 {}
C {lab_pin.sym} 4060 40760 0 0 {name=l32745 lab=VSS}
C {bitcell_6t.sym} 4200 40800 0 0 {name=Xr204c21}
N 4160 40840 4140 40840 {}
C {lab_pin.sym} 4140 40840 0 0 {name=l32746 lab=BL21}
N 4160 40800 4140 40800 {}
C {lab_pin.sym} 4140 40800 0 0 {name=l32747 lab=BLB21}
N 4160 40760 4140 40760 {}
C {lab_pin.sym} 4140 40760 0 0 {name=l32748 lab=WL204}
N 4240 40840 4260 40840 {}
C {lab_pin.sym} 4260 40840 0 0 {name=l32749 lab=VDD}
N 4240 40760 4260 40760 {}
C {lab_pin.sym} 4260 40760 0 0 {name=l32750 lab=VSS}
C {bitcell_6t.sym} 4400 40800 0 0 {name=Xr204c22}
N 4360 40840 4340 40840 {}
C {lab_pin.sym} 4340 40840 0 0 {name=l32751 lab=BL22}
N 4360 40800 4340 40800 {}
C {lab_pin.sym} 4340 40800 0 0 {name=l32752 lab=BLB22}
N 4360 40760 4340 40760 {}
C {lab_pin.sym} 4340 40760 0 0 {name=l32753 lab=WL204}
N 4440 40840 4460 40840 {}
C {lab_pin.sym} 4460 40840 0 0 {name=l32754 lab=VDD}
N 4440 40760 4460 40760 {}
C {lab_pin.sym} 4460 40760 0 0 {name=l32755 lab=VSS}
C {bitcell_6t.sym} 4600 40800 0 0 {name=Xr204c23}
N 4560 40840 4540 40840 {}
C {lab_pin.sym} 4540 40840 0 0 {name=l32756 lab=BL23}
N 4560 40800 4540 40800 {}
C {lab_pin.sym} 4540 40800 0 0 {name=l32757 lab=BLB23}
N 4560 40760 4540 40760 {}
C {lab_pin.sym} 4540 40760 0 0 {name=l32758 lab=WL204}
N 4640 40840 4660 40840 {}
C {lab_pin.sym} 4660 40840 0 0 {name=l32759 lab=VDD}
N 4640 40760 4660 40760 {}
C {lab_pin.sym} 4660 40760 0 0 {name=l32760 lab=VSS}
C {bitcell_6t.sym} 4800 40800 0 0 {name=Xr204c24}
N 4760 40840 4740 40840 {}
C {lab_pin.sym} 4740 40840 0 0 {name=l32761 lab=BL24}
N 4760 40800 4740 40800 {}
C {lab_pin.sym} 4740 40800 0 0 {name=l32762 lab=BLB24}
N 4760 40760 4740 40760 {}
C {lab_pin.sym} 4740 40760 0 0 {name=l32763 lab=WL204}
N 4840 40840 4860 40840 {}
C {lab_pin.sym} 4860 40840 0 0 {name=l32764 lab=VDD}
N 4840 40760 4860 40760 {}
C {lab_pin.sym} 4860 40760 0 0 {name=l32765 lab=VSS}
C {bitcell_6t.sym} 5000 40800 0 0 {name=Xr204c25}
N 4960 40840 4940 40840 {}
C {lab_pin.sym} 4940 40840 0 0 {name=l32766 lab=BL25}
N 4960 40800 4940 40800 {}
C {lab_pin.sym} 4940 40800 0 0 {name=l32767 lab=BLB25}
N 4960 40760 4940 40760 {}
C {lab_pin.sym} 4940 40760 0 0 {name=l32768 lab=WL204}
N 5040 40840 5060 40840 {}
C {lab_pin.sym} 5060 40840 0 0 {name=l32769 lab=VDD}
N 5040 40760 5060 40760 {}
C {lab_pin.sym} 5060 40760 0 0 {name=l32770 lab=VSS}
C {bitcell_6t.sym} 5200 40800 0 0 {name=Xr204c26}
N 5160 40840 5140 40840 {}
C {lab_pin.sym} 5140 40840 0 0 {name=l32771 lab=BL26}
N 5160 40800 5140 40800 {}
C {lab_pin.sym} 5140 40800 0 0 {name=l32772 lab=BLB26}
N 5160 40760 5140 40760 {}
C {lab_pin.sym} 5140 40760 0 0 {name=l32773 lab=WL204}
N 5240 40840 5260 40840 {}
C {lab_pin.sym} 5260 40840 0 0 {name=l32774 lab=VDD}
N 5240 40760 5260 40760 {}
C {lab_pin.sym} 5260 40760 0 0 {name=l32775 lab=VSS}
C {bitcell_6t.sym} 5400 40800 0 0 {name=Xr204c27}
N 5360 40840 5340 40840 {}
C {lab_pin.sym} 5340 40840 0 0 {name=l32776 lab=BL27}
N 5360 40800 5340 40800 {}
C {lab_pin.sym} 5340 40800 0 0 {name=l32777 lab=BLB27}
N 5360 40760 5340 40760 {}
C {lab_pin.sym} 5340 40760 0 0 {name=l32778 lab=WL204}
N 5440 40840 5460 40840 {}
C {lab_pin.sym} 5460 40840 0 0 {name=l32779 lab=VDD}
N 5440 40760 5460 40760 {}
C {lab_pin.sym} 5460 40760 0 0 {name=l32780 lab=VSS}
C {bitcell_6t.sym} 5600 40800 0 0 {name=Xr204c28}
N 5560 40840 5540 40840 {}
C {lab_pin.sym} 5540 40840 0 0 {name=l32781 lab=BL28}
N 5560 40800 5540 40800 {}
C {lab_pin.sym} 5540 40800 0 0 {name=l32782 lab=BLB28}
N 5560 40760 5540 40760 {}
C {lab_pin.sym} 5540 40760 0 0 {name=l32783 lab=WL204}
N 5640 40840 5660 40840 {}
C {lab_pin.sym} 5660 40840 0 0 {name=l32784 lab=VDD}
N 5640 40760 5660 40760 {}
C {lab_pin.sym} 5660 40760 0 0 {name=l32785 lab=VSS}
C {bitcell_6t.sym} 5800 40800 0 0 {name=Xr204c29}
N 5760 40840 5740 40840 {}
C {lab_pin.sym} 5740 40840 0 0 {name=l32786 lab=BL29}
N 5760 40800 5740 40800 {}
C {lab_pin.sym} 5740 40800 0 0 {name=l32787 lab=BLB29}
N 5760 40760 5740 40760 {}
C {lab_pin.sym} 5740 40760 0 0 {name=l32788 lab=WL204}
N 5840 40840 5860 40840 {}
C {lab_pin.sym} 5860 40840 0 0 {name=l32789 lab=VDD}
N 5840 40760 5860 40760 {}
C {lab_pin.sym} 5860 40760 0 0 {name=l32790 lab=VSS}
C {bitcell_6t.sym} 6000 40800 0 0 {name=Xr204c30}
N 5960 40840 5940 40840 {}
C {lab_pin.sym} 5940 40840 0 0 {name=l32791 lab=BL30}
N 5960 40800 5940 40800 {}
C {lab_pin.sym} 5940 40800 0 0 {name=l32792 lab=BLB30}
N 5960 40760 5940 40760 {}
C {lab_pin.sym} 5940 40760 0 0 {name=l32793 lab=WL204}
N 6040 40840 6060 40840 {}
C {lab_pin.sym} 6060 40840 0 0 {name=l32794 lab=VDD}
N 6040 40760 6060 40760 {}
C {lab_pin.sym} 6060 40760 0 0 {name=l32795 lab=VSS}
C {bitcell_6t.sym} 6200 40800 0 0 {name=Xr204c31}
N 6160 40840 6140 40840 {}
C {lab_pin.sym} 6140 40840 0 0 {name=l32796 lab=BL31}
N 6160 40800 6140 40800 {}
C {lab_pin.sym} 6140 40800 0 0 {name=l32797 lab=BLB31}
N 6160 40760 6140 40760 {}
C {lab_pin.sym} 6140 40760 0 0 {name=l32798 lab=WL204}
N 6240 40840 6260 40840 {}
C {lab_pin.sym} 6260 40840 0 0 {name=l32799 lab=VDD}
N 6240 40760 6260 40760 {}
C {lab_pin.sym} 6260 40760 0 0 {name=l32800 lab=VSS}
C {bitcell_6t.sym} 0 41000 0 0 {name=Xr205c0}
N -40 41040 -60 41040 {}
C {lab_pin.sym} -60 41040 0 0 {name=l32801 lab=BL0}
N -40 41000 -60 41000 {}
C {lab_pin.sym} -60 41000 0 0 {name=l32802 lab=BLB0}
N -40 40960 -60 40960 {}
C {lab_pin.sym} -60 40960 0 0 {name=l32803 lab=WL205}
N 40 41040 60 41040 {}
C {lab_pin.sym} 60 41040 0 0 {name=l32804 lab=VDD}
N 40 40960 60 40960 {}
C {lab_pin.sym} 60 40960 0 0 {name=l32805 lab=VSS}
C {bitcell_6t.sym} 200 41000 0 0 {name=Xr205c1}
N 160 41040 140 41040 {}
C {lab_pin.sym} 140 41040 0 0 {name=l32806 lab=BL1}
N 160 41000 140 41000 {}
C {lab_pin.sym} 140 41000 0 0 {name=l32807 lab=BLB1}
N 160 40960 140 40960 {}
C {lab_pin.sym} 140 40960 0 0 {name=l32808 lab=WL205}
N 240 41040 260 41040 {}
C {lab_pin.sym} 260 41040 0 0 {name=l32809 lab=VDD}
N 240 40960 260 40960 {}
C {lab_pin.sym} 260 40960 0 0 {name=l32810 lab=VSS}
C {bitcell_6t.sym} 400 41000 0 0 {name=Xr205c2}
N 360 41040 340 41040 {}
C {lab_pin.sym} 340 41040 0 0 {name=l32811 lab=BL2}
N 360 41000 340 41000 {}
C {lab_pin.sym} 340 41000 0 0 {name=l32812 lab=BLB2}
N 360 40960 340 40960 {}
C {lab_pin.sym} 340 40960 0 0 {name=l32813 lab=WL205}
N 440 41040 460 41040 {}
C {lab_pin.sym} 460 41040 0 0 {name=l32814 lab=VDD}
N 440 40960 460 40960 {}
C {lab_pin.sym} 460 40960 0 0 {name=l32815 lab=VSS}
C {bitcell_6t.sym} 600 41000 0 0 {name=Xr205c3}
N 560 41040 540 41040 {}
C {lab_pin.sym} 540 41040 0 0 {name=l32816 lab=BL3}
N 560 41000 540 41000 {}
C {lab_pin.sym} 540 41000 0 0 {name=l32817 lab=BLB3}
N 560 40960 540 40960 {}
C {lab_pin.sym} 540 40960 0 0 {name=l32818 lab=WL205}
N 640 41040 660 41040 {}
C {lab_pin.sym} 660 41040 0 0 {name=l32819 lab=VDD}
N 640 40960 660 40960 {}
C {lab_pin.sym} 660 40960 0 0 {name=l32820 lab=VSS}
C {bitcell_6t.sym} 800 41000 0 0 {name=Xr205c4}
N 760 41040 740 41040 {}
C {lab_pin.sym} 740 41040 0 0 {name=l32821 lab=BL4}
N 760 41000 740 41000 {}
C {lab_pin.sym} 740 41000 0 0 {name=l32822 lab=BLB4}
N 760 40960 740 40960 {}
C {lab_pin.sym} 740 40960 0 0 {name=l32823 lab=WL205}
N 840 41040 860 41040 {}
C {lab_pin.sym} 860 41040 0 0 {name=l32824 lab=VDD}
N 840 40960 860 40960 {}
C {lab_pin.sym} 860 40960 0 0 {name=l32825 lab=VSS}
C {bitcell_6t.sym} 1000 41000 0 0 {name=Xr205c5}
N 960 41040 940 41040 {}
C {lab_pin.sym} 940 41040 0 0 {name=l32826 lab=BL5}
N 960 41000 940 41000 {}
C {lab_pin.sym} 940 41000 0 0 {name=l32827 lab=BLB5}
N 960 40960 940 40960 {}
C {lab_pin.sym} 940 40960 0 0 {name=l32828 lab=WL205}
N 1040 41040 1060 41040 {}
C {lab_pin.sym} 1060 41040 0 0 {name=l32829 lab=VDD}
N 1040 40960 1060 40960 {}
C {lab_pin.sym} 1060 40960 0 0 {name=l32830 lab=VSS}
C {bitcell_6t.sym} 1200 41000 0 0 {name=Xr205c6}
N 1160 41040 1140 41040 {}
C {lab_pin.sym} 1140 41040 0 0 {name=l32831 lab=BL6}
N 1160 41000 1140 41000 {}
C {lab_pin.sym} 1140 41000 0 0 {name=l32832 lab=BLB6}
N 1160 40960 1140 40960 {}
C {lab_pin.sym} 1140 40960 0 0 {name=l32833 lab=WL205}
N 1240 41040 1260 41040 {}
C {lab_pin.sym} 1260 41040 0 0 {name=l32834 lab=VDD}
N 1240 40960 1260 40960 {}
C {lab_pin.sym} 1260 40960 0 0 {name=l32835 lab=VSS}
C {bitcell_6t.sym} 1400 41000 0 0 {name=Xr205c7}
N 1360 41040 1340 41040 {}
C {lab_pin.sym} 1340 41040 0 0 {name=l32836 lab=BL7}
N 1360 41000 1340 41000 {}
C {lab_pin.sym} 1340 41000 0 0 {name=l32837 lab=BLB7}
N 1360 40960 1340 40960 {}
C {lab_pin.sym} 1340 40960 0 0 {name=l32838 lab=WL205}
N 1440 41040 1460 41040 {}
C {lab_pin.sym} 1460 41040 0 0 {name=l32839 lab=VDD}
N 1440 40960 1460 40960 {}
C {lab_pin.sym} 1460 40960 0 0 {name=l32840 lab=VSS}
C {bitcell_6t.sym} 1600 41000 0 0 {name=Xr205c8}
N 1560 41040 1540 41040 {}
C {lab_pin.sym} 1540 41040 0 0 {name=l32841 lab=BL8}
N 1560 41000 1540 41000 {}
C {lab_pin.sym} 1540 41000 0 0 {name=l32842 lab=BLB8}
N 1560 40960 1540 40960 {}
C {lab_pin.sym} 1540 40960 0 0 {name=l32843 lab=WL205}
N 1640 41040 1660 41040 {}
C {lab_pin.sym} 1660 41040 0 0 {name=l32844 lab=VDD}
N 1640 40960 1660 40960 {}
C {lab_pin.sym} 1660 40960 0 0 {name=l32845 lab=VSS}
C {bitcell_6t.sym} 1800 41000 0 0 {name=Xr205c9}
N 1760 41040 1740 41040 {}
C {lab_pin.sym} 1740 41040 0 0 {name=l32846 lab=BL9}
N 1760 41000 1740 41000 {}
C {lab_pin.sym} 1740 41000 0 0 {name=l32847 lab=BLB9}
N 1760 40960 1740 40960 {}
C {lab_pin.sym} 1740 40960 0 0 {name=l32848 lab=WL205}
N 1840 41040 1860 41040 {}
C {lab_pin.sym} 1860 41040 0 0 {name=l32849 lab=VDD}
N 1840 40960 1860 40960 {}
C {lab_pin.sym} 1860 40960 0 0 {name=l32850 lab=VSS}
C {bitcell_6t.sym} 2000 41000 0 0 {name=Xr205c10}
N 1960 41040 1940 41040 {}
C {lab_pin.sym} 1940 41040 0 0 {name=l32851 lab=BL10}
N 1960 41000 1940 41000 {}
C {lab_pin.sym} 1940 41000 0 0 {name=l32852 lab=BLB10}
N 1960 40960 1940 40960 {}
C {lab_pin.sym} 1940 40960 0 0 {name=l32853 lab=WL205}
N 2040 41040 2060 41040 {}
C {lab_pin.sym} 2060 41040 0 0 {name=l32854 lab=VDD}
N 2040 40960 2060 40960 {}
C {lab_pin.sym} 2060 40960 0 0 {name=l32855 lab=VSS}
C {bitcell_6t.sym} 2200 41000 0 0 {name=Xr205c11}
N 2160 41040 2140 41040 {}
C {lab_pin.sym} 2140 41040 0 0 {name=l32856 lab=BL11}
N 2160 41000 2140 41000 {}
C {lab_pin.sym} 2140 41000 0 0 {name=l32857 lab=BLB11}
N 2160 40960 2140 40960 {}
C {lab_pin.sym} 2140 40960 0 0 {name=l32858 lab=WL205}
N 2240 41040 2260 41040 {}
C {lab_pin.sym} 2260 41040 0 0 {name=l32859 lab=VDD}
N 2240 40960 2260 40960 {}
C {lab_pin.sym} 2260 40960 0 0 {name=l32860 lab=VSS}
C {bitcell_6t.sym} 2400 41000 0 0 {name=Xr205c12}
N 2360 41040 2340 41040 {}
C {lab_pin.sym} 2340 41040 0 0 {name=l32861 lab=BL12}
N 2360 41000 2340 41000 {}
C {lab_pin.sym} 2340 41000 0 0 {name=l32862 lab=BLB12}
N 2360 40960 2340 40960 {}
C {lab_pin.sym} 2340 40960 0 0 {name=l32863 lab=WL205}
N 2440 41040 2460 41040 {}
C {lab_pin.sym} 2460 41040 0 0 {name=l32864 lab=VDD}
N 2440 40960 2460 40960 {}
C {lab_pin.sym} 2460 40960 0 0 {name=l32865 lab=VSS}
C {bitcell_6t.sym} 2600 41000 0 0 {name=Xr205c13}
N 2560 41040 2540 41040 {}
C {lab_pin.sym} 2540 41040 0 0 {name=l32866 lab=BL13}
N 2560 41000 2540 41000 {}
C {lab_pin.sym} 2540 41000 0 0 {name=l32867 lab=BLB13}
N 2560 40960 2540 40960 {}
C {lab_pin.sym} 2540 40960 0 0 {name=l32868 lab=WL205}
N 2640 41040 2660 41040 {}
C {lab_pin.sym} 2660 41040 0 0 {name=l32869 lab=VDD}
N 2640 40960 2660 40960 {}
C {lab_pin.sym} 2660 40960 0 0 {name=l32870 lab=VSS}
C {bitcell_6t.sym} 2800 41000 0 0 {name=Xr205c14}
N 2760 41040 2740 41040 {}
C {lab_pin.sym} 2740 41040 0 0 {name=l32871 lab=BL14}
N 2760 41000 2740 41000 {}
C {lab_pin.sym} 2740 41000 0 0 {name=l32872 lab=BLB14}
N 2760 40960 2740 40960 {}
C {lab_pin.sym} 2740 40960 0 0 {name=l32873 lab=WL205}
N 2840 41040 2860 41040 {}
C {lab_pin.sym} 2860 41040 0 0 {name=l32874 lab=VDD}
N 2840 40960 2860 40960 {}
C {lab_pin.sym} 2860 40960 0 0 {name=l32875 lab=VSS}
C {bitcell_6t.sym} 3000 41000 0 0 {name=Xr205c15}
N 2960 41040 2940 41040 {}
C {lab_pin.sym} 2940 41040 0 0 {name=l32876 lab=BL15}
N 2960 41000 2940 41000 {}
C {lab_pin.sym} 2940 41000 0 0 {name=l32877 lab=BLB15}
N 2960 40960 2940 40960 {}
C {lab_pin.sym} 2940 40960 0 0 {name=l32878 lab=WL205}
N 3040 41040 3060 41040 {}
C {lab_pin.sym} 3060 41040 0 0 {name=l32879 lab=VDD}
N 3040 40960 3060 40960 {}
C {lab_pin.sym} 3060 40960 0 0 {name=l32880 lab=VSS}
C {bitcell_6t.sym} 3200 41000 0 0 {name=Xr205c16}
N 3160 41040 3140 41040 {}
C {lab_pin.sym} 3140 41040 0 0 {name=l32881 lab=BL16}
N 3160 41000 3140 41000 {}
C {lab_pin.sym} 3140 41000 0 0 {name=l32882 lab=BLB16}
N 3160 40960 3140 40960 {}
C {lab_pin.sym} 3140 40960 0 0 {name=l32883 lab=WL205}
N 3240 41040 3260 41040 {}
C {lab_pin.sym} 3260 41040 0 0 {name=l32884 lab=VDD}
N 3240 40960 3260 40960 {}
C {lab_pin.sym} 3260 40960 0 0 {name=l32885 lab=VSS}
C {bitcell_6t.sym} 3400 41000 0 0 {name=Xr205c17}
N 3360 41040 3340 41040 {}
C {lab_pin.sym} 3340 41040 0 0 {name=l32886 lab=BL17}
N 3360 41000 3340 41000 {}
C {lab_pin.sym} 3340 41000 0 0 {name=l32887 lab=BLB17}
N 3360 40960 3340 40960 {}
C {lab_pin.sym} 3340 40960 0 0 {name=l32888 lab=WL205}
N 3440 41040 3460 41040 {}
C {lab_pin.sym} 3460 41040 0 0 {name=l32889 lab=VDD}
N 3440 40960 3460 40960 {}
C {lab_pin.sym} 3460 40960 0 0 {name=l32890 lab=VSS}
C {bitcell_6t.sym} 3600 41000 0 0 {name=Xr205c18}
N 3560 41040 3540 41040 {}
C {lab_pin.sym} 3540 41040 0 0 {name=l32891 lab=BL18}
N 3560 41000 3540 41000 {}
C {lab_pin.sym} 3540 41000 0 0 {name=l32892 lab=BLB18}
N 3560 40960 3540 40960 {}
C {lab_pin.sym} 3540 40960 0 0 {name=l32893 lab=WL205}
N 3640 41040 3660 41040 {}
C {lab_pin.sym} 3660 41040 0 0 {name=l32894 lab=VDD}
N 3640 40960 3660 40960 {}
C {lab_pin.sym} 3660 40960 0 0 {name=l32895 lab=VSS}
C {bitcell_6t.sym} 3800 41000 0 0 {name=Xr205c19}
N 3760 41040 3740 41040 {}
C {lab_pin.sym} 3740 41040 0 0 {name=l32896 lab=BL19}
N 3760 41000 3740 41000 {}
C {lab_pin.sym} 3740 41000 0 0 {name=l32897 lab=BLB19}
N 3760 40960 3740 40960 {}
C {lab_pin.sym} 3740 40960 0 0 {name=l32898 lab=WL205}
N 3840 41040 3860 41040 {}
C {lab_pin.sym} 3860 41040 0 0 {name=l32899 lab=VDD}
N 3840 40960 3860 40960 {}
C {lab_pin.sym} 3860 40960 0 0 {name=l32900 lab=VSS}
C {bitcell_6t.sym} 4000 41000 0 0 {name=Xr205c20}
N 3960 41040 3940 41040 {}
C {lab_pin.sym} 3940 41040 0 0 {name=l32901 lab=BL20}
N 3960 41000 3940 41000 {}
C {lab_pin.sym} 3940 41000 0 0 {name=l32902 lab=BLB20}
N 3960 40960 3940 40960 {}
C {lab_pin.sym} 3940 40960 0 0 {name=l32903 lab=WL205}
N 4040 41040 4060 41040 {}
C {lab_pin.sym} 4060 41040 0 0 {name=l32904 lab=VDD}
N 4040 40960 4060 40960 {}
C {lab_pin.sym} 4060 40960 0 0 {name=l32905 lab=VSS}
C {bitcell_6t.sym} 4200 41000 0 0 {name=Xr205c21}
N 4160 41040 4140 41040 {}
C {lab_pin.sym} 4140 41040 0 0 {name=l32906 lab=BL21}
N 4160 41000 4140 41000 {}
C {lab_pin.sym} 4140 41000 0 0 {name=l32907 lab=BLB21}
N 4160 40960 4140 40960 {}
C {lab_pin.sym} 4140 40960 0 0 {name=l32908 lab=WL205}
N 4240 41040 4260 41040 {}
C {lab_pin.sym} 4260 41040 0 0 {name=l32909 lab=VDD}
N 4240 40960 4260 40960 {}
C {lab_pin.sym} 4260 40960 0 0 {name=l32910 lab=VSS}
C {bitcell_6t.sym} 4400 41000 0 0 {name=Xr205c22}
N 4360 41040 4340 41040 {}
C {lab_pin.sym} 4340 41040 0 0 {name=l32911 lab=BL22}
N 4360 41000 4340 41000 {}
C {lab_pin.sym} 4340 41000 0 0 {name=l32912 lab=BLB22}
N 4360 40960 4340 40960 {}
C {lab_pin.sym} 4340 40960 0 0 {name=l32913 lab=WL205}
N 4440 41040 4460 41040 {}
C {lab_pin.sym} 4460 41040 0 0 {name=l32914 lab=VDD}
N 4440 40960 4460 40960 {}
C {lab_pin.sym} 4460 40960 0 0 {name=l32915 lab=VSS}
C {bitcell_6t.sym} 4600 41000 0 0 {name=Xr205c23}
N 4560 41040 4540 41040 {}
C {lab_pin.sym} 4540 41040 0 0 {name=l32916 lab=BL23}
N 4560 41000 4540 41000 {}
C {lab_pin.sym} 4540 41000 0 0 {name=l32917 lab=BLB23}
N 4560 40960 4540 40960 {}
C {lab_pin.sym} 4540 40960 0 0 {name=l32918 lab=WL205}
N 4640 41040 4660 41040 {}
C {lab_pin.sym} 4660 41040 0 0 {name=l32919 lab=VDD}
N 4640 40960 4660 40960 {}
C {lab_pin.sym} 4660 40960 0 0 {name=l32920 lab=VSS}
C {bitcell_6t.sym} 4800 41000 0 0 {name=Xr205c24}
N 4760 41040 4740 41040 {}
C {lab_pin.sym} 4740 41040 0 0 {name=l32921 lab=BL24}
N 4760 41000 4740 41000 {}
C {lab_pin.sym} 4740 41000 0 0 {name=l32922 lab=BLB24}
N 4760 40960 4740 40960 {}
C {lab_pin.sym} 4740 40960 0 0 {name=l32923 lab=WL205}
N 4840 41040 4860 41040 {}
C {lab_pin.sym} 4860 41040 0 0 {name=l32924 lab=VDD}
N 4840 40960 4860 40960 {}
C {lab_pin.sym} 4860 40960 0 0 {name=l32925 lab=VSS}
C {bitcell_6t.sym} 5000 41000 0 0 {name=Xr205c25}
N 4960 41040 4940 41040 {}
C {lab_pin.sym} 4940 41040 0 0 {name=l32926 lab=BL25}
N 4960 41000 4940 41000 {}
C {lab_pin.sym} 4940 41000 0 0 {name=l32927 lab=BLB25}
N 4960 40960 4940 40960 {}
C {lab_pin.sym} 4940 40960 0 0 {name=l32928 lab=WL205}
N 5040 41040 5060 41040 {}
C {lab_pin.sym} 5060 41040 0 0 {name=l32929 lab=VDD}
N 5040 40960 5060 40960 {}
C {lab_pin.sym} 5060 40960 0 0 {name=l32930 lab=VSS}
C {bitcell_6t.sym} 5200 41000 0 0 {name=Xr205c26}
N 5160 41040 5140 41040 {}
C {lab_pin.sym} 5140 41040 0 0 {name=l32931 lab=BL26}
N 5160 41000 5140 41000 {}
C {lab_pin.sym} 5140 41000 0 0 {name=l32932 lab=BLB26}
N 5160 40960 5140 40960 {}
C {lab_pin.sym} 5140 40960 0 0 {name=l32933 lab=WL205}
N 5240 41040 5260 41040 {}
C {lab_pin.sym} 5260 41040 0 0 {name=l32934 lab=VDD}
N 5240 40960 5260 40960 {}
C {lab_pin.sym} 5260 40960 0 0 {name=l32935 lab=VSS}
C {bitcell_6t.sym} 5400 41000 0 0 {name=Xr205c27}
N 5360 41040 5340 41040 {}
C {lab_pin.sym} 5340 41040 0 0 {name=l32936 lab=BL27}
N 5360 41000 5340 41000 {}
C {lab_pin.sym} 5340 41000 0 0 {name=l32937 lab=BLB27}
N 5360 40960 5340 40960 {}
C {lab_pin.sym} 5340 40960 0 0 {name=l32938 lab=WL205}
N 5440 41040 5460 41040 {}
C {lab_pin.sym} 5460 41040 0 0 {name=l32939 lab=VDD}
N 5440 40960 5460 40960 {}
C {lab_pin.sym} 5460 40960 0 0 {name=l32940 lab=VSS}
C {bitcell_6t.sym} 5600 41000 0 0 {name=Xr205c28}
N 5560 41040 5540 41040 {}
C {lab_pin.sym} 5540 41040 0 0 {name=l32941 lab=BL28}
N 5560 41000 5540 41000 {}
C {lab_pin.sym} 5540 41000 0 0 {name=l32942 lab=BLB28}
N 5560 40960 5540 40960 {}
C {lab_pin.sym} 5540 40960 0 0 {name=l32943 lab=WL205}
N 5640 41040 5660 41040 {}
C {lab_pin.sym} 5660 41040 0 0 {name=l32944 lab=VDD}
N 5640 40960 5660 40960 {}
C {lab_pin.sym} 5660 40960 0 0 {name=l32945 lab=VSS}
C {bitcell_6t.sym} 5800 41000 0 0 {name=Xr205c29}
N 5760 41040 5740 41040 {}
C {lab_pin.sym} 5740 41040 0 0 {name=l32946 lab=BL29}
N 5760 41000 5740 41000 {}
C {lab_pin.sym} 5740 41000 0 0 {name=l32947 lab=BLB29}
N 5760 40960 5740 40960 {}
C {lab_pin.sym} 5740 40960 0 0 {name=l32948 lab=WL205}
N 5840 41040 5860 41040 {}
C {lab_pin.sym} 5860 41040 0 0 {name=l32949 lab=VDD}
N 5840 40960 5860 40960 {}
C {lab_pin.sym} 5860 40960 0 0 {name=l32950 lab=VSS}
C {bitcell_6t.sym} 6000 41000 0 0 {name=Xr205c30}
N 5960 41040 5940 41040 {}
C {lab_pin.sym} 5940 41040 0 0 {name=l32951 lab=BL30}
N 5960 41000 5940 41000 {}
C {lab_pin.sym} 5940 41000 0 0 {name=l32952 lab=BLB30}
N 5960 40960 5940 40960 {}
C {lab_pin.sym} 5940 40960 0 0 {name=l32953 lab=WL205}
N 6040 41040 6060 41040 {}
C {lab_pin.sym} 6060 41040 0 0 {name=l32954 lab=VDD}
N 6040 40960 6060 40960 {}
C {lab_pin.sym} 6060 40960 0 0 {name=l32955 lab=VSS}
C {bitcell_6t.sym} 6200 41000 0 0 {name=Xr205c31}
N 6160 41040 6140 41040 {}
C {lab_pin.sym} 6140 41040 0 0 {name=l32956 lab=BL31}
N 6160 41000 6140 41000 {}
C {lab_pin.sym} 6140 41000 0 0 {name=l32957 lab=BLB31}
N 6160 40960 6140 40960 {}
C {lab_pin.sym} 6140 40960 0 0 {name=l32958 lab=WL205}
N 6240 41040 6260 41040 {}
C {lab_pin.sym} 6260 41040 0 0 {name=l32959 lab=VDD}
N 6240 40960 6260 40960 {}
C {lab_pin.sym} 6260 40960 0 0 {name=l32960 lab=VSS}
C {bitcell_6t.sym} 0 41200 0 0 {name=Xr206c0}
N -40 41240 -60 41240 {}
C {lab_pin.sym} -60 41240 0 0 {name=l32961 lab=BL0}
N -40 41200 -60 41200 {}
C {lab_pin.sym} -60 41200 0 0 {name=l32962 lab=BLB0}
N -40 41160 -60 41160 {}
C {lab_pin.sym} -60 41160 0 0 {name=l32963 lab=WL206}
N 40 41240 60 41240 {}
C {lab_pin.sym} 60 41240 0 0 {name=l32964 lab=VDD}
N 40 41160 60 41160 {}
C {lab_pin.sym} 60 41160 0 0 {name=l32965 lab=VSS}
C {bitcell_6t.sym} 200 41200 0 0 {name=Xr206c1}
N 160 41240 140 41240 {}
C {lab_pin.sym} 140 41240 0 0 {name=l32966 lab=BL1}
N 160 41200 140 41200 {}
C {lab_pin.sym} 140 41200 0 0 {name=l32967 lab=BLB1}
N 160 41160 140 41160 {}
C {lab_pin.sym} 140 41160 0 0 {name=l32968 lab=WL206}
N 240 41240 260 41240 {}
C {lab_pin.sym} 260 41240 0 0 {name=l32969 lab=VDD}
N 240 41160 260 41160 {}
C {lab_pin.sym} 260 41160 0 0 {name=l32970 lab=VSS}
C {bitcell_6t.sym} 400 41200 0 0 {name=Xr206c2}
N 360 41240 340 41240 {}
C {lab_pin.sym} 340 41240 0 0 {name=l32971 lab=BL2}
N 360 41200 340 41200 {}
C {lab_pin.sym} 340 41200 0 0 {name=l32972 lab=BLB2}
N 360 41160 340 41160 {}
C {lab_pin.sym} 340 41160 0 0 {name=l32973 lab=WL206}
N 440 41240 460 41240 {}
C {lab_pin.sym} 460 41240 0 0 {name=l32974 lab=VDD}
N 440 41160 460 41160 {}
C {lab_pin.sym} 460 41160 0 0 {name=l32975 lab=VSS}
C {bitcell_6t.sym} 600 41200 0 0 {name=Xr206c3}
N 560 41240 540 41240 {}
C {lab_pin.sym} 540 41240 0 0 {name=l32976 lab=BL3}
N 560 41200 540 41200 {}
C {lab_pin.sym} 540 41200 0 0 {name=l32977 lab=BLB3}
N 560 41160 540 41160 {}
C {lab_pin.sym} 540 41160 0 0 {name=l32978 lab=WL206}
N 640 41240 660 41240 {}
C {lab_pin.sym} 660 41240 0 0 {name=l32979 lab=VDD}
N 640 41160 660 41160 {}
C {lab_pin.sym} 660 41160 0 0 {name=l32980 lab=VSS}
C {bitcell_6t.sym} 800 41200 0 0 {name=Xr206c4}
N 760 41240 740 41240 {}
C {lab_pin.sym} 740 41240 0 0 {name=l32981 lab=BL4}
N 760 41200 740 41200 {}
C {lab_pin.sym} 740 41200 0 0 {name=l32982 lab=BLB4}
N 760 41160 740 41160 {}
C {lab_pin.sym} 740 41160 0 0 {name=l32983 lab=WL206}
N 840 41240 860 41240 {}
C {lab_pin.sym} 860 41240 0 0 {name=l32984 lab=VDD}
N 840 41160 860 41160 {}
C {lab_pin.sym} 860 41160 0 0 {name=l32985 lab=VSS}
C {bitcell_6t.sym} 1000 41200 0 0 {name=Xr206c5}
N 960 41240 940 41240 {}
C {lab_pin.sym} 940 41240 0 0 {name=l32986 lab=BL5}
N 960 41200 940 41200 {}
C {lab_pin.sym} 940 41200 0 0 {name=l32987 lab=BLB5}
N 960 41160 940 41160 {}
C {lab_pin.sym} 940 41160 0 0 {name=l32988 lab=WL206}
N 1040 41240 1060 41240 {}
C {lab_pin.sym} 1060 41240 0 0 {name=l32989 lab=VDD}
N 1040 41160 1060 41160 {}
C {lab_pin.sym} 1060 41160 0 0 {name=l32990 lab=VSS}
C {bitcell_6t.sym} 1200 41200 0 0 {name=Xr206c6}
N 1160 41240 1140 41240 {}
C {lab_pin.sym} 1140 41240 0 0 {name=l32991 lab=BL6}
N 1160 41200 1140 41200 {}
C {lab_pin.sym} 1140 41200 0 0 {name=l32992 lab=BLB6}
N 1160 41160 1140 41160 {}
C {lab_pin.sym} 1140 41160 0 0 {name=l32993 lab=WL206}
N 1240 41240 1260 41240 {}
C {lab_pin.sym} 1260 41240 0 0 {name=l32994 lab=VDD}
N 1240 41160 1260 41160 {}
C {lab_pin.sym} 1260 41160 0 0 {name=l32995 lab=VSS}
C {bitcell_6t.sym} 1400 41200 0 0 {name=Xr206c7}
N 1360 41240 1340 41240 {}
C {lab_pin.sym} 1340 41240 0 0 {name=l32996 lab=BL7}
N 1360 41200 1340 41200 {}
C {lab_pin.sym} 1340 41200 0 0 {name=l32997 lab=BLB7}
N 1360 41160 1340 41160 {}
C {lab_pin.sym} 1340 41160 0 0 {name=l32998 lab=WL206}
N 1440 41240 1460 41240 {}
C {lab_pin.sym} 1460 41240 0 0 {name=l32999 lab=VDD}
N 1440 41160 1460 41160 {}
C {lab_pin.sym} 1460 41160 0 0 {name=l33000 lab=VSS}
C {bitcell_6t.sym} 1600 41200 0 0 {name=Xr206c8}
N 1560 41240 1540 41240 {}
C {lab_pin.sym} 1540 41240 0 0 {name=l33001 lab=BL8}
N 1560 41200 1540 41200 {}
C {lab_pin.sym} 1540 41200 0 0 {name=l33002 lab=BLB8}
N 1560 41160 1540 41160 {}
C {lab_pin.sym} 1540 41160 0 0 {name=l33003 lab=WL206}
N 1640 41240 1660 41240 {}
C {lab_pin.sym} 1660 41240 0 0 {name=l33004 lab=VDD}
N 1640 41160 1660 41160 {}
C {lab_pin.sym} 1660 41160 0 0 {name=l33005 lab=VSS}
C {bitcell_6t.sym} 1800 41200 0 0 {name=Xr206c9}
N 1760 41240 1740 41240 {}
C {lab_pin.sym} 1740 41240 0 0 {name=l33006 lab=BL9}
N 1760 41200 1740 41200 {}
C {lab_pin.sym} 1740 41200 0 0 {name=l33007 lab=BLB9}
N 1760 41160 1740 41160 {}
C {lab_pin.sym} 1740 41160 0 0 {name=l33008 lab=WL206}
N 1840 41240 1860 41240 {}
C {lab_pin.sym} 1860 41240 0 0 {name=l33009 lab=VDD}
N 1840 41160 1860 41160 {}
C {lab_pin.sym} 1860 41160 0 0 {name=l33010 lab=VSS}
C {bitcell_6t.sym} 2000 41200 0 0 {name=Xr206c10}
N 1960 41240 1940 41240 {}
C {lab_pin.sym} 1940 41240 0 0 {name=l33011 lab=BL10}
N 1960 41200 1940 41200 {}
C {lab_pin.sym} 1940 41200 0 0 {name=l33012 lab=BLB10}
N 1960 41160 1940 41160 {}
C {lab_pin.sym} 1940 41160 0 0 {name=l33013 lab=WL206}
N 2040 41240 2060 41240 {}
C {lab_pin.sym} 2060 41240 0 0 {name=l33014 lab=VDD}
N 2040 41160 2060 41160 {}
C {lab_pin.sym} 2060 41160 0 0 {name=l33015 lab=VSS}
C {bitcell_6t.sym} 2200 41200 0 0 {name=Xr206c11}
N 2160 41240 2140 41240 {}
C {lab_pin.sym} 2140 41240 0 0 {name=l33016 lab=BL11}
N 2160 41200 2140 41200 {}
C {lab_pin.sym} 2140 41200 0 0 {name=l33017 lab=BLB11}
N 2160 41160 2140 41160 {}
C {lab_pin.sym} 2140 41160 0 0 {name=l33018 lab=WL206}
N 2240 41240 2260 41240 {}
C {lab_pin.sym} 2260 41240 0 0 {name=l33019 lab=VDD}
N 2240 41160 2260 41160 {}
C {lab_pin.sym} 2260 41160 0 0 {name=l33020 lab=VSS}
C {bitcell_6t.sym} 2400 41200 0 0 {name=Xr206c12}
N 2360 41240 2340 41240 {}
C {lab_pin.sym} 2340 41240 0 0 {name=l33021 lab=BL12}
N 2360 41200 2340 41200 {}
C {lab_pin.sym} 2340 41200 0 0 {name=l33022 lab=BLB12}
N 2360 41160 2340 41160 {}
C {lab_pin.sym} 2340 41160 0 0 {name=l33023 lab=WL206}
N 2440 41240 2460 41240 {}
C {lab_pin.sym} 2460 41240 0 0 {name=l33024 lab=VDD}
N 2440 41160 2460 41160 {}
C {lab_pin.sym} 2460 41160 0 0 {name=l33025 lab=VSS}
C {bitcell_6t.sym} 2600 41200 0 0 {name=Xr206c13}
N 2560 41240 2540 41240 {}
C {lab_pin.sym} 2540 41240 0 0 {name=l33026 lab=BL13}
N 2560 41200 2540 41200 {}
C {lab_pin.sym} 2540 41200 0 0 {name=l33027 lab=BLB13}
N 2560 41160 2540 41160 {}
C {lab_pin.sym} 2540 41160 0 0 {name=l33028 lab=WL206}
N 2640 41240 2660 41240 {}
C {lab_pin.sym} 2660 41240 0 0 {name=l33029 lab=VDD}
N 2640 41160 2660 41160 {}
C {lab_pin.sym} 2660 41160 0 0 {name=l33030 lab=VSS}
C {bitcell_6t.sym} 2800 41200 0 0 {name=Xr206c14}
N 2760 41240 2740 41240 {}
C {lab_pin.sym} 2740 41240 0 0 {name=l33031 lab=BL14}
N 2760 41200 2740 41200 {}
C {lab_pin.sym} 2740 41200 0 0 {name=l33032 lab=BLB14}
N 2760 41160 2740 41160 {}
C {lab_pin.sym} 2740 41160 0 0 {name=l33033 lab=WL206}
N 2840 41240 2860 41240 {}
C {lab_pin.sym} 2860 41240 0 0 {name=l33034 lab=VDD}
N 2840 41160 2860 41160 {}
C {lab_pin.sym} 2860 41160 0 0 {name=l33035 lab=VSS}
C {bitcell_6t.sym} 3000 41200 0 0 {name=Xr206c15}
N 2960 41240 2940 41240 {}
C {lab_pin.sym} 2940 41240 0 0 {name=l33036 lab=BL15}
N 2960 41200 2940 41200 {}
C {lab_pin.sym} 2940 41200 0 0 {name=l33037 lab=BLB15}
N 2960 41160 2940 41160 {}
C {lab_pin.sym} 2940 41160 0 0 {name=l33038 lab=WL206}
N 3040 41240 3060 41240 {}
C {lab_pin.sym} 3060 41240 0 0 {name=l33039 lab=VDD}
N 3040 41160 3060 41160 {}
C {lab_pin.sym} 3060 41160 0 0 {name=l33040 lab=VSS}
C {bitcell_6t.sym} 3200 41200 0 0 {name=Xr206c16}
N 3160 41240 3140 41240 {}
C {lab_pin.sym} 3140 41240 0 0 {name=l33041 lab=BL16}
N 3160 41200 3140 41200 {}
C {lab_pin.sym} 3140 41200 0 0 {name=l33042 lab=BLB16}
N 3160 41160 3140 41160 {}
C {lab_pin.sym} 3140 41160 0 0 {name=l33043 lab=WL206}
N 3240 41240 3260 41240 {}
C {lab_pin.sym} 3260 41240 0 0 {name=l33044 lab=VDD}
N 3240 41160 3260 41160 {}
C {lab_pin.sym} 3260 41160 0 0 {name=l33045 lab=VSS}
C {bitcell_6t.sym} 3400 41200 0 0 {name=Xr206c17}
N 3360 41240 3340 41240 {}
C {lab_pin.sym} 3340 41240 0 0 {name=l33046 lab=BL17}
N 3360 41200 3340 41200 {}
C {lab_pin.sym} 3340 41200 0 0 {name=l33047 lab=BLB17}
N 3360 41160 3340 41160 {}
C {lab_pin.sym} 3340 41160 0 0 {name=l33048 lab=WL206}
N 3440 41240 3460 41240 {}
C {lab_pin.sym} 3460 41240 0 0 {name=l33049 lab=VDD}
N 3440 41160 3460 41160 {}
C {lab_pin.sym} 3460 41160 0 0 {name=l33050 lab=VSS}
C {bitcell_6t.sym} 3600 41200 0 0 {name=Xr206c18}
N 3560 41240 3540 41240 {}
C {lab_pin.sym} 3540 41240 0 0 {name=l33051 lab=BL18}
N 3560 41200 3540 41200 {}
C {lab_pin.sym} 3540 41200 0 0 {name=l33052 lab=BLB18}
N 3560 41160 3540 41160 {}
C {lab_pin.sym} 3540 41160 0 0 {name=l33053 lab=WL206}
N 3640 41240 3660 41240 {}
C {lab_pin.sym} 3660 41240 0 0 {name=l33054 lab=VDD}
N 3640 41160 3660 41160 {}
C {lab_pin.sym} 3660 41160 0 0 {name=l33055 lab=VSS}
C {bitcell_6t.sym} 3800 41200 0 0 {name=Xr206c19}
N 3760 41240 3740 41240 {}
C {lab_pin.sym} 3740 41240 0 0 {name=l33056 lab=BL19}
N 3760 41200 3740 41200 {}
C {lab_pin.sym} 3740 41200 0 0 {name=l33057 lab=BLB19}
N 3760 41160 3740 41160 {}
C {lab_pin.sym} 3740 41160 0 0 {name=l33058 lab=WL206}
N 3840 41240 3860 41240 {}
C {lab_pin.sym} 3860 41240 0 0 {name=l33059 lab=VDD}
N 3840 41160 3860 41160 {}
C {lab_pin.sym} 3860 41160 0 0 {name=l33060 lab=VSS}
C {bitcell_6t.sym} 4000 41200 0 0 {name=Xr206c20}
N 3960 41240 3940 41240 {}
C {lab_pin.sym} 3940 41240 0 0 {name=l33061 lab=BL20}
N 3960 41200 3940 41200 {}
C {lab_pin.sym} 3940 41200 0 0 {name=l33062 lab=BLB20}
N 3960 41160 3940 41160 {}
C {lab_pin.sym} 3940 41160 0 0 {name=l33063 lab=WL206}
N 4040 41240 4060 41240 {}
C {lab_pin.sym} 4060 41240 0 0 {name=l33064 lab=VDD}
N 4040 41160 4060 41160 {}
C {lab_pin.sym} 4060 41160 0 0 {name=l33065 lab=VSS}
C {bitcell_6t.sym} 4200 41200 0 0 {name=Xr206c21}
N 4160 41240 4140 41240 {}
C {lab_pin.sym} 4140 41240 0 0 {name=l33066 lab=BL21}
N 4160 41200 4140 41200 {}
C {lab_pin.sym} 4140 41200 0 0 {name=l33067 lab=BLB21}
N 4160 41160 4140 41160 {}
C {lab_pin.sym} 4140 41160 0 0 {name=l33068 lab=WL206}
N 4240 41240 4260 41240 {}
C {lab_pin.sym} 4260 41240 0 0 {name=l33069 lab=VDD}
N 4240 41160 4260 41160 {}
C {lab_pin.sym} 4260 41160 0 0 {name=l33070 lab=VSS}
C {bitcell_6t.sym} 4400 41200 0 0 {name=Xr206c22}
N 4360 41240 4340 41240 {}
C {lab_pin.sym} 4340 41240 0 0 {name=l33071 lab=BL22}
N 4360 41200 4340 41200 {}
C {lab_pin.sym} 4340 41200 0 0 {name=l33072 lab=BLB22}
N 4360 41160 4340 41160 {}
C {lab_pin.sym} 4340 41160 0 0 {name=l33073 lab=WL206}
N 4440 41240 4460 41240 {}
C {lab_pin.sym} 4460 41240 0 0 {name=l33074 lab=VDD}
N 4440 41160 4460 41160 {}
C {lab_pin.sym} 4460 41160 0 0 {name=l33075 lab=VSS}
C {bitcell_6t.sym} 4600 41200 0 0 {name=Xr206c23}
N 4560 41240 4540 41240 {}
C {lab_pin.sym} 4540 41240 0 0 {name=l33076 lab=BL23}
N 4560 41200 4540 41200 {}
C {lab_pin.sym} 4540 41200 0 0 {name=l33077 lab=BLB23}
N 4560 41160 4540 41160 {}
C {lab_pin.sym} 4540 41160 0 0 {name=l33078 lab=WL206}
N 4640 41240 4660 41240 {}
C {lab_pin.sym} 4660 41240 0 0 {name=l33079 lab=VDD}
N 4640 41160 4660 41160 {}
C {lab_pin.sym} 4660 41160 0 0 {name=l33080 lab=VSS}
C {bitcell_6t.sym} 4800 41200 0 0 {name=Xr206c24}
N 4760 41240 4740 41240 {}
C {lab_pin.sym} 4740 41240 0 0 {name=l33081 lab=BL24}
N 4760 41200 4740 41200 {}
C {lab_pin.sym} 4740 41200 0 0 {name=l33082 lab=BLB24}
N 4760 41160 4740 41160 {}
C {lab_pin.sym} 4740 41160 0 0 {name=l33083 lab=WL206}
N 4840 41240 4860 41240 {}
C {lab_pin.sym} 4860 41240 0 0 {name=l33084 lab=VDD}
N 4840 41160 4860 41160 {}
C {lab_pin.sym} 4860 41160 0 0 {name=l33085 lab=VSS}
C {bitcell_6t.sym} 5000 41200 0 0 {name=Xr206c25}
N 4960 41240 4940 41240 {}
C {lab_pin.sym} 4940 41240 0 0 {name=l33086 lab=BL25}
N 4960 41200 4940 41200 {}
C {lab_pin.sym} 4940 41200 0 0 {name=l33087 lab=BLB25}
N 4960 41160 4940 41160 {}
C {lab_pin.sym} 4940 41160 0 0 {name=l33088 lab=WL206}
N 5040 41240 5060 41240 {}
C {lab_pin.sym} 5060 41240 0 0 {name=l33089 lab=VDD}
N 5040 41160 5060 41160 {}
C {lab_pin.sym} 5060 41160 0 0 {name=l33090 lab=VSS}
C {bitcell_6t.sym} 5200 41200 0 0 {name=Xr206c26}
N 5160 41240 5140 41240 {}
C {lab_pin.sym} 5140 41240 0 0 {name=l33091 lab=BL26}
N 5160 41200 5140 41200 {}
C {lab_pin.sym} 5140 41200 0 0 {name=l33092 lab=BLB26}
N 5160 41160 5140 41160 {}
C {lab_pin.sym} 5140 41160 0 0 {name=l33093 lab=WL206}
N 5240 41240 5260 41240 {}
C {lab_pin.sym} 5260 41240 0 0 {name=l33094 lab=VDD}
N 5240 41160 5260 41160 {}
C {lab_pin.sym} 5260 41160 0 0 {name=l33095 lab=VSS}
C {bitcell_6t.sym} 5400 41200 0 0 {name=Xr206c27}
N 5360 41240 5340 41240 {}
C {lab_pin.sym} 5340 41240 0 0 {name=l33096 lab=BL27}
N 5360 41200 5340 41200 {}
C {lab_pin.sym} 5340 41200 0 0 {name=l33097 lab=BLB27}
N 5360 41160 5340 41160 {}
C {lab_pin.sym} 5340 41160 0 0 {name=l33098 lab=WL206}
N 5440 41240 5460 41240 {}
C {lab_pin.sym} 5460 41240 0 0 {name=l33099 lab=VDD}
N 5440 41160 5460 41160 {}
C {lab_pin.sym} 5460 41160 0 0 {name=l33100 lab=VSS}
C {bitcell_6t.sym} 5600 41200 0 0 {name=Xr206c28}
N 5560 41240 5540 41240 {}
C {lab_pin.sym} 5540 41240 0 0 {name=l33101 lab=BL28}
N 5560 41200 5540 41200 {}
C {lab_pin.sym} 5540 41200 0 0 {name=l33102 lab=BLB28}
N 5560 41160 5540 41160 {}
C {lab_pin.sym} 5540 41160 0 0 {name=l33103 lab=WL206}
N 5640 41240 5660 41240 {}
C {lab_pin.sym} 5660 41240 0 0 {name=l33104 lab=VDD}
N 5640 41160 5660 41160 {}
C {lab_pin.sym} 5660 41160 0 0 {name=l33105 lab=VSS}
C {bitcell_6t.sym} 5800 41200 0 0 {name=Xr206c29}
N 5760 41240 5740 41240 {}
C {lab_pin.sym} 5740 41240 0 0 {name=l33106 lab=BL29}
N 5760 41200 5740 41200 {}
C {lab_pin.sym} 5740 41200 0 0 {name=l33107 lab=BLB29}
N 5760 41160 5740 41160 {}
C {lab_pin.sym} 5740 41160 0 0 {name=l33108 lab=WL206}
N 5840 41240 5860 41240 {}
C {lab_pin.sym} 5860 41240 0 0 {name=l33109 lab=VDD}
N 5840 41160 5860 41160 {}
C {lab_pin.sym} 5860 41160 0 0 {name=l33110 lab=VSS}
C {bitcell_6t.sym} 6000 41200 0 0 {name=Xr206c30}
N 5960 41240 5940 41240 {}
C {lab_pin.sym} 5940 41240 0 0 {name=l33111 lab=BL30}
N 5960 41200 5940 41200 {}
C {lab_pin.sym} 5940 41200 0 0 {name=l33112 lab=BLB30}
N 5960 41160 5940 41160 {}
C {lab_pin.sym} 5940 41160 0 0 {name=l33113 lab=WL206}
N 6040 41240 6060 41240 {}
C {lab_pin.sym} 6060 41240 0 0 {name=l33114 lab=VDD}
N 6040 41160 6060 41160 {}
C {lab_pin.sym} 6060 41160 0 0 {name=l33115 lab=VSS}
C {bitcell_6t.sym} 6200 41200 0 0 {name=Xr206c31}
N 6160 41240 6140 41240 {}
C {lab_pin.sym} 6140 41240 0 0 {name=l33116 lab=BL31}
N 6160 41200 6140 41200 {}
C {lab_pin.sym} 6140 41200 0 0 {name=l33117 lab=BLB31}
N 6160 41160 6140 41160 {}
C {lab_pin.sym} 6140 41160 0 0 {name=l33118 lab=WL206}
N 6240 41240 6260 41240 {}
C {lab_pin.sym} 6260 41240 0 0 {name=l33119 lab=VDD}
N 6240 41160 6260 41160 {}
C {lab_pin.sym} 6260 41160 0 0 {name=l33120 lab=VSS}
C {bitcell_6t.sym} 0 41400 0 0 {name=Xr207c0}
N -40 41440 -60 41440 {}
C {lab_pin.sym} -60 41440 0 0 {name=l33121 lab=BL0}
N -40 41400 -60 41400 {}
C {lab_pin.sym} -60 41400 0 0 {name=l33122 lab=BLB0}
N -40 41360 -60 41360 {}
C {lab_pin.sym} -60 41360 0 0 {name=l33123 lab=WL207}
N 40 41440 60 41440 {}
C {lab_pin.sym} 60 41440 0 0 {name=l33124 lab=VDD}
N 40 41360 60 41360 {}
C {lab_pin.sym} 60 41360 0 0 {name=l33125 lab=VSS}
C {bitcell_6t.sym} 200 41400 0 0 {name=Xr207c1}
N 160 41440 140 41440 {}
C {lab_pin.sym} 140 41440 0 0 {name=l33126 lab=BL1}
N 160 41400 140 41400 {}
C {lab_pin.sym} 140 41400 0 0 {name=l33127 lab=BLB1}
N 160 41360 140 41360 {}
C {lab_pin.sym} 140 41360 0 0 {name=l33128 lab=WL207}
N 240 41440 260 41440 {}
C {lab_pin.sym} 260 41440 0 0 {name=l33129 lab=VDD}
N 240 41360 260 41360 {}
C {lab_pin.sym} 260 41360 0 0 {name=l33130 lab=VSS}
C {bitcell_6t.sym} 400 41400 0 0 {name=Xr207c2}
N 360 41440 340 41440 {}
C {lab_pin.sym} 340 41440 0 0 {name=l33131 lab=BL2}
N 360 41400 340 41400 {}
C {lab_pin.sym} 340 41400 0 0 {name=l33132 lab=BLB2}
N 360 41360 340 41360 {}
C {lab_pin.sym} 340 41360 0 0 {name=l33133 lab=WL207}
N 440 41440 460 41440 {}
C {lab_pin.sym} 460 41440 0 0 {name=l33134 lab=VDD}
N 440 41360 460 41360 {}
C {lab_pin.sym} 460 41360 0 0 {name=l33135 lab=VSS}
C {bitcell_6t.sym} 600 41400 0 0 {name=Xr207c3}
N 560 41440 540 41440 {}
C {lab_pin.sym} 540 41440 0 0 {name=l33136 lab=BL3}
N 560 41400 540 41400 {}
C {lab_pin.sym} 540 41400 0 0 {name=l33137 lab=BLB3}
N 560 41360 540 41360 {}
C {lab_pin.sym} 540 41360 0 0 {name=l33138 lab=WL207}
N 640 41440 660 41440 {}
C {lab_pin.sym} 660 41440 0 0 {name=l33139 lab=VDD}
N 640 41360 660 41360 {}
C {lab_pin.sym} 660 41360 0 0 {name=l33140 lab=VSS}
C {bitcell_6t.sym} 800 41400 0 0 {name=Xr207c4}
N 760 41440 740 41440 {}
C {lab_pin.sym} 740 41440 0 0 {name=l33141 lab=BL4}
N 760 41400 740 41400 {}
C {lab_pin.sym} 740 41400 0 0 {name=l33142 lab=BLB4}
N 760 41360 740 41360 {}
C {lab_pin.sym} 740 41360 0 0 {name=l33143 lab=WL207}
N 840 41440 860 41440 {}
C {lab_pin.sym} 860 41440 0 0 {name=l33144 lab=VDD}
N 840 41360 860 41360 {}
C {lab_pin.sym} 860 41360 0 0 {name=l33145 lab=VSS}
C {bitcell_6t.sym} 1000 41400 0 0 {name=Xr207c5}
N 960 41440 940 41440 {}
C {lab_pin.sym} 940 41440 0 0 {name=l33146 lab=BL5}
N 960 41400 940 41400 {}
C {lab_pin.sym} 940 41400 0 0 {name=l33147 lab=BLB5}
N 960 41360 940 41360 {}
C {lab_pin.sym} 940 41360 0 0 {name=l33148 lab=WL207}
N 1040 41440 1060 41440 {}
C {lab_pin.sym} 1060 41440 0 0 {name=l33149 lab=VDD}
N 1040 41360 1060 41360 {}
C {lab_pin.sym} 1060 41360 0 0 {name=l33150 lab=VSS}
C {bitcell_6t.sym} 1200 41400 0 0 {name=Xr207c6}
N 1160 41440 1140 41440 {}
C {lab_pin.sym} 1140 41440 0 0 {name=l33151 lab=BL6}
N 1160 41400 1140 41400 {}
C {lab_pin.sym} 1140 41400 0 0 {name=l33152 lab=BLB6}
N 1160 41360 1140 41360 {}
C {lab_pin.sym} 1140 41360 0 0 {name=l33153 lab=WL207}
N 1240 41440 1260 41440 {}
C {lab_pin.sym} 1260 41440 0 0 {name=l33154 lab=VDD}
N 1240 41360 1260 41360 {}
C {lab_pin.sym} 1260 41360 0 0 {name=l33155 lab=VSS}
C {bitcell_6t.sym} 1400 41400 0 0 {name=Xr207c7}
N 1360 41440 1340 41440 {}
C {lab_pin.sym} 1340 41440 0 0 {name=l33156 lab=BL7}
N 1360 41400 1340 41400 {}
C {lab_pin.sym} 1340 41400 0 0 {name=l33157 lab=BLB7}
N 1360 41360 1340 41360 {}
C {lab_pin.sym} 1340 41360 0 0 {name=l33158 lab=WL207}
N 1440 41440 1460 41440 {}
C {lab_pin.sym} 1460 41440 0 0 {name=l33159 lab=VDD}
N 1440 41360 1460 41360 {}
C {lab_pin.sym} 1460 41360 0 0 {name=l33160 lab=VSS}
C {bitcell_6t.sym} 1600 41400 0 0 {name=Xr207c8}
N 1560 41440 1540 41440 {}
C {lab_pin.sym} 1540 41440 0 0 {name=l33161 lab=BL8}
N 1560 41400 1540 41400 {}
C {lab_pin.sym} 1540 41400 0 0 {name=l33162 lab=BLB8}
N 1560 41360 1540 41360 {}
C {lab_pin.sym} 1540 41360 0 0 {name=l33163 lab=WL207}
N 1640 41440 1660 41440 {}
C {lab_pin.sym} 1660 41440 0 0 {name=l33164 lab=VDD}
N 1640 41360 1660 41360 {}
C {lab_pin.sym} 1660 41360 0 0 {name=l33165 lab=VSS}
C {bitcell_6t.sym} 1800 41400 0 0 {name=Xr207c9}
N 1760 41440 1740 41440 {}
C {lab_pin.sym} 1740 41440 0 0 {name=l33166 lab=BL9}
N 1760 41400 1740 41400 {}
C {lab_pin.sym} 1740 41400 0 0 {name=l33167 lab=BLB9}
N 1760 41360 1740 41360 {}
C {lab_pin.sym} 1740 41360 0 0 {name=l33168 lab=WL207}
N 1840 41440 1860 41440 {}
C {lab_pin.sym} 1860 41440 0 0 {name=l33169 lab=VDD}
N 1840 41360 1860 41360 {}
C {lab_pin.sym} 1860 41360 0 0 {name=l33170 lab=VSS}
C {bitcell_6t.sym} 2000 41400 0 0 {name=Xr207c10}
N 1960 41440 1940 41440 {}
C {lab_pin.sym} 1940 41440 0 0 {name=l33171 lab=BL10}
N 1960 41400 1940 41400 {}
C {lab_pin.sym} 1940 41400 0 0 {name=l33172 lab=BLB10}
N 1960 41360 1940 41360 {}
C {lab_pin.sym} 1940 41360 0 0 {name=l33173 lab=WL207}
N 2040 41440 2060 41440 {}
C {lab_pin.sym} 2060 41440 0 0 {name=l33174 lab=VDD}
N 2040 41360 2060 41360 {}
C {lab_pin.sym} 2060 41360 0 0 {name=l33175 lab=VSS}
C {bitcell_6t.sym} 2200 41400 0 0 {name=Xr207c11}
N 2160 41440 2140 41440 {}
C {lab_pin.sym} 2140 41440 0 0 {name=l33176 lab=BL11}
N 2160 41400 2140 41400 {}
C {lab_pin.sym} 2140 41400 0 0 {name=l33177 lab=BLB11}
N 2160 41360 2140 41360 {}
C {lab_pin.sym} 2140 41360 0 0 {name=l33178 lab=WL207}
N 2240 41440 2260 41440 {}
C {lab_pin.sym} 2260 41440 0 0 {name=l33179 lab=VDD}
N 2240 41360 2260 41360 {}
C {lab_pin.sym} 2260 41360 0 0 {name=l33180 lab=VSS}
C {bitcell_6t.sym} 2400 41400 0 0 {name=Xr207c12}
N 2360 41440 2340 41440 {}
C {lab_pin.sym} 2340 41440 0 0 {name=l33181 lab=BL12}
N 2360 41400 2340 41400 {}
C {lab_pin.sym} 2340 41400 0 0 {name=l33182 lab=BLB12}
N 2360 41360 2340 41360 {}
C {lab_pin.sym} 2340 41360 0 0 {name=l33183 lab=WL207}
N 2440 41440 2460 41440 {}
C {lab_pin.sym} 2460 41440 0 0 {name=l33184 lab=VDD}
N 2440 41360 2460 41360 {}
C {lab_pin.sym} 2460 41360 0 0 {name=l33185 lab=VSS}
C {bitcell_6t.sym} 2600 41400 0 0 {name=Xr207c13}
N 2560 41440 2540 41440 {}
C {lab_pin.sym} 2540 41440 0 0 {name=l33186 lab=BL13}
N 2560 41400 2540 41400 {}
C {lab_pin.sym} 2540 41400 0 0 {name=l33187 lab=BLB13}
N 2560 41360 2540 41360 {}
C {lab_pin.sym} 2540 41360 0 0 {name=l33188 lab=WL207}
N 2640 41440 2660 41440 {}
C {lab_pin.sym} 2660 41440 0 0 {name=l33189 lab=VDD}
N 2640 41360 2660 41360 {}
C {lab_pin.sym} 2660 41360 0 0 {name=l33190 lab=VSS}
C {bitcell_6t.sym} 2800 41400 0 0 {name=Xr207c14}
N 2760 41440 2740 41440 {}
C {lab_pin.sym} 2740 41440 0 0 {name=l33191 lab=BL14}
N 2760 41400 2740 41400 {}
C {lab_pin.sym} 2740 41400 0 0 {name=l33192 lab=BLB14}
N 2760 41360 2740 41360 {}
C {lab_pin.sym} 2740 41360 0 0 {name=l33193 lab=WL207}
N 2840 41440 2860 41440 {}
C {lab_pin.sym} 2860 41440 0 0 {name=l33194 lab=VDD}
N 2840 41360 2860 41360 {}
C {lab_pin.sym} 2860 41360 0 0 {name=l33195 lab=VSS}
C {bitcell_6t.sym} 3000 41400 0 0 {name=Xr207c15}
N 2960 41440 2940 41440 {}
C {lab_pin.sym} 2940 41440 0 0 {name=l33196 lab=BL15}
N 2960 41400 2940 41400 {}
C {lab_pin.sym} 2940 41400 0 0 {name=l33197 lab=BLB15}
N 2960 41360 2940 41360 {}
C {lab_pin.sym} 2940 41360 0 0 {name=l33198 lab=WL207}
N 3040 41440 3060 41440 {}
C {lab_pin.sym} 3060 41440 0 0 {name=l33199 lab=VDD}
N 3040 41360 3060 41360 {}
C {lab_pin.sym} 3060 41360 0 0 {name=l33200 lab=VSS}
C {bitcell_6t.sym} 3200 41400 0 0 {name=Xr207c16}
N 3160 41440 3140 41440 {}
C {lab_pin.sym} 3140 41440 0 0 {name=l33201 lab=BL16}
N 3160 41400 3140 41400 {}
C {lab_pin.sym} 3140 41400 0 0 {name=l33202 lab=BLB16}
N 3160 41360 3140 41360 {}
C {lab_pin.sym} 3140 41360 0 0 {name=l33203 lab=WL207}
N 3240 41440 3260 41440 {}
C {lab_pin.sym} 3260 41440 0 0 {name=l33204 lab=VDD}
N 3240 41360 3260 41360 {}
C {lab_pin.sym} 3260 41360 0 0 {name=l33205 lab=VSS}
C {bitcell_6t.sym} 3400 41400 0 0 {name=Xr207c17}
N 3360 41440 3340 41440 {}
C {lab_pin.sym} 3340 41440 0 0 {name=l33206 lab=BL17}
N 3360 41400 3340 41400 {}
C {lab_pin.sym} 3340 41400 0 0 {name=l33207 lab=BLB17}
N 3360 41360 3340 41360 {}
C {lab_pin.sym} 3340 41360 0 0 {name=l33208 lab=WL207}
N 3440 41440 3460 41440 {}
C {lab_pin.sym} 3460 41440 0 0 {name=l33209 lab=VDD}
N 3440 41360 3460 41360 {}
C {lab_pin.sym} 3460 41360 0 0 {name=l33210 lab=VSS}
C {bitcell_6t.sym} 3600 41400 0 0 {name=Xr207c18}
N 3560 41440 3540 41440 {}
C {lab_pin.sym} 3540 41440 0 0 {name=l33211 lab=BL18}
N 3560 41400 3540 41400 {}
C {lab_pin.sym} 3540 41400 0 0 {name=l33212 lab=BLB18}
N 3560 41360 3540 41360 {}
C {lab_pin.sym} 3540 41360 0 0 {name=l33213 lab=WL207}
N 3640 41440 3660 41440 {}
C {lab_pin.sym} 3660 41440 0 0 {name=l33214 lab=VDD}
N 3640 41360 3660 41360 {}
C {lab_pin.sym} 3660 41360 0 0 {name=l33215 lab=VSS}
C {bitcell_6t.sym} 3800 41400 0 0 {name=Xr207c19}
N 3760 41440 3740 41440 {}
C {lab_pin.sym} 3740 41440 0 0 {name=l33216 lab=BL19}
N 3760 41400 3740 41400 {}
C {lab_pin.sym} 3740 41400 0 0 {name=l33217 lab=BLB19}
N 3760 41360 3740 41360 {}
C {lab_pin.sym} 3740 41360 0 0 {name=l33218 lab=WL207}
N 3840 41440 3860 41440 {}
C {lab_pin.sym} 3860 41440 0 0 {name=l33219 lab=VDD}
N 3840 41360 3860 41360 {}
C {lab_pin.sym} 3860 41360 0 0 {name=l33220 lab=VSS}
C {bitcell_6t.sym} 4000 41400 0 0 {name=Xr207c20}
N 3960 41440 3940 41440 {}
C {lab_pin.sym} 3940 41440 0 0 {name=l33221 lab=BL20}
N 3960 41400 3940 41400 {}
C {lab_pin.sym} 3940 41400 0 0 {name=l33222 lab=BLB20}
N 3960 41360 3940 41360 {}
C {lab_pin.sym} 3940 41360 0 0 {name=l33223 lab=WL207}
N 4040 41440 4060 41440 {}
C {lab_pin.sym} 4060 41440 0 0 {name=l33224 lab=VDD}
N 4040 41360 4060 41360 {}
C {lab_pin.sym} 4060 41360 0 0 {name=l33225 lab=VSS}
C {bitcell_6t.sym} 4200 41400 0 0 {name=Xr207c21}
N 4160 41440 4140 41440 {}
C {lab_pin.sym} 4140 41440 0 0 {name=l33226 lab=BL21}
N 4160 41400 4140 41400 {}
C {lab_pin.sym} 4140 41400 0 0 {name=l33227 lab=BLB21}
N 4160 41360 4140 41360 {}
C {lab_pin.sym} 4140 41360 0 0 {name=l33228 lab=WL207}
N 4240 41440 4260 41440 {}
C {lab_pin.sym} 4260 41440 0 0 {name=l33229 lab=VDD}
N 4240 41360 4260 41360 {}
C {lab_pin.sym} 4260 41360 0 0 {name=l33230 lab=VSS}
C {bitcell_6t.sym} 4400 41400 0 0 {name=Xr207c22}
N 4360 41440 4340 41440 {}
C {lab_pin.sym} 4340 41440 0 0 {name=l33231 lab=BL22}
N 4360 41400 4340 41400 {}
C {lab_pin.sym} 4340 41400 0 0 {name=l33232 lab=BLB22}
N 4360 41360 4340 41360 {}
C {lab_pin.sym} 4340 41360 0 0 {name=l33233 lab=WL207}
N 4440 41440 4460 41440 {}
C {lab_pin.sym} 4460 41440 0 0 {name=l33234 lab=VDD}
N 4440 41360 4460 41360 {}
C {lab_pin.sym} 4460 41360 0 0 {name=l33235 lab=VSS}
C {bitcell_6t.sym} 4600 41400 0 0 {name=Xr207c23}
N 4560 41440 4540 41440 {}
C {lab_pin.sym} 4540 41440 0 0 {name=l33236 lab=BL23}
N 4560 41400 4540 41400 {}
C {lab_pin.sym} 4540 41400 0 0 {name=l33237 lab=BLB23}
N 4560 41360 4540 41360 {}
C {lab_pin.sym} 4540 41360 0 0 {name=l33238 lab=WL207}
N 4640 41440 4660 41440 {}
C {lab_pin.sym} 4660 41440 0 0 {name=l33239 lab=VDD}
N 4640 41360 4660 41360 {}
C {lab_pin.sym} 4660 41360 0 0 {name=l33240 lab=VSS}
C {bitcell_6t.sym} 4800 41400 0 0 {name=Xr207c24}
N 4760 41440 4740 41440 {}
C {lab_pin.sym} 4740 41440 0 0 {name=l33241 lab=BL24}
N 4760 41400 4740 41400 {}
C {lab_pin.sym} 4740 41400 0 0 {name=l33242 lab=BLB24}
N 4760 41360 4740 41360 {}
C {lab_pin.sym} 4740 41360 0 0 {name=l33243 lab=WL207}
N 4840 41440 4860 41440 {}
C {lab_pin.sym} 4860 41440 0 0 {name=l33244 lab=VDD}
N 4840 41360 4860 41360 {}
C {lab_pin.sym} 4860 41360 0 0 {name=l33245 lab=VSS}
C {bitcell_6t.sym} 5000 41400 0 0 {name=Xr207c25}
N 4960 41440 4940 41440 {}
C {lab_pin.sym} 4940 41440 0 0 {name=l33246 lab=BL25}
N 4960 41400 4940 41400 {}
C {lab_pin.sym} 4940 41400 0 0 {name=l33247 lab=BLB25}
N 4960 41360 4940 41360 {}
C {lab_pin.sym} 4940 41360 0 0 {name=l33248 lab=WL207}
N 5040 41440 5060 41440 {}
C {lab_pin.sym} 5060 41440 0 0 {name=l33249 lab=VDD}
N 5040 41360 5060 41360 {}
C {lab_pin.sym} 5060 41360 0 0 {name=l33250 lab=VSS}
C {bitcell_6t.sym} 5200 41400 0 0 {name=Xr207c26}
N 5160 41440 5140 41440 {}
C {lab_pin.sym} 5140 41440 0 0 {name=l33251 lab=BL26}
N 5160 41400 5140 41400 {}
C {lab_pin.sym} 5140 41400 0 0 {name=l33252 lab=BLB26}
N 5160 41360 5140 41360 {}
C {lab_pin.sym} 5140 41360 0 0 {name=l33253 lab=WL207}
N 5240 41440 5260 41440 {}
C {lab_pin.sym} 5260 41440 0 0 {name=l33254 lab=VDD}
N 5240 41360 5260 41360 {}
C {lab_pin.sym} 5260 41360 0 0 {name=l33255 lab=VSS}
C {bitcell_6t.sym} 5400 41400 0 0 {name=Xr207c27}
N 5360 41440 5340 41440 {}
C {lab_pin.sym} 5340 41440 0 0 {name=l33256 lab=BL27}
N 5360 41400 5340 41400 {}
C {lab_pin.sym} 5340 41400 0 0 {name=l33257 lab=BLB27}
N 5360 41360 5340 41360 {}
C {lab_pin.sym} 5340 41360 0 0 {name=l33258 lab=WL207}
N 5440 41440 5460 41440 {}
C {lab_pin.sym} 5460 41440 0 0 {name=l33259 lab=VDD}
N 5440 41360 5460 41360 {}
C {lab_pin.sym} 5460 41360 0 0 {name=l33260 lab=VSS}
C {bitcell_6t.sym} 5600 41400 0 0 {name=Xr207c28}
N 5560 41440 5540 41440 {}
C {lab_pin.sym} 5540 41440 0 0 {name=l33261 lab=BL28}
N 5560 41400 5540 41400 {}
C {lab_pin.sym} 5540 41400 0 0 {name=l33262 lab=BLB28}
N 5560 41360 5540 41360 {}
C {lab_pin.sym} 5540 41360 0 0 {name=l33263 lab=WL207}
N 5640 41440 5660 41440 {}
C {lab_pin.sym} 5660 41440 0 0 {name=l33264 lab=VDD}
N 5640 41360 5660 41360 {}
C {lab_pin.sym} 5660 41360 0 0 {name=l33265 lab=VSS}
C {bitcell_6t.sym} 5800 41400 0 0 {name=Xr207c29}
N 5760 41440 5740 41440 {}
C {lab_pin.sym} 5740 41440 0 0 {name=l33266 lab=BL29}
N 5760 41400 5740 41400 {}
C {lab_pin.sym} 5740 41400 0 0 {name=l33267 lab=BLB29}
N 5760 41360 5740 41360 {}
C {lab_pin.sym} 5740 41360 0 0 {name=l33268 lab=WL207}
N 5840 41440 5860 41440 {}
C {lab_pin.sym} 5860 41440 0 0 {name=l33269 lab=VDD}
N 5840 41360 5860 41360 {}
C {lab_pin.sym} 5860 41360 0 0 {name=l33270 lab=VSS}
C {bitcell_6t.sym} 6000 41400 0 0 {name=Xr207c30}
N 5960 41440 5940 41440 {}
C {lab_pin.sym} 5940 41440 0 0 {name=l33271 lab=BL30}
N 5960 41400 5940 41400 {}
C {lab_pin.sym} 5940 41400 0 0 {name=l33272 lab=BLB30}
N 5960 41360 5940 41360 {}
C {lab_pin.sym} 5940 41360 0 0 {name=l33273 lab=WL207}
N 6040 41440 6060 41440 {}
C {lab_pin.sym} 6060 41440 0 0 {name=l33274 lab=VDD}
N 6040 41360 6060 41360 {}
C {lab_pin.sym} 6060 41360 0 0 {name=l33275 lab=VSS}
C {bitcell_6t.sym} 6200 41400 0 0 {name=Xr207c31}
N 6160 41440 6140 41440 {}
C {lab_pin.sym} 6140 41440 0 0 {name=l33276 lab=BL31}
N 6160 41400 6140 41400 {}
C {lab_pin.sym} 6140 41400 0 0 {name=l33277 lab=BLB31}
N 6160 41360 6140 41360 {}
C {lab_pin.sym} 6140 41360 0 0 {name=l33278 lab=WL207}
N 6240 41440 6260 41440 {}
C {lab_pin.sym} 6260 41440 0 0 {name=l33279 lab=VDD}
N 6240 41360 6260 41360 {}
C {lab_pin.sym} 6260 41360 0 0 {name=l33280 lab=VSS}
C {bitcell_6t.sym} 0 41600 0 0 {name=Xr208c0}
N -40 41640 -60 41640 {}
C {lab_pin.sym} -60 41640 0 0 {name=l33281 lab=BL0}
N -40 41600 -60 41600 {}
C {lab_pin.sym} -60 41600 0 0 {name=l33282 lab=BLB0}
N -40 41560 -60 41560 {}
C {lab_pin.sym} -60 41560 0 0 {name=l33283 lab=WL208}
N 40 41640 60 41640 {}
C {lab_pin.sym} 60 41640 0 0 {name=l33284 lab=VDD}
N 40 41560 60 41560 {}
C {lab_pin.sym} 60 41560 0 0 {name=l33285 lab=VSS}
C {bitcell_6t.sym} 200 41600 0 0 {name=Xr208c1}
N 160 41640 140 41640 {}
C {lab_pin.sym} 140 41640 0 0 {name=l33286 lab=BL1}
N 160 41600 140 41600 {}
C {lab_pin.sym} 140 41600 0 0 {name=l33287 lab=BLB1}
N 160 41560 140 41560 {}
C {lab_pin.sym} 140 41560 0 0 {name=l33288 lab=WL208}
N 240 41640 260 41640 {}
C {lab_pin.sym} 260 41640 0 0 {name=l33289 lab=VDD}
N 240 41560 260 41560 {}
C {lab_pin.sym} 260 41560 0 0 {name=l33290 lab=VSS}
C {bitcell_6t.sym} 400 41600 0 0 {name=Xr208c2}
N 360 41640 340 41640 {}
C {lab_pin.sym} 340 41640 0 0 {name=l33291 lab=BL2}
N 360 41600 340 41600 {}
C {lab_pin.sym} 340 41600 0 0 {name=l33292 lab=BLB2}
N 360 41560 340 41560 {}
C {lab_pin.sym} 340 41560 0 0 {name=l33293 lab=WL208}
N 440 41640 460 41640 {}
C {lab_pin.sym} 460 41640 0 0 {name=l33294 lab=VDD}
N 440 41560 460 41560 {}
C {lab_pin.sym} 460 41560 0 0 {name=l33295 lab=VSS}
C {bitcell_6t.sym} 600 41600 0 0 {name=Xr208c3}
N 560 41640 540 41640 {}
C {lab_pin.sym} 540 41640 0 0 {name=l33296 lab=BL3}
N 560 41600 540 41600 {}
C {lab_pin.sym} 540 41600 0 0 {name=l33297 lab=BLB3}
N 560 41560 540 41560 {}
C {lab_pin.sym} 540 41560 0 0 {name=l33298 lab=WL208}
N 640 41640 660 41640 {}
C {lab_pin.sym} 660 41640 0 0 {name=l33299 lab=VDD}
N 640 41560 660 41560 {}
C {lab_pin.sym} 660 41560 0 0 {name=l33300 lab=VSS}
C {bitcell_6t.sym} 800 41600 0 0 {name=Xr208c4}
N 760 41640 740 41640 {}
C {lab_pin.sym} 740 41640 0 0 {name=l33301 lab=BL4}
N 760 41600 740 41600 {}
C {lab_pin.sym} 740 41600 0 0 {name=l33302 lab=BLB4}
N 760 41560 740 41560 {}
C {lab_pin.sym} 740 41560 0 0 {name=l33303 lab=WL208}
N 840 41640 860 41640 {}
C {lab_pin.sym} 860 41640 0 0 {name=l33304 lab=VDD}
N 840 41560 860 41560 {}
C {lab_pin.sym} 860 41560 0 0 {name=l33305 lab=VSS}
C {bitcell_6t.sym} 1000 41600 0 0 {name=Xr208c5}
N 960 41640 940 41640 {}
C {lab_pin.sym} 940 41640 0 0 {name=l33306 lab=BL5}
N 960 41600 940 41600 {}
C {lab_pin.sym} 940 41600 0 0 {name=l33307 lab=BLB5}
N 960 41560 940 41560 {}
C {lab_pin.sym} 940 41560 0 0 {name=l33308 lab=WL208}
N 1040 41640 1060 41640 {}
C {lab_pin.sym} 1060 41640 0 0 {name=l33309 lab=VDD}
N 1040 41560 1060 41560 {}
C {lab_pin.sym} 1060 41560 0 0 {name=l33310 lab=VSS}
C {bitcell_6t.sym} 1200 41600 0 0 {name=Xr208c6}
N 1160 41640 1140 41640 {}
C {lab_pin.sym} 1140 41640 0 0 {name=l33311 lab=BL6}
N 1160 41600 1140 41600 {}
C {lab_pin.sym} 1140 41600 0 0 {name=l33312 lab=BLB6}
N 1160 41560 1140 41560 {}
C {lab_pin.sym} 1140 41560 0 0 {name=l33313 lab=WL208}
N 1240 41640 1260 41640 {}
C {lab_pin.sym} 1260 41640 0 0 {name=l33314 lab=VDD}
N 1240 41560 1260 41560 {}
C {lab_pin.sym} 1260 41560 0 0 {name=l33315 lab=VSS}
C {bitcell_6t.sym} 1400 41600 0 0 {name=Xr208c7}
N 1360 41640 1340 41640 {}
C {lab_pin.sym} 1340 41640 0 0 {name=l33316 lab=BL7}
N 1360 41600 1340 41600 {}
C {lab_pin.sym} 1340 41600 0 0 {name=l33317 lab=BLB7}
N 1360 41560 1340 41560 {}
C {lab_pin.sym} 1340 41560 0 0 {name=l33318 lab=WL208}
N 1440 41640 1460 41640 {}
C {lab_pin.sym} 1460 41640 0 0 {name=l33319 lab=VDD}
N 1440 41560 1460 41560 {}
C {lab_pin.sym} 1460 41560 0 0 {name=l33320 lab=VSS}
C {bitcell_6t.sym} 1600 41600 0 0 {name=Xr208c8}
N 1560 41640 1540 41640 {}
C {lab_pin.sym} 1540 41640 0 0 {name=l33321 lab=BL8}
N 1560 41600 1540 41600 {}
C {lab_pin.sym} 1540 41600 0 0 {name=l33322 lab=BLB8}
N 1560 41560 1540 41560 {}
C {lab_pin.sym} 1540 41560 0 0 {name=l33323 lab=WL208}
N 1640 41640 1660 41640 {}
C {lab_pin.sym} 1660 41640 0 0 {name=l33324 lab=VDD}
N 1640 41560 1660 41560 {}
C {lab_pin.sym} 1660 41560 0 0 {name=l33325 lab=VSS}
C {bitcell_6t.sym} 1800 41600 0 0 {name=Xr208c9}
N 1760 41640 1740 41640 {}
C {lab_pin.sym} 1740 41640 0 0 {name=l33326 lab=BL9}
N 1760 41600 1740 41600 {}
C {lab_pin.sym} 1740 41600 0 0 {name=l33327 lab=BLB9}
N 1760 41560 1740 41560 {}
C {lab_pin.sym} 1740 41560 0 0 {name=l33328 lab=WL208}
N 1840 41640 1860 41640 {}
C {lab_pin.sym} 1860 41640 0 0 {name=l33329 lab=VDD}
N 1840 41560 1860 41560 {}
C {lab_pin.sym} 1860 41560 0 0 {name=l33330 lab=VSS}
C {bitcell_6t.sym} 2000 41600 0 0 {name=Xr208c10}
N 1960 41640 1940 41640 {}
C {lab_pin.sym} 1940 41640 0 0 {name=l33331 lab=BL10}
N 1960 41600 1940 41600 {}
C {lab_pin.sym} 1940 41600 0 0 {name=l33332 lab=BLB10}
N 1960 41560 1940 41560 {}
C {lab_pin.sym} 1940 41560 0 0 {name=l33333 lab=WL208}
N 2040 41640 2060 41640 {}
C {lab_pin.sym} 2060 41640 0 0 {name=l33334 lab=VDD}
N 2040 41560 2060 41560 {}
C {lab_pin.sym} 2060 41560 0 0 {name=l33335 lab=VSS}
C {bitcell_6t.sym} 2200 41600 0 0 {name=Xr208c11}
N 2160 41640 2140 41640 {}
C {lab_pin.sym} 2140 41640 0 0 {name=l33336 lab=BL11}
N 2160 41600 2140 41600 {}
C {lab_pin.sym} 2140 41600 0 0 {name=l33337 lab=BLB11}
N 2160 41560 2140 41560 {}
C {lab_pin.sym} 2140 41560 0 0 {name=l33338 lab=WL208}
N 2240 41640 2260 41640 {}
C {lab_pin.sym} 2260 41640 0 0 {name=l33339 lab=VDD}
N 2240 41560 2260 41560 {}
C {lab_pin.sym} 2260 41560 0 0 {name=l33340 lab=VSS}
C {bitcell_6t.sym} 2400 41600 0 0 {name=Xr208c12}
N 2360 41640 2340 41640 {}
C {lab_pin.sym} 2340 41640 0 0 {name=l33341 lab=BL12}
N 2360 41600 2340 41600 {}
C {lab_pin.sym} 2340 41600 0 0 {name=l33342 lab=BLB12}
N 2360 41560 2340 41560 {}
C {lab_pin.sym} 2340 41560 0 0 {name=l33343 lab=WL208}
N 2440 41640 2460 41640 {}
C {lab_pin.sym} 2460 41640 0 0 {name=l33344 lab=VDD}
N 2440 41560 2460 41560 {}
C {lab_pin.sym} 2460 41560 0 0 {name=l33345 lab=VSS}
C {bitcell_6t.sym} 2600 41600 0 0 {name=Xr208c13}
N 2560 41640 2540 41640 {}
C {lab_pin.sym} 2540 41640 0 0 {name=l33346 lab=BL13}
N 2560 41600 2540 41600 {}
C {lab_pin.sym} 2540 41600 0 0 {name=l33347 lab=BLB13}
N 2560 41560 2540 41560 {}
C {lab_pin.sym} 2540 41560 0 0 {name=l33348 lab=WL208}
N 2640 41640 2660 41640 {}
C {lab_pin.sym} 2660 41640 0 0 {name=l33349 lab=VDD}
N 2640 41560 2660 41560 {}
C {lab_pin.sym} 2660 41560 0 0 {name=l33350 lab=VSS}
C {bitcell_6t.sym} 2800 41600 0 0 {name=Xr208c14}
N 2760 41640 2740 41640 {}
C {lab_pin.sym} 2740 41640 0 0 {name=l33351 lab=BL14}
N 2760 41600 2740 41600 {}
C {lab_pin.sym} 2740 41600 0 0 {name=l33352 lab=BLB14}
N 2760 41560 2740 41560 {}
C {lab_pin.sym} 2740 41560 0 0 {name=l33353 lab=WL208}
N 2840 41640 2860 41640 {}
C {lab_pin.sym} 2860 41640 0 0 {name=l33354 lab=VDD}
N 2840 41560 2860 41560 {}
C {lab_pin.sym} 2860 41560 0 0 {name=l33355 lab=VSS}
C {bitcell_6t.sym} 3000 41600 0 0 {name=Xr208c15}
N 2960 41640 2940 41640 {}
C {lab_pin.sym} 2940 41640 0 0 {name=l33356 lab=BL15}
N 2960 41600 2940 41600 {}
C {lab_pin.sym} 2940 41600 0 0 {name=l33357 lab=BLB15}
N 2960 41560 2940 41560 {}
C {lab_pin.sym} 2940 41560 0 0 {name=l33358 lab=WL208}
N 3040 41640 3060 41640 {}
C {lab_pin.sym} 3060 41640 0 0 {name=l33359 lab=VDD}
N 3040 41560 3060 41560 {}
C {lab_pin.sym} 3060 41560 0 0 {name=l33360 lab=VSS}
C {bitcell_6t.sym} 3200 41600 0 0 {name=Xr208c16}
N 3160 41640 3140 41640 {}
C {lab_pin.sym} 3140 41640 0 0 {name=l33361 lab=BL16}
N 3160 41600 3140 41600 {}
C {lab_pin.sym} 3140 41600 0 0 {name=l33362 lab=BLB16}
N 3160 41560 3140 41560 {}
C {lab_pin.sym} 3140 41560 0 0 {name=l33363 lab=WL208}
N 3240 41640 3260 41640 {}
C {lab_pin.sym} 3260 41640 0 0 {name=l33364 lab=VDD}
N 3240 41560 3260 41560 {}
C {lab_pin.sym} 3260 41560 0 0 {name=l33365 lab=VSS}
C {bitcell_6t.sym} 3400 41600 0 0 {name=Xr208c17}
N 3360 41640 3340 41640 {}
C {lab_pin.sym} 3340 41640 0 0 {name=l33366 lab=BL17}
N 3360 41600 3340 41600 {}
C {lab_pin.sym} 3340 41600 0 0 {name=l33367 lab=BLB17}
N 3360 41560 3340 41560 {}
C {lab_pin.sym} 3340 41560 0 0 {name=l33368 lab=WL208}
N 3440 41640 3460 41640 {}
C {lab_pin.sym} 3460 41640 0 0 {name=l33369 lab=VDD}
N 3440 41560 3460 41560 {}
C {lab_pin.sym} 3460 41560 0 0 {name=l33370 lab=VSS}
C {bitcell_6t.sym} 3600 41600 0 0 {name=Xr208c18}
N 3560 41640 3540 41640 {}
C {lab_pin.sym} 3540 41640 0 0 {name=l33371 lab=BL18}
N 3560 41600 3540 41600 {}
C {lab_pin.sym} 3540 41600 0 0 {name=l33372 lab=BLB18}
N 3560 41560 3540 41560 {}
C {lab_pin.sym} 3540 41560 0 0 {name=l33373 lab=WL208}
N 3640 41640 3660 41640 {}
C {lab_pin.sym} 3660 41640 0 0 {name=l33374 lab=VDD}
N 3640 41560 3660 41560 {}
C {lab_pin.sym} 3660 41560 0 0 {name=l33375 lab=VSS}
C {bitcell_6t.sym} 3800 41600 0 0 {name=Xr208c19}
N 3760 41640 3740 41640 {}
C {lab_pin.sym} 3740 41640 0 0 {name=l33376 lab=BL19}
N 3760 41600 3740 41600 {}
C {lab_pin.sym} 3740 41600 0 0 {name=l33377 lab=BLB19}
N 3760 41560 3740 41560 {}
C {lab_pin.sym} 3740 41560 0 0 {name=l33378 lab=WL208}
N 3840 41640 3860 41640 {}
C {lab_pin.sym} 3860 41640 0 0 {name=l33379 lab=VDD}
N 3840 41560 3860 41560 {}
C {lab_pin.sym} 3860 41560 0 0 {name=l33380 lab=VSS}
C {bitcell_6t.sym} 4000 41600 0 0 {name=Xr208c20}
N 3960 41640 3940 41640 {}
C {lab_pin.sym} 3940 41640 0 0 {name=l33381 lab=BL20}
N 3960 41600 3940 41600 {}
C {lab_pin.sym} 3940 41600 0 0 {name=l33382 lab=BLB20}
N 3960 41560 3940 41560 {}
C {lab_pin.sym} 3940 41560 0 0 {name=l33383 lab=WL208}
N 4040 41640 4060 41640 {}
C {lab_pin.sym} 4060 41640 0 0 {name=l33384 lab=VDD}
N 4040 41560 4060 41560 {}
C {lab_pin.sym} 4060 41560 0 0 {name=l33385 lab=VSS}
C {bitcell_6t.sym} 4200 41600 0 0 {name=Xr208c21}
N 4160 41640 4140 41640 {}
C {lab_pin.sym} 4140 41640 0 0 {name=l33386 lab=BL21}
N 4160 41600 4140 41600 {}
C {lab_pin.sym} 4140 41600 0 0 {name=l33387 lab=BLB21}
N 4160 41560 4140 41560 {}
C {lab_pin.sym} 4140 41560 0 0 {name=l33388 lab=WL208}
N 4240 41640 4260 41640 {}
C {lab_pin.sym} 4260 41640 0 0 {name=l33389 lab=VDD}
N 4240 41560 4260 41560 {}
C {lab_pin.sym} 4260 41560 0 0 {name=l33390 lab=VSS}
C {bitcell_6t.sym} 4400 41600 0 0 {name=Xr208c22}
N 4360 41640 4340 41640 {}
C {lab_pin.sym} 4340 41640 0 0 {name=l33391 lab=BL22}
N 4360 41600 4340 41600 {}
C {lab_pin.sym} 4340 41600 0 0 {name=l33392 lab=BLB22}
N 4360 41560 4340 41560 {}
C {lab_pin.sym} 4340 41560 0 0 {name=l33393 lab=WL208}
N 4440 41640 4460 41640 {}
C {lab_pin.sym} 4460 41640 0 0 {name=l33394 lab=VDD}
N 4440 41560 4460 41560 {}
C {lab_pin.sym} 4460 41560 0 0 {name=l33395 lab=VSS}
C {bitcell_6t.sym} 4600 41600 0 0 {name=Xr208c23}
N 4560 41640 4540 41640 {}
C {lab_pin.sym} 4540 41640 0 0 {name=l33396 lab=BL23}
N 4560 41600 4540 41600 {}
C {lab_pin.sym} 4540 41600 0 0 {name=l33397 lab=BLB23}
N 4560 41560 4540 41560 {}
C {lab_pin.sym} 4540 41560 0 0 {name=l33398 lab=WL208}
N 4640 41640 4660 41640 {}
C {lab_pin.sym} 4660 41640 0 0 {name=l33399 lab=VDD}
N 4640 41560 4660 41560 {}
C {lab_pin.sym} 4660 41560 0 0 {name=l33400 lab=VSS}
C {bitcell_6t.sym} 4800 41600 0 0 {name=Xr208c24}
N 4760 41640 4740 41640 {}
C {lab_pin.sym} 4740 41640 0 0 {name=l33401 lab=BL24}
N 4760 41600 4740 41600 {}
C {lab_pin.sym} 4740 41600 0 0 {name=l33402 lab=BLB24}
N 4760 41560 4740 41560 {}
C {lab_pin.sym} 4740 41560 0 0 {name=l33403 lab=WL208}
N 4840 41640 4860 41640 {}
C {lab_pin.sym} 4860 41640 0 0 {name=l33404 lab=VDD}
N 4840 41560 4860 41560 {}
C {lab_pin.sym} 4860 41560 0 0 {name=l33405 lab=VSS}
C {bitcell_6t.sym} 5000 41600 0 0 {name=Xr208c25}
N 4960 41640 4940 41640 {}
C {lab_pin.sym} 4940 41640 0 0 {name=l33406 lab=BL25}
N 4960 41600 4940 41600 {}
C {lab_pin.sym} 4940 41600 0 0 {name=l33407 lab=BLB25}
N 4960 41560 4940 41560 {}
C {lab_pin.sym} 4940 41560 0 0 {name=l33408 lab=WL208}
N 5040 41640 5060 41640 {}
C {lab_pin.sym} 5060 41640 0 0 {name=l33409 lab=VDD}
N 5040 41560 5060 41560 {}
C {lab_pin.sym} 5060 41560 0 0 {name=l33410 lab=VSS}
C {bitcell_6t.sym} 5200 41600 0 0 {name=Xr208c26}
N 5160 41640 5140 41640 {}
C {lab_pin.sym} 5140 41640 0 0 {name=l33411 lab=BL26}
N 5160 41600 5140 41600 {}
C {lab_pin.sym} 5140 41600 0 0 {name=l33412 lab=BLB26}
N 5160 41560 5140 41560 {}
C {lab_pin.sym} 5140 41560 0 0 {name=l33413 lab=WL208}
N 5240 41640 5260 41640 {}
C {lab_pin.sym} 5260 41640 0 0 {name=l33414 lab=VDD}
N 5240 41560 5260 41560 {}
C {lab_pin.sym} 5260 41560 0 0 {name=l33415 lab=VSS}
C {bitcell_6t.sym} 5400 41600 0 0 {name=Xr208c27}
N 5360 41640 5340 41640 {}
C {lab_pin.sym} 5340 41640 0 0 {name=l33416 lab=BL27}
N 5360 41600 5340 41600 {}
C {lab_pin.sym} 5340 41600 0 0 {name=l33417 lab=BLB27}
N 5360 41560 5340 41560 {}
C {lab_pin.sym} 5340 41560 0 0 {name=l33418 lab=WL208}
N 5440 41640 5460 41640 {}
C {lab_pin.sym} 5460 41640 0 0 {name=l33419 lab=VDD}
N 5440 41560 5460 41560 {}
C {lab_pin.sym} 5460 41560 0 0 {name=l33420 lab=VSS}
C {bitcell_6t.sym} 5600 41600 0 0 {name=Xr208c28}
N 5560 41640 5540 41640 {}
C {lab_pin.sym} 5540 41640 0 0 {name=l33421 lab=BL28}
N 5560 41600 5540 41600 {}
C {lab_pin.sym} 5540 41600 0 0 {name=l33422 lab=BLB28}
N 5560 41560 5540 41560 {}
C {lab_pin.sym} 5540 41560 0 0 {name=l33423 lab=WL208}
N 5640 41640 5660 41640 {}
C {lab_pin.sym} 5660 41640 0 0 {name=l33424 lab=VDD}
N 5640 41560 5660 41560 {}
C {lab_pin.sym} 5660 41560 0 0 {name=l33425 lab=VSS}
C {bitcell_6t.sym} 5800 41600 0 0 {name=Xr208c29}
N 5760 41640 5740 41640 {}
C {lab_pin.sym} 5740 41640 0 0 {name=l33426 lab=BL29}
N 5760 41600 5740 41600 {}
C {lab_pin.sym} 5740 41600 0 0 {name=l33427 lab=BLB29}
N 5760 41560 5740 41560 {}
C {lab_pin.sym} 5740 41560 0 0 {name=l33428 lab=WL208}
N 5840 41640 5860 41640 {}
C {lab_pin.sym} 5860 41640 0 0 {name=l33429 lab=VDD}
N 5840 41560 5860 41560 {}
C {lab_pin.sym} 5860 41560 0 0 {name=l33430 lab=VSS}
C {bitcell_6t.sym} 6000 41600 0 0 {name=Xr208c30}
N 5960 41640 5940 41640 {}
C {lab_pin.sym} 5940 41640 0 0 {name=l33431 lab=BL30}
N 5960 41600 5940 41600 {}
C {lab_pin.sym} 5940 41600 0 0 {name=l33432 lab=BLB30}
N 5960 41560 5940 41560 {}
C {lab_pin.sym} 5940 41560 0 0 {name=l33433 lab=WL208}
N 6040 41640 6060 41640 {}
C {lab_pin.sym} 6060 41640 0 0 {name=l33434 lab=VDD}
N 6040 41560 6060 41560 {}
C {lab_pin.sym} 6060 41560 0 0 {name=l33435 lab=VSS}
C {bitcell_6t.sym} 6200 41600 0 0 {name=Xr208c31}
N 6160 41640 6140 41640 {}
C {lab_pin.sym} 6140 41640 0 0 {name=l33436 lab=BL31}
N 6160 41600 6140 41600 {}
C {lab_pin.sym} 6140 41600 0 0 {name=l33437 lab=BLB31}
N 6160 41560 6140 41560 {}
C {lab_pin.sym} 6140 41560 0 0 {name=l33438 lab=WL208}
N 6240 41640 6260 41640 {}
C {lab_pin.sym} 6260 41640 0 0 {name=l33439 lab=VDD}
N 6240 41560 6260 41560 {}
C {lab_pin.sym} 6260 41560 0 0 {name=l33440 lab=VSS}
C {bitcell_6t.sym} 0 41800 0 0 {name=Xr209c0}
N -40 41840 -60 41840 {}
C {lab_pin.sym} -60 41840 0 0 {name=l33441 lab=BL0}
N -40 41800 -60 41800 {}
C {lab_pin.sym} -60 41800 0 0 {name=l33442 lab=BLB0}
N -40 41760 -60 41760 {}
C {lab_pin.sym} -60 41760 0 0 {name=l33443 lab=WL209}
N 40 41840 60 41840 {}
C {lab_pin.sym} 60 41840 0 0 {name=l33444 lab=VDD}
N 40 41760 60 41760 {}
C {lab_pin.sym} 60 41760 0 0 {name=l33445 lab=VSS}
C {bitcell_6t.sym} 200 41800 0 0 {name=Xr209c1}
N 160 41840 140 41840 {}
C {lab_pin.sym} 140 41840 0 0 {name=l33446 lab=BL1}
N 160 41800 140 41800 {}
C {lab_pin.sym} 140 41800 0 0 {name=l33447 lab=BLB1}
N 160 41760 140 41760 {}
C {lab_pin.sym} 140 41760 0 0 {name=l33448 lab=WL209}
N 240 41840 260 41840 {}
C {lab_pin.sym} 260 41840 0 0 {name=l33449 lab=VDD}
N 240 41760 260 41760 {}
C {lab_pin.sym} 260 41760 0 0 {name=l33450 lab=VSS}
C {bitcell_6t.sym} 400 41800 0 0 {name=Xr209c2}
N 360 41840 340 41840 {}
C {lab_pin.sym} 340 41840 0 0 {name=l33451 lab=BL2}
N 360 41800 340 41800 {}
C {lab_pin.sym} 340 41800 0 0 {name=l33452 lab=BLB2}
N 360 41760 340 41760 {}
C {lab_pin.sym} 340 41760 0 0 {name=l33453 lab=WL209}
N 440 41840 460 41840 {}
C {lab_pin.sym} 460 41840 0 0 {name=l33454 lab=VDD}
N 440 41760 460 41760 {}
C {lab_pin.sym} 460 41760 0 0 {name=l33455 lab=VSS}
C {bitcell_6t.sym} 600 41800 0 0 {name=Xr209c3}
N 560 41840 540 41840 {}
C {lab_pin.sym} 540 41840 0 0 {name=l33456 lab=BL3}
N 560 41800 540 41800 {}
C {lab_pin.sym} 540 41800 0 0 {name=l33457 lab=BLB3}
N 560 41760 540 41760 {}
C {lab_pin.sym} 540 41760 0 0 {name=l33458 lab=WL209}
N 640 41840 660 41840 {}
C {lab_pin.sym} 660 41840 0 0 {name=l33459 lab=VDD}
N 640 41760 660 41760 {}
C {lab_pin.sym} 660 41760 0 0 {name=l33460 lab=VSS}
C {bitcell_6t.sym} 800 41800 0 0 {name=Xr209c4}
N 760 41840 740 41840 {}
C {lab_pin.sym} 740 41840 0 0 {name=l33461 lab=BL4}
N 760 41800 740 41800 {}
C {lab_pin.sym} 740 41800 0 0 {name=l33462 lab=BLB4}
N 760 41760 740 41760 {}
C {lab_pin.sym} 740 41760 0 0 {name=l33463 lab=WL209}
N 840 41840 860 41840 {}
C {lab_pin.sym} 860 41840 0 0 {name=l33464 lab=VDD}
N 840 41760 860 41760 {}
C {lab_pin.sym} 860 41760 0 0 {name=l33465 lab=VSS}
C {bitcell_6t.sym} 1000 41800 0 0 {name=Xr209c5}
N 960 41840 940 41840 {}
C {lab_pin.sym} 940 41840 0 0 {name=l33466 lab=BL5}
N 960 41800 940 41800 {}
C {lab_pin.sym} 940 41800 0 0 {name=l33467 lab=BLB5}
N 960 41760 940 41760 {}
C {lab_pin.sym} 940 41760 0 0 {name=l33468 lab=WL209}
N 1040 41840 1060 41840 {}
C {lab_pin.sym} 1060 41840 0 0 {name=l33469 lab=VDD}
N 1040 41760 1060 41760 {}
C {lab_pin.sym} 1060 41760 0 0 {name=l33470 lab=VSS}
C {bitcell_6t.sym} 1200 41800 0 0 {name=Xr209c6}
N 1160 41840 1140 41840 {}
C {lab_pin.sym} 1140 41840 0 0 {name=l33471 lab=BL6}
N 1160 41800 1140 41800 {}
C {lab_pin.sym} 1140 41800 0 0 {name=l33472 lab=BLB6}
N 1160 41760 1140 41760 {}
C {lab_pin.sym} 1140 41760 0 0 {name=l33473 lab=WL209}
N 1240 41840 1260 41840 {}
C {lab_pin.sym} 1260 41840 0 0 {name=l33474 lab=VDD}
N 1240 41760 1260 41760 {}
C {lab_pin.sym} 1260 41760 0 0 {name=l33475 lab=VSS}
C {bitcell_6t.sym} 1400 41800 0 0 {name=Xr209c7}
N 1360 41840 1340 41840 {}
C {lab_pin.sym} 1340 41840 0 0 {name=l33476 lab=BL7}
N 1360 41800 1340 41800 {}
C {lab_pin.sym} 1340 41800 0 0 {name=l33477 lab=BLB7}
N 1360 41760 1340 41760 {}
C {lab_pin.sym} 1340 41760 0 0 {name=l33478 lab=WL209}
N 1440 41840 1460 41840 {}
C {lab_pin.sym} 1460 41840 0 0 {name=l33479 lab=VDD}
N 1440 41760 1460 41760 {}
C {lab_pin.sym} 1460 41760 0 0 {name=l33480 lab=VSS}
C {bitcell_6t.sym} 1600 41800 0 0 {name=Xr209c8}
N 1560 41840 1540 41840 {}
C {lab_pin.sym} 1540 41840 0 0 {name=l33481 lab=BL8}
N 1560 41800 1540 41800 {}
C {lab_pin.sym} 1540 41800 0 0 {name=l33482 lab=BLB8}
N 1560 41760 1540 41760 {}
C {lab_pin.sym} 1540 41760 0 0 {name=l33483 lab=WL209}
N 1640 41840 1660 41840 {}
C {lab_pin.sym} 1660 41840 0 0 {name=l33484 lab=VDD}
N 1640 41760 1660 41760 {}
C {lab_pin.sym} 1660 41760 0 0 {name=l33485 lab=VSS}
C {bitcell_6t.sym} 1800 41800 0 0 {name=Xr209c9}
N 1760 41840 1740 41840 {}
C {lab_pin.sym} 1740 41840 0 0 {name=l33486 lab=BL9}
N 1760 41800 1740 41800 {}
C {lab_pin.sym} 1740 41800 0 0 {name=l33487 lab=BLB9}
N 1760 41760 1740 41760 {}
C {lab_pin.sym} 1740 41760 0 0 {name=l33488 lab=WL209}
N 1840 41840 1860 41840 {}
C {lab_pin.sym} 1860 41840 0 0 {name=l33489 lab=VDD}
N 1840 41760 1860 41760 {}
C {lab_pin.sym} 1860 41760 0 0 {name=l33490 lab=VSS}
C {bitcell_6t.sym} 2000 41800 0 0 {name=Xr209c10}
N 1960 41840 1940 41840 {}
C {lab_pin.sym} 1940 41840 0 0 {name=l33491 lab=BL10}
N 1960 41800 1940 41800 {}
C {lab_pin.sym} 1940 41800 0 0 {name=l33492 lab=BLB10}
N 1960 41760 1940 41760 {}
C {lab_pin.sym} 1940 41760 0 0 {name=l33493 lab=WL209}
N 2040 41840 2060 41840 {}
C {lab_pin.sym} 2060 41840 0 0 {name=l33494 lab=VDD}
N 2040 41760 2060 41760 {}
C {lab_pin.sym} 2060 41760 0 0 {name=l33495 lab=VSS}
C {bitcell_6t.sym} 2200 41800 0 0 {name=Xr209c11}
N 2160 41840 2140 41840 {}
C {lab_pin.sym} 2140 41840 0 0 {name=l33496 lab=BL11}
N 2160 41800 2140 41800 {}
C {lab_pin.sym} 2140 41800 0 0 {name=l33497 lab=BLB11}
N 2160 41760 2140 41760 {}
C {lab_pin.sym} 2140 41760 0 0 {name=l33498 lab=WL209}
N 2240 41840 2260 41840 {}
C {lab_pin.sym} 2260 41840 0 0 {name=l33499 lab=VDD}
N 2240 41760 2260 41760 {}
C {lab_pin.sym} 2260 41760 0 0 {name=l33500 lab=VSS}
C {bitcell_6t.sym} 2400 41800 0 0 {name=Xr209c12}
N 2360 41840 2340 41840 {}
C {lab_pin.sym} 2340 41840 0 0 {name=l33501 lab=BL12}
N 2360 41800 2340 41800 {}
C {lab_pin.sym} 2340 41800 0 0 {name=l33502 lab=BLB12}
N 2360 41760 2340 41760 {}
C {lab_pin.sym} 2340 41760 0 0 {name=l33503 lab=WL209}
N 2440 41840 2460 41840 {}
C {lab_pin.sym} 2460 41840 0 0 {name=l33504 lab=VDD}
N 2440 41760 2460 41760 {}
C {lab_pin.sym} 2460 41760 0 0 {name=l33505 lab=VSS}
C {bitcell_6t.sym} 2600 41800 0 0 {name=Xr209c13}
N 2560 41840 2540 41840 {}
C {lab_pin.sym} 2540 41840 0 0 {name=l33506 lab=BL13}
N 2560 41800 2540 41800 {}
C {lab_pin.sym} 2540 41800 0 0 {name=l33507 lab=BLB13}
N 2560 41760 2540 41760 {}
C {lab_pin.sym} 2540 41760 0 0 {name=l33508 lab=WL209}
N 2640 41840 2660 41840 {}
C {lab_pin.sym} 2660 41840 0 0 {name=l33509 lab=VDD}
N 2640 41760 2660 41760 {}
C {lab_pin.sym} 2660 41760 0 0 {name=l33510 lab=VSS}
C {bitcell_6t.sym} 2800 41800 0 0 {name=Xr209c14}
N 2760 41840 2740 41840 {}
C {lab_pin.sym} 2740 41840 0 0 {name=l33511 lab=BL14}
N 2760 41800 2740 41800 {}
C {lab_pin.sym} 2740 41800 0 0 {name=l33512 lab=BLB14}
N 2760 41760 2740 41760 {}
C {lab_pin.sym} 2740 41760 0 0 {name=l33513 lab=WL209}
N 2840 41840 2860 41840 {}
C {lab_pin.sym} 2860 41840 0 0 {name=l33514 lab=VDD}
N 2840 41760 2860 41760 {}
C {lab_pin.sym} 2860 41760 0 0 {name=l33515 lab=VSS}
C {bitcell_6t.sym} 3000 41800 0 0 {name=Xr209c15}
N 2960 41840 2940 41840 {}
C {lab_pin.sym} 2940 41840 0 0 {name=l33516 lab=BL15}
N 2960 41800 2940 41800 {}
C {lab_pin.sym} 2940 41800 0 0 {name=l33517 lab=BLB15}
N 2960 41760 2940 41760 {}
C {lab_pin.sym} 2940 41760 0 0 {name=l33518 lab=WL209}
N 3040 41840 3060 41840 {}
C {lab_pin.sym} 3060 41840 0 0 {name=l33519 lab=VDD}
N 3040 41760 3060 41760 {}
C {lab_pin.sym} 3060 41760 0 0 {name=l33520 lab=VSS}
C {bitcell_6t.sym} 3200 41800 0 0 {name=Xr209c16}
N 3160 41840 3140 41840 {}
C {lab_pin.sym} 3140 41840 0 0 {name=l33521 lab=BL16}
N 3160 41800 3140 41800 {}
C {lab_pin.sym} 3140 41800 0 0 {name=l33522 lab=BLB16}
N 3160 41760 3140 41760 {}
C {lab_pin.sym} 3140 41760 0 0 {name=l33523 lab=WL209}
N 3240 41840 3260 41840 {}
C {lab_pin.sym} 3260 41840 0 0 {name=l33524 lab=VDD}
N 3240 41760 3260 41760 {}
C {lab_pin.sym} 3260 41760 0 0 {name=l33525 lab=VSS}
C {bitcell_6t.sym} 3400 41800 0 0 {name=Xr209c17}
N 3360 41840 3340 41840 {}
C {lab_pin.sym} 3340 41840 0 0 {name=l33526 lab=BL17}
N 3360 41800 3340 41800 {}
C {lab_pin.sym} 3340 41800 0 0 {name=l33527 lab=BLB17}
N 3360 41760 3340 41760 {}
C {lab_pin.sym} 3340 41760 0 0 {name=l33528 lab=WL209}
N 3440 41840 3460 41840 {}
C {lab_pin.sym} 3460 41840 0 0 {name=l33529 lab=VDD}
N 3440 41760 3460 41760 {}
C {lab_pin.sym} 3460 41760 0 0 {name=l33530 lab=VSS}
C {bitcell_6t.sym} 3600 41800 0 0 {name=Xr209c18}
N 3560 41840 3540 41840 {}
C {lab_pin.sym} 3540 41840 0 0 {name=l33531 lab=BL18}
N 3560 41800 3540 41800 {}
C {lab_pin.sym} 3540 41800 0 0 {name=l33532 lab=BLB18}
N 3560 41760 3540 41760 {}
C {lab_pin.sym} 3540 41760 0 0 {name=l33533 lab=WL209}
N 3640 41840 3660 41840 {}
C {lab_pin.sym} 3660 41840 0 0 {name=l33534 lab=VDD}
N 3640 41760 3660 41760 {}
C {lab_pin.sym} 3660 41760 0 0 {name=l33535 lab=VSS}
C {bitcell_6t.sym} 3800 41800 0 0 {name=Xr209c19}
N 3760 41840 3740 41840 {}
C {lab_pin.sym} 3740 41840 0 0 {name=l33536 lab=BL19}
N 3760 41800 3740 41800 {}
C {lab_pin.sym} 3740 41800 0 0 {name=l33537 lab=BLB19}
N 3760 41760 3740 41760 {}
C {lab_pin.sym} 3740 41760 0 0 {name=l33538 lab=WL209}
N 3840 41840 3860 41840 {}
C {lab_pin.sym} 3860 41840 0 0 {name=l33539 lab=VDD}
N 3840 41760 3860 41760 {}
C {lab_pin.sym} 3860 41760 0 0 {name=l33540 lab=VSS}
C {bitcell_6t.sym} 4000 41800 0 0 {name=Xr209c20}
N 3960 41840 3940 41840 {}
C {lab_pin.sym} 3940 41840 0 0 {name=l33541 lab=BL20}
N 3960 41800 3940 41800 {}
C {lab_pin.sym} 3940 41800 0 0 {name=l33542 lab=BLB20}
N 3960 41760 3940 41760 {}
C {lab_pin.sym} 3940 41760 0 0 {name=l33543 lab=WL209}
N 4040 41840 4060 41840 {}
C {lab_pin.sym} 4060 41840 0 0 {name=l33544 lab=VDD}
N 4040 41760 4060 41760 {}
C {lab_pin.sym} 4060 41760 0 0 {name=l33545 lab=VSS}
C {bitcell_6t.sym} 4200 41800 0 0 {name=Xr209c21}
N 4160 41840 4140 41840 {}
C {lab_pin.sym} 4140 41840 0 0 {name=l33546 lab=BL21}
N 4160 41800 4140 41800 {}
C {lab_pin.sym} 4140 41800 0 0 {name=l33547 lab=BLB21}
N 4160 41760 4140 41760 {}
C {lab_pin.sym} 4140 41760 0 0 {name=l33548 lab=WL209}
N 4240 41840 4260 41840 {}
C {lab_pin.sym} 4260 41840 0 0 {name=l33549 lab=VDD}
N 4240 41760 4260 41760 {}
C {lab_pin.sym} 4260 41760 0 0 {name=l33550 lab=VSS}
C {bitcell_6t.sym} 4400 41800 0 0 {name=Xr209c22}
N 4360 41840 4340 41840 {}
C {lab_pin.sym} 4340 41840 0 0 {name=l33551 lab=BL22}
N 4360 41800 4340 41800 {}
C {lab_pin.sym} 4340 41800 0 0 {name=l33552 lab=BLB22}
N 4360 41760 4340 41760 {}
C {lab_pin.sym} 4340 41760 0 0 {name=l33553 lab=WL209}
N 4440 41840 4460 41840 {}
C {lab_pin.sym} 4460 41840 0 0 {name=l33554 lab=VDD}
N 4440 41760 4460 41760 {}
C {lab_pin.sym} 4460 41760 0 0 {name=l33555 lab=VSS}
C {bitcell_6t.sym} 4600 41800 0 0 {name=Xr209c23}
N 4560 41840 4540 41840 {}
C {lab_pin.sym} 4540 41840 0 0 {name=l33556 lab=BL23}
N 4560 41800 4540 41800 {}
C {lab_pin.sym} 4540 41800 0 0 {name=l33557 lab=BLB23}
N 4560 41760 4540 41760 {}
C {lab_pin.sym} 4540 41760 0 0 {name=l33558 lab=WL209}
N 4640 41840 4660 41840 {}
C {lab_pin.sym} 4660 41840 0 0 {name=l33559 lab=VDD}
N 4640 41760 4660 41760 {}
C {lab_pin.sym} 4660 41760 0 0 {name=l33560 lab=VSS}
C {bitcell_6t.sym} 4800 41800 0 0 {name=Xr209c24}
N 4760 41840 4740 41840 {}
C {lab_pin.sym} 4740 41840 0 0 {name=l33561 lab=BL24}
N 4760 41800 4740 41800 {}
C {lab_pin.sym} 4740 41800 0 0 {name=l33562 lab=BLB24}
N 4760 41760 4740 41760 {}
C {lab_pin.sym} 4740 41760 0 0 {name=l33563 lab=WL209}
N 4840 41840 4860 41840 {}
C {lab_pin.sym} 4860 41840 0 0 {name=l33564 lab=VDD}
N 4840 41760 4860 41760 {}
C {lab_pin.sym} 4860 41760 0 0 {name=l33565 lab=VSS}
C {bitcell_6t.sym} 5000 41800 0 0 {name=Xr209c25}
N 4960 41840 4940 41840 {}
C {lab_pin.sym} 4940 41840 0 0 {name=l33566 lab=BL25}
N 4960 41800 4940 41800 {}
C {lab_pin.sym} 4940 41800 0 0 {name=l33567 lab=BLB25}
N 4960 41760 4940 41760 {}
C {lab_pin.sym} 4940 41760 0 0 {name=l33568 lab=WL209}
N 5040 41840 5060 41840 {}
C {lab_pin.sym} 5060 41840 0 0 {name=l33569 lab=VDD}
N 5040 41760 5060 41760 {}
C {lab_pin.sym} 5060 41760 0 0 {name=l33570 lab=VSS}
C {bitcell_6t.sym} 5200 41800 0 0 {name=Xr209c26}
N 5160 41840 5140 41840 {}
C {lab_pin.sym} 5140 41840 0 0 {name=l33571 lab=BL26}
N 5160 41800 5140 41800 {}
C {lab_pin.sym} 5140 41800 0 0 {name=l33572 lab=BLB26}
N 5160 41760 5140 41760 {}
C {lab_pin.sym} 5140 41760 0 0 {name=l33573 lab=WL209}
N 5240 41840 5260 41840 {}
C {lab_pin.sym} 5260 41840 0 0 {name=l33574 lab=VDD}
N 5240 41760 5260 41760 {}
C {lab_pin.sym} 5260 41760 0 0 {name=l33575 lab=VSS}
C {bitcell_6t.sym} 5400 41800 0 0 {name=Xr209c27}
N 5360 41840 5340 41840 {}
C {lab_pin.sym} 5340 41840 0 0 {name=l33576 lab=BL27}
N 5360 41800 5340 41800 {}
C {lab_pin.sym} 5340 41800 0 0 {name=l33577 lab=BLB27}
N 5360 41760 5340 41760 {}
C {lab_pin.sym} 5340 41760 0 0 {name=l33578 lab=WL209}
N 5440 41840 5460 41840 {}
C {lab_pin.sym} 5460 41840 0 0 {name=l33579 lab=VDD}
N 5440 41760 5460 41760 {}
C {lab_pin.sym} 5460 41760 0 0 {name=l33580 lab=VSS}
C {bitcell_6t.sym} 5600 41800 0 0 {name=Xr209c28}
N 5560 41840 5540 41840 {}
C {lab_pin.sym} 5540 41840 0 0 {name=l33581 lab=BL28}
N 5560 41800 5540 41800 {}
C {lab_pin.sym} 5540 41800 0 0 {name=l33582 lab=BLB28}
N 5560 41760 5540 41760 {}
C {lab_pin.sym} 5540 41760 0 0 {name=l33583 lab=WL209}
N 5640 41840 5660 41840 {}
C {lab_pin.sym} 5660 41840 0 0 {name=l33584 lab=VDD}
N 5640 41760 5660 41760 {}
C {lab_pin.sym} 5660 41760 0 0 {name=l33585 lab=VSS}
C {bitcell_6t.sym} 5800 41800 0 0 {name=Xr209c29}
N 5760 41840 5740 41840 {}
C {lab_pin.sym} 5740 41840 0 0 {name=l33586 lab=BL29}
N 5760 41800 5740 41800 {}
C {lab_pin.sym} 5740 41800 0 0 {name=l33587 lab=BLB29}
N 5760 41760 5740 41760 {}
C {lab_pin.sym} 5740 41760 0 0 {name=l33588 lab=WL209}
N 5840 41840 5860 41840 {}
C {lab_pin.sym} 5860 41840 0 0 {name=l33589 lab=VDD}
N 5840 41760 5860 41760 {}
C {lab_pin.sym} 5860 41760 0 0 {name=l33590 lab=VSS}
C {bitcell_6t.sym} 6000 41800 0 0 {name=Xr209c30}
N 5960 41840 5940 41840 {}
C {lab_pin.sym} 5940 41840 0 0 {name=l33591 lab=BL30}
N 5960 41800 5940 41800 {}
C {lab_pin.sym} 5940 41800 0 0 {name=l33592 lab=BLB30}
N 5960 41760 5940 41760 {}
C {lab_pin.sym} 5940 41760 0 0 {name=l33593 lab=WL209}
N 6040 41840 6060 41840 {}
C {lab_pin.sym} 6060 41840 0 0 {name=l33594 lab=VDD}
N 6040 41760 6060 41760 {}
C {lab_pin.sym} 6060 41760 0 0 {name=l33595 lab=VSS}
C {bitcell_6t.sym} 6200 41800 0 0 {name=Xr209c31}
N 6160 41840 6140 41840 {}
C {lab_pin.sym} 6140 41840 0 0 {name=l33596 lab=BL31}
N 6160 41800 6140 41800 {}
C {lab_pin.sym} 6140 41800 0 0 {name=l33597 lab=BLB31}
N 6160 41760 6140 41760 {}
C {lab_pin.sym} 6140 41760 0 0 {name=l33598 lab=WL209}
N 6240 41840 6260 41840 {}
C {lab_pin.sym} 6260 41840 0 0 {name=l33599 lab=VDD}
N 6240 41760 6260 41760 {}
C {lab_pin.sym} 6260 41760 0 0 {name=l33600 lab=VSS}
C {bitcell_6t.sym} 0 42000 0 0 {name=Xr210c0}
N -40 42040 -60 42040 {}
C {lab_pin.sym} -60 42040 0 0 {name=l33601 lab=BL0}
N -40 42000 -60 42000 {}
C {lab_pin.sym} -60 42000 0 0 {name=l33602 lab=BLB0}
N -40 41960 -60 41960 {}
C {lab_pin.sym} -60 41960 0 0 {name=l33603 lab=WL210}
N 40 42040 60 42040 {}
C {lab_pin.sym} 60 42040 0 0 {name=l33604 lab=VDD}
N 40 41960 60 41960 {}
C {lab_pin.sym} 60 41960 0 0 {name=l33605 lab=VSS}
C {bitcell_6t.sym} 200 42000 0 0 {name=Xr210c1}
N 160 42040 140 42040 {}
C {lab_pin.sym} 140 42040 0 0 {name=l33606 lab=BL1}
N 160 42000 140 42000 {}
C {lab_pin.sym} 140 42000 0 0 {name=l33607 lab=BLB1}
N 160 41960 140 41960 {}
C {lab_pin.sym} 140 41960 0 0 {name=l33608 lab=WL210}
N 240 42040 260 42040 {}
C {lab_pin.sym} 260 42040 0 0 {name=l33609 lab=VDD}
N 240 41960 260 41960 {}
C {lab_pin.sym} 260 41960 0 0 {name=l33610 lab=VSS}
C {bitcell_6t.sym} 400 42000 0 0 {name=Xr210c2}
N 360 42040 340 42040 {}
C {lab_pin.sym} 340 42040 0 0 {name=l33611 lab=BL2}
N 360 42000 340 42000 {}
C {lab_pin.sym} 340 42000 0 0 {name=l33612 lab=BLB2}
N 360 41960 340 41960 {}
C {lab_pin.sym} 340 41960 0 0 {name=l33613 lab=WL210}
N 440 42040 460 42040 {}
C {lab_pin.sym} 460 42040 0 0 {name=l33614 lab=VDD}
N 440 41960 460 41960 {}
C {lab_pin.sym} 460 41960 0 0 {name=l33615 lab=VSS}
C {bitcell_6t.sym} 600 42000 0 0 {name=Xr210c3}
N 560 42040 540 42040 {}
C {lab_pin.sym} 540 42040 0 0 {name=l33616 lab=BL3}
N 560 42000 540 42000 {}
C {lab_pin.sym} 540 42000 0 0 {name=l33617 lab=BLB3}
N 560 41960 540 41960 {}
C {lab_pin.sym} 540 41960 0 0 {name=l33618 lab=WL210}
N 640 42040 660 42040 {}
C {lab_pin.sym} 660 42040 0 0 {name=l33619 lab=VDD}
N 640 41960 660 41960 {}
C {lab_pin.sym} 660 41960 0 0 {name=l33620 lab=VSS}
C {bitcell_6t.sym} 800 42000 0 0 {name=Xr210c4}
N 760 42040 740 42040 {}
C {lab_pin.sym} 740 42040 0 0 {name=l33621 lab=BL4}
N 760 42000 740 42000 {}
C {lab_pin.sym} 740 42000 0 0 {name=l33622 lab=BLB4}
N 760 41960 740 41960 {}
C {lab_pin.sym} 740 41960 0 0 {name=l33623 lab=WL210}
N 840 42040 860 42040 {}
C {lab_pin.sym} 860 42040 0 0 {name=l33624 lab=VDD}
N 840 41960 860 41960 {}
C {lab_pin.sym} 860 41960 0 0 {name=l33625 lab=VSS}
C {bitcell_6t.sym} 1000 42000 0 0 {name=Xr210c5}
N 960 42040 940 42040 {}
C {lab_pin.sym} 940 42040 0 0 {name=l33626 lab=BL5}
N 960 42000 940 42000 {}
C {lab_pin.sym} 940 42000 0 0 {name=l33627 lab=BLB5}
N 960 41960 940 41960 {}
C {lab_pin.sym} 940 41960 0 0 {name=l33628 lab=WL210}
N 1040 42040 1060 42040 {}
C {lab_pin.sym} 1060 42040 0 0 {name=l33629 lab=VDD}
N 1040 41960 1060 41960 {}
C {lab_pin.sym} 1060 41960 0 0 {name=l33630 lab=VSS}
C {bitcell_6t.sym} 1200 42000 0 0 {name=Xr210c6}
N 1160 42040 1140 42040 {}
C {lab_pin.sym} 1140 42040 0 0 {name=l33631 lab=BL6}
N 1160 42000 1140 42000 {}
C {lab_pin.sym} 1140 42000 0 0 {name=l33632 lab=BLB6}
N 1160 41960 1140 41960 {}
C {lab_pin.sym} 1140 41960 0 0 {name=l33633 lab=WL210}
N 1240 42040 1260 42040 {}
C {lab_pin.sym} 1260 42040 0 0 {name=l33634 lab=VDD}
N 1240 41960 1260 41960 {}
C {lab_pin.sym} 1260 41960 0 0 {name=l33635 lab=VSS}
C {bitcell_6t.sym} 1400 42000 0 0 {name=Xr210c7}
N 1360 42040 1340 42040 {}
C {lab_pin.sym} 1340 42040 0 0 {name=l33636 lab=BL7}
N 1360 42000 1340 42000 {}
C {lab_pin.sym} 1340 42000 0 0 {name=l33637 lab=BLB7}
N 1360 41960 1340 41960 {}
C {lab_pin.sym} 1340 41960 0 0 {name=l33638 lab=WL210}
N 1440 42040 1460 42040 {}
C {lab_pin.sym} 1460 42040 0 0 {name=l33639 lab=VDD}
N 1440 41960 1460 41960 {}
C {lab_pin.sym} 1460 41960 0 0 {name=l33640 lab=VSS}
C {bitcell_6t.sym} 1600 42000 0 0 {name=Xr210c8}
N 1560 42040 1540 42040 {}
C {lab_pin.sym} 1540 42040 0 0 {name=l33641 lab=BL8}
N 1560 42000 1540 42000 {}
C {lab_pin.sym} 1540 42000 0 0 {name=l33642 lab=BLB8}
N 1560 41960 1540 41960 {}
C {lab_pin.sym} 1540 41960 0 0 {name=l33643 lab=WL210}
N 1640 42040 1660 42040 {}
C {lab_pin.sym} 1660 42040 0 0 {name=l33644 lab=VDD}
N 1640 41960 1660 41960 {}
C {lab_pin.sym} 1660 41960 0 0 {name=l33645 lab=VSS}
C {bitcell_6t.sym} 1800 42000 0 0 {name=Xr210c9}
N 1760 42040 1740 42040 {}
C {lab_pin.sym} 1740 42040 0 0 {name=l33646 lab=BL9}
N 1760 42000 1740 42000 {}
C {lab_pin.sym} 1740 42000 0 0 {name=l33647 lab=BLB9}
N 1760 41960 1740 41960 {}
C {lab_pin.sym} 1740 41960 0 0 {name=l33648 lab=WL210}
N 1840 42040 1860 42040 {}
C {lab_pin.sym} 1860 42040 0 0 {name=l33649 lab=VDD}
N 1840 41960 1860 41960 {}
C {lab_pin.sym} 1860 41960 0 0 {name=l33650 lab=VSS}
C {bitcell_6t.sym} 2000 42000 0 0 {name=Xr210c10}
N 1960 42040 1940 42040 {}
C {lab_pin.sym} 1940 42040 0 0 {name=l33651 lab=BL10}
N 1960 42000 1940 42000 {}
C {lab_pin.sym} 1940 42000 0 0 {name=l33652 lab=BLB10}
N 1960 41960 1940 41960 {}
C {lab_pin.sym} 1940 41960 0 0 {name=l33653 lab=WL210}
N 2040 42040 2060 42040 {}
C {lab_pin.sym} 2060 42040 0 0 {name=l33654 lab=VDD}
N 2040 41960 2060 41960 {}
C {lab_pin.sym} 2060 41960 0 0 {name=l33655 lab=VSS}
C {bitcell_6t.sym} 2200 42000 0 0 {name=Xr210c11}
N 2160 42040 2140 42040 {}
C {lab_pin.sym} 2140 42040 0 0 {name=l33656 lab=BL11}
N 2160 42000 2140 42000 {}
C {lab_pin.sym} 2140 42000 0 0 {name=l33657 lab=BLB11}
N 2160 41960 2140 41960 {}
C {lab_pin.sym} 2140 41960 0 0 {name=l33658 lab=WL210}
N 2240 42040 2260 42040 {}
C {lab_pin.sym} 2260 42040 0 0 {name=l33659 lab=VDD}
N 2240 41960 2260 41960 {}
C {lab_pin.sym} 2260 41960 0 0 {name=l33660 lab=VSS}
C {bitcell_6t.sym} 2400 42000 0 0 {name=Xr210c12}
N 2360 42040 2340 42040 {}
C {lab_pin.sym} 2340 42040 0 0 {name=l33661 lab=BL12}
N 2360 42000 2340 42000 {}
C {lab_pin.sym} 2340 42000 0 0 {name=l33662 lab=BLB12}
N 2360 41960 2340 41960 {}
C {lab_pin.sym} 2340 41960 0 0 {name=l33663 lab=WL210}
N 2440 42040 2460 42040 {}
C {lab_pin.sym} 2460 42040 0 0 {name=l33664 lab=VDD}
N 2440 41960 2460 41960 {}
C {lab_pin.sym} 2460 41960 0 0 {name=l33665 lab=VSS}
C {bitcell_6t.sym} 2600 42000 0 0 {name=Xr210c13}
N 2560 42040 2540 42040 {}
C {lab_pin.sym} 2540 42040 0 0 {name=l33666 lab=BL13}
N 2560 42000 2540 42000 {}
C {lab_pin.sym} 2540 42000 0 0 {name=l33667 lab=BLB13}
N 2560 41960 2540 41960 {}
C {lab_pin.sym} 2540 41960 0 0 {name=l33668 lab=WL210}
N 2640 42040 2660 42040 {}
C {lab_pin.sym} 2660 42040 0 0 {name=l33669 lab=VDD}
N 2640 41960 2660 41960 {}
C {lab_pin.sym} 2660 41960 0 0 {name=l33670 lab=VSS}
C {bitcell_6t.sym} 2800 42000 0 0 {name=Xr210c14}
N 2760 42040 2740 42040 {}
C {lab_pin.sym} 2740 42040 0 0 {name=l33671 lab=BL14}
N 2760 42000 2740 42000 {}
C {lab_pin.sym} 2740 42000 0 0 {name=l33672 lab=BLB14}
N 2760 41960 2740 41960 {}
C {lab_pin.sym} 2740 41960 0 0 {name=l33673 lab=WL210}
N 2840 42040 2860 42040 {}
C {lab_pin.sym} 2860 42040 0 0 {name=l33674 lab=VDD}
N 2840 41960 2860 41960 {}
C {lab_pin.sym} 2860 41960 0 0 {name=l33675 lab=VSS}
C {bitcell_6t.sym} 3000 42000 0 0 {name=Xr210c15}
N 2960 42040 2940 42040 {}
C {lab_pin.sym} 2940 42040 0 0 {name=l33676 lab=BL15}
N 2960 42000 2940 42000 {}
C {lab_pin.sym} 2940 42000 0 0 {name=l33677 lab=BLB15}
N 2960 41960 2940 41960 {}
C {lab_pin.sym} 2940 41960 0 0 {name=l33678 lab=WL210}
N 3040 42040 3060 42040 {}
C {lab_pin.sym} 3060 42040 0 0 {name=l33679 lab=VDD}
N 3040 41960 3060 41960 {}
C {lab_pin.sym} 3060 41960 0 0 {name=l33680 lab=VSS}
C {bitcell_6t.sym} 3200 42000 0 0 {name=Xr210c16}
N 3160 42040 3140 42040 {}
C {lab_pin.sym} 3140 42040 0 0 {name=l33681 lab=BL16}
N 3160 42000 3140 42000 {}
C {lab_pin.sym} 3140 42000 0 0 {name=l33682 lab=BLB16}
N 3160 41960 3140 41960 {}
C {lab_pin.sym} 3140 41960 0 0 {name=l33683 lab=WL210}
N 3240 42040 3260 42040 {}
C {lab_pin.sym} 3260 42040 0 0 {name=l33684 lab=VDD}
N 3240 41960 3260 41960 {}
C {lab_pin.sym} 3260 41960 0 0 {name=l33685 lab=VSS}
C {bitcell_6t.sym} 3400 42000 0 0 {name=Xr210c17}
N 3360 42040 3340 42040 {}
C {lab_pin.sym} 3340 42040 0 0 {name=l33686 lab=BL17}
N 3360 42000 3340 42000 {}
C {lab_pin.sym} 3340 42000 0 0 {name=l33687 lab=BLB17}
N 3360 41960 3340 41960 {}
C {lab_pin.sym} 3340 41960 0 0 {name=l33688 lab=WL210}
N 3440 42040 3460 42040 {}
C {lab_pin.sym} 3460 42040 0 0 {name=l33689 lab=VDD}
N 3440 41960 3460 41960 {}
C {lab_pin.sym} 3460 41960 0 0 {name=l33690 lab=VSS}
C {bitcell_6t.sym} 3600 42000 0 0 {name=Xr210c18}
N 3560 42040 3540 42040 {}
C {lab_pin.sym} 3540 42040 0 0 {name=l33691 lab=BL18}
N 3560 42000 3540 42000 {}
C {lab_pin.sym} 3540 42000 0 0 {name=l33692 lab=BLB18}
N 3560 41960 3540 41960 {}
C {lab_pin.sym} 3540 41960 0 0 {name=l33693 lab=WL210}
N 3640 42040 3660 42040 {}
C {lab_pin.sym} 3660 42040 0 0 {name=l33694 lab=VDD}
N 3640 41960 3660 41960 {}
C {lab_pin.sym} 3660 41960 0 0 {name=l33695 lab=VSS}
C {bitcell_6t.sym} 3800 42000 0 0 {name=Xr210c19}
N 3760 42040 3740 42040 {}
C {lab_pin.sym} 3740 42040 0 0 {name=l33696 lab=BL19}
N 3760 42000 3740 42000 {}
C {lab_pin.sym} 3740 42000 0 0 {name=l33697 lab=BLB19}
N 3760 41960 3740 41960 {}
C {lab_pin.sym} 3740 41960 0 0 {name=l33698 lab=WL210}
N 3840 42040 3860 42040 {}
C {lab_pin.sym} 3860 42040 0 0 {name=l33699 lab=VDD}
N 3840 41960 3860 41960 {}
C {lab_pin.sym} 3860 41960 0 0 {name=l33700 lab=VSS}
C {bitcell_6t.sym} 4000 42000 0 0 {name=Xr210c20}
N 3960 42040 3940 42040 {}
C {lab_pin.sym} 3940 42040 0 0 {name=l33701 lab=BL20}
N 3960 42000 3940 42000 {}
C {lab_pin.sym} 3940 42000 0 0 {name=l33702 lab=BLB20}
N 3960 41960 3940 41960 {}
C {lab_pin.sym} 3940 41960 0 0 {name=l33703 lab=WL210}
N 4040 42040 4060 42040 {}
C {lab_pin.sym} 4060 42040 0 0 {name=l33704 lab=VDD}
N 4040 41960 4060 41960 {}
C {lab_pin.sym} 4060 41960 0 0 {name=l33705 lab=VSS}
C {bitcell_6t.sym} 4200 42000 0 0 {name=Xr210c21}
N 4160 42040 4140 42040 {}
C {lab_pin.sym} 4140 42040 0 0 {name=l33706 lab=BL21}
N 4160 42000 4140 42000 {}
C {lab_pin.sym} 4140 42000 0 0 {name=l33707 lab=BLB21}
N 4160 41960 4140 41960 {}
C {lab_pin.sym} 4140 41960 0 0 {name=l33708 lab=WL210}
N 4240 42040 4260 42040 {}
C {lab_pin.sym} 4260 42040 0 0 {name=l33709 lab=VDD}
N 4240 41960 4260 41960 {}
C {lab_pin.sym} 4260 41960 0 0 {name=l33710 lab=VSS}
C {bitcell_6t.sym} 4400 42000 0 0 {name=Xr210c22}
N 4360 42040 4340 42040 {}
C {lab_pin.sym} 4340 42040 0 0 {name=l33711 lab=BL22}
N 4360 42000 4340 42000 {}
C {lab_pin.sym} 4340 42000 0 0 {name=l33712 lab=BLB22}
N 4360 41960 4340 41960 {}
C {lab_pin.sym} 4340 41960 0 0 {name=l33713 lab=WL210}
N 4440 42040 4460 42040 {}
C {lab_pin.sym} 4460 42040 0 0 {name=l33714 lab=VDD}
N 4440 41960 4460 41960 {}
C {lab_pin.sym} 4460 41960 0 0 {name=l33715 lab=VSS}
C {bitcell_6t.sym} 4600 42000 0 0 {name=Xr210c23}
N 4560 42040 4540 42040 {}
C {lab_pin.sym} 4540 42040 0 0 {name=l33716 lab=BL23}
N 4560 42000 4540 42000 {}
C {lab_pin.sym} 4540 42000 0 0 {name=l33717 lab=BLB23}
N 4560 41960 4540 41960 {}
C {lab_pin.sym} 4540 41960 0 0 {name=l33718 lab=WL210}
N 4640 42040 4660 42040 {}
C {lab_pin.sym} 4660 42040 0 0 {name=l33719 lab=VDD}
N 4640 41960 4660 41960 {}
C {lab_pin.sym} 4660 41960 0 0 {name=l33720 lab=VSS}
C {bitcell_6t.sym} 4800 42000 0 0 {name=Xr210c24}
N 4760 42040 4740 42040 {}
C {lab_pin.sym} 4740 42040 0 0 {name=l33721 lab=BL24}
N 4760 42000 4740 42000 {}
C {lab_pin.sym} 4740 42000 0 0 {name=l33722 lab=BLB24}
N 4760 41960 4740 41960 {}
C {lab_pin.sym} 4740 41960 0 0 {name=l33723 lab=WL210}
N 4840 42040 4860 42040 {}
C {lab_pin.sym} 4860 42040 0 0 {name=l33724 lab=VDD}
N 4840 41960 4860 41960 {}
C {lab_pin.sym} 4860 41960 0 0 {name=l33725 lab=VSS}
C {bitcell_6t.sym} 5000 42000 0 0 {name=Xr210c25}
N 4960 42040 4940 42040 {}
C {lab_pin.sym} 4940 42040 0 0 {name=l33726 lab=BL25}
N 4960 42000 4940 42000 {}
C {lab_pin.sym} 4940 42000 0 0 {name=l33727 lab=BLB25}
N 4960 41960 4940 41960 {}
C {lab_pin.sym} 4940 41960 0 0 {name=l33728 lab=WL210}
N 5040 42040 5060 42040 {}
C {lab_pin.sym} 5060 42040 0 0 {name=l33729 lab=VDD}
N 5040 41960 5060 41960 {}
C {lab_pin.sym} 5060 41960 0 0 {name=l33730 lab=VSS}
C {bitcell_6t.sym} 5200 42000 0 0 {name=Xr210c26}
N 5160 42040 5140 42040 {}
C {lab_pin.sym} 5140 42040 0 0 {name=l33731 lab=BL26}
N 5160 42000 5140 42000 {}
C {lab_pin.sym} 5140 42000 0 0 {name=l33732 lab=BLB26}
N 5160 41960 5140 41960 {}
C {lab_pin.sym} 5140 41960 0 0 {name=l33733 lab=WL210}
N 5240 42040 5260 42040 {}
C {lab_pin.sym} 5260 42040 0 0 {name=l33734 lab=VDD}
N 5240 41960 5260 41960 {}
C {lab_pin.sym} 5260 41960 0 0 {name=l33735 lab=VSS}
C {bitcell_6t.sym} 5400 42000 0 0 {name=Xr210c27}
N 5360 42040 5340 42040 {}
C {lab_pin.sym} 5340 42040 0 0 {name=l33736 lab=BL27}
N 5360 42000 5340 42000 {}
C {lab_pin.sym} 5340 42000 0 0 {name=l33737 lab=BLB27}
N 5360 41960 5340 41960 {}
C {lab_pin.sym} 5340 41960 0 0 {name=l33738 lab=WL210}
N 5440 42040 5460 42040 {}
C {lab_pin.sym} 5460 42040 0 0 {name=l33739 lab=VDD}
N 5440 41960 5460 41960 {}
C {lab_pin.sym} 5460 41960 0 0 {name=l33740 lab=VSS}
C {bitcell_6t.sym} 5600 42000 0 0 {name=Xr210c28}
N 5560 42040 5540 42040 {}
C {lab_pin.sym} 5540 42040 0 0 {name=l33741 lab=BL28}
N 5560 42000 5540 42000 {}
C {lab_pin.sym} 5540 42000 0 0 {name=l33742 lab=BLB28}
N 5560 41960 5540 41960 {}
C {lab_pin.sym} 5540 41960 0 0 {name=l33743 lab=WL210}
N 5640 42040 5660 42040 {}
C {lab_pin.sym} 5660 42040 0 0 {name=l33744 lab=VDD}
N 5640 41960 5660 41960 {}
C {lab_pin.sym} 5660 41960 0 0 {name=l33745 lab=VSS}
C {bitcell_6t.sym} 5800 42000 0 0 {name=Xr210c29}
N 5760 42040 5740 42040 {}
C {lab_pin.sym} 5740 42040 0 0 {name=l33746 lab=BL29}
N 5760 42000 5740 42000 {}
C {lab_pin.sym} 5740 42000 0 0 {name=l33747 lab=BLB29}
N 5760 41960 5740 41960 {}
C {lab_pin.sym} 5740 41960 0 0 {name=l33748 lab=WL210}
N 5840 42040 5860 42040 {}
C {lab_pin.sym} 5860 42040 0 0 {name=l33749 lab=VDD}
N 5840 41960 5860 41960 {}
C {lab_pin.sym} 5860 41960 0 0 {name=l33750 lab=VSS}
C {bitcell_6t.sym} 6000 42000 0 0 {name=Xr210c30}
N 5960 42040 5940 42040 {}
C {lab_pin.sym} 5940 42040 0 0 {name=l33751 lab=BL30}
N 5960 42000 5940 42000 {}
C {lab_pin.sym} 5940 42000 0 0 {name=l33752 lab=BLB30}
N 5960 41960 5940 41960 {}
C {lab_pin.sym} 5940 41960 0 0 {name=l33753 lab=WL210}
N 6040 42040 6060 42040 {}
C {lab_pin.sym} 6060 42040 0 0 {name=l33754 lab=VDD}
N 6040 41960 6060 41960 {}
C {lab_pin.sym} 6060 41960 0 0 {name=l33755 lab=VSS}
C {bitcell_6t.sym} 6200 42000 0 0 {name=Xr210c31}
N 6160 42040 6140 42040 {}
C {lab_pin.sym} 6140 42040 0 0 {name=l33756 lab=BL31}
N 6160 42000 6140 42000 {}
C {lab_pin.sym} 6140 42000 0 0 {name=l33757 lab=BLB31}
N 6160 41960 6140 41960 {}
C {lab_pin.sym} 6140 41960 0 0 {name=l33758 lab=WL210}
N 6240 42040 6260 42040 {}
C {lab_pin.sym} 6260 42040 0 0 {name=l33759 lab=VDD}
N 6240 41960 6260 41960 {}
C {lab_pin.sym} 6260 41960 0 0 {name=l33760 lab=VSS}
C {bitcell_6t.sym} 0 42200 0 0 {name=Xr211c0}
N -40 42240 -60 42240 {}
C {lab_pin.sym} -60 42240 0 0 {name=l33761 lab=BL0}
N -40 42200 -60 42200 {}
C {lab_pin.sym} -60 42200 0 0 {name=l33762 lab=BLB0}
N -40 42160 -60 42160 {}
C {lab_pin.sym} -60 42160 0 0 {name=l33763 lab=WL211}
N 40 42240 60 42240 {}
C {lab_pin.sym} 60 42240 0 0 {name=l33764 lab=VDD}
N 40 42160 60 42160 {}
C {lab_pin.sym} 60 42160 0 0 {name=l33765 lab=VSS}
C {bitcell_6t.sym} 200 42200 0 0 {name=Xr211c1}
N 160 42240 140 42240 {}
C {lab_pin.sym} 140 42240 0 0 {name=l33766 lab=BL1}
N 160 42200 140 42200 {}
C {lab_pin.sym} 140 42200 0 0 {name=l33767 lab=BLB1}
N 160 42160 140 42160 {}
C {lab_pin.sym} 140 42160 0 0 {name=l33768 lab=WL211}
N 240 42240 260 42240 {}
C {lab_pin.sym} 260 42240 0 0 {name=l33769 lab=VDD}
N 240 42160 260 42160 {}
C {lab_pin.sym} 260 42160 0 0 {name=l33770 lab=VSS}
C {bitcell_6t.sym} 400 42200 0 0 {name=Xr211c2}
N 360 42240 340 42240 {}
C {lab_pin.sym} 340 42240 0 0 {name=l33771 lab=BL2}
N 360 42200 340 42200 {}
C {lab_pin.sym} 340 42200 0 0 {name=l33772 lab=BLB2}
N 360 42160 340 42160 {}
C {lab_pin.sym} 340 42160 0 0 {name=l33773 lab=WL211}
N 440 42240 460 42240 {}
C {lab_pin.sym} 460 42240 0 0 {name=l33774 lab=VDD}
N 440 42160 460 42160 {}
C {lab_pin.sym} 460 42160 0 0 {name=l33775 lab=VSS}
C {bitcell_6t.sym} 600 42200 0 0 {name=Xr211c3}
N 560 42240 540 42240 {}
C {lab_pin.sym} 540 42240 0 0 {name=l33776 lab=BL3}
N 560 42200 540 42200 {}
C {lab_pin.sym} 540 42200 0 0 {name=l33777 lab=BLB3}
N 560 42160 540 42160 {}
C {lab_pin.sym} 540 42160 0 0 {name=l33778 lab=WL211}
N 640 42240 660 42240 {}
C {lab_pin.sym} 660 42240 0 0 {name=l33779 lab=VDD}
N 640 42160 660 42160 {}
C {lab_pin.sym} 660 42160 0 0 {name=l33780 lab=VSS}
C {bitcell_6t.sym} 800 42200 0 0 {name=Xr211c4}
N 760 42240 740 42240 {}
C {lab_pin.sym} 740 42240 0 0 {name=l33781 lab=BL4}
N 760 42200 740 42200 {}
C {lab_pin.sym} 740 42200 0 0 {name=l33782 lab=BLB4}
N 760 42160 740 42160 {}
C {lab_pin.sym} 740 42160 0 0 {name=l33783 lab=WL211}
N 840 42240 860 42240 {}
C {lab_pin.sym} 860 42240 0 0 {name=l33784 lab=VDD}
N 840 42160 860 42160 {}
C {lab_pin.sym} 860 42160 0 0 {name=l33785 lab=VSS}
C {bitcell_6t.sym} 1000 42200 0 0 {name=Xr211c5}
N 960 42240 940 42240 {}
C {lab_pin.sym} 940 42240 0 0 {name=l33786 lab=BL5}
N 960 42200 940 42200 {}
C {lab_pin.sym} 940 42200 0 0 {name=l33787 lab=BLB5}
N 960 42160 940 42160 {}
C {lab_pin.sym} 940 42160 0 0 {name=l33788 lab=WL211}
N 1040 42240 1060 42240 {}
C {lab_pin.sym} 1060 42240 0 0 {name=l33789 lab=VDD}
N 1040 42160 1060 42160 {}
C {lab_pin.sym} 1060 42160 0 0 {name=l33790 lab=VSS}
C {bitcell_6t.sym} 1200 42200 0 0 {name=Xr211c6}
N 1160 42240 1140 42240 {}
C {lab_pin.sym} 1140 42240 0 0 {name=l33791 lab=BL6}
N 1160 42200 1140 42200 {}
C {lab_pin.sym} 1140 42200 0 0 {name=l33792 lab=BLB6}
N 1160 42160 1140 42160 {}
C {lab_pin.sym} 1140 42160 0 0 {name=l33793 lab=WL211}
N 1240 42240 1260 42240 {}
C {lab_pin.sym} 1260 42240 0 0 {name=l33794 lab=VDD}
N 1240 42160 1260 42160 {}
C {lab_pin.sym} 1260 42160 0 0 {name=l33795 lab=VSS}
C {bitcell_6t.sym} 1400 42200 0 0 {name=Xr211c7}
N 1360 42240 1340 42240 {}
C {lab_pin.sym} 1340 42240 0 0 {name=l33796 lab=BL7}
N 1360 42200 1340 42200 {}
C {lab_pin.sym} 1340 42200 0 0 {name=l33797 lab=BLB7}
N 1360 42160 1340 42160 {}
C {lab_pin.sym} 1340 42160 0 0 {name=l33798 lab=WL211}
N 1440 42240 1460 42240 {}
C {lab_pin.sym} 1460 42240 0 0 {name=l33799 lab=VDD}
N 1440 42160 1460 42160 {}
C {lab_pin.sym} 1460 42160 0 0 {name=l33800 lab=VSS}
C {bitcell_6t.sym} 1600 42200 0 0 {name=Xr211c8}
N 1560 42240 1540 42240 {}
C {lab_pin.sym} 1540 42240 0 0 {name=l33801 lab=BL8}
N 1560 42200 1540 42200 {}
C {lab_pin.sym} 1540 42200 0 0 {name=l33802 lab=BLB8}
N 1560 42160 1540 42160 {}
C {lab_pin.sym} 1540 42160 0 0 {name=l33803 lab=WL211}
N 1640 42240 1660 42240 {}
C {lab_pin.sym} 1660 42240 0 0 {name=l33804 lab=VDD}
N 1640 42160 1660 42160 {}
C {lab_pin.sym} 1660 42160 0 0 {name=l33805 lab=VSS}
C {bitcell_6t.sym} 1800 42200 0 0 {name=Xr211c9}
N 1760 42240 1740 42240 {}
C {lab_pin.sym} 1740 42240 0 0 {name=l33806 lab=BL9}
N 1760 42200 1740 42200 {}
C {lab_pin.sym} 1740 42200 0 0 {name=l33807 lab=BLB9}
N 1760 42160 1740 42160 {}
C {lab_pin.sym} 1740 42160 0 0 {name=l33808 lab=WL211}
N 1840 42240 1860 42240 {}
C {lab_pin.sym} 1860 42240 0 0 {name=l33809 lab=VDD}
N 1840 42160 1860 42160 {}
C {lab_pin.sym} 1860 42160 0 0 {name=l33810 lab=VSS}
C {bitcell_6t.sym} 2000 42200 0 0 {name=Xr211c10}
N 1960 42240 1940 42240 {}
C {lab_pin.sym} 1940 42240 0 0 {name=l33811 lab=BL10}
N 1960 42200 1940 42200 {}
C {lab_pin.sym} 1940 42200 0 0 {name=l33812 lab=BLB10}
N 1960 42160 1940 42160 {}
C {lab_pin.sym} 1940 42160 0 0 {name=l33813 lab=WL211}
N 2040 42240 2060 42240 {}
C {lab_pin.sym} 2060 42240 0 0 {name=l33814 lab=VDD}
N 2040 42160 2060 42160 {}
C {lab_pin.sym} 2060 42160 0 0 {name=l33815 lab=VSS}
C {bitcell_6t.sym} 2200 42200 0 0 {name=Xr211c11}
N 2160 42240 2140 42240 {}
C {lab_pin.sym} 2140 42240 0 0 {name=l33816 lab=BL11}
N 2160 42200 2140 42200 {}
C {lab_pin.sym} 2140 42200 0 0 {name=l33817 lab=BLB11}
N 2160 42160 2140 42160 {}
C {lab_pin.sym} 2140 42160 0 0 {name=l33818 lab=WL211}
N 2240 42240 2260 42240 {}
C {lab_pin.sym} 2260 42240 0 0 {name=l33819 lab=VDD}
N 2240 42160 2260 42160 {}
C {lab_pin.sym} 2260 42160 0 0 {name=l33820 lab=VSS}
C {bitcell_6t.sym} 2400 42200 0 0 {name=Xr211c12}
N 2360 42240 2340 42240 {}
C {lab_pin.sym} 2340 42240 0 0 {name=l33821 lab=BL12}
N 2360 42200 2340 42200 {}
C {lab_pin.sym} 2340 42200 0 0 {name=l33822 lab=BLB12}
N 2360 42160 2340 42160 {}
C {lab_pin.sym} 2340 42160 0 0 {name=l33823 lab=WL211}
N 2440 42240 2460 42240 {}
C {lab_pin.sym} 2460 42240 0 0 {name=l33824 lab=VDD}
N 2440 42160 2460 42160 {}
C {lab_pin.sym} 2460 42160 0 0 {name=l33825 lab=VSS}
C {bitcell_6t.sym} 2600 42200 0 0 {name=Xr211c13}
N 2560 42240 2540 42240 {}
C {lab_pin.sym} 2540 42240 0 0 {name=l33826 lab=BL13}
N 2560 42200 2540 42200 {}
C {lab_pin.sym} 2540 42200 0 0 {name=l33827 lab=BLB13}
N 2560 42160 2540 42160 {}
C {lab_pin.sym} 2540 42160 0 0 {name=l33828 lab=WL211}
N 2640 42240 2660 42240 {}
C {lab_pin.sym} 2660 42240 0 0 {name=l33829 lab=VDD}
N 2640 42160 2660 42160 {}
C {lab_pin.sym} 2660 42160 0 0 {name=l33830 lab=VSS}
C {bitcell_6t.sym} 2800 42200 0 0 {name=Xr211c14}
N 2760 42240 2740 42240 {}
C {lab_pin.sym} 2740 42240 0 0 {name=l33831 lab=BL14}
N 2760 42200 2740 42200 {}
C {lab_pin.sym} 2740 42200 0 0 {name=l33832 lab=BLB14}
N 2760 42160 2740 42160 {}
C {lab_pin.sym} 2740 42160 0 0 {name=l33833 lab=WL211}
N 2840 42240 2860 42240 {}
C {lab_pin.sym} 2860 42240 0 0 {name=l33834 lab=VDD}
N 2840 42160 2860 42160 {}
C {lab_pin.sym} 2860 42160 0 0 {name=l33835 lab=VSS}
C {bitcell_6t.sym} 3000 42200 0 0 {name=Xr211c15}
N 2960 42240 2940 42240 {}
C {lab_pin.sym} 2940 42240 0 0 {name=l33836 lab=BL15}
N 2960 42200 2940 42200 {}
C {lab_pin.sym} 2940 42200 0 0 {name=l33837 lab=BLB15}
N 2960 42160 2940 42160 {}
C {lab_pin.sym} 2940 42160 0 0 {name=l33838 lab=WL211}
N 3040 42240 3060 42240 {}
C {lab_pin.sym} 3060 42240 0 0 {name=l33839 lab=VDD}
N 3040 42160 3060 42160 {}
C {lab_pin.sym} 3060 42160 0 0 {name=l33840 lab=VSS}
C {bitcell_6t.sym} 3200 42200 0 0 {name=Xr211c16}
N 3160 42240 3140 42240 {}
C {lab_pin.sym} 3140 42240 0 0 {name=l33841 lab=BL16}
N 3160 42200 3140 42200 {}
C {lab_pin.sym} 3140 42200 0 0 {name=l33842 lab=BLB16}
N 3160 42160 3140 42160 {}
C {lab_pin.sym} 3140 42160 0 0 {name=l33843 lab=WL211}
N 3240 42240 3260 42240 {}
C {lab_pin.sym} 3260 42240 0 0 {name=l33844 lab=VDD}
N 3240 42160 3260 42160 {}
C {lab_pin.sym} 3260 42160 0 0 {name=l33845 lab=VSS}
C {bitcell_6t.sym} 3400 42200 0 0 {name=Xr211c17}
N 3360 42240 3340 42240 {}
C {lab_pin.sym} 3340 42240 0 0 {name=l33846 lab=BL17}
N 3360 42200 3340 42200 {}
C {lab_pin.sym} 3340 42200 0 0 {name=l33847 lab=BLB17}
N 3360 42160 3340 42160 {}
C {lab_pin.sym} 3340 42160 0 0 {name=l33848 lab=WL211}
N 3440 42240 3460 42240 {}
C {lab_pin.sym} 3460 42240 0 0 {name=l33849 lab=VDD}
N 3440 42160 3460 42160 {}
C {lab_pin.sym} 3460 42160 0 0 {name=l33850 lab=VSS}
C {bitcell_6t.sym} 3600 42200 0 0 {name=Xr211c18}
N 3560 42240 3540 42240 {}
C {lab_pin.sym} 3540 42240 0 0 {name=l33851 lab=BL18}
N 3560 42200 3540 42200 {}
C {lab_pin.sym} 3540 42200 0 0 {name=l33852 lab=BLB18}
N 3560 42160 3540 42160 {}
C {lab_pin.sym} 3540 42160 0 0 {name=l33853 lab=WL211}
N 3640 42240 3660 42240 {}
C {lab_pin.sym} 3660 42240 0 0 {name=l33854 lab=VDD}
N 3640 42160 3660 42160 {}
C {lab_pin.sym} 3660 42160 0 0 {name=l33855 lab=VSS}
C {bitcell_6t.sym} 3800 42200 0 0 {name=Xr211c19}
N 3760 42240 3740 42240 {}
C {lab_pin.sym} 3740 42240 0 0 {name=l33856 lab=BL19}
N 3760 42200 3740 42200 {}
C {lab_pin.sym} 3740 42200 0 0 {name=l33857 lab=BLB19}
N 3760 42160 3740 42160 {}
C {lab_pin.sym} 3740 42160 0 0 {name=l33858 lab=WL211}
N 3840 42240 3860 42240 {}
C {lab_pin.sym} 3860 42240 0 0 {name=l33859 lab=VDD}
N 3840 42160 3860 42160 {}
C {lab_pin.sym} 3860 42160 0 0 {name=l33860 lab=VSS}
C {bitcell_6t.sym} 4000 42200 0 0 {name=Xr211c20}
N 3960 42240 3940 42240 {}
C {lab_pin.sym} 3940 42240 0 0 {name=l33861 lab=BL20}
N 3960 42200 3940 42200 {}
C {lab_pin.sym} 3940 42200 0 0 {name=l33862 lab=BLB20}
N 3960 42160 3940 42160 {}
C {lab_pin.sym} 3940 42160 0 0 {name=l33863 lab=WL211}
N 4040 42240 4060 42240 {}
C {lab_pin.sym} 4060 42240 0 0 {name=l33864 lab=VDD}
N 4040 42160 4060 42160 {}
C {lab_pin.sym} 4060 42160 0 0 {name=l33865 lab=VSS}
C {bitcell_6t.sym} 4200 42200 0 0 {name=Xr211c21}
N 4160 42240 4140 42240 {}
C {lab_pin.sym} 4140 42240 0 0 {name=l33866 lab=BL21}
N 4160 42200 4140 42200 {}
C {lab_pin.sym} 4140 42200 0 0 {name=l33867 lab=BLB21}
N 4160 42160 4140 42160 {}
C {lab_pin.sym} 4140 42160 0 0 {name=l33868 lab=WL211}
N 4240 42240 4260 42240 {}
C {lab_pin.sym} 4260 42240 0 0 {name=l33869 lab=VDD}
N 4240 42160 4260 42160 {}
C {lab_pin.sym} 4260 42160 0 0 {name=l33870 lab=VSS}
C {bitcell_6t.sym} 4400 42200 0 0 {name=Xr211c22}
N 4360 42240 4340 42240 {}
C {lab_pin.sym} 4340 42240 0 0 {name=l33871 lab=BL22}
N 4360 42200 4340 42200 {}
C {lab_pin.sym} 4340 42200 0 0 {name=l33872 lab=BLB22}
N 4360 42160 4340 42160 {}
C {lab_pin.sym} 4340 42160 0 0 {name=l33873 lab=WL211}
N 4440 42240 4460 42240 {}
C {lab_pin.sym} 4460 42240 0 0 {name=l33874 lab=VDD}
N 4440 42160 4460 42160 {}
C {lab_pin.sym} 4460 42160 0 0 {name=l33875 lab=VSS}
C {bitcell_6t.sym} 4600 42200 0 0 {name=Xr211c23}
N 4560 42240 4540 42240 {}
C {lab_pin.sym} 4540 42240 0 0 {name=l33876 lab=BL23}
N 4560 42200 4540 42200 {}
C {lab_pin.sym} 4540 42200 0 0 {name=l33877 lab=BLB23}
N 4560 42160 4540 42160 {}
C {lab_pin.sym} 4540 42160 0 0 {name=l33878 lab=WL211}
N 4640 42240 4660 42240 {}
C {lab_pin.sym} 4660 42240 0 0 {name=l33879 lab=VDD}
N 4640 42160 4660 42160 {}
C {lab_pin.sym} 4660 42160 0 0 {name=l33880 lab=VSS}
C {bitcell_6t.sym} 4800 42200 0 0 {name=Xr211c24}
N 4760 42240 4740 42240 {}
C {lab_pin.sym} 4740 42240 0 0 {name=l33881 lab=BL24}
N 4760 42200 4740 42200 {}
C {lab_pin.sym} 4740 42200 0 0 {name=l33882 lab=BLB24}
N 4760 42160 4740 42160 {}
C {lab_pin.sym} 4740 42160 0 0 {name=l33883 lab=WL211}
N 4840 42240 4860 42240 {}
C {lab_pin.sym} 4860 42240 0 0 {name=l33884 lab=VDD}
N 4840 42160 4860 42160 {}
C {lab_pin.sym} 4860 42160 0 0 {name=l33885 lab=VSS}
C {bitcell_6t.sym} 5000 42200 0 0 {name=Xr211c25}
N 4960 42240 4940 42240 {}
C {lab_pin.sym} 4940 42240 0 0 {name=l33886 lab=BL25}
N 4960 42200 4940 42200 {}
C {lab_pin.sym} 4940 42200 0 0 {name=l33887 lab=BLB25}
N 4960 42160 4940 42160 {}
C {lab_pin.sym} 4940 42160 0 0 {name=l33888 lab=WL211}
N 5040 42240 5060 42240 {}
C {lab_pin.sym} 5060 42240 0 0 {name=l33889 lab=VDD}
N 5040 42160 5060 42160 {}
C {lab_pin.sym} 5060 42160 0 0 {name=l33890 lab=VSS}
C {bitcell_6t.sym} 5200 42200 0 0 {name=Xr211c26}
N 5160 42240 5140 42240 {}
C {lab_pin.sym} 5140 42240 0 0 {name=l33891 lab=BL26}
N 5160 42200 5140 42200 {}
C {lab_pin.sym} 5140 42200 0 0 {name=l33892 lab=BLB26}
N 5160 42160 5140 42160 {}
C {lab_pin.sym} 5140 42160 0 0 {name=l33893 lab=WL211}
N 5240 42240 5260 42240 {}
C {lab_pin.sym} 5260 42240 0 0 {name=l33894 lab=VDD}
N 5240 42160 5260 42160 {}
C {lab_pin.sym} 5260 42160 0 0 {name=l33895 lab=VSS}
C {bitcell_6t.sym} 5400 42200 0 0 {name=Xr211c27}
N 5360 42240 5340 42240 {}
C {lab_pin.sym} 5340 42240 0 0 {name=l33896 lab=BL27}
N 5360 42200 5340 42200 {}
C {lab_pin.sym} 5340 42200 0 0 {name=l33897 lab=BLB27}
N 5360 42160 5340 42160 {}
C {lab_pin.sym} 5340 42160 0 0 {name=l33898 lab=WL211}
N 5440 42240 5460 42240 {}
C {lab_pin.sym} 5460 42240 0 0 {name=l33899 lab=VDD}
N 5440 42160 5460 42160 {}
C {lab_pin.sym} 5460 42160 0 0 {name=l33900 lab=VSS}
C {bitcell_6t.sym} 5600 42200 0 0 {name=Xr211c28}
N 5560 42240 5540 42240 {}
C {lab_pin.sym} 5540 42240 0 0 {name=l33901 lab=BL28}
N 5560 42200 5540 42200 {}
C {lab_pin.sym} 5540 42200 0 0 {name=l33902 lab=BLB28}
N 5560 42160 5540 42160 {}
C {lab_pin.sym} 5540 42160 0 0 {name=l33903 lab=WL211}
N 5640 42240 5660 42240 {}
C {lab_pin.sym} 5660 42240 0 0 {name=l33904 lab=VDD}
N 5640 42160 5660 42160 {}
C {lab_pin.sym} 5660 42160 0 0 {name=l33905 lab=VSS}
C {bitcell_6t.sym} 5800 42200 0 0 {name=Xr211c29}
N 5760 42240 5740 42240 {}
C {lab_pin.sym} 5740 42240 0 0 {name=l33906 lab=BL29}
N 5760 42200 5740 42200 {}
C {lab_pin.sym} 5740 42200 0 0 {name=l33907 lab=BLB29}
N 5760 42160 5740 42160 {}
C {lab_pin.sym} 5740 42160 0 0 {name=l33908 lab=WL211}
N 5840 42240 5860 42240 {}
C {lab_pin.sym} 5860 42240 0 0 {name=l33909 lab=VDD}
N 5840 42160 5860 42160 {}
C {lab_pin.sym} 5860 42160 0 0 {name=l33910 lab=VSS}
C {bitcell_6t.sym} 6000 42200 0 0 {name=Xr211c30}
N 5960 42240 5940 42240 {}
C {lab_pin.sym} 5940 42240 0 0 {name=l33911 lab=BL30}
N 5960 42200 5940 42200 {}
C {lab_pin.sym} 5940 42200 0 0 {name=l33912 lab=BLB30}
N 5960 42160 5940 42160 {}
C {lab_pin.sym} 5940 42160 0 0 {name=l33913 lab=WL211}
N 6040 42240 6060 42240 {}
C {lab_pin.sym} 6060 42240 0 0 {name=l33914 lab=VDD}
N 6040 42160 6060 42160 {}
C {lab_pin.sym} 6060 42160 0 0 {name=l33915 lab=VSS}
C {bitcell_6t.sym} 6200 42200 0 0 {name=Xr211c31}
N 6160 42240 6140 42240 {}
C {lab_pin.sym} 6140 42240 0 0 {name=l33916 lab=BL31}
N 6160 42200 6140 42200 {}
C {lab_pin.sym} 6140 42200 0 0 {name=l33917 lab=BLB31}
N 6160 42160 6140 42160 {}
C {lab_pin.sym} 6140 42160 0 0 {name=l33918 lab=WL211}
N 6240 42240 6260 42240 {}
C {lab_pin.sym} 6260 42240 0 0 {name=l33919 lab=VDD}
N 6240 42160 6260 42160 {}
C {lab_pin.sym} 6260 42160 0 0 {name=l33920 lab=VSS}
C {bitcell_6t.sym} 0 42400 0 0 {name=Xr212c0}
N -40 42440 -60 42440 {}
C {lab_pin.sym} -60 42440 0 0 {name=l33921 lab=BL0}
N -40 42400 -60 42400 {}
C {lab_pin.sym} -60 42400 0 0 {name=l33922 lab=BLB0}
N -40 42360 -60 42360 {}
C {lab_pin.sym} -60 42360 0 0 {name=l33923 lab=WL212}
N 40 42440 60 42440 {}
C {lab_pin.sym} 60 42440 0 0 {name=l33924 lab=VDD}
N 40 42360 60 42360 {}
C {lab_pin.sym} 60 42360 0 0 {name=l33925 lab=VSS}
C {bitcell_6t.sym} 200 42400 0 0 {name=Xr212c1}
N 160 42440 140 42440 {}
C {lab_pin.sym} 140 42440 0 0 {name=l33926 lab=BL1}
N 160 42400 140 42400 {}
C {lab_pin.sym} 140 42400 0 0 {name=l33927 lab=BLB1}
N 160 42360 140 42360 {}
C {lab_pin.sym} 140 42360 0 0 {name=l33928 lab=WL212}
N 240 42440 260 42440 {}
C {lab_pin.sym} 260 42440 0 0 {name=l33929 lab=VDD}
N 240 42360 260 42360 {}
C {lab_pin.sym} 260 42360 0 0 {name=l33930 lab=VSS}
C {bitcell_6t.sym} 400 42400 0 0 {name=Xr212c2}
N 360 42440 340 42440 {}
C {lab_pin.sym} 340 42440 0 0 {name=l33931 lab=BL2}
N 360 42400 340 42400 {}
C {lab_pin.sym} 340 42400 0 0 {name=l33932 lab=BLB2}
N 360 42360 340 42360 {}
C {lab_pin.sym} 340 42360 0 0 {name=l33933 lab=WL212}
N 440 42440 460 42440 {}
C {lab_pin.sym} 460 42440 0 0 {name=l33934 lab=VDD}
N 440 42360 460 42360 {}
C {lab_pin.sym} 460 42360 0 0 {name=l33935 lab=VSS}
C {bitcell_6t.sym} 600 42400 0 0 {name=Xr212c3}
N 560 42440 540 42440 {}
C {lab_pin.sym} 540 42440 0 0 {name=l33936 lab=BL3}
N 560 42400 540 42400 {}
C {lab_pin.sym} 540 42400 0 0 {name=l33937 lab=BLB3}
N 560 42360 540 42360 {}
C {lab_pin.sym} 540 42360 0 0 {name=l33938 lab=WL212}
N 640 42440 660 42440 {}
C {lab_pin.sym} 660 42440 0 0 {name=l33939 lab=VDD}
N 640 42360 660 42360 {}
C {lab_pin.sym} 660 42360 0 0 {name=l33940 lab=VSS}
C {bitcell_6t.sym} 800 42400 0 0 {name=Xr212c4}
N 760 42440 740 42440 {}
C {lab_pin.sym} 740 42440 0 0 {name=l33941 lab=BL4}
N 760 42400 740 42400 {}
C {lab_pin.sym} 740 42400 0 0 {name=l33942 lab=BLB4}
N 760 42360 740 42360 {}
C {lab_pin.sym} 740 42360 0 0 {name=l33943 lab=WL212}
N 840 42440 860 42440 {}
C {lab_pin.sym} 860 42440 0 0 {name=l33944 lab=VDD}
N 840 42360 860 42360 {}
C {lab_pin.sym} 860 42360 0 0 {name=l33945 lab=VSS}
C {bitcell_6t.sym} 1000 42400 0 0 {name=Xr212c5}
N 960 42440 940 42440 {}
C {lab_pin.sym} 940 42440 0 0 {name=l33946 lab=BL5}
N 960 42400 940 42400 {}
C {lab_pin.sym} 940 42400 0 0 {name=l33947 lab=BLB5}
N 960 42360 940 42360 {}
C {lab_pin.sym} 940 42360 0 0 {name=l33948 lab=WL212}
N 1040 42440 1060 42440 {}
C {lab_pin.sym} 1060 42440 0 0 {name=l33949 lab=VDD}
N 1040 42360 1060 42360 {}
C {lab_pin.sym} 1060 42360 0 0 {name=l33950 lab=VSS}
C {bitcell_6t.sym} 1200 42400 0 0 {name=Xr212c6}
N 1160 42440 1140 42440 {}
C {lab_pin.sym} 1140 42440 0 0 {name=l33951 lab=BL6}
N 1160 42400 1140 42400 {}
C {lab_pin.sym} 1140 42400 0 0 {name=l33952 lab=BLB6}
N 1160 42360 1140 42360 {}
C {lab_pin.sym} 1140 42360 0 0 {name=l33953 lab=WL212}
N 1240 42440 1260 42440 {}
C {lab_pin.sym} 1260 42440 0 0 {name=l33954 lab=VDD}
N 1240 42360 1260 42360 {}
C {lab_pin.sym} 1260 42360 0 0 {name=l33955 lab=VSS}
C {bitcell_6t.sym} 1400 42400 0 0 {name=Xr212c7}
N 1360 42440 1340 42440 {}
C {lab_pin.sym} 1340 42440 0 0 {name=l33956 lab=BL7}
N 1360 42400 1340 42400 {}
C {lab_pin.sym} 1340 42400 0 0 {name=l33957 lab=BLB7}
N 1360 42360 1340 42360 {}
C {lab_pin.sym} 1340 42360 0 0 {name=l33958 lab=WL212}
N 1440 42440 1460 42440 {}
C {lab_pin.sym} 1460 42440 0 0 {name=l33959 lab=VDD}
N 1440 42360 1460 42360 {}
C {lab_pin.sym} 1460 42360 0 0 {name=l33960 lab=VSS}
C {bitcell_6t.sym} 1600 42400 0 0 {name=Xr212c8}
N 1560 42440 1540 42440 {}
C {lab_pin.sym} 1540 42440 0 0 {name=l33961 lab=BL8}
N 1560 42400 1540 42400 {}
C {lab_pin.sym} 1540 42400 0 0 {name=l33962 lab=BLB8}
N 1560 42360 1540 42360 {}
C {lab_pin.sym} 1540 42360 0 0 {name=l33963 lab=WL212}
N 1640 42440 1660 42440 {}
C {lab_pin.sym} 1660 42440 0 0 {name=l33964 lab=VDD}
N 1640 42360 1660 42360 {}
C {lab_pin.sym} 1660 42360 0 0 {name=l33965 lab=VSS}
C {bitcell_6t.sym} 1800 42400 0 0 {name=Xr212c9}
N 1760 42440 1740 42440 {}
C {lab_pin.sym} 1740 42440 0 0 {name=l33966 lab=BL9}
N 1760 42400 1740 42400 {}
C {lab_pin.sym} 1740 42400 0 0 {name=l33967 lab=BLB9}
N 1760 42360 1740 42360 {}
C {lab_pin.sym} 1740 42360 0 0 {name=l33968 lab=WL212}
N 1840 42440 1860 42440 {}
C {lab_pin.sym} 1860 42440 0 0 {name=l33969 lab=VDD}
N 1840 42360 1860 42360 {}
C {lab_pin.sym} 1860 42360 0 0 {name=l33970 lab=VSS}
C {bitcell_6t.sym} 2000 42400 0 0 {name=Xr212c10}
N 1960 42440 1940 42440 {}
C {lab_pin.sym} 1940 42440 0 0 {name=l33971 lab=BL10}
N 1960 42400 1940 42400 {}
C {lab_pin.sym} 1940 42400 0 0 {name=l33972 lab=BLB10}
N 1960 42360 1940 42360 {}
C {lab_pin.sym} 1940 42360 0 0 {name=l33973 lab=WL212}
N 2040 42440 2060 42440 {}
C {lab_pin.sym} 2060 42440 0 0 {name=l33974 lab=VDD}
N 2040 42360 2060 42360 {}
C {lab_pin.sym} 2060 42360 0 0 {name=l33975 lab=VSS}
C {bitcell_6t.sym} 2200 42400 0 0 {name=Xr212c11}
N 2160 42440 2140 42440 {}
C {lab_pin.sym} 2140 42440 0 0 {name=l33976 lab=BL11}
N 2160 42400 2140 42400 {}
C {lab_pin.sym} 2140 42400 0 0 {name=l33977 lab=BLB11}
N 2160 42360 2140 42360 {}
C {lab_pin.sym} 2140 42360 0 0 {name=l33978 lab=WL212}
N 2240 42440 2260 42440 {}
C {lab_pin.sym} 2260 42440 0 0 {name=l33979 lab=VDD}
N 2240 42360 2260 42360 {}
C {lab_pin.sym} 2260 42360 0 0 {name=l33980 lab=VSS}
C {bitcell_6t.sym} 2400 42400 0 0 {name=Xr212c12}
N 2360 42440 2340 42440 {}
C {lab_pin.sym} 2340 42440 0 0 {name=l33981 lab=BL12}
N 2360 42400 2340 42400 {}
C {lab_pin.sym} 2340 42400 0 0 {name=l33982 lab=BLB12}
N 2360 42360 2340 42360 {}
C {lab_pin.sym} 2340 42360 0 0 {name=l33983 lab=WL212}
N 2440 42440 2460 42440 {}
C {lab_pin.sym} 2460 42440 0 0 {name=l33984 lab=VDD}
N 2440 42360 2460 42360 {}
C {lab_pin.sym} 2460 42360 0 0 {name=l33985 lab=VSS}
C {bitcell_6t.sym} 2600 42400 0 0 {name=Xr212c13}
N 2560 42440 2540 42440 {}
C {lab_pin.sym} 2540 42440 0 0 {name=l33986 lab=BL13}
N 2560 42400 2540 42400 {}
C {lab_pin.sym} 2540 42400 0 0 {name=l33987 lab=BLB13}
N 2560 42360 2540 42360 {}
C {lab_pin.sym} 2540 42360 0 0 {name=l33988 lab=WL212}
N 2640 42440 2660 42440 {}
C {lab_pin.sym} 2660 42440 0 0 {name=l33989 lab=VDD}
N 2640 42360 2660 42360 {}
C {lab_pin.sym} 2660 42360 0 0 {name=l33990 lab=VSS}
C {bitcell_6t.sym} 2800 42400 0 0 {name=Xr212c14}
N 2760 42440 2740 42440 {}
C {lab_pin.sym} 2740 42440 0 0 {name=l33991 lab=BL14}
N 2760 42400 2740 42400 {}
C {lab_pin.sym} 2740 42400 0 0 {name=l33992 lab=BLB14}
N 2760 42360 2740 42360 {}
C {lab_pin.sym} 2740 42360 0 0 {name=l33993 lab=WL212}
N 2840 42440 2860 42440 {}
C {lab_pin.sym} 2860 42440 0 0 {name=l33994 lab=VDD}
N 2840 42360 2860 42360 {}
C {lab_pin.sym} 2860 42360 0 0 {name=l33995 lab=VSS}
C {bitcell_6t.sym} 3000 42400 0 0 {name=Xr212c15}
N 2960 42440 2940 42440 {}
C {lab_pin.sym} 2940 42440 0 0 {name=l33996 lab=BL15}
N 2960 42400 2940 42400 {}
C {lab_pin.sym} 2940 42400 0 0 {name=l33997 lab=BLB15}
N 2960 42360 2940 42360 {}
C {lab_pin.sym} 2940 42360 0 0 {name=l33998 lab=WL212}
N 3040 42440 3060 42440 {}
C {lab_pin.sym} 3060 42440 0 0 {name=l33999 lab=VDD}
N 3040 42360 3060 42360 {}
C {lab_pin.sym} 3060 42360 0 0 {name=l34000 lab=VSS}
C {bitcell_6t.sym} 3200 42400 0 0 {name=Xr212c16}
N 3160 42440 3140 42440 {}
C {lab_pin.sym} 3140 42440 0 0 {name=l34001 lab=BL16}
N 3160 42400 3140 42400 {}
C {lab_pin.sym} 3140 42400 0 0 {name=l34002 lab=BLB16}
N 3160 42360 3140 42360 {}
C {lab_pin.sym} 3140 42360 0 0 {name=l34003 lab=WL212}
N 3240 42440 3260 42440 {}
C {lab_pin.sym} 3260 42440 0 0 {name=l34004 lab=VDD}
N 3240 42360 3260 42360 {}
C {lab_pin.sym} 3260 42360 0 0 {name=l34005 lab=VSS}
C {bitcell_6t.sym} 3400 42400 0 0 {name=Xr212c17}
N 3360 42440 3340 42440 {}
C {lab_pin.sym} 3340 42440 0 0 {name=l34006 lab=BL17}
N 3360 42400 3340 42400 {}
C {lab_pin.sym} 3340 42400 0 0 {name=l34007 lab=BLB17}
N 3360 42360 3340 42360 {}
C {lab_pin.sym} 3340 42360 0 0 {name=l34008 lab=WL212}
N 3440 42440 3460 42440 {}
C {lab_pin.sym} 3460 42440 0 0 {name=l34009 lab=VDD}
N 3440 42360 3460 42360 {}
C {lab_pin.sym} 3460 42360 0 0 {name=l34010 lab=VSS}
C {bitcell_6t.sym} 3600 42400 0 0 {name=Xr212c18}
N 3560 42440 3540 42440 {}
C {lab_pin.sym} 3540 42440 0 0 {name=l34011 lab=BL18}
N 3560 42400 3540 42400 {}
C {lab_pin.sym} 3540 42400 0 0 {name=l34012 lab=BLB18}
N 3560 42360 3540 42360 {}
C {lab_pin.sym} 3540 42360 0 0 {name=l34013 lab=WL212}
N 3640 42440 3660 42440 {}
C {lab_pin.sym} 3660 42440 0 0 {name=l34014 lab=VDD}
N 3640 42360 3660 42360 {}
C {lab_pin.sym} 3660 42360 0 0 {name=l34015 lab=VSS}
C {bitcell_6t.sym} 3800 42400 0 0 {name=Xr212c19}
N 3760 42440 3740 42440 {}
C {lab_pin.sym} 3740 42440 0 0 {name=l34016 lab=BL19}
N 3760 42400 3740 42400 {}
C {lab_pin.sym} 3740 42400 0 0 {name=l34017 lab=BLB19}
N 3760 42360 3740 42360 {}
C {lab_pin.sym} 3740 42360 0 0 {name=l34018 lab=WL212}
N 3840 42440 3860 42440 {}
C {lab_pin.sym} 3860 42440 0 0 {name=l34019 lab=VDD}
N 3840 42360 3860 42360 {}
C {lab_pin.sym} 3860 42360 0 0 {name=l34020 lab=VSS}
C {bitcell_6t.sym} 4000 42400 0 0 {name=Xr212c20}
N 3960 42440 3940 42440 {}
C {lab_pin.sym} 3940 42440 0 0 {name=l34021 lab=BL20}
N 3960 42400 3940 42400 {}
C {lab_pin.sym} 3940 42400 0 0 {name=l34022 lab=BLB20}
N 3960 42360 3940 42360 {}
C {lab_pin.sym} 3940 42360 0 0 {name=l34023 lab=WL212}
N 4040 42440 4060 42440 {}
C {lab_pin.sym} 4060 42440 0 0 {name=l34024 lab=VDD}
N 4040 42360 4060 42360 {}
C {lab_pin.sym} 4060 42360 0 0 {name=l34025 lab=VSS}
C {bitcell_6t.sym} 4200 42400 0 0 {name=Xr212c21}
N 4160 42440 4140 42440 {}
C {lab_pin.sym} 4140 42440 0 0 {name=l34026 lab=BL21}
N 4160 42400 4140 42400 {}
C {lab_pin.sym} 4140 42400 0 0 {name=l34027 lab=BLB21}
N 4160 42360 4140 42360 {}
C {lab_pin.sym} 4140 42360 0 0 {name=l34028 lab=WL212}
N 4240 42440 4260 42440 {}
C {lab_pin.sym} 4260 42440 0 0 {name=l34029 lab=VDD}
N 4240 42360 4260 42360 {}
C {lab_pin.sym} 4260 42360 0 0 {name=l34030 lab=VSS}
C {bitcell_6t.sym} 4400 42400 0 0 {name=Xr212c22}
N 4360 42440 4340 42440 {}
C {lab_pin.sym} 4340 42440 0 0 {name=l34031 lab=BL22}
N 4360 42400 4340 42400 {}
C {lab_pin.sym} 4340 42400 0 0 {name=l34032 lab=BLB22}
N 4360 42360 4340 42360 {}
C {lab_pin.sym} 4340 42360 0 0 {name=l34033 lab=WL212}
N 4440 42440 4460 42440 {}
C {lab_pin.sym} 4460 42440 0 0 {name=l34034 lab=VDD}
N 4440 42360 4460 42360 {}
C {lab_pin.sym} 4460 42360 0 0 {name=l34035 lab=VSS}
C {bitcell_6t.sym} 4600 42400 0 0 {name=Xr212c23}
N 4560 42440 4540 42440 {}
C {lab_pin.sym} 4540 42440 0 0 {name=l34036 lab=BL23}
N 4560 42400 4540 42400 {}
C {lab_pin.sym} 4540 42400 0 0 {name=l34037 lab=BLB23}
N 4560 42360 4540 42360 {}
C {lab_pin.sym} 4540 42360 0 0 {name=l34038 lab=WL212}
N 4640 42440 4660 42440 {}
C {lab_pin.sym} 4660 42440 0 0 {name=l34039 lab=VDD}
N 4640 42360 4660 42360 {}
C {lab_pin.sym} 4660 42360 0 0 {name=l34040 lab=VSS}
C {bitcell_6t.sym} 4800 42400 0 0 {name=Xr212c24}
N 4760 42440 4740 42440 {}
C {lab_pin.sym} 4740 42440 0 0 {name=l34041 lab=BL24}
N 4760 42400 4740 42400 {}
C {lab_pin.sym} 4740 42400 0 0 {name=l34042 lab=BLB24}
N 4760 42360 4740 42360 {}
C {lab_pin.sym} 4740 42360 0 0 {name=l34043 lab=WL212}
N 4840 42440 4860 42440 {}
C {lab_pin.sym} 4860 42440 0 0 {name=l34044 lab=VDD}
N 4840 42360 4860 42360 {}
C {lab_pin.sym} 4860 42360 0 0 {name=l34045 lab=VSS}
C {bitcell_6t.sym} 5000 42400 0 0 {name=Xr212c25}
N 4960 42440 4940 42440 {}
C {lab_pin.sym} 4940 42440 0 0 {name=l34046 lab=BL25}
N 4960 42400 4940 42400 {}
C {lab_pin.sym} 4940 42400 0 0 {name=l34047 lab=BLB25}
N 4960 42360 4940 42360 {}
C {lab_pin.sym} 4940 42360 0 0 {name=l34048 lab=WL212}
N 5040 42440 5060 42440 {}
C {lab_pin.sym} 5060 42440 0 0 {name=l34049 lab=VDD}
N 5040 42360 5060 42360 {}
C {lab_pin.sym} 5060 42360 0 0 {name=l34050 lab=VSS}
C {bitcell_6t.sym} 5200 42400 0 0 {name=Xr212c26}
N 5160 42440 5140 42440 {}
C {lab_pin.sym} 5140 42440 0 0 {name=l34051 lab=BL26}
N 5160 42400 5140 42400 {}
C {lab_pin.sym} 5140 42400 0 0 {name=l34052 lab=BLB26}
N 5160 42360 5140 42360 {}
C {lab_pin.sym} 5140 42360 0 0 {name=l34053 lab=WL212}
N 5240 42440 5260 42440 {}
C {lab_pin.sym} 5260 42440 0 0 {name=l34054 lab=VDD}
N 5240 42360 5260 42360 {}
C {lab_pin.sym} 5260 42360 0 0 {name=l34055 lab=VSS}
C {bitcell_6t.sym} 5400 42400 0 0 {name=Xr212c27}
N 5360 42440 5340 42440 {}
C {lab_pin.sym} 5340 42440 0 0 {name=l34056 lab=BL27}
N 5360 42400 5340 42400 {}
C {lab_pin.sym} 5340 42400 0 0 {name=l34057 lab=BLB27}
N 5360 42360 5340 42360 {}
C {lab_pin.sym} 5340 42360 0 0 {name=l34058 lab=WL212}
N 5440 42440 5460 42440 {}
C {lab_pin.sym} 5460 42440 0 0 {name=l34059 lab=VDD}
N 5440 42360 5460 42360 {}
C {lab_pin.sym} 5460 42360 0 0 {name=l34060 lab=VSS}
C {bitcell_6t.sym} 5600 42400 0 0 {name=Xr212c28}
N 5560 42440 5540 42440 {}
C {lab_pin.sym} 5540 42440 0 0 {name=l34061 lab=BL28}
N 5560 42400 5540 42400 {}
C {lab_pin.sym} 5540 42400 0 0 {name=l34062 lab=BLB28}
N 5560 42360 5540 42360 {}
C {lab_pin.sym} 5540 42360 0 0 {name=l34063 lab=WL212}
N 5640 42440 5660 42440 {}
C {lab_pin.sym} 5660 42440 0 0 {name=l34064 lab=VDD}
N 5640 42360 5660 42360 {}
C {lab_pin.sym} 5660 42360 0 0 {name=l34065 lab=VSS}
C {bitcell_6t.sym} 5800 42400 0 0 {name=Xr212c29}
N 5760 42440 5740 42440 {}
C {lab_pin.sym} 5740 42440 0 0 {name=l34066 lab=BL29}
N 5760 42400 5740 42400 {}
C {lab_pin.sym} 5740 42400 0 0 {name=l34067 lab=BLB29}
N 5760 42360 5740 42360 {}
C {lab_pin.sym} 5740 42360 0 0 {name=l34068 lab=WL212}
N 5840 42440 5860 42440 {}
C {lab_pin.sym} 5860 42440 0 0 {name=l34069 lab=VDD}
N 5840 42360 5860 42360 {}
C {lab_pin.sym} 5860 42360 0 0 {name=l34070 lab=VSS}
C {bitcell_6t.sym} 6000 42400 0 0 {name=Xr212c30}
N 5960 42440 5940 42440 {}
C {lab_pin.sym} 5940 42440 0 0 {name=l34071 lab=BL30}
N 5960 42400 5940 42400 {}
C {lab_pin.sym} 5940 42400 0 0 {name=l34072 lab=BLB30}
N 5960 42360 5940 42360 {}
C {lab_pin.sym} 5940 42360 0 0 {name=l34073 lab=WL212}
N 6040 42440 6060 42440 {}
C {lab_pin.sym} 6060 42440 0 0 {name=l34074 lab=VDD}
N 6040 42360 6060 42360 {}
C {lab_pin.sym} 6060 42360 0 0 {name=l34075 lab=VSS}
C {bitcell_6t.sym} 6200 42400 0 0 {name=Xr212c31}
N 6160 42440 6140 42440 {}
C {lab_pin.sym} 6140 42440 0 0 {name=l34076 lab=BL31}
N 6160 42400 6140 42400 {}
C {lab_pin.sym} 6140 42400 0 0 {name=l34077 lab=BLB31}
N 6160 42360 6140 42360 {}
C {lab_pin.sym} 6140 42360 0 0 {name=l34078 lab=WL212}
N 6240 42440 6260 42440 {}
C {lab_pin.sym} 6260 42440 0 0 {name=l34079 lab=VDD}
N 6240 42360 6260 42360 {}
C {lab_pin.sym} 6260 42360 0 0 {name=l34080 lab=VSS}
C {bitcell_6t.sym} 0 42600 0 0 {name=Xr213c0}
N -40 42640 -60 42640 {}
C {lab_pin.sym} -60 42640 0 0 {name=l34081 lab=BL0}
N -40 42600 -60 42600 {}
C {lab_pin.sym} -60 42600 0 0 {name=l34082 lab=BLB0}
N -40 42560 -60 42560 {}
C {lab_pin.sym} -60 42560 0 0 {name=l34083 lab=WL213}
N 40 42640 60 42640 {}
C {lab_pin.sym} 60 42640 0 0 {name=l34084 lab=VDD}
N 40 42560 60 42560 {}
C {lab_pin.sym} 60 42560 0 0 {name=l34085 lab=VSS}
C {bitcell_6t.sym} 200 42600 0 0 {name=Xr213c1}
N 160 42640 140 42640 {}
C {lab_pin.sym} 140 42640 0 0 {name=l34086 lab=BL1}
N 160 42600 140 42600 {}
C {lab_pin.sym} 140 42600 0 0 {name=l34087 lab=BLB1}
N 160 42560 140 42560 {}
C {lab_pin.sym} 140 42560 0 0 {name=l34088 lab=WL213}
N 240 42640 260 42640 {}
C {lab_pin.sym} 260 42640 0 0 {name=l34089 lab=VDD}
N 240 42560 260 42560 {}
C {lab_pin.sym} 260 42560 0 0 {name=l34090 lab=VSS}
C {bitcell_6t.sym} 400 42600 0 0 {name=Xr213c2}
N 360 42640 340 42640 {}
C {lab_pin.sym} 340 42640 0 0 {name=l34091 lab=BL2}
N 360 42600 340 42600 {}
C {lab_pin.sym} 340 42600 0 0 {name=l34092 lab=BLB2}
N 360 42560 340 42560 {}
C {lab_pin.sym} 340 42560 0 0 {name=l34093 lab=WL213}
N 440 42640 460 42640 {}
C {lab_pin.sym} 460 42640 0 0 {name=l34094 lab=VDD}
N 440 42560 460 42560 {}
C {lab_pin.sym} 460 42560 0 0 {name=l34095 lab=VSS}
C {bitcell_6t.sym} 600 42600 0 0 {name=Xr213c3}
N 560 42640 540 42640 {}
C {lab_pin.sym} 540 42640 0 0 {name=l34096 lab=BL3}
N 560 42600 540 42600 {}
C {lab_pin.sym} 540 42600 0 0 {name=l34097 lab=BLB3}
N 560 42560 540 42560 {}
C {lab_pin.sym} 540 42560 0 0 {name=l34098 lab=WL213}
N 640 42640 660 42640 {}
C {lab_pin.sym} 660 42640 0 0 {name=l34099 lab=VDD}
N 640 42560 660 42560 {}
C {lab_pin.sym} 660 42560 0 0 {name=l34100 lab=VSS}
C {bitcell_6t.sym} 800 42600 0 0 {name=Xr213c4}
N 760 42640 740 42640 {}
C {lab_pin.sym} 740 42640 0 0 {name=l34101 lab=BL4}
N 760 42600 740 42600 {}
C {lab_pin.sym} 740 42600 0 0 {name=l34102 lab=BLB4}
N 760 42560 740 42560 {}
C {lab_pin.sym} 740 42560 0 0 {name=l34103 lab=WL213}
N 840 42640 860 42640 {}
C {lab_pin.sym} 860 42640 0 0 {name=l34104 lab=VDD}
N 840 42560 860 42560 {}
C {lab_pin.sym} 860 42560 0 0 {name=l34105 lab=VSS}
C {bitcell_6t.sym} 1000 42600 0 0 {name=Xr213c5}
N 960 42640 940 42640 {}
C {lab_pin.sym} 940 42640 0 0 {name=l34106 lab=BL5}
N 960 42600 940 42600 {}
C {lab_pin.sym} 940 42600 0 0 {name=l34107 lab=BLB5}
N 960 42560 940 42560 {}
C {lab_pin.sym} 940 42560 0 0 {name=l34108 lab=WL213}
N 1040 42640 1060 42640 {}
C {lab_pin.sym} 1060 42640 0 0 {name=l34109 lab=VDD}
N 1040 42560 1060 42560 {}
C {lab_pin.sym} 1060 42560 0 0 {name=l34110 lab=VSS}
C {bitcell_6t.sym} 1200 42600 0 0 {name=Xr213c6}
N 1160 42640 1140 42640 {}
C {lab_pin.sym} 1140 42640 0 0 {name=l34111 lab=BL6}
N 1160 42600 1140 42600 {}
C {lab_pin.sym} 1140 42600 0 0 {name=l34112 lab=BLB6}
N 1160 42560 1140 42560 {}
C {lab_pin.sym} 1140 42560 0 0 {name=l34113 lab=WL213}
N 1240 42640 1260 42640 {}
C {lab_pin.sym} 1260 42640 0 0 {name=l34114 lab=VDD}
N 1240 42560 1260 42560 {}
C {lab_pin.sym} 1260 42560 0 0 {name=l34115 lab=VSS}
C {bitcell_6t.sym} 1400 42600 0 0 {name=Xr213c7}
N 1360 42640 1340 42640 {}
C {lab_pin.sym} 1340 42640 0 0 {name=l34116 lab=BL7}
N 1360 42600 1340 42600 {}
C {lab_pin.sym} 1340 42600 0 0 {name=l34117 lab=BLB7}
N 1360 42560 1340 42560 {}
C {lab_pin.sym} 1340 42560 0 0 {name=l34118 lab=WL213}
N 1440 42640 1460 42640 {}
C {lab_pin.sym} 1460 42640 0 0 {name=l34119 lab=VDD}
N 1440 42560 1460 42560 {}
C {lab_pin.sym} 1460 42560 0 0 {name=l34120 lab=VSS}
C {bitcell_6t.sym} 1600 42600 0 0 {name=Xr213c8}
N 1560 42640 1540 42640 {}
C {lab_pin.sym} 1540 42640 0 0 {name=l34121 lab=BL8}
N 1560 42600 1540 42600 {}
C {lab_pin.sym} 1540 42600 0 0 {name=l34122 lab=BLB8}
N 1560 42560 1540 42560 {}
C {lab_pin.sym} 1540 42560 0 0 {name=l34123 lab=WL213}
N 1640 42640 1660 42640 {}
C {lab_pin.sym} 1660 42640 0 0 {name=l34124 lab=VDD}
N 1640 42560 1660 42560 {}
C {lab_pin.sym} 1660 42560 0 0 {name=l34125 lab=VSS}
C {bitcell_6t.sym} 1800 42600 0 0 {name=Xr213c9}
N 1760 42640 1740 42640 {}
C {lab_pin.sym} 1740 42640 0 0 {name=l34126 lab=BL9}
N 1760 42600 1740 42600 {}
C {lab_pin.sym} 1740 42600 0 0 {name=l34127 lab=BLB9}
N 1760 42560 1740 42560 {}
C {lab_pin.sym} 1740 42560 0 0 {name=l34128 lab=WL213}
N 1840 42640 1860 42640 {}
C {lab_pin.sym} 1860 42640 0 0 {name=l34129 lab=VDD}
N 1840 42560 1860 42560 {}
C {lab_pin.sym} 1860 42560 0 0 {name=l34130 lab=VSS}
C {bitcell_6t.sym} 2000 42600 0 0 {name=Xr213c10}
N 1960 42640 1940 42640 {}
C {lab_pin.sym} 1940 42640 0 0 {name=l34131 lab=BL10}
N 1960 42600 1940 42600 {}
C {lab_pin.sym} 1940 42600 0 0 {name=l34132 lab=BLB10}
N 1960 42560 1940 42560 {}
C {lab_pin.sym} 1940 42560 0 0 {name=l34133 lab=WL213}
N 2040 42640 2060 42640 {}
C {lab_pin.sym} 2060 42640 0 0 {name=l34134 lab=VDD}
N 2040 42560 2060 42560 {}
C {lab_pin.sym} 2060 42560 0 0 {name=l34135 lab=VSS}
C {bitcell_6t.sym} 2200 42600 0 0 {name=Xr213c11}
N 2160 42640 2140 42640 {}
C {lab_pin.sym} 2140 42640 0 0 {name=l34136 lab=BL11}
N 2160 42600 2140 42600 {}
C {lab_pin.sym} 2140 42600 0 0 {name=l34137 lab=BLB11}
N 2160 42560 2140 42560 {}
C {lab_pin.sym} 2140 42560 0 0 {name=l34138 lab=WL213}
N 2240 42640 2260 42640 {}
C {lab_pin.sym} 2260 42640 0 0 {name=l34139 lab=VDD}
N 2240 42560 2260 42560 {}
C {lab_pin.sym} 2260 42560 0 0 {name=l34140 lab=VSS}
C {bitcell_6t.sym} 2400 42600 0 0 {name=Xr213c12}
N 2360 42640 2340 42640 {}
C {lab_pin.sym} 2340 42640 0 0 {name=l34141 lab=BL12}
N 2360 42600 2340 42600 {}
C {lab_pin.sym} 2340 42600 0 0 {name=l34142 lab=BLB12}
N 2360 42560 2340 42560 {}
C {lab_pin.sym} 2340 42560 0 0 {name=l34143 lab=WL213}
N 2440 42640 2460 42640 {}
C {lab_pin.sym} 2460 42640 0 0 {name=l34144 lab=VDD}
N 2440 42560 2460 42560 {}
C {lab_pin.sym} 2460 42560 0 0 {name=l34145 lab=VSS}
C {bitcell_6t.sym} 2600 42600 0 0 {name=Xr213c13}
N 2560 42640 2540 42640 {}
C {lab_pin.sym} 2540 42640 0 0 {name=l34146 lab=BL13}
N 2560 42600 2540 42600 {}
C {lab_pin.sym} 2540 42600 0 0 {name=l34147 lab=BLB13}
N 2560 42560 2540 42560 {}
C {lab_pin.sym} 2540 42560 0 0 {name=l34148 lab=WL213}
N 2640 42640 2660 42640 {}
C {lab_pin.sym} 2660 42640 0 0 {name=l34149 lab=VDD}
N 2640 42560 2660 42560 {}
C {lab_pin.sym} 2660 42560 0 0 {name=l34150 lab=VSS}
C {bitcell_6t.sym} 2800 42600 0 0 {name=Xr213c14}
N 2760 42640 2740 42640 {}
C {lab_pin.sym} 2740 42640 0 0 {name=l34151 lab=BL14}
N 2760 42600 2740 42600 {}
C {lab_pin.sym} 2740 42600 0 0 {name=l34152 lab=BLB14}
N 2760 42560 2740 42560 {}
C {lab_pin.sym} 2740 42560 0 0 {name=l34153 lab=WL213}
N 2840 42640 2860 42640 {}
C {lab_pin.sym} 2860 42640 0 0 {name=l34154 lab=VDD}
N 2840 42560 2860 42560 {}
C {lab_pin.sym} 2860 42560 0 0 {name=l34155 lab=VSS}
C {bitcell_6t.sym} 3000 42600 0 0 {name=Xr213c15}
N 2960 42640 2940 42640 {}
C {lab_pin.sym} 2940 42640 0 0 {name=l34156 lab=BL15}
N 2960 42600 2940 42600 {}
C {lab_pin.sym} 2940 42600 0 0 {name=l34157 lab=BLB15}
N 2960 42560 2940 42560 {}
C {lab_pin.sym} 2940 42560 0 0 {name=l34158 lab=WL213}
N 3040 42640 3060 42640 {}
C {lab_pin.sym} 3060 42640 0 0 {name=l34159 lab=VDD}
N 3040 42560 3060 42560 {}
C {lab_pin.sym} 3060 42560 0 0 {name=l34160 lab=VSS}
C {bitcell_6t.sym} 3200 42600 0 0 {name=Xr213c16}
N 3160 42640 3140 42640 {}
C {lab_pin.sym} 3140 42640 0 0 {name=l34161 lab=BL16}
N 3160 42600 3140 42600 {}
C {lab_pin.sym} 3140 42600 0 0 {name=l34162 lab=BLB16}
N 3160 42560 3140 42560 {}
C {lab_pin.sym} 3140 42560 0 0 {name=l34163 lab=WL213}
N 3240 42640 3260 42640 {}
C {lab_pin.sym} 3260 42640 0 0 {name=l34164 lab=VDD}
N 3240 42560 3260 42560 {}
C {lab_pin.sym} 3260 42560 0 0 {name=l34165 lab=VSS}
C {bitcell_6t.sym} 3400 42600 0 0 {name=Xr213c17}
N 3360 42640 3340 42640 {}
C {lab_pin.sym} 3340 42640 0 0 {name=l34166 lab=BL17}
N 3360 42600 3340 42600 {}
C {lab_pin.sym} 3340 42600 0 0 {name=l34167 lab=BLB17}
N 3360 42560 3340 42560 {}
C {lab_pin.sym} 3340 42560 0 0 {name=l34168 lab=WL213}
N 3440 42640 3460 42640 {}
C {lab_pin.sym} 3460 42640 0 0 {name=l34169 lab=VDD}
N 3440 42560 3460 42560 {}
C {lab_pin.sym} 3460 42560 0 0 {name=l34170 lab=VSS}
C {bitcell_6t.sym} 3600 42600 0 0 {name=Xr213c18}
N 3560 42640 3540 42640 {}
C {lab_pin.sym} 3540 42640 0 0 {name=l34171 lab=BL18}
N 3560 42600 3540 42600 {}
C {lab_pin.sym} 3540 42600 0 0 {name=l34172 lab=BLB18}
N 3560 42560 3540 42560 {}
C {lab_pin.sym} 3540 42560 0 0 {name=l34173 lab=WL213}
N 3640 42640 3660 42640 {}
C {lab_pin.sym} 3660 42640 0 0 {name=l34174 lab=VDD}
N 3640 42560 3660 42560 {}
C {lab_pin.sym} 3660 42560 0 0 {name=l34175 lab=VSS}
C {bitcell_6t.sym} 3800 42600 0 0 {name=Xr213c19}
N 3760 42640 3740 42640 {}
C {lab_pin.sym} 3740 42640 0 0 {name=l34176 lab=BL19}
N 3760 42600 3740 42600 {}
C {lab_pin.sym} 3740 42600 0 0 {name=l34177 lab=BLB19}
N 3760 42560 3740 42560 {}
C {lab_pin.sym} 3740 42560 0 0 {name=l34178 lab=WL213}
N 3840 42640 3860 42640 {}
C {lab_pin.sym} 3860 42640 0 0 {name=l34179 lab=VDD}
N 3840 42560 3860 42560 {}
C {lab_pin.sym} 3860 42560 0 0 {name=l34180 lab=VSS}
C {bitcell_6t.sym} 4000 42600 0 0 {name=Xr213c20}
N 3960 42640 3940 42640 {}
C {lab_pin.sym} 3940 42640 0 0 {name=l34181 lab=BL20}
N 3960 42600 3940 42600 {}
C {lab_pin.sym} 3940 42600 0 0 {name=l34182 lab=BLB20}
N 3960 42560 3940 42560 {}
C {lab_pin.sym} 3940 42560 0 0 {name=l34183 lab=WL213}
N 4040 42640 4060 42640 {}
C {lab_pin.sym} 4060 42640 0 0 {name=l34184 lab=VDD}
N 4040 42560 4060 42560 {}
C {lab_pin.sym} 4060 42560 0 0 {name=l34185 lab=VSS}
C {bitcell_6t.sym} 4200 42600 0 0 {name=Xr213c21}
N 4160 42640 4140 42640 {}
C {lab_pin.sym} 4140 42640 0 0 {name=l34186 lab=BL21}
N 4160 42600 4140 42600 {}
C {lab_pin.sym} 4140 42600 0 0 {name=l34187 lab=BLB21}
N 4160 42560 4140 42560 {}
C {lab_pin.sym} 4140 42560 0 0 {name=l34188 lab=WL213}
N 4240 42640 4260 42640 {}
C {lab_pin.sym} 4260 42640 0 0 {name=l34189 lab=VDD}
N 4240 42560 4260 42560 {}
C {lab_pin.sym} 4260 42560 0 0 {name=l34190 lab=VSS}
C {bitcell_6t.sym} 4400 42600 0 0 {name=Xr213c22}
N 4360 42640 4340 42640 {}
C {lab_pin.sym} 4340 42640 0 0 {name=l34191 lab=BL22}
N 4360 42600 4340 42600 {}
C {lab_pin.sym} 4340 42600 0 0 {name=l34192 lab=BLB22}
N 4360 42560 4340 42560 {}
C {lab_pin.sym} 4340 42560 0 0 {name=l34193 lab=WL213}
N 4440 42640 4460 42640 {}
C {lab_pin.sym} 4460 42640 0 0 {name=l34194 lab=VDD}
N 4440 42560 4460 42560 {}
C {lab_pin.sym} 4460 42560 0 0 {name=l34195 lab=VSS}
C {bitcell_6t.sym} 4600 42600 0 0 {name=Xr213c23}
N 4560 42640 4540 42640 {}
C {lab_pin.sym} 4540 42640 0 0 {name=l34196 lab=BL23}
N 4560 42600 4540 42600 {}
C {lab_pin.sym} 4540 42600 0 0 {name=l34197 lab=BLB23}
N 4560 42560 4540 42560 {}
C {lab_pin.sym} 4540 42560 0 0 {name=l34198 lab=WL213}
N 4640 42640 4660 42640 {}
C {lab_pin.sym} 4660 42640 0 0 {name=l34199 lab=VDD}
N 4640 42560 4660 42560 {}
C {lab_pin.sym} 4660 42560 0 0 {name=l34200 lab=VSS}
C {bitcell_6t.sym} 4800 42600 0 0 {name=Xr213c24}
N 4760 42640 4740 42640 {}
C {lab_pin.sym} 4740 42640 0 0 {name=l34201 lab=BL24}
N 4760 42600 4740 42600 {}
C {lab_pin.sym} 4740 42600 0 0 {name=l34202 lab=BLB24}
N 4760 42560 4740 42560 {}
C {lab_pin.sym} 4740 42560 0 0 {name=l34203 lab=WL213}
N 4840 42640 4860 42640 {}
C {lab_pin.sym} 4860 42640 0 0 {name=l34204 lab=VDD}
N 4840 42560 4860 42560 {}
C {lab_pin.sym} 4860 42560 0 0 {name=l34205 lab=VSS}
C {bitcell_6t.sym} 5000 42600 0 0 {name=Xr213c25}
N 4960 42640 4940 42640 {}
C {lab_pin.sym} 4940 42640 0 0 {name=l34206 lab=BL25}
N 4960 42600 4940 42600 {}
C {lab_pin.sym} 4940 42600 0 0 {name=l34207 lab=BLB25}
N 4960 42560 4940 42560 {}
C {lab_pin.sym} 4940 42560 0 0 {name=l34208 lab=WL213}
N 5040 42640 5060 42640 {}
C {lab_pin.sym} 5060 42640 0 0 {name=l34209 lab=VDD}
N 5040 42560 5060 42560 {}
C {lab_pin.sym} 5060 42560 0 0 {name=l34210 lab=VSS}
C {bitcell_6t.sym} 5200 42600 0 0 {name=Xr213c26}
N 5160 42640 5140 42640 {}
C {lab_pin.sym} 5140 42640 0 0 {name=l34211 lab=BL26}
N 5160 42600 5140 42600 {}
C {lab_pin.sym} 5140 42600 0 0 {name=l34212 lab=BLB26}
N 5160 42560 5140 42560 {}
C {lab_pin.sym} 5140 42560 0 0 {name=l34213 lab=WL213}
N 5240 42640 5260 42640 {}
C {lab_pin.sym} 5260 42640 0 0 {name=l34214 lab=VDD}
N 5240 42560 5260 42560 {}
C {lab_pin.sym} 5260 42560 0 0 {name=l34215 lab=VSS}
C {bitcell_6t.sym} 5400 42600 0 0 {name=Xr213c27}
N 5360 42640 5340 42640 {}
C {lab_pin.sym} 5340 42640 0 0 {name=l34216 lab=BL27}
N 5360 42600 5340 42600 {}
C {lab_pin.sym} 5340 42600 0 0 {name=l34217 lab=BLB27}
N 5360 42560 5340 42560 {}
C {lab_pin.sym} 5340 42560 0 0 {name=l34218 lab=WL213}
N 5440 42640 5460 42640 {}
C {lab_pin.sym} 5460 42640 0 0 {name=l34219 lab=VDD}
N 5440 42560 5460 42560 {}
C {lab_pin.sym} 5460 42560 0 0 {name=l34220 lab=VSS}
C {bitcell_6t.sym} 5600 42600 0 0 {name=Xr213c28}
N 5560 42640 5540 42640 {}
C {lab_pin.sym} 5540 42640 0 0 {name=l34221 lab=BL28}
N 5560 42600 5540 42600 {}
C {lab_pin.sym} 5540 42600 0 0 {name=l34222 lab=BLB28}
N 5560 42560 5540 42560 {}
C {lab_pin.sym} 5540 42560 0 0 {name=l34223 lab=WL213}
N 5640 42640 5660 42640 {}
C {lab_pin.sym} 5660 42640 0 0 {name=l34224 lab=VDD}
N 5640 42560 5660 42560 {}
C {lab_pin.sym} 5660 42560 0 0 {name=l34225 lab=VSS}
C {bitcell_6t.sym} 5800 42600 0 0 {name=Xr213c29}
N 5760 42640 5740 42640 {}
C {lab_pin.sym} 5740 42640 0 0 {name=l34226 lab=BL29}
N 5760 42600 5740 42600 {}
C {lab_pin.sym} 5740 42600 0 0 {name=l34227 lab=BLB29}
N 5760 42560 5740 42560 {}
C {lab_pin.sym} 5740 42560 0 0 {name=l34228 lab=WL213}
N 5840 42640 5860 42640 {}
C {lab_pin.sym} 5860 42640 0 0 {name=l34229 lab=VDD}
N 5840 42560 5860 42560 {}
C {lab_pin.sym} 5860 42560 0 0 {name=l34230 lab=VSS}
C {bitcell_6t.sym} 6000 42600 0 0 {name=Xr213c30}
N 5960 42640 5940 42640 {}
C {lab_pin.sym} 5940 42640 0 0 {name=l34231 lab=BL30}
N 5960 42600 5940 42600 {}
C {lab_pin.sym} 5940 42600 0 0 {name=l34232 lab=BLB30}
N 5960 42560 5940 42560 {}
C {lab_pin.sym} 5940 42560 0 0 {name=l34233 lab=WL213}
N 6040 42640 6060 42640 {}
C {lab_pin.sym} 6060 42640 0 0 {name=l34234 lab=VDD}
N 6040 42560 6060 42560 {}
C {lab_pin.sym} 6060 42560 0 0 {name=l34235 lab=VSS}
C {bitcell_6t.sym} 6200 42600 0 0 {name=Xr213c31}
N 6160 42640 6140 42640 {}
C {lab_pin.sym} 6140 42640 0 0 {name=l34236 lab=BL31}
N 6160 42600 6140 42600 {}
C {lab_pin.sym} 6140 42600 0 0 {name=l34237 lab=BLB31}
N 6160 42560 6140 42560 {}
C {lab_pin.sym} 6140 42560 0 0 {name=l34238 lab=WL213}
N 6240 42640 6260 42640 {}
C {lab_pin.sym} 6260 42640 0 0 {name=l34239 lab=VDD}
N 6240 42560 6260 42560 {}
C {lab_pin.sym} 6260 42560 0 0 {name=l34240 lab=VSS}
C {bitcell_6t.sym} 0 42800 0 0 {name=Xr214c0}
N -40 42840 -60 42840 {}
C {lab_pin.sym} -60 42840 0 0 {name=l34241 lab=BL0}
N -40 42800 -60 42800 {}
C {lab_pin.sym} -60 42800 0 0 {name=l34242 lab=BLB0}
N -40 42760 -60 42760 {}
C {lab_pin.sym} -60 42760 0 0 {name=l34243 lab=WL214}
N 40 42840 60 42840 {}
C {lab_pin.sym} 60 42840 0 0 {name=l34244 lab=VDD}
N 40 42760 60 42760 {}
C {lab_pin.sym} 60 42760 0 0 {name=l34245 lab=VSS}
C {bitcell_6t.sym} 200 42800 0 0 {name=Xr214c1}
N 160 42840 140 42840 {}
C {lab_pin.sym} 140 42840 0 0 {name=l34246 lab=BL1}
N 160 42800 140 42800 {}
C {lab_pin.sym} 140 42800 0 0 {name=l34247 lab=BLB1}
N 160 42760 140 42760 {}
C {lab_pin.sym} 140 42760 0 0 {name=l34248 lab=WL214}
N 240 42840 260 42840 {}
C {lab_pin.sym} 260 42840 0 0 {name=l34249 lab=VDD}
N 240 42760 260 42760 {}
C {lab_pin.sym} 260 42760 0 0 {name=l34250 lab=VSS}
C {bitcell_6t.sym} 400 42800 0 0 {name=Xr214c2}
N 360 42840 340 42840 {}
C {lab_pin.sym} 340 42840 0 0 {name=l34251 lab=BL2}
N 360 42800 340 42800 {}
C {lab_pin.sym} 340 42800 0 0 {name=l34252 lab=BLB2}
N 360 42760 340 42760 {}
C {lab_pin.sym} 340 42760 0 0 {name=l34253 lab=WL214}
N 440 42840 460 42840 {}
C {lab_pin.sym} 460 42840 0 0 {name=l34254 lab=VDD}
N 440 42760 460 42760 {}
C {lab_pin.sym} 460 42760 0 0 {name=l34255 lab=VSS}
C {bitcell_6t.sym} 600 42800 0 0 {name=Xr214c3}
N 560 42840 540 42840 {}
C {lab_pin.sym} 540 42840 0 0 {name=l34256 lab=BL3}
N 560 42800 540 42800 {}
C {lab_pin.sym} 540 42800 0 0 {name=l34257 lab=BLB3}
N 560 42760 540 42760 {}
C {lab_pin.sym} 540 42760 0 0 {name=l34258 lab=WL214}
N 640 42840 660 42840 {}
C {lab_pin.sym} 660 42840 0 0 {name=l34259 lab=VDD}
N 640 42760 660 42760 {}
C {lab_pin.sym} 660 42760 0 0 {name=l34260 lab=VSS}
C {bitcell_6t.sym} 800 42800 0 0 {name=Xr214c4}
N 760 42840 740 42840 {}
C {lab_pin.sym} 740 42840 0 0 {name=l34261 lab=BL4}
N 760 42800 740 42800 {}
C {lab_pin.sym} 740 42800 0 0 {name=l34262 lab=BLB4}
N 760 42760 740 42760 {}
C {lab_pin.sym} 740 42760 0 0 {name=l34263 lab=WL214}
N 840 42840 860 42840 {}
C {lab_pin.sym} 860 42840 0 0 {name=l34264 lab=VDD}
N 840 42760 860 42760 {}
C {lab_pin.sym} 860 42760 0 0 {name=l34265 lab=VSS}
C {bitcell_6t.sym} 1000 42800 0 0 {name=Xr214c5}
N 960 42840 940 42840 {}
C {lab_pin.sym} 940 42840 0 0 {name=l34266 lab=BL5}
N 960 42800 940 42800 {}
C {lab_pin.sym} 940 42800 0 0 {name=l34267 lab=BLB5}
N 960 42760 940 42760 {}
C {lab_pin.sym} 940 42760 0 0 {name=l34268 lab=WL214}
N 1040 42840 1060 42840 {}
C {lab_pin.sym} 1060 42840 0 0 {name=l34269 lab=VDD}
N 1040 42760 1060 42760 {}
C {lab_pin.sym} 1060 42760 0 0 {name=l34270 lab=VSS}
C {bitcell_6t.sym} 1200 42800 0 0 {name=Xr214c6}
N 1160 42840 1140 42840 {}
C {lab_pin.sym} 1140 42840 0 0 {name=l34271 lab=BL6}
N 1160 42800 1140 42800 {}
C {lab_pin.sym} 1140 42800 0 0 {name=l34272 lab=BLB6}
N 1160 42760 1140 42760 {}
C {lab_pin.sym} 1140 42760 0 0 {name=l34273 lab=WL214}
N 1240 42840 1260 42840 {}
C {lab_pin.sym} 1260 42840 0 0 {name=l34274 lab=VDD}
N 1240 42760 1260 42760 {}
C {lab_pin.sym} 1260 42760 0 0 {name=l34275 lab=VSS}
C {bitcell_6t.sym} 1400 42800 0 0 {name=Xr214c7}
N 1360 42840 1340 42840 {}
C {lab_pin.sym} 1340 42840 0 0 {name=l34276 lab=BL7}
N 1360 42800 1340 42800 {}
C {lab_pin.sym} 1340 42800 0 0 {name=l34277 lab=BLB7}
N 1360 42760 1340 42760 {}
C {lab_pin.sym} 1340 42760 0 0 {name=l34278 lab=WL214}
N 1440 42840 1460 42840 {}
C {lab_pin.sym} 1460 42840 0 0 {name=l34279 lab=VDD}
N 1440 42760 1460 42760 {}
C {lab_pin.sym} 1460 42760 0 0 {name=l34280 lab=VSS}
C {bitcell_6t.sym} 1600 42800 0 0 {name=Xr214c8}
N 1560 42840 1540 42840 {}
C {lab_pin.sym} 1540 42840 0 0 {name=l34281 lab=BL8}
N 1560 42800 1540 42800 {}
C {lab_pin.sym} 1540 42800 0 0 {name=l34282 lab=BLB8}
N 1560 42760 1540 42760 {}
C {lab_pin.sym} 1540 42760 0 0 {name=l34283 lab=WL214}
N 1640 42840 1660 42840 {}
C {lab_pin.sym} 1660 42840 0 0 {name=l34284 lab=VDD}
N 1640 42760 1660 42760 {}
C {lab_pin.sym} 1660 42760 0 0 {name=l34285 lab=VSS}
C {bitcell_6t.sym} 1800 42800 0 0 {name=Xr214c9}
N 1760 42840 1740 42840 {}
C {lab_pin.sym} 1740 42840 0 0 {name=l34286 lab=BL9}
N 1760 42800 1740 42800 {}
C {lab_pin.sym} 1740 42800 0 0 {name=l34287 lab=BLB9}
N 1760 42760 1740 42760 {}
C {lab_pin.sym} 1740 42760 0 0 {name=l34288 lab=WL214}
N 1840 42840 1860 42840 {}
C {lab_pin.sym} 1860 42840 0 0 {name=l34289 lab=VDD}
N 1840 42760 1860 42760 {}
C {lab_pin.sym} 1860 42760 0 0 {name=l34290 lab=VSS}
C {bitcell_6t.sym} 2000 42800 0 0 {name=Xr214c10}
N 1960 42840 1940 42840 {}
C {lab_pin.sym} 1940 42840 0 0 {name=l34291 lab=BL10}
N 1960 42800 1940 42800 {}
C {lab_pin.sym} 1940 42800 0 0 {name=l34292 lab=BLB10}
N 1960 42760 1940 42760 {}
C {lab_pin.sym} 1940 42760 0 0 {name=l34293 lab=WL214}
N 2040 42840 2060 42840 {}
C {lab_pin.sym} 2060 42840 0 0 {name=l34294 lab=VDD}
N 2040 42760 2060 42760 {}
C {lab_pin.sym} 2060 42760 0 0 {name=l34295 lab=VSS}
C {bitcell_6t.sym} 2200 42800 0 0 {name=Xr214c11}
N 2160 42840 2140 42840 {}
C {lab_pin.sym} 2140 42840 0 0 {name=l34296 lab=BL11}
N 2160 42800 2140 42800 {}
C {lab_pin.sym} 2140 42800 0 0 {name=l34297 lab=BLB11}
N 2160 42760 2140 42760 {}
C {lab_pin.sym} 2140 42760 0 0 {name=l34298 lab=WL214}
N 2240 42840 2260 42840 {}
C {lab_pin.sym} 2260 42840 0 0 {name=l34299 lab=VDD}
N 2240 42760 2260 42760 {}
C {lab_pin.sym} 2260 42760 0 0 {name=l34300 lab=VSS}
C {bitcell_6t.sym} 2400 42800 0 0 {name=Xr214c12}
N 2360 42840 2340 42840 {}
C {lab_pin.sym} 2340 42840 0 0 {name=l34301 lab=BL12}
N 2360 42800 2340 42800 {}
C {lab_pin.sym} 2340 42800 0 0 {name=l34302 lab=BLB12}
N 2360 42760 2340 42760 {}
C {lab_pin.sym} 2340 42760 0 0 {name=l34303 lab=WL214}
N 2440 42840 2460 42840 {}
C {lab_pin.sym} 2460 42840 0 0 {name=l34304 lab=VDD}
N 2440 42760 2460 42760 {}
C {lab_pin.sym} 2460 42760 0 0 {name=l34305 lab=VSS}
C {bitcell_6t.sym} 2600 42800 0 0 {name=Xr214c13}
N 2560 42840 2540 42840 {}
C {lab_pin.sym} 2540 42840 0 0 {name=l34306 lab=BL13}
N 2560 42800 2540 42800 {}
C {lab_pin.sym} 2540 42800 0 0 {name=l34307 lab=BLB13}
N 2560 42760 2540 42760 {}
C {lab_pin.sym} 2540 42760 0 0 {name=l34308 lab=WL214}
N 2640 42840 2660 42840 {}
C {lab_pin.sym} 2660 42840 0 0 {name=l34309 lab=VDD}
N 2640 42760 2660 42760 {}
C {lab_pin.sym} 2660 42760 0 0 {name=l34310 lab=VSS}
C {bitcell_6t.sym} 2800 42800 0 0 {name=Xr214c14}
N 2760 42840 2740 42840 {}
C {lab_pin.sym} 2740 42840 0 0 {name=l34311 lab=BL14}
N 2760 42800 2740 42800 {}
C {lab_pin.sym} 2740 42800 0 0 {name=l34312 lab=BLB14}
N 2760 42760 2740 42760 {}
C {lab_pin.sym} 2740 42760 0 0 {name=l34313 lab=WL214}
N 2840 42840 2860 42840 {}
C {lab_pin.sym} 2860 42840 0 0 {name=l34314 lab=VDD}
N 2840 42760 2860 42760 {}
C {lab_pin.sym} 2860 42760 0 0 {name=l34315 lab=VSS}
C {bitcell_6t.sym} 3000 42800 0 0 {name=Xr214c15}
N 2960 42840 2940 42840 {}
C {lab_pin.sym} 2940 42840 0 0 {name=l34316 lab=BL15}
N 2960 42800 2940 42800 {}
C {lab_pin.sym} 2940 42800 0 0 {name=l34317 lab=BLB15}
N 2960 42760 2940 42760 {}
C {lab_pin.sym} 2940 42760 0 0 {name=l34318 lab=WL214}
N 3040 42840 3060 42840 {}
C {lab_pin.sym} 3060 42840 0 0 {name=l34319 lab=VDD}
N 3040 42760 3060 42760 {}
C {lab_pin.sym} 3060 42760 0 0 {name=l34320 lab=VSS}
C {bitcell_6t.sym} 3200 42800 0 0 {name=Xr214c16}
N 3160 42840 3140 42840 {}
C {lab_pin.sym} 3140 42840 0 0 {name=l34321 lab=BL16}
N 3160 42800 3140 42800 {}
C {lab_pin.sym} 3140 42800 0 0 {name=l34322 lab=BLB16}
N 3160 42760 3140 42760 {}
C {lab_pin.sym} 3140 42760 0 0 {name=l34323 lab=WL214}
N 3240 42840 3260 42840 {}
C {lab_pin.sym} 3260 42840 0 0 {name=l34324 lab=VDD}
N 3240 42760 3260 42760 {}
C {lab_pin.sym} 3260 42760 0 0 {name=l34325 lab=VSS}
C {bitcell_6t.sym} 3400 42800 0 0 {name=Xr214c17}
N 3360 42840 3340 42840 {}
C {lab_pin.sym} 3340 42840 0 0 {name=l34326 lab=BL17}
N 3360 42800 3340 42800 {}
C {lab_pin.sym} 3340 42800 0 0 {name=l34327 lab=BLB17}
N 3360 42760 3340 42760 {}
C {lab_pin.sym} 3340 42760 0 0 {name=l34328 lab=WL214}
N 3440 42840 3460 42840 {}
C {lab_pin.sym} 3460 42840 0 0 {name=l34329 lab=VDD}
N 3440 42760 3460 42760 {}
C {lab_pin.sym} 3460 42760 0 0 {name=l34330 lab=VSS}
C {bitcell_6t.sym} 3600 42800 0 0 {name=Xr214c18}
N 3560 42840 3540 42840 {}
C {lab_pin.sym} 3540 42840 0 0 {name=l34331 lab=BL18}
N 3560 42800 3540 42800 {}
C {lab_pin.sym} 3540 42800 0 0 {name=l34332 lab=BLB18}
N 3560 42760 3540 42760 {}
C {lab_pin.sym} 3540 42760 0 0 {name=l34333 lab=WL214}
N 3640 42840 3660 42840 {}
C {lab_pin.sym} 3660 42840 0 0 {name=l34334 lab=VDD}
N 3640 42760 3660 42760 {}
C {lab_pin.sym} 3660 42760 0 0 {name=l34335 lab=VSS}
C {bitcell_6t.sym} 3800 42800 0 0 {name=Xr214c19}
N 3760 42840 3740 42840 {}
C {lab_pin.sym} 3740 42840 0 0 {name=l34336 lab=BL19}
N 3760 42800 3740 42800 {}
C {lab_pin.sym} 3740 42800 0 0 {name=l34337 lab=BLB19}
N 3760 42760 3740 42760 {}
C {lab_pin.sym} 3740 42760 0 0 {name=l34338 lab=WL214}
N 3840 42840 3860 42840 {}
C {lab_pin.sym} 3860 42840 0 0 {name=l34339 lab=VDD}
N 3840 42760 3860 42760 {}
C {lab_pin.sym} 3860 42760 0 0 {name=l34340 lab=VSS}
C {bitcell_6t.sym} 4000 42800 0 0 {name=Xr214c20}
N 3960 42840 3940 42840 {}
C {lab_pin.sym} 3940 42840 0 0 {name=l34341 lab=BL20}
N 3960 42800 3940 42800 {}
C {lab_pin.sym} 3940 42800 0 0 {name=l34342 lab=BLB20}
N 3960 42760 3940 42760 {}
C {lab_pin.sym} 3940 42760 0 0 {name=l34343 lab=WL214}
N 4040 42840 4060 42840 {}
C {lab_pin.sym} 4060 42840 0 0 {name=l34344 lab=VDD}
N 4040 42760 4060 42760 {}
C {lab_pin.sym} 4060 42760 0 0 {name=l34345 lab=VSS}
C {bitcell_6t.sym} 4200 42800 0 0 {name=Xr214c21}
N 4160 42840 4140 42840 {}
C {lab_pin.sym} 4140 42840 0 0 {name=l34346 lab=BL21}
N 4160 42800 4140 42800 {}
C {lab_pin.sym} 4140 42800 0 0 {name=l34347 lab=BLB21}
N 4160 42760 4140 42760 {}
C {lab_pin.sym} 4140 42760 0 0 {name=l34348 lab=WL214}
N 4240 42840 4260 42840 {}
C {lab_pin.sym} 4260 42840 0 0 {name=l34349 lab=VDD}
N 4240 42760 4260 42760 {}
C {lab_pin.sym} 4260 42760 0 0 {name=l34350 lab=VSS}
C {bitcell_6t.sym} 4400 42800 0 0 {name=Xr214c22}
N 4360 42840 4340 42840 {}
C {lab_pin.sym} 4340 42840 0 0 {name=l34351 lab=BL22}
N 4360 42800 4340 42800 {}
C {lab_pin.sym} 4340 42800 0 0 {name=l34352 lab=BLB22}
N 4360 42760 4340 42760 {}
C {lab_pin.sym} 4340 42760 0 0 {name=l34353 lab=WL214}
N 4440 42840 4460 42840 {}
C {lab_pin.sym} 4460 42840 0 0 {name=l34354 lab=VDD}
N 4440 42760 4460 42760 {}
C {lab_pin.sym} 4460 42760 0 0 {name=l34355 lab=VSS}
C {bitcell_6t.sym} 4600 42800 0 0 {name=Xr214c23}
N 4560 42840 4540 42840 {}
C {lab_pin.sym} 4540 42840 0 0 {name=l34356 lab=BL23}
N 4560 42800 4540 42800 {}
C {lab_pin.sym} 4540 42800 0 0 {name=l34357 lab=BLB23}
N 4560 42760 4540 42760 {}
C {lab_pin.sym} 4540 42760 0 0 {name=l34358 lab=WL214}
N 4640 42840 4660 42840 {}
C {lab_pin.sym} 4660 42840 0 0 {name=l34359 lab=VDD}
N 4640 42760 4660 42760 {}
C {lab_pin.sym} 4660 42760 0 0 {name=l34360 lab=VSS}
C {bitcell_6t.sym} 4800 42800 0 0 {name=Xr214c24}
N 4760 42840 4740 42840 {}
C {lab_pin.sym} 4740 42840 0 0 {name=l34361 lab=BL24}
N 4760 42800 4740 42800 {}
C {lab_pin.sym} 4740 42800 0 0 {name=l34362 lab=BLB24}
N 4760 42760 4740 42760 {}
C {lab_pin.sym} 4740 42760 0 0 {name=l34363 lab=WL214}
N 4840 42840 4860 42840 {}
C {lab_pin.sym} 4860 42840 0 0 {name=l34364 lab=VDD}
N 4840 42760 4860 42760 {}
C {lab_pin.sym} 4860 42760 0 0 {name=l34365 lab=VSS}
C {bitcell_6t.sym} 5000 42800 0 0 {name=Xr214c25}
N 4960 42840 4940 42840 {}
C {lab_pin.sym} 4940 42840 0 0 {name=l34366 lab=BL25}
N 4960 42800 4940 42800 {}
C {lab_pin.sym} 4940 42800 0 0 {name=l34367 lab=BLB25}
N 4960 42760 4940 42760 {}
C {lab_pin.sym} 4940 42760 0 0 {name=l34368 lab=WL214}
N 5040 42840 5060 42840 {}
C {lab_pin.sym} 5060 42840 0 0 {name=l34369 lab=VDD}
N 5040 42760 5060 42760 {}
C {lab_pin.sym} 5060 42760 0 0 {name=l34370 lab=VSS}
C {bitcell_6t.sym} 5200 42800 0 0 {name=Xr214c26}
N 5160 42840 5140 42840 {}
C {lab_pin.sym} 5140 42840 0 0 {name=l34371 lab=BL26}
N 5160 42800 5140 42800 {}
C {lab_pin.sym} 5140 42800 0 0 {name=l34372 lab=BLB26}
N 5160 42760 5140 42760 {}
C {lab_pin.sym} 5140 42760 0 0 {name=l34373 lab=WL214}
N 5240 42840 5260 42840 {}
C {lab_pin.sym} 5260 42840 0 0 {name=l34374 lab=VDD}
N 5240 42760 5260 42760 {}
C {lab_pin.sym} 5260 42760 0 0 {name=l34375 lab=VSS}
C {bitcell_6t.sym} 5400 42800 0 0 {name=Xr214c27}
N 5360 42840 5340 42840 {}
C {lab_pin.sym} 5340 42840 0 0 {name=l34376 lab=BL27}
N 5360 42800 5340 42800 {}
C {lab_pin.sym} 5340 42800 0 0 {name=l34377 lab=BLB27}
N 5360 42760 5340 42760 {}
C {lab_pin.sym} 5340 42760 0 0 {name=l34378 lab=WL214}
N 5440 42840 5460 42840 {}
C {lab_pin.sym} 5460 42840 0 0 {name=l34379 lab=VDD}
N 5440 42760 5460 42760 {}
C {lab_pin.sym} 5460 42760 0 0 {name=l34380 lab=VSS}
C {bitcell_6t.sym} 5600 42800 0 0 {name=Xr214c28}
N 5560 42840 5540 42840 {}
C {lab_pin.sym} 5540 42840 0 0 {name=l34381 lab=BL28}
N 5560 42800 5540 42800 {}
C {lab_pin.sym} 5540 42800 0 0 {name=l34382 lab=BLB28}
N 5560 42760 5540 42760 {}
C {lab_pin.sym} 5540 42760 0 0 {name=l34383 lab=WL214}
N 5640 42840 5660 42840 {}
C {lab_pin.sym} 5660 42840 0 0 {name=l34384 lab=VDD}
N 5640 42760 5660 42760 {}
C {lab_pin.sym} 5660 42760 0 0 {name=l34385 lab=VSS}
C {bitcell_6t.sym} 5800 42800 0 0 {name=Xr214c29}
N 5760 42840 5740 42840 {}
C {lab_pin.sym} 5740 42840 0 0 {name=l34386 lab=BL29}
N 5760 42800 5740 42800 {}
C {lab_pin.sym} 5740 42800 0 0 {name=l34387 lab=BLB29}
N 5760 42760 5740 42760 {}
C {lab_pin.sym} 5740 42760 0 0 {name=l34388 lab=WL214}
N 5840 42840 5860 42840 {}
C {lab_pin.sym} 5860 42840 0 0 {name=l34389 lab=VDD}
N 5840 42760 5860 42760 {}
C {lab_pin.sym} 5860 42760 0 0 {name=l34390 lab=VSS}
C {bitcell_6t.sym} 6000 42800 0 0 {name=Xr214c30}
N 5960 42840 5940 42840 {}
C {lab_pin.sym} 5940 42840 0 0 {name=l34391 lab=BL30}
N 5960 42800 5940 42800 {}
C {lab_pin.sym} 5940 42800 0 0 {name=l34392 lab=BLB30}
N 5960 42760 5940 42760 {}
C {lab_pin.sym} 5940 42760 0 0 {name=l34393 lab=WL214}
N 6040 42840 6060 42840 {}
C {lab_pin.sym} 6060 42840 0 0 {name=l34394 lab=VDD}
N 6040 42760 6060 42760 {}
C {lab_pin.sym} 6060 42760 0 0 {name=l34395 lab=VSS}
C {bitcell_6t.sym} 6200 42800 0 0 {name=Xr214c31}
N 6160 42840 6140 42840 {}
C {lab_pin.sym} 6140 42840 0 0 {name=l34396 lab=BL31}
N 6160 42800 6140 42800 {}
C {lab_pin.sym} 6140 42800 0 0 {name=l34397 lab=BLB31}
N 6160 42760 6140 42760 {}
C {lab_pin.sym} 6140 42760 0 0 {name=l34398 lab=WL214}
N 6240 42840 6260 42840 {}
C {lab_pin.sym} 6260 42840 0 0 {name=l34399 lab=VDD}
N 6240 42760 6260 42760 {}
C {lab_pin.sym} 6260 42760 0 0 {name=l34400 lab=VSS}
C {bitcell_6t.sym} 0 43000 0 0 {name=Xr215c0}
N -40 43040 -60 43040 {}
C {lab_pin.sym} -60 43040 0 0 {name=l34401 lab=BL0}
N -40 43000 -60 43000 {}
C {lab_pin.sym} -60 43000 0 0 {name=l34402 lab=BLB0}
N -40 42960 -60 42960 {}
C {lab_pin.sym} -60 42960 0 0 {name=l34403 lab=WL215}
N 40 43040 60 43040 {}
C {lab_pin.sym} 60 43040 0 0 {name=l34404 lab=VDD}
N 40 42960 60 42960 {}
C {lab_pin.sym} 60 42960 0 0 {name=l34405 lab=VSS}
C {bitcell_6t.sym} 200 43000 0 0 {name=Xr215c1}
N 160 43040 140 43040 {}
C {lab_pin.sym} 140 43040 0 0 {name=l34406 lab=BL1}
N 160 43000 140 43000 {}
C {lab_pin.sym} 140 43000 0 0 {name=l34407 lab=BLB1}
N 160 42960 140 42960 {}
C {lab_pin.sym} 140 42960 0 0 {name=l34408 lab=WL215}
N 240 43040 260 43040 {}
C {lab_pin.sym} 260 43040 0 0 {name=l34409 lab=VDD}
N 240 42960 260 42960 {}
C {lab_pin.sym} 260 42960 0 0 {name=l34410 lab=VSS}
C {bitcell_6t.sym} 400 43000 0 0 {name=Xr215c2}
N 360 43040 340 43040 {}
C {lab_pin.sym} 340 43040 0 0 {name=l34411 lab=BL2}
N 360 43000 340 43000 {}
C {lab_pin.sym} 340 43000 0 0 {name=l34412 lab=BLB2}
N 360 42960 340 42960 {}
C {lab_pin.sym} 340 42960 0 0 {name=l34413 lab=WL215}
N 440 43040 460 43040 {}
C {lab_pin.sym} 460 43040 0 0 {name=l34414 lab=VDD}
N 440 42960 460 42960 {}
C {lab_pin.sym} 460 42960 0 0 {name=l34415 lab=VSS}
C {bitcell_6t.sym} 600 43000 0 0 {name=Xr215c3}
N 560 43040 540 43040 {}
C {lab_pin.sym} 540 43040 0 0 {name=l34416 lab=BL3}
N 560 43000 540 43000 {}
C {lab_pin.sym} 540 43000 0 0 {name=l34417 lab=BLB3}
N 560 42960 540 42960 {}
C {lab_pin.sym} 540 42960 0 0 {name=l34418 lab=WL215}
N 640 43040 660 43040 {}
C {lab_pin.sym} 660 43040 0 0 {name=l34419 lab=VDD}
N 640 42960 660 42960 {}
C {lab_pin.sym} 660 42960 0 0 {name=l34420 lab=VSS}
C {bitcell_6t.sym} 800 43000 0 0 {name=Xr215c4}
N 760 43040 740 43040 {}
C {lab_pin.sym} 740 43040 0 0 {name=l34421 lab=BL4}
N 760 43000 740 43000 {}
C {lab_pin.sym} 740 43000 0 0 {name=l34422 lab=BLB4}
N 760 42960 740 42960 {}
C {lab_pin.sym} 740 42960 0 0 {name=l34423 lab=WL215}
N 840 43040 860 43040 {}
C {lab_pin.sym} 860 43040 0 0 {name=l34424 lab=VDD}
N 840 42960 860 42960 {}
C {lab_pin.sym} 860 42960 0 0 {name=l34425 lab=VSS}
C {bitcell_6t.sym} 1000 43000 0 0 {name=Xr215c5}
N 960 43040 940 43040 {}
C {lab_pin.sym} 940 43040 0 0 {name=l34426 lab=BL5}
N 960 43000 940 43000 {}
C {lab_pin.sym} 940 43000 0 0 {name=l34427 lab=BLB5}
N 960 42960 940 42960 {}
C {lab_pin.sym} 940 42960 0 0 {name=l34428 lab=WL215}
N 1040 43040 1060 43040 {}
C {lab_pin.sym} 1060 43040 0 0 {name=l34429 lab=VDD}
N 1040 42960 1060 42960 {}
C {lab_pin.sym} 1060 42960 0 0 {name=l34430 lab=VSS}
C {bitcell_6t.sym} 1200 43000 0 0 {name=Xr215c6}
N 1160 43040 1140 43040 {}
C {lab_pin.sym} 1140 43040 0 0 {name=l34431 lab=BL6}
N 1160 43000 1140 43000 {}
C {lab_pin.sym} 1140 43000 0 0 {name=l34432 lab=BLB6}
N 1160 42960 1140 42960 {}
C {lab_pin.sym} 1140 42960 0 0 {name=l34433 lab=WL215}
N 1240 43040 1260 43040 {}
C {lab_pin.sym} 1260 43040 0 0 {name=l34434 lab=VDD}
N 1240 42960 1260 42960 {}
C {lab_pin.sym} 1260 42960 0 0 {name=l34435 lab=VSS}
C {bitcell_6t.sym} 1400 43000 0 0 {name=Xr215c7}
N 1360 43040 1340 43040 {}
C {lab_pin.sym} 1340 43040 0 0 {name=l34436 lab=BL7}
N 1360 43000 1340 43000 {}
C {lab_pin.sym} 1340 43000 0 0 {name=l34437 lab=BLB7}
N 1360 42960 1340 42960 {}
C {lab_pin.sym} 1340 42960 0 0 {name=l34438 lab=WL215}
N 1440 43040 1460 43040 {}
C {lab_pin.sym} 1460 43040 0 0 {name=l34439 lab=VDD}
N 1440 42960 1460 42960 {}
C {lab_pin.sym} 1460 42960 0 0 {name=l34440 lab=VSS}
C {bitcell_6t.sym} 1600 43000 0 0 {name=Xr215c8}
N 1560 43040 1540 43040 {}
C {lab_pin.sym} 1540 43040 0 0 {name=l34441 lab=BL8}
N 1560 43000 1540 43000 {}
C {lab_pin.sym} 1540 43000 0 0 {name=l34442 lab=BLB8}
N 1560 42960 1540 42960 {}
C {lab_pin.sym} 1540 42960 0 0 {name=l34443 lab=WL215}
N 1640 43040 1660 43040 {}
C {lab_pin.sym} 1660 43040 0 0 {name=l34444 lab=VDD}
N 1640 42960 1660 42960 {}
C {lab_pin.sym} 1660 42960 0 0 {name=l34445 lab=VSS}
C {bitcell_6t.sym} 1800 43000 0 0 {name=Xr215c9}
N 1760 43040 1740 43040 {}
C {lab_pin.sym} 1740 43040 0 0 {name=l34446 lab=BL9}
N 1760 43000 1740 43000 {}
C {lab_pin.sym} 1740 43000 0 0 {name=l34447 lab=BLB9}
N 1760 42960 1740 42960 {}
C {lab_pin.sym} 1740 42960 0 0 {name=l34448 lab=WL215}
N 1840 43040 1860 43040 {}
C {lab_pin.sym} 1860 43040 0 0 {name=l34449 lab=VDD}
N 1840 42960 1860 42960 {}
C {lab_pin.sym} 1860 42960 0 0 {name=l34450 lab=VSS}
C {bitcell_6t.sym} 2000 43000 0 0 {name=Xr215c10}
N 1960 43040 1940 43040 {}
C {lab_pin.sym} 1940 43040 0 0 {name=l34451 lab=BL10}
N 1960 43000 1940 43000 {}
C {lab_pin.sym} 1940 43000 0 0 {name=l34452 lab=BLB10}
N 1960 42960 1940 42960 {}
C {lab_pin.sym} 1940 42960 0 0 {name=l34453 lab=WL215}
N 2040 43040 2060 43040 {}
C {lab_pin.sym} 2060 43040 0 0 {name=l34454 lab=VDD}
N 2040 42960 2060 42960 {}
C {lab_pin.sym} 2060 42960 0 0 {name=l34455 lab=VSS}
C {bitcell_6t.sym} 2200 43000 0 0 {name=Xr215c11}
N 2160 43040 2140 43040 {}
C {lab_pin.sym} 2140 43040 0 0 {name=l34456 lab=BL11}
N 2160 43000 2140 43000 {}
C {lab_pin.sym} 2140 43000 0 0 {name=l34457 lab=BLB11}
N 2160 42960 2140 42960 {}
C {lab_pin.sym} 2140 42960 0 0 {name=l34458 lab=WL215}
N 2240 43040 2260 43040 {}
C {lab_pin.sym} 2260 43040 0 0 {name=l34459 lab=VDD}
N 2240 42960 2260 42960 {}
C {lab_pin.sym} 2260 42960 0 0 {name=l34460 lab=VSS}
C {bitcell_6t.sym} 2400 43000 0 0 {name=Xr215c12}
N 2360 43040 2340 43040 {}
C {lab_pin.sym} 2340 43040 0 0 {name=l34461 lab=BL12}
N 2360 43000 2340 43000 {}
C {lab_pin.sym} 2340 43000 0 0 {name=l34462 lab=BLB12}
N 2360 42960 2340 42960 {}
C {lab_pin.sym} 2340 42960 0 0 {name=l34463 lab=WL215}
N 2440 43040 2460 43040 {}
C {lab_pin.sym} 2460 43040 0 0 {name=l34464 lab=VDD}
N 2440 42960 2460 42960 {}
C {lab_pin.sym} 2460 42960 0 0 {name=l34465 lab=VSS}
C {bitcell_6t.sym} 2600 43000 0 0 {name=Xr215c13}
N 2560 43040 2540 43040 {}
C {lab_pin.sym} 2540 43040 0 0 {name=l34466 lab=BL13}
N 2560 43000 2540 43000 {}
C {lab_pin.sym} 2540 43000 0 0 {name=l34467 lab=BLB13}
N 2560 42960 2540 42960 {}
C {lab_pin.sym} 2540 42960 0 0 {name=l34468 lab=WL215}
N 2640 43040 2660 43040 {}
C {lab_pin.sym} 2660 43040 0 0 {name=l34469 lab=VDD}
N 2640 42960 2660 42960 {}
C {lab_pin.sym} 2660 42960 0 0 {name=l34470 lab=VSS}
C {bitcell_6t.sym} 2800 43000 0 0 {name=Xr215c14}
N 2760 43040 2740 43040 {}
C {lab_pin.sym} 2740 43040 0 0 {name=l34471 lab=BL14}
N 2760 43000 2740 43000 {}
C {lab_pin.sym} 2740 43000 0 0 {name=l34472 lab=BLB14}
N 2760 42960 2740 42960 {}
C {lab_pin.sym} 2740 42960 0 0 {name=l34473 lab=WL215}
N 2840 43040 2860 43040 {}
C {lab_pin.sym} 2860 43040 0 0 {name=l34474 lab=VDD}
N 2840 42960 2860 42960 {}
C {lab_pin.sym} 2860 42960 0 0 {name=l34475 lab=VSS}
C {bitcell_6t.sym} 3000 43000 0 0 {name=Xr215c15}
N 2960 43040 2940 43040 {}
C {lab_pin.sym} 2940 43040 0 0 {name=l34476 lab=BL15}
N 2960 43000 2940 43000 {}
C {lab_pin.sym} 2940 43000 0 0 {name=l34477 lab=BLB15}
N 2960 42960 2940 42960 {}
C {lab_pin.sym} 2940 42960 0 0 {name=l34478 lab=WL215}
N 3040 43040 3060 43040 {}
C {lab_pin.sym} 3060 43040 0 0 {name=l34479 lab=VDD}
N 3040 42960 3060 42960 {}
C {lab_pin.sym} 3060 42960 0 0 {name=l34480 lab=VSS}
C {bitcell_6t.sym} 3200 43000 0 0 {name=Xr215c16}
N 3160 43040 3140 43040 {}
C {lab_pin.sym} 3140 43040 0 0 {name=l34481 lab=BL16}
N 3160 43000 3140 43000 {}
C {lab_pin.sym} 3140 43000 0 0 {name=l34482 lab=BLB16}
N 3160 42960 3140 42960 {}
C {lab_pin.sym} 3140 42960 0 0 {name=l34483 lab=WL215}
N 3240 43040 3260 43040 {}
C {lab_pin.sym} 3260 43040 0 0 {name=l34484 lab=VDD}
N 3240 42960 3260 42960 {}
C {lab_pin.sym} 3260 42960 0 0 {name=l34485 lab=VSS}
C {bitcell_6t.sym} 3400 43000 0 0 {name=Xr215c17}
N 3360 43040 3340 43040 {}
C {lab_pin.sym} 3340 43040 0 0 {name=l34486 lab=BL17}
N 3360 43000 3340 43000 {}
C {lab_pin.sym} 3340 43000 0 0 {name=l34487 lab=BLB17}
N 3360 42960 3340 42960 {}
C {lab_pin.sym} 3340 42960 0 0 {name=l34488 lab=WL215}
N 3440 43040 3460 43040 {}
C {lab_pin.sym} 3460 43040 0 0 {name=l34489 lab=VDD}
N 3440 42960 3460 42960 {}
C {lab_pin.sym} 3460 42960 0 0 {name=l34490 lab=VSS}
C {bitcell_6t.sym} 3600 43000 0 0 {name=Xr215c18}
N 3560 43040 3540 43040 {}
C {lab_pin.sym} 3540 43040 0 0 {name=l34491 lab=BL18}
N 3560 43000 3540 43000 {}
C {lab_pin.sym} 3540 43000 0 0 {name=l34492 lab=BLB18}
N 3560 42960 3540 42960 {}
C {lab_pin.sym} 3540 42960 0 0 {name=l34493 lab=WL215}
N 3640 43040 3660 43040 {}
C {lab_pin.sym} 3660 43040 0 0 {name=l34494 lab=VDD}
N 3640 42960 3660 42960 {}
C {lab_pin.sym} 3660 42960 0 0 {name=l34495 lab=VSS}
C {bitcell_6t.sym} 3800 43000 0 0 {name=Xr215c19}
N 3760 43040 3740 43040 {}
C {lab_pin.sym} 3740 43040 0 0 {name=l34496 lab=BL19}
N 3760 43000 3740 43000 {}
C {lab_pin.sym} 3740 43000 0 0 {name=l34497 lab=BLB19}
N 3760 42960 3740 42960 {}
C {lab_pin.sym} 3740 42960 0 0 {name=l34498 lab=WL215}
N 3840 43040 3860 43040 {}
C {lab_pin.sym} 3860 43040 0 0 {name=l34499 lab=VDD}
N 3840 42960 3860 42960 {}
C {lab_pin.sym} 3860 42960 0 0 {name=l34500 lab=VSS}
C {bitcell_6t.sym} 4000 43000 0 0 {name=Xr215c20}
N 3960 43040 3940 43040 {}
C {lab_pin.sym} 3940 43040 0 0 {name=l34501 lab=BL20}
N 3960 43000 3940 43000 {}
C {lab_pin.sym} 3940 43000 0 0 {name=l34502 lab=BLB20}
N 3960 42960 3940 42960 {}
C {lab_pin.sym} 3940 42960 0 0 {name=l34503 lab=WL215}
N 4040 43040 4060 43040 {}
C {lab_pin.sym} 4060 43040 0 0 {name=l34504 lab=VDD}
N 4040 42960 4060 42960 {}
C {lab_pin.sym} 4060 42960 0 0 {name=l34505 lab=VSS}
C {bitcell_6t.sym} 4200 43000 0 0 {name=Xr215c21}
N 4160 43040 4140 43040 {}
C {lab_pin.sym} 4140 43040 0 0 {name=l34506 lab=BL21}
N 4160 43000 4140 43000 {}
C {lab_pin.sym} 4140 43000 0 0 {name=l34507 lab=BLB21}
N 4160 42960 4140 42960 {}
C {lab_pin.sym} 4140 42960 0 0 {name=l34508 lab=WL215}
N 4240 43040 4260 43040 {}
C {lab_pin.sym} 4260 43040 0 0 {name=l34509 lab=VDD}
N 4240 42960 4260 42960 {}
C {lab_pin.sym} 4260 42960 0 0 {name=l34510 lab=VSS}
C {bitcell_6t.sym} 4400 43000 0 0 {name=Xr215c22}
N 4360 43040 4340 43040 {}
C {lab_pin.sym} 4340 43040 0 0 {name=l34511 lab=BL22}
N 4360 43000 4340 43000 {}
C {lab_pin.sym} 4340 43000 0 0 {name=l34512 lab=BLB22}
N 4360 42960 4340 42960 {}
C {lab_pin.sym} 4340 42960 0 0 {name=l34513 lab=WL215}
N 4440 43040 4460 43040 {}
C {lab_pin.sym} 4460 43040 0 0 {name=l34514 lab=VDD}
N 4440 42960 4460 42960 {}
C {lab_pin.sym} 4460 42960 0 0 {name=l34515 lab=VSS}
C {bitcell_6t.sym} 4600 43000 0 0 {name=Xr215c23}
N 4560 43040 4540 43040 {}
C {lab_pin.sym} 4540 43040 0 0 {name=l34516 lab=BL23}
N 4560 43000 4540 43000 {}
C {lab_pin.sym} 4540 43000 0 0 {name=l34517 lab=BLB23}
N 4560 42960 4540 42960 {}
C {lab_pin.sym} 4540 42960 0 0 {name=l34518 lab=WL215}
N 4640 43040 4660 43040 {}
C {lab_pin.sym} 4660 43040 0 0 {name=l34519 lab=VDD}
N 4640 42960 4660 42960 {}
C {lab_pin.sym} 4660 42960 0 0 {name=l34520 lab=VSS}
C {bitcell_6t.sym} 4800 43000 0 0 {name=Xr215c24}
N 4760 43040 4740 43040 {}
C {lab_pin.sym} 4740 43040 0 0 {name=l34521 lab=BL24}
N 4760 43000 4740 43000 {}
C {lab_pin.sym} 4740 43000 0 0 {name=l34522 lab=BLB24}
N 4760 42960 4740 42960 {}
C {lab_pin.sym} 4740 42960 0 0 {name=l34523 lab=WL215}
N 4840 43040 4860 43040 {}
C {lab_pin.sym} 4860 43040 0 0 {name=l34524 lab=VDD}
N 4840 42960 4860 42960 {}
C {lab_pin.sym} 4860 42960 0 0 {name=l34525 lab=VSS}
C {bitcell_6t.sym} 5000 43000 0 0 {name=Xr215c25}
N 4960 43040 4940 43040 {}
C {lab_pin.sym} 4940 43040 0 0 {name=l34526 lab=BL25}
N 4960 43000 4940 43000 {}
C {lab_pin.sym} 4940 43000 0 0 {name=l34527 lab=BLB25}
N 4960 42960 4940 42960 {}
C {lab_pin.sym} 4940 42960 0 0 {name=l34528 lab=WL215}
N 5040 43040 5060 43040 {}
C {lab_pin.sym} 5060 43040 0 0 {name=l34529 lab=VDD}
N 5040 42960 5060 42960 {}
C {lab_pin.sym} 5060 42960 0 0 {name=l34530 lab=VSS}
C {bitcell_6t.sym} 5200 43000 0 0 {name=Xr215c26}
N 5160 43040 5140 43040 {}
C {lab_pin.sym} 5140 43040 0 0 {name=l34531 lab=BL26}
N 5160 43000 5140 43000 {}
C {lab_pin.sym} 5140 43000 0 0 {name=l34532 lab=BLB26}
N 5160 42960 5140 42960 {}
C {lab_pin.sym} 5140 42960 0 0 {name=l34533 lab=WL215}
N 5240 43040 5260 43040 {}
C {lab_pin.sym} 5260 43040 0 0 {name=l34534 lab=VDD}
N 5240 42960 5260 42960 {}
C {lab_pin.sym} 5260 42960 0 0 {name=l34535 lab=VSS}
C {bitcell_6t.sym} 5400 43000 0 0 {name=Xr215c27}
N 5360 43040 5340 43040 {}
C {lab_pin.sym} 5340 43040 0 0 {name=l34536 lab=BL27}
N 5360 43000 5340 43000 {}
C {lab_pin.sym} 5340 43000 0 0 {name=l34537 lab=BLB27}
N 5360 42960 5340 42960 {}
C {lab_pin.sym} 5340 42960 0 0 {name=l34538 lab=WL215}
N 5440 43040 5460 43040 {}
C {lab_pin.sym} 5460 43040 0 0 {name=l34539 lab=VDD}
N 5440 42960 5460 42960 {}
C {lab_pin.sym} 5460 42960 0 0 {name=l34540 lab=VSS}
C {bitcell_6t.sym} 5600 43000 0 0 {name=Xr215c28}
N 5560 43040 5540 43040 {}
C {lab_pin.sym} 5540 43040 0 0 {name=l34541 lab=BL28}
N 5560 43000 5540 43000 {}
C {lab_pin.sym} 5540 43000 0 0 {name=l34542 lab=BLB28}
N 5560 42960 5540 42960 {}
C {lab_pin.sym} 5540 42960 0 0 {name=l34543 lab=WL215}
N 5640 43040 5660 43040 {}
C {lab_pin.sym} 5660 43040 0 0 {name=l34544 lab=VDD}
N 5640 42960 5660 42960 {}
C {lab_pin.sym} 5660 42960 0 0 {name=l34545 lab=VSS}
C {bitcell_6t.sym} 5800 43000 0 0 {name=Xr215c29}
N 5760 43040 5740 43040 {}
C {lab_pin.sym} 5740 43040 0 0 {name=l34546 lab=BL29}
N 5760 43000 5740 43000 {}
C {lab_pin.sym} 5740 43000 0 0 {name=l34547 lab=BLB29}
N 5760 42960 5740 42960 {}
C {lab_pin.sym} 5740 42960 0 0 {name=l34548 lab=WL215}
N 5840 43040 5860 43040 {}
C {lab_pin.sym} 5860 43040 0 0 {name=l34549 lab=VDD}
N 5840 42960 5860 42960 {}
C {lab_pin.sym} 5860 42960 0 0 {name=l34550 lab=VSS}
C {bitcell_6t.sym} 6000 43000 0 0 {name=Xr215c30}
N 5960 43040 5940 43040 {}
C {lab_pin.sym} 5940 43040 0 0 {name=l34551 lab=BL30}
N 5960 43000 5940 43000 {}
C {lab_pin.sym} 5940 43000 0 0 {name=l34552 lab=BLB30}
N 5960 42960 5940 42960 {}
C {lab_pin.sym} 5940 42960 0 0 {name=l34553 lab=WL215}
N 6040 43040 6060 43040 {}
C {lab_pin.sym} 6060 43040 0 0 {name=l34554 lab=VDD}
N 6040 42960 6060 42960 {}
C {lab_pin.sym} 6060 42960 0 0 {name=l34555 lab=VSS}
C {bitcell_6t.sym} 6200 43000 0 0 {name=Xr215c31}
N 6160 43040 6140 43040 {}
C {lab_pin.sym} 6140 43040 0 0 {name=l34556 lab=BL31}
N 6160 43000 6140 43000 {}
C {lab_pin.sym} 6140 43000 0 0 {name=l34557 lab=BLB31}
N 6160 42960 6140 42960 {}
C {lab_pin.sym} 6140 42960 0 0 {name=l34558 lab=WL215}
N 6240 43040 6260 43040 {}
C {lab_pin.sym} 6260 43040 0 0 {name=l34559 lab=VDD}
N 6240 42960 6260 42960 {}
C {lab_pin.sym} 6260 42960 0 0 {name=l34560 lab=VSS}
C {bitcell_6t.sym} 0 43200 0 0 {name=Xr216c0}
N -40 43240 -60 43240 {}
C {lab_pin.sym} -60 43240 0 0 {name=l34561 lab=BL0}
N -40 43200 -60 43200 {}
C {lab_pin.sym} -60 43200 0 0 {name=l34562 lab=BLB0}
N -40 43160 -60 43160 {}
C {lab_pin.sym} -60 43160 0 0 {name=l34563 lab=WL216}
N 40 43240 60 43240 {}
C {lab_pin.sym} 60 43240 0 0 {name=l34564 lab=VDD}
N 40 43160 60 43160 {}
C {lab_pin.sym} 60 43160 0 0 {name=l34565 lab=VSS}
C {bitcell_6t.sym} 200 43200 0 0 {name=Xr216c1}
N 160 43240 140 43240 {}
C {lab_pin.sym} 140 43240 0 0 {name=l34566 lab=BL1}
N 160 43200 140 43200 {}
C {lab_pin.sym} 140 43200 0 0 {name=l34567 lab=BLB1}
N 160 43160 140 43160 {}
C {lab_pin.sym} 140 43160 0 0 {name=l34568 lab=WL216}
N 240 43240 260 43240 {}
C {lab_pin.sym} 260 43240 0 0 {name=l34569 lab=VDD}
N 240 43160 260 43160 {}
C {lab_pin.sym} 260 43160 0 0 {name=l34570 lab=VSS}
C {bitcell_6t.sym} 400 43200 0 0 {name=Xr216c2}
N 360 43240 340 43240 {}
C {lab_pin.sym} 340 43240 0 0 {name=l34571 lab=BL2}
N 360 43200 340 43200 {}
C {lab_pin.sym} 340 43200 0 0 {name=l34572 lab=BLB2}
N 360 43160 340 43160 {}
C {lab_pin.sym} 340 43160 0 0 {name=l34573 lab=WL216}
N 440 43240 460 43240 {}
C {lab_pin.sym} 460 43240 0 0 {name=l34574 lab=VDD}
N 440 43160 460 43160 {}
C {lab_pin.sym} 460 43160 0 0 {name=l34575 lab=VSS}
C {bitcell_6t.sym} 600 43200 0 0 {name=Xr216c3}
N 560 43240 540 43240 {}
C {lab_pin.sym} 540 43240 0 0 {name=l34576 lab=BL3}
N 560 43200 540 43200 {}
C {lab_pin.sym} 540 43200 0 0 {name=l34577 lab=BLB3}
N 560 43160 540 43160 {}
C {lab_pin.sym} 540 43160 0 0 {name=l34578 lab=WL216}
N 640 43240 660 43240 {}
C {lab_pin.sym} 660 43240 0 0 {name=l34579 lab=VDD}
N 640 43160 660 43160 {}
C {lab_pin.sym} 660 43160 0 0 {name=l34580 lab=VSS}
C {bitcell_6t.sym} 800 43200 0 0 {name=Xr216c4}
N 760 43240 740 43240 {}
C {lab_pin.sym} 740 43240 0 0 {name=l34581 lab=BL4}
N 760 43200 740 43200 {}
C {lab_pin.sym} 740 43200 0 0 {name=l34582 lab=BLB4}
N 760 43160 740 43160 {}
C {lab_pin.sym} 740 43160 0 0 {name=l34583 lab=WL216}
N 840 43240 860 43240 {}
C {lab_pin.sym} 860 43240 0 0 {name=l34584 lab=VDD}
N 840 43160 860 43160 {}
C {lab_pin.sym} 860 43160 0 0 {name=l34585 lab=VSS}
C {bitcell_6t.sym} 1000 43200 0 0 {name=Xr216c5}
N 960 43240 940 43240 {}
C {lab_pin.sym} 940 43240 0 0 {name=l34586 lab=BL5}
N 960 43200 940 43200 {}
C {lab_pin.sym} 940 43200 0 0 {name=l34587 lab=BLB5}
N 960 43160 940 43160 {}
C {lab_pin.sym} 940 43160 0 0 {name=l34588 lab=WL216}
N 1040 43240 1060 43240 {}
C {lab_pin.sym} 1060 43240 0 0 {name=l34589 lab=VDD}
N 1040 43160 1060 43160 {}
C {lab_pin.sym} 1060 43160 0 0 {name=l34590 lab=VSS}
C {bitcell_6t.sym} 1200 43200 0 0 {name=Xr216c6}
N 1160 43240 1140 43240 {}
C {lab_pin.sym} 1140 43240 0 0 {name=l34591 lab=BL6}
N 1160 43200 1140 43200 {}
C {lab_pin.sym} 1140 43200 0 0 {name=l34592 lab=BLB6}
N 1160 43160 1140 43160 {}
C {lab_pin.sym} 1140 43160 0 0 {name=l34593 lab=WL216}
N 1240 43240 1260 43240 {}
C {lab_pin.sym} 1260 43240 0 0 {name=l34594 lab=VDD}
N 1240 43160 1260 43160 {}
C {lab_pin.sym} 1260 43160 0 0 {name=l34595 lab=VSS}
C {bitcell_6t.sym} 1400 43200 0 0 {name=Xr216c7}
N 1360 43240 1340 43240 {}
C {lab_pin.sym} 1340 43240 0 0 {name=l34596 lab=BL7}
N 1360 43200 1340 43200 {}
C {lab_pin.sym} 1340 43200 0 0 {name=l34597 lab=BLB7}
N 1360 43160 1340 43160 {}
C {lab_pin.sym} 1340 43160 0 0 {name=l34598 lab=WL216}
N 1440 43240 1460 43240 {}
C {lab_pin.sym} 1460 43240 0 0 {name=l34599 lab=VDD}
N 1440 43160 1460 43160 {}
C {lab_pin.sym} 1460 43160 0 0 {name=l34600 lab=VSS}
C {bitcell_6t.sym} 1600 43200 0 0 {name=Xr216c8}
N 1560 43240 1540 43240 {}
C {lab_pin.sym} 1540 43240 0 0 {name=l34601 lab=BL8}
N 1560 43200 1540 43200 {}
C {lab_pin.sym} 1540 43200 0 0 {name=l34602 lab=BLB8}
N 1560 43160 1540 43160 {}
C {lab_pin.sym} 1540 43160 0 0 {name=l34603 lab=WL216}
N 1640 43240 1660 43240 {}
C {lab_pin.sym} 1660 43240 0 0 {name=l34604 lab=VDD}
N 1640 43160 1660 43160 {}
C {lab_pin.sym} 1660 43160 0 0 {name=l34605 lab=VSS}
C {bitcell_6t.sym} 1800 43200 0 0 {name=Xr216c9}
N 1760 43240 1740 43240 {}
C {lab_pin.sym} 1740 43240 0 0 {name=l34606 lab=BL9}
N 1760 43200 1740 43200 {}
C {lab_pin.sym} 1740 43200 0 0 {name=l34607 lab=BLB9}
N 1760 43160 1740 43160 {}
C {lab_pin.sym} 1740 43160 0 0 {name=l34608 lab=WL216}
N 1840 43240 1860 43240 {}
C {lab_pin.sym} 1860 43240 0 0 {name=l34609 lab=VDD}
N 1840 43160 1860 43160 {}
C {lab_pin.sym} 1860 43160 0 0 {name=l34610 lab=VSS}
C {bitcell_6t.sym} 2000 43200 0 0 {name=Xr216c10}
N 1960 43240 1940 43240 {}
C {lab_pin.sym} 1940 43240 0 0 {name=l34611 lab=BL10}
N 1960 43200 1940 43200 {}
C {lab_pin.sym} 1940 43200 0 0 {name=l34612 lab=BLB10}
N 1960 43160 1940 43160 {}
C {lab_pin.sym} 1940 43160 0 0 {name=l34613 lab=WL216}
N 2040 43240 2060 43240 {}
C {lab_pin.sym} 2060 43240 0 0 {name=l34614 lab=VDD}
N 2040 43160 2060 43160 {}
C {lab_pin.sym} 2060 43160 0 0 {name=l34615 lab=VSS}
C {bitcell_6t.sym} 2200 43200 0 0 {name=Xr216c11}
N 2160 43240 2140 43240 {}
C {lab_pin.sym} 2140 43240 0 0 {name=l34616 lab=BL11}
N 2160 43200 2140 43200 {}
C {lab_pin.sym} 2140 43200 0 0 {name=l34617 lab=BLB11}
N 2160 43160 2140 43160 {}
C {lab_pin.sym} 2140 43160 0 0 {name=l34618 lab=WL216}
N 2240 43240 2260 43240 {}
C {lab_pin.sym} 2260 43240 0 0 {name=l34619 lab=VDD}
N 2240 43160 2260 43160 {}
C {lab_pin.sym} 2260 43160 0 0 {name=l34620 lab=VSS}
C {bitcell_6t.sym} 2400 43200 0 0 {name=Xr216c12}
N 2360 43240 2340 43240 {}
C {lab_pin.sym} 2340 43240 0 0 {name=l34621 lab=BL12}
N 2360 43200 2340 43200 {}
C {lab_pin.sym} 2340 43200 0 0 {name=l34622 lab=BLB12}
N 2360 43160 2340 43160 {}
C {lab_pin.sym} 2340 43160 0 0 {name=l34623 lab=WL216}
N 2440 43240 2460 43240 {}
C {lab_pin.sym} 2460 43240 0 0 {name=l34624 lab=VDD}
N 2440 43160 2460 43160 {}
C {lab_pin.sym} 2460 43160 0 0 {name=l34625 lab=VSS}
C {bitcell_6t.sym} 2600 43200 0 0 {name=Xr216c13}
N 2560 43240 2540 43240 {}
C {lab_pin.sym} 2540 43240 0 0 {name=l34626 lab=BL13}
N 2560 43200 2540 43200 {}
C {lab_pin.sym} 2540 43200 0 0 {name=l34627 lab=BLB13}
N 2560 43160 2540 43160 {}
C {lab_pin.sym} 2540 43160 0 0 {name=l34628 lab=WL216}
N 2640 43240 2660 43240 {}
C {lab_pin.sym} 2660 43240 0 0 {name=l34629 lab=VDD}
N 2640 43160 2660 43160 {}
C {lab_pin.sym} 2660 43160 0 0 {name=l34630 lab=VSS}
C {bitcell_6t.sym} 2800 43200 0 0 {name=Xr216c14}
N 2760 43240 2740 43240 {}
C {lab_pin.sym} 2740 43240 0 0 {name=l34631 lab=BL14}
N 2760 43200 2740 43200 {}
C {lab_pin.sym} 2740 43200 0 0 {name=l34632 lab=BLB14}
N 2760 43160 2740 43160 {}
C {lab_pin.sym} 2740 43160 0 0 {name=l34633 lab=WL216}
N 2840 43240 2860 43240 {}
C {lab_pin.sym} 2860 43240 0 0 {name=l34634 lab=VDD}
N 2840 43160 2860 43160 {}
C {lab_pin.sym} 2860 43160 0 0 {name=l34635 lab=VSS}
C {bitcell_6t.sym} 3000 43200 0 0 {name=Xr216c15}
N 2960 43240 2940 43240 {}
C {lab_pin.sym} 2940 43240 0 0 {name=l34636 lab=BL15}
N 2960 43200 2940 43200 {}
C {lab_pin.sym} 2940 43200 0 0 {name=l34637 lab=BLB15}
N 2960 43160 2940 43160 {}
C {lab_pin.sym} 2940 43160 0 0 {name=l34638 lab=WL216}
N 3040 43240 3060 43240 {}
C {lab_pin.sym} 3060 43240 0 0 {name=l34639 lab=VDD}
N 3040 43160 3060 43160 {}
C {lab_pin.sym} 3060 43160 0 0 {name=l34640 lab=VSS}
C {bitcell_6t.sym} 3200 43200 0 0 {name=Xr216c16}
N 3160 43240 3140 43240 {}
C {lab_pin.sym} 3140 43240 0 0 {name=l34641 lab=BL16}
N 3160 43200 3140 43200 {}
C {lab_pin.sym} 3140 43200 0 0 {name=l34642 lab=BLB16}
N 3160 43160 3140 43160 {}
C {lab_pin.sym} 3140 43160 0 0 {name=l34643 lab=WL216}
N 3240 43240 3260 43240 {}
C {lab_pin.sym} 3260 43240 0 0 {name=l34644 lab=VDD}
N 3240 43160 3260 43160 {}
C {lab_pin.sym} 3260 43160 0 0 {name=l34645 lab=VSS}
C {bitcell_6t.sym} 3400 43200 0 0 {name=Xr216c17}
N 3360 43240 3340 43240 {}
C {lab_pin.sym} 3340 43240 0 0 {name=l34646 lab=BL17}
N 3360 43200 3340 43200 {}
C {lab_pin.sym} 3340 43200 0 0 {name=l34647 lab=BLB17}
N 3360 43160 3340 43160 {}
C {lab_pin.sym} 3340 43160 0 0 {name=l34648 lab=WL216}
N 3440 43240 3460 43240 {}
C {lab_pin.sym} 3460 43240 0 0 {name=l34649 lab=VDD}
N 3440 43160 3460 43160 {}
C {lab_pin.sym} 3460 43160 0 0 {name=l34650 lab=VSS}
C {bitcell_6t.sym} 3600 43200 0 0 {name=Xr216c18}
N 3560 43240 3540 43240 {}
C {lab_pin.sym} 3540 43240 0 0 {name=l34651 lab=BL18}
N 3560 43200 3540 43200 {}
C {lab_pin.sym} 3540 43200 0 0 {name=l34652 lab=BLB18}
N 3560 43160 3540 43160 {}
C {lab_pin.sym} 3540 43160 0 0 {name=l34653 lab=WL216}
N 3640 43240 3660 43240 {}
C {lab_pin.sym} 3660 43240 0 0 {name=l34654 lab=VDD}
N 3640 43160 3660 43160 {}
C {lab_pin.sym} 3660 43160 0 0 {name=l34655 lab=VSS}
C {bitcell_6t.sym} 3800 43200 0 0 {name=Xr216c19}
N 3760 43240 3740 43240 {}
C {lab_pin.sym} 3740 43240 0 0 {name=l34656 lab=BL19}
N 3760 43200 3740 43200 {}
C {lab_pin.sym} 3740 43200 0 0 {name=l34657 lab=BLB19}
N 3760 43160 3740 43160 {}
C {lab_pin.sym} 3740 43160 0 0 {name=l34658 lab=WL216}
N 3840 43240 3860 43240 {}
C {lab_pin.sym} 3860 43240 0 0 {name=l34659 lab=VDD}
N 3840 43160 3860 43160 {}
C {lab_pin.sym} 3860 43160 0 0 {name=l34660 lab=VSS}
C {bitcell_6t.sym} 4000 43200 0 0 {name=Xr216c20}
N 3960 43240 3940 43240 {}
C {lab_pin.sym} 3940 43240 0 0 {name=l34661 lab=BL20}
N 3960 43200 3940 43200 {}
C {lab_pin.sym} 3940 43200 0 0 {name=l34662 lab=BLB20}
N 3960 43160 3940 43160 {}
C {lab_pin.sym} 3940 43160 0 0 {name=l34663 lab=WL216}
N 4040 43240 4060 43240 {}
C {lab_pin.sym} 4060 43240 0 0 {name=l34664 lab=VDD}
N 4040 43160 4060 43160 {}
C {lab_pin.sym} 4060 43160 0 0 {name=l34665 lab=VSS}
C {bitcell_6t.sym} 4200 43200 0 0 {name=Xr216c21}
N 4160 43240 4140 43240 {}
C {lab_pin.sym} 4140 43240 0 0 {name=l34666 lab=BL21}
N 4160 43200 4140 43200 {}
C {lab_pin.sym} 4140 43200 0 0 {name=l34667 lab=BLB21}
N 4160 43160 4140 43160 {}
C {lab_pin.sym} 4140 43160 0 0 {name=l34668 lab=WL216}
N 4240 43240 4260 43240 {}
C {lab_pin.sym} 4260 43240 0 0 {name=l34669 lab=VDD}
N 4240 43160 4260 43160 {}
C {lab_pin.sym} 4260 43160 0 0 {name=l34670 lab=VSS}
C {bitcell_6t.sym} 4400 43200 0 0 {name=Xr216c22}
N 4360 43240 4340 43240 {}
C {lab_pin.sym} 4340 43240 0 0 {name=l34671 lab=BL22}
N 4360 43200 4340 43200 {}
C {lab_pin.sym} 4340 43200 0 0 {name=l34672 lab=BLB22}
N 4360 43160 4340 43160 {}
C {lab_pin.sym} 4340 43160 0 0 {name=l34673 lab=WL216}
N 4440 43240 4460 43240 {}
C {lab_pin.sym} 4460 43240 0 0 {name=l34674 lab=VDD}
N 4440 43160 4460 43160 {}
C {lab_pin.sym} 4460 43160 0 0 {name=l34675 lab=VSS}
C {bitcell_6t.sym} 4600 43200 0 0 {name=Xr216c23}
N 4560 43240 4540 43240 {}
C {lab_pin.sym} 4540 43240 0 0 {name=l34676 lab=BL23}
N 4560 43200 4540 43200 {}
C {lab_pin.sym} 4540 43200 0 0 {name=l34677 lab=BLB23}
N 4560 43160 4540 43160 {}
C {lab_pin.sym} 4540 43160 0 0 {name=l34678 lab=WL216}
N 4640 43240 4660 43240 {}
C {lab_pin.sym} 4660 43240 0 0 {name=l34679 lab=VDD}
N 4640 43160 4660 43160 {}
C {lab_pin.sym} 4660 43160 0 0 {name=l34680 lab=VSS}
C {bitcell_6t.sym} 4800 43200 0 0 {name=Xr216c24}
N 4760 43240 4740 43240 {}
C {lab_pin.sym} 4740 43240 0 0 {name=l34681 lab=BL24}
N 4760 43200 4740 43200 {}
C {lab_pin.sym} 4740 43200 0 0 {name=l34682 lab=BLB24}
N 4760 43160 4740 43160 {}
C {lab_pin.sym} 4740 43160 0 0 {name=l34683 lab=WL216}
N 4840 43240 4860 43240 {}
C {lab_pin.sym} 4860 43240 0 0 {name=l34684 lab=VDD}
N 4840 43160 4860 43160 {}
C {lab_pin.sym} 4860 43160 0 0 {name=l34685 lab=VSS}
C {bitcell_6t.sym} 5000 43200 0 0 {name=Xr216c25}
N 4960 43240 4940 43240 {}
C {lab_pin.sym} 4940 43240 0 0 {name=l34686 lab=BL25}
N 4960 43200 4940 43200 {}
C {lab_pin.sym} 4940 43200 0 0 {name=l34687 lab=BLB25}
N 4960 43160 4940 43160 {}
C {lab_pin.sym} 4940 43160 0 0 {name=l34688 lab=WL216}
N 5040 43240 5060 43240 {}
C {lab_pin.sym} 5060 43240 0 0 {name=l34689 lab=VDD}
N 5040 43160 5060 43160 {}
C {lab_pin.sym} 5060 43160 0 0 {name=l34690 lab=VSS}
C {bitcell_6t.sym} 5200 43200 0 0 {name=Xr216c26}
N 5160 43240 5140 43240 {}
C {lab_pin.sym} 5140 43240 0 0 {name=l34691 lab=BL26}
N 5160 43200 5140 43200 {}
C {lab_pin.sym} 5140 43200 0 0 {name=l34692 lab=BLB26}
N 5160 43160 5140 43160 {}
C {lab_pin.sym} 5140 43160 0 0 {name=l34693 lab=WL216}
N 5240 43240 5260 43240 {}
C {lab_pin.sym} 5260 43240 0 0 {name=l34694 lab=VDD}
N 5240 43160 5260 43160 {}
C {lab_pin.sym} 5260 43160 0 0 {name=l34695 lab=VSS}
C {bitcell_6t.sym} 5400 43200 0 0 {name=Xr216c27}
N 5360 43240 5340 43240 {}
C {lab_pin.sym} 5340 43240 0 0 {name=l34696 lab=BL27}
N 5360 43200 5340 43200 {}
C {lab_pin.sym} 5340 43200 0 0 {name=l34697 lab=BLB27}
N 5360 43160 5340 43160 {}
C {lab_pin.sym} 5340 43160 0 0 {name=l34698 lab=WL216}
N 5440 43240 5460 43240 {}
C {lab_pin.sym} 5460 43240 0 0 {name=l34699 lab=VDD}
N 5440 43160 5460 43160 {}
C {lab_pin.sym} 5460 43160 0 0 {name=l34700 lab=VSS}
C {bitcell_6t.sym} 5600 43200 0 0 {name=Xr216c28}
N 5560 43240 5540 43240 {}
C {lab_pin.sym} 5540 43240 0 0 {name=l34701 lab=BL28}
N 5560 43200 5540 43200 {}
C {lab_pin.sym} 5540 43200 0 0 {name=l34702 lab=BLB28}
N 5560 43160 5540 43160 {}
C {lab_pin.sym} 5540 43160 0 0 {name=l34703 lab=WL216}
N 5640 43240 5660 43240 {}
C {lab_pin.sym} 5660 43240 0 0 {name=l34704 lab=VDD}
N 5640 43160 5660 43160 {}
C {lab_pin.sym} 5660 43160 0 0 {name=l34705 lab=VSS}
C {bitcell_6t.sym} 5800 43200 0 0 {name=Xr216c29}
N 5760 43240 5740 43240 {}
C {lab_pin.sym} 5740 43240 0 0 {name=l34706 lab=BL29}
N 5760 43200 5740 43200 {}
C {lab_pin.sym} 5740 43200 0 0 {name=l34707 lab=BLB29}
N 5760 43160 5740 43160 {}
C {lab_pin.sym} 5740 43160 0 0 {name=l34708 lab=WL216}
N 5840 43240 5860 43240 {}
C {lab_pin.sym} 5860 43240 0 0 {name=l34709 lab=VDD}
N 5840 43160 5860 43160 {}
C {lab_pin.sym} 5860 43160 0 0 {name=l34710 lab=VSS}
C {bitcell_6t.sym} 6000 43200 0 0 {name=Xr216c30}
N 5960 43240 5940 43240 {}
C {lab_pin.sym} 5940 43240 0 0 {name=l34711 lab=BL30}
N 5960 43200 5940 43200 {}
C {lab_pin.sym} 5940 43200 0 0 {name=l34712 lab=BLB30}
N 5960 43160 5940 43160 {}
C {lab_pin.sym} 5940 43160 0 0 {name=l34713 lab=WL216}
N 6040 43240 6060 43240 {}
C {lab_pin.sym} 6060 43240 0 0 {name=l34714 lab=VDD}
N 6040 43160 6060 43160 {}
C {lab_pin.sym} 6060 43160 0 0 {name=l34715 lab=VSS}
C {bitcell_6t.sym} 6200 43200 0 0 {name=Xr216c31}
N 6160 43240 6140 43240 {}
C {lab_pin.sym} 6140 43240 0 0 {name=l34716 lab=BL31}
N 6160 43200 6140 43200 {}
C {lab_pin.sym} 6140 43200 0 0 {name=l34717 lab=BLB31}
N 6160 43160 6140 43160 {}
C {lab_pin.sym} 6140 43160 0 0 {name=l34718 lab=WL216}
N 6240 43240 6260 43240 {}
C {lab_pin.sym} 6260 43240 0 0 {name=l34719 lab=VDD}
N 6240 43160 6260 43160 {}
C {lab_pin.sym} 6260 43160 0 0 {name=l34720 lab=VSS}
C {bitcell_6t.sym} 0 43400 0 0 {name=Xr217c0}
N -40 43440 -60 43440 {}
C {lab_pin.sym} -60 43440 0 0 {name=l34721 lab=BL0}
N -40 43400 -60 43400 {}
C {lab_pin.sym} -60 43400 0 0 {name=l34722 lab=BLB0}
N -40 43360 -60 43360 {}
C {lab_pin.sym} -60 43360 0 0 {name=l34723 lab=WL217}
N 40 43440 60 43440 {}
C {lab_pin.sym} 60 43440 0 0 {name=l34724 lab=VDD}
N 40 43360 60 43360 {}
C {lab_pin.sym} 60 43360 0 0 {name=l34725 lab=VSS}
C {bitcell_6t.sym} 200 43400 0 0 {name=Xr217c1}
N 160 43440 140 43440 {}
C {lab_pin.sym} 140 43440 0 0 {name=l34726 lab=BL1}
N 160 43400 140 43400 {}
C {lab_pin.sym} 140 43400 0 0 {name=l34727 lab=BLB1}
N 160 43360 140 43360 {}
C {lab_pin.sym} 140 43360 0 0 {name=l34728 lab=WL217}
N 240 43440 260 43440 {}
C {lab_pin.sym} 260 43440 0 0 {name=l34729 lab=VDD}
N 240 43360 260 43360 {}
C {lab_pin.sym} 260 43360 0 0 {name=l34730 lab=VSS}
C {bitcell_6t.sym} 400 43400 0 0 {name=Xr217c2}
N 360 43440 340 43440 {}
C {lab_pin.sym} 340 43440 0 0 {name=l34731 lab=BL2}
N 360 43400 340 43400 {}
C {lab_pin.sym} 340 43400 0 0 {name=l34732 lab=BLB2}
N 360 43360 340 43360 {}
C {lab_pin.sym} 340 43360 0 0 {name=l34733 lab=WL217}
N 440 43440 460 43440 {}
C {lab_pin.sym} 460 43440 0 0 {name=l34734 lab=VDD}
N 440 43360 460 43360 {}
C {lab_pin.sym} 460 43360 0 0 {name=l34735 lab=VSS}
C {bitcell_6t.sym} 600 43400 0 0 {name=Xr217c3}
N 560 43440 540 43440 {}
C {lab_pin.sym} 540 43440 0 0 {name=l34736 lab=BL3}
N 560 43400 540 43400 {}
C {lab_pin.sym} 540 43400 0 0 {name=l34737 lab=BLB3}
N 560 43360 540 43360 {}
C {lab_pin.sym} 540 43360 0 0 {name=l34738 lab=WL217}
N 640 43440 660 43440 {}
C {lab_pin.sym} 660 43440 0 0 {name=l34739 lab=VDD}
N 640 43360 660 43360 {}
C {lab_pin.sym} 660 43360 0 0 {name=l34740 lab=VSS}
C {bitcell_6t.sym} 800 43400 0 0 {name=Xr217c4}
N 760 43440 740 43440 {}
C {lab_pin.sym} 740 43440 0 0 {name=l34741 lab=BL4}
N 760 43400 740 43400 {}
C {lab_pin.sym} 740 43400 0 0 {name=l34742 lab=BLB4}
N 760 43360 740 43360 {}
C {lab_pin.sym} 740 43360 0 0 {name=l34743 lab=WL217}
N 840 43440 860 43440 {}
C {lab_pin.sym} 860 43440 0 0 {name=l34744 lab=VDD}
N 840 43360 860 43360 {}
C {lab_pin.sym} 860 43360 0 0 {name=l34745 lab=VSS}
C {bitcell_6t.sym} 1000 43400 0 0 {name=Xr217c5}
N 960 43440 940 43440 {}
C {lab_pin.sym} 940 43440 0 0 {name=l34746 lab=BL5}
N 960 43400 940 43400 {}
C {lab_pin.sym} 940 43400 0 0 {name=l34747 lab=BLB5}
N 960 43360 940 43360 {}
C {lab_pin.sym} 940 43360 0 0 {name=l34748 lab=WL217}
N 1040 43440 1060 43440 {}
C {lab_pin.sym} 1060 43440 0 0 {name=l34749 lab=VDD}
N 1040 43360 1060 43360 {}
C {lab_pin.sym} 1060 43360 0 0 {name=l34750 lab=VSS}
C {bitcell_6t.sym} 1200 43400 0 0 {name=Xr217c6}
N 1160 43440 1140 43440 {}
C {lab_pin.sym} 1140 43440 0 0 {name=l34751 lab=BL6}
N 1160 43400 1140 43400 {}
C {lab_pin.sym} 1140 43400 0 0 {name=l34752 lab=BLB6}
N 1160 43360 1140 43360 {}
C {lab_pin.sym} 1140 43360 0 0 {name=l34753 lab=WL217}
N 1240 43440 1260 43440 {}
C {lab_pin.sym} 1260 43440 0 0 {name=l34754 lab=VDD}
N 1240 43360 1260 43360 {}
C {lab_pin.sym} 1260 43360 0 0 {name=l34755 lab=VSS}
C {bitcell_6t.sym} 1400 43400 0 0 {name=Xr217c7}
N 1360 43440 1340 43440 {}
C {lab_pin.sym} 1340 43440 0 0 {name=l34756 lab=BL7}
N 1360 43400 1340 43400 {}
C {lab_pin.sym} 1340 43400 0 0 {name=l34757 lab=BLB7}
N 1360 43360 1340 43360 {}
C {lab_pin.sym} 1340 43360 0 0 {name=l34758 lab=WL217}
N 1440 43440 1460 43440 {}
C {lab_pin.sym} 1460 43440 0 0 {name=l34759 lab=VDD}
N 1440 43360 1460 43360 {}
C {lab_pin.sym} 1460 43360 0 0 {name=l34760 lab=VSS}
C {bitcell_6t.sym} 1600 43400 0 0 {name=Xr217c8}
N 1560 43440 1540 43440 {}
C {lab_pin.sym} 1540 43440 0 0 {name=l34761 lab=BL8}
N 1560 43400 1540 43400 {}
C {lab_pin.sym} 1540 43400 0 0 {name=l34762 lab=BLB8}
N 1560 43360 1540 43360 {}
C {lab_pin.sym} 1540 43360 0 0 {name=l34763 lab=WL217}
N 1640 43440 1660 43440 {}
C {lab_pin.sym} 1660 43440 0 0 {name=l34764 lab=VDD}
N 1640 43360 1660 43360 {}
C {lab_pin.sym} 1660 43360 0 0 {name=l34765 lab=VSS}
C {bitcell_6t.sym} 1800 43400 0 0 {name=Xr217c9}
N 1760 43440 1740 43440 {}
C {lab_pin.sym} 1740 43440 0 0 {name=l34766 lab=BL9}
N 1760 43400 1740 43400 {}
C {lab_pin.sym} 1740 43400 0 0 {name=l34767 lab=BLB9}
N 1760 43360 1740 43360 {}
C {lab_pin.sym} 1740 43360 0 0 {name=l34768 lab=WL217}
N 1840 43440 1860 43440 {}
C {lab_pin.sym} 1860 43440 0 0 {name=l34769 lab=VDD}
N 1840 43360 1860 43360 {}
C {lab_pin.sym} 1860 43360 0 0 {name=l34770 lab=VSS}
C {bitcell_6t.sym} 2000 43400 0 0 {name=Xr217c10}
N 1960 43440 1940 43440 {}
C {lab_pin.sym} 1940 43440 0 0 {name=l34771 lab=BL10}
N 1960 43400 1940 43400 {}
C {lab_pin.sym} 1940 43400 0 0 {name=l34772 lab=BLB10}
N 1960 43360 1940 43360 {}
C {lab_pin.sym} 1940 43360 0 0 {name=l34773 lab=WL217}
N 2040 43440 2060 43440 {}
C {lab_pin.sym} 2060 43440 0 0 {name=l34774 lab=VDD}
N 2040 43360 2060 43360 {}
C {lab_pin.sym} 2060 43360 0 0 {name=l34775 lab=VSS}
C {bitcell_6t.sym} 2200 43400 0 0 {name=Xr217c11}
N 2160 43440 2140 43440 {}
C {lab_pin.sym} 2140 43440 0 0 {name=l34776 lab=BL11}
N 2160 43400 2140 43400 {}
C {lab_pin.sym} 2140 43400 0 0 {name=l34777 lab=BLB11}
N 2160 43360 2140 43360 {}
C {lab_pin.sym} 2140 43360 0 0 {name=l34778 lab=WL217}
N 2240 43440 2260 43440 {}
C {lab_pin.sym} 2260 43440 0 0 {name=l34779 lab=VDD}
N 2240 43360 2260 43360 {}
C {lab_pin.sym} 2260 43360 0 0 {name=l34780 lab=VSS}
C {bitcell_6t.sym} 2400 43400 0 0 {name=Xr217c12}
N 2360 43440 2340 43440 {}
C {lab_pin.sym} 2340 43440 0 0 {name=l34781 lab=BL12}
N 2360 43400 2340 43400 {}
C {lab_pin.sym} 2340 43400 0 0 {name=l34782 lab=BLB12}
N 2360 43360 2340 43360 {}
C {lab_pin.sym} 2340 43360 0 0 {name=l34783 lab=WL217}
N 2440 43440 2460 43440 {}
C {lab_pin.sym} 2460 43440 0 0 {name=l34784 lab=VDD}
N 2440 43360 2460 43360 {}
C {lab_pin.sym} 2460 43360 0 0 {name=l34785 lab=VSS}
C {bitcell_6t.sym} 2600 43400 0 0 {name=Xr217c13}
N 2560 43440 2540 43440 {}
C {lab_pin.sym} 2540 43440 0 0 {name=l34786 lab=BL13}
N 2560 43400 2540 43400 {}
C {lab_pin.sym} 2540 43400 0 0 {name=l34787 lab=BLB13}
N 2560 43360 2540 43360 {}
C {lab_pin.sym} 2540 43360 0 0 {name=l34788 lab=WL217}
N 2640 43440 2660 43440 {}
C {lab_pin.sym} 2660 43440 0 0 {name=l34789 lab=VDD}
N 2640 43360 2660 43360 {}
C {lab_pin.sym} 2660 43360 0 0 {name=l34790 lab=VSS}
C {bitcell_6t.sym} 2800 43400 0 0 {name=Xr217c14}
N 2760 43440 2740 43440 {}
C {lab_pin.sym} 2740 43440 0 0 {name=l34791 lab=BL14}
N 2760 43400 2740 43400 {}
C {lab_pin.sym} 2740 43400 0 0 {name=l34792 lab=BLB14}
N 2760 43360 2740 43360 {}
C {lab_pin.sym} 2740 43360 0 0 {name=l34793 lab=WL217}
N 2840 43440 2860 43440 {}
C {lab_pin.sym} 2860 43440 0 0 {name=l34794 lab=VDD}
N 2840 43360 2860 43360 {}
C {lab_pin.sym} 2860 43360 0 0 {name=l34795 lab=VSS}
C {bitcell_6t.sym} 3000 43400 0 0 {name=Xr217c15}
N 2960 43440 2940 43440 {}
C {lab_pin.sym} 2940 43440 0 0 {name=l34796 lab=BL15}
N 2960 43400 2940 43400 {}
C {lab_pin.sym} 2940 43400 0 0 {name=l34797 lab=BLB15}
N 2960 43360 2940 43360 {}
C {lab_pin.sym} 2940 43360 0 0 {name=l34798 lab=WL217}
N 3040 43440 3060 43440 {}
C {lab_pin.sym} 3060 43440 0 0 {name=l34799 lab=VDD}
N 3040 43360 3060 43360 {}
C {lab_pin.sym} 3060 43360 0 0 {name=l34800 lab=VSS}
C {bitcell_6t.sym} 3200 43400 0 0 {name=Xr217c16}
N 3160 43440 3140 43440 {}
C {lab_pin.sym} 3140 43440 0 0 {name=l34801 lab=BL16}
N 3160 43400 3140 43400 {}
C {lab_pin.sym} 3140 43400 0 0 {name=l34802 lab=BLB16}
N 3160 43360 3140 43360 {}
C {lab_pin.sym} 3140 43360 0 0 {name=l34803 lab=WL217}
N 3240 43440 3260 43440 {}
C {lab_pin.sym} 3260 43440 0 0 {name=l34804 lab=VDD}
N 3240 43360 3260 43360 {}
C {lab_pin.sym} 3260 43360 0 0 {name=l34805 lab=VSS}
C {bitcell_6t.sym} 3400 43400 0 0 {name=Xr217c17}
N 3360 43440 3340 43440 {}
C {lab_pin.sym} 3340 43440 0 0 {name=l34806 lab=BL17}
N 3360 43400 3340 43400 {}
C {lab_pin.sym} 3340 43400 0 0 {name=l34807 lab=BLB17}
N 3360 43360 3340 43360 {}
C {lab_pin.sym} 3340 43360 0 0 {name=l34808 lab=WL217}
N 3440 43440 3460 43440 {}
C {lab_pin.sym} 3460 43440 0 0 {name=l34809 lab=VDD}
N 3440 43360 3460 43360 {}
C {lab_pin.sym} 3460 43360 0 0 {name=l34810 lab=VSS}
C {bitcell_6t.sym} 3600 43400 0 0 {name=Xr217c18}
N 3560 43440 3540 43440 {}
C {lab_pin.sym} 3540 43440 0 0 {name=l34811 lab=BL18}
N 3560 43400 3540 43400 {}
C {lab_pin.sym} 3540 43400 0 0 {name=l34812 lab=BLB18}
N 3560 43360 3540 43360 {}
C {lab_pin.sym} 3540 43360 0 0 {name=l34813 lab=WL217}
N 3640 43440 3660 43440 {}
C {lab_pin.sym} 3660 43440 0 0 {name=l34814 lab=VDD}
N 3640 43360 3660 43360 {}
C {lab_pin.sym} 3660 43360 0 0 {name=l34815 lab=VSS}
C {bitcell_6t.sym} 3800 43400 0 0 {name=Xr217c19}
N 3760 43440 3740 43440 {}
C {lab_pin.sym} 3740 43440 0 0 {name=l34816 lab=BL19}
N 3760 43400 3740 43400 {}
C {lab_pin.sym} 3740 43400 0 0 {name=l34817 lab=BLB19}
N 3760 43360 3740 43360 {}
C {lab_pin.sym} 3740 43360 0 0 {name=l34818 lab=WL217}
N 3840 43440 3860 43440 {}
C {lab_pin.sym} 3860 43440 0 0 {name=l34819 lab=VDD}
N 3840 43360 3860 43360 {}
C {lab_pin.sym} 3860 43360 0 0 {name=l34820 lab=VSS}
C {bitcell_6t.sym} 4000 43400 0 0 {name=Xr217c20}
N 3960 43440 3940 43440 {}
C {lab_pin.sym} 3940 43440 0 0 {name=l34821 lab=BL20}
N 3960 43400 3940 43400 {}
C {lab_pin.sym} 3940 43400 0 0 {name=l34822 lab=BLB20}
N 3960 43360 3940 43360 {}
C {lab_pin.sym} 3940 43360 0 0 {name=l34823 lab=WL217}
N 4040 43440 4060 43440 {}
C {lab_pin.sym} 4060 43440 0 0 {name=l34824 lab=VDD}
N 4040 43360 4060 43360 {}
C {lab_pin.sym} 4060 43360 0 0 {name=l34825 lab=VSS}
C {bitcell_6t.sym} 4200 43400 0 0 {name=Xr217c21}
N 4160 43440 4140 43440 {}
C {lab_pin.sym} 4140 43440 0 0 {name=l34826 lab=BL21}
N 4160 43400 4140 43400 {}
C {lab_pin.sym} 4140 43400 0 0 {name=l34827 lab=BLB21}
N 4160 43360 4140 43360 {}
C {lab_pin.sym} 4140 43360 0 0 {name=l34828 lab=WL217}
N 4240 43440 4260 43440 {}
C {lab_pin.sym} 4260 43440 0 0 {name=l34829 lab=VDD}
N 4240 43360 4260 43360 {}
C {lab_pin.sym} 4260 43360 0 0 {name=l34830 lab=VSS}
C {bitcell_6t.sym} 4400 43400 0 0 {name=Xr217c22}
N 4360 43440 4340 43440 {}
C {lab_pin.sym} 4340 43440 0 0 {name=l34831 lab=BL22}
N 4360 43400 4340 43400 {}
C {lab_pin.sym} 4340 43400 0 0 {name=l34832 lab=BLB22}
N 4360 43360 4340 43360 {}
C {lab_pin.sym} 4340 43360 0 0 {name=l34833 lab=WL217}
N 4440 43440 4460 43440 {}
C {lab_pin.sym} 4460 43440 0 0 {name=l34834 lab=VDD}
N 4440 43360 4460 43360 {}
C {lab_pin.sym} 4460 43360 0 0 {name=l34835 lab=VSS}
C {bitcell_6t.sym} 4600 43400 0 0 {name=Xr217c23}
N 4560 43440 4540 43440 {}
C {lab_pin.sym} 4540 43440 0 0 {name=l34836 lab=BL23}
N 4560 43400 4540 43400 {}
C {lab_pin.sym} 4540 43400 0 0 {name=l34837 lab=BLB23}
N 4560 43360 4540 43360 {}
C {lab_pin.sym} 4540 43360 0 0 {name=l34838 lab=WL217}
N 4640 43440 4660 43440 {}
C {lab_pin.sym} 4660 43440 0 0 {name=l34839 lab=VDD}
N 4640 43360 4660 43360 {}
C {lab_pin.sym} 4660 43360 0 0 {name=l34840 lab=VSS}
C {bitcell_6t.sym} 4800 43400 0 0 {name=Xr217c24}
N 4760 43440 4740 43440 {}
C {lab_pin.sym} 4740 43440 0 0 {name=l34841 lab=BL24}
N 4760 43400 4740 43400 {}
C {lab_pin.sym} 4740 43400 0 0 {name=l34842 lab=BLB24}
N 4760 43360 4740 43360 {}
C {lab_pin.sym} 4740 43360 0 0 {name=l34843 lab=WL217}
N 4840 43440 4860 43440 {}
C {lab_pin.sym} 4860 43440 0 0 {name=l34844 lab=VDD}
N 4840 43360 4860 43360 {}
C {lab_pin.sym} 4860 43360 0 0 {name=l34845 lab=VSS}
C {bitcell_6t.sym} 5000 43400 0 0 {name=Xr217c25}
N 4960 43440 4940 43440 {}
C {lab_pin.sym} 4940 43440 0 0 {name=l34846 lab=BL25}
N 4960 43400 4940 43400 {}
C {lab_pin.sym} 4940 43400 0 0 {name=l34847 lab=BLB25}
N 4960 43360 4940 43360 {}
C {lab_pin.sym} 4940 43360 0 0 {name=l34848 lab=WL217}
N 5040 43440 5060 43440 {}
C {lab_pin.sym} 5060 43440 0 0 {name=l34849 lab=VDD}
N 5040 43360 5060 43360 {}
C {lab_pin.sym} 5060 43360 0 0 {name=l34850 lab=VSS}
C {bitcell_6t.sym} 5200 43400 0 0 {name=Xr217c26}
N 5160 43440 5140 43440 {}
C {lab_pin.sym} 5140 43440 0 0 {name=l34851 lab=BL26}
N 5160 43400 5140 43400 {}
C {lab_pin.sym} 5140 43400 0 0 {name=l34852 lab=BLB26}
N 5160 43360 5140 43360 {}
C {lab_pin.sym} 5140 43360 0 0 {name=l34853 lab=WL217}
N 5240 43440 5260 43440 {}
C {lab_pin.sym} 5260 43440 0 0 {name=l34854 lab=VDD}
N 5240 43360 5260 43360 {}
C {lab_pin.sym} 5260 43360 0 0 {name=l34855 lab=VSS}
C {bitcell_6t.sym} 5400 43400 0 0 {name=Xr217c27}
N 5360 43440 5340 43440 {}
C {lab_pin.sym} 5340 43440 0 0 {name=l34856 lab=BL27}
N 5360 43400 5340 43400 {}
C {lab_pin.sym} 5340 43400 0 0 {name=l34857 lab=BLB27}
N 5360 43360 5340 43360 {}
C {lab_pin.sym} 5340 43360 0 0 {name=l34858 lab=WL217}
N 5440 43440 5460 43440 {}
C {lab_pin.sym} 5460 43440 0 0 {name=l34859 lab=VDD}
N 5440 43360 5460 43360 {}
C {lab_pin.sym} 5460 43360 0 0 {name=l34860 lab=VSS}
C {bitcell_6t.sym} 5600 43400 0 0 {name=Xr217c28}
N 5560 43440 5540 43440 {}
C {lab_pin.sym} 5540 43440 0 0 {name=l34861 lab=BL28}
N 5560 43400 5540 43400 {}
C {lab_pin.sym} 5540 43400 0 0 {name=l34862 lab=BLB28}
N 5560 43360 5540 43360 {}
C {lab_pin.sym} 5540 43360 0 0 {name=l34863 lab=WL217}
N 5640 43440 5660 43440 {}
C {lab_pin.sym} 5660 43440 0 0 {name=l34864 lab=VDD}
N 5640 43360 5660 43360 {}
C {lab_pin.sym} 5660 43360 0 0 {name=l34865 lab=VSS}
C {bitcell_6t.sym} 5800 43400 0 0 {name=Xr217c29}
N 5760 43440 5740 43440 {}
C {lab_pin.sym} 5740 43440 0 0 {name=l34866 lab=BL29}
N 5760 43400 5740 43400 {}
C {lab_pin.sym} 5740 43400 0 0 {name=l34867 lab=BLB29}
N 5760 43360 5740 43360 {}
C {lab_pin.sym} 5740 43360 0 0 {name=l34868 lab=WL217}
N 5840 43440 5860 43440 {}
C {lab_pin.sym} 5860 43440 0 0 {name=l34869 lab=VDD}
N 5840 43360 5860 43360 {}
C {lab_pin.sym} 5860 43360 0 0 {name=l34870 lab=VSS}
C {bitcell_6t.sym} 6000 43400 0 0 {name=Xr217c30}
N 5960 43440 5940 43440 {}
C {lab_pin.sym} 5940 43440 0 0 {name=l34871 lab=BL30}
N 5960 43400 5940 43400 {}
C {lab_pin.sym} 5940 43400 0 0 {name=l34872 lab=BLB30}
N 5960 43360 5940 43360 {}
C {lab_pin.sym} 5940 43360 0 0 {name=l34873 lab=WL217}
N 6040 43440 6060 43440 {}
C {lab_pin.sym} 6060 43440 0 0 {name=l34874 lab=VDD}
N 6040 43360 6060 43360 {}
C {lab_pin.sym} 6060 43360 0 0 {name=l34875 lab=VSS}
C {bitcell_6t.sym} 6200 43400 0 0 {name=Xr217c31}
N 6160 43440 6140 43440 {}
C {lab_pin.sym} 6140 43440 0 0 {name=l34876 lab=BL31}
N 6160 43400 6140 43400 {}
C {lab_pin.sym} 6140 43400 0 0 {name=l34877 lab=BLB31}
N 6160 43360 6140 43360 {}
C {lab_pin.sym} 6140 43360 0 0 {name=l34878 lab=WL217}
N 6240 43440 6260 43440 {}
C {lab_pin.sym} 6260 43440 0 0 {name=l34879 lab=VDD}
N 6240 43360 6260 43360 {}
C {lab_pin.sym} 6260 43360 0 0 {name=l34880 lab=VSS}
C {bitcell_6t.sym} 0 43600 0 0 {name=Xr218c0}
N -40 43640 -60 43640 {}
C {lab_pin.sym} -60 43640 0 0 {name=l34881 lab=BL0}
N -40 43600 -60 43600 {}
C {lab_pin.sym} -60 43600 0 0 {name=l34882 lab=BLB0}
N -40 43560 -60 43560 {}
C {lab_pin.sym} -60 43560 0 0 {name=l34883 lab=WL218}
N 40 43640 60 43640 {}
C {lab_pin.sym} 60 43640 0 0 {name=l34884 lab=VDD}
N 40 43560 60 43560 {}
C {lab_pin.sym} 60 43560 0 0 {name=l34885 lab=VSS}
C {bitcell_6t.sym} 200 43600 0 0 {name=Xr218c1}
N 160 43640 140 43640 {}
C {lab_pin.sym} 140 43640 0 0 {name=l34886 lab=BL1}
N 160 43600 140 43600 {}
C {lab_pin.sym} 140 43600 0 0 {name=l34887 lab=BLB1}
N 160 43560 140 43560 {}
C {lab_pin.sym} 140 43560 0 0 {name=l34888 lab=WL218}
N 240 43640 260 43640 {}
C {lab_pin.sym} 260 43640 0 0 {name=l34889 lab=VDD}
N 240 43560 260 43560 {}
C {lab_pin.sym} 260 43560 0 0 {name=l34890 lab=VSS}
C {bitcell_6t.sym} 400 43600 0 0 {name=Xr218c2}
N 360 43640 340 43640 {}
C {lab_pin.sym} 340 43640 0 0 {name=l34891 lab=BL2}
N 360 43600 340 43600 {}
C {lab_pin.sym} 340 43600 0 0 {name=l34892 lab=BLB2}
N 360 43560 340 43560 {}
C {lab_pin.sym} 340 43560 0 0 {name=l34893 lab=WL218}
N 440 43640 460 43640 {}
C {lab_pin.sym} 460 43640 0 0 {name=l34894 lab=VDD}
N 440 43560 460 43560 {}
C {lab_pin.sym} 460 43560 0 0 {name=l34895 lab=VSS}
C {bitcell_6t.sym} 600 43600 0 0 {name=Xr218c3}
N 560 43640 540 43640 {}
C {lab_pin.sym} 540 43640 0 0 {name=l34896 lab=BL3}
N 560 43600 540 43600 {}
C {lab_pin.sym} 540 43600 0 0 {name=l34897 lab=BLB3}
N 560 43560 540 43560 {}
C {lab_pin.sym} 540 43560 0 0 {name=l34898 lab=WL218}
N 640 43640 660 43640 {}
C {lab_pin.sym} 660 43640 0 0 {name=l34899 lab=VDD}
N 640 43560 660 43560 {}
C {lab_pin.sym} 660 43560 0 0 {name=l34900 lab=VSS}
C {bitcell_6t.sym} 800 43600 0 0 {name=Xr218c4}
N 760 43640 740 43640 {}
C {lab_pin.sym} 740 43640 0 0 {name=l34901 lab=BL4}
N 760 43600 740 43600 {}
C {lab_pin.sym} 740 43600 0 0 {name=l34902 lab=BLB4}
N 760 43560 740 43560 {}
C {lab_pin.sym} 740 43560 0 0 {name=l34903 lab=WL218}
N 840 43640 860 43640 {}
C {lab_pin.sym} 860 43640 0 0 {name=l34904 lab=VDD}
N 840 43560 860 43560 {}
C {lab_pin.sym} 860 43560 0 0 {name=l34905 lab=VSS}
C {bitcell_6t.sym} 1000 43600 0 0 {name=Xr218c5}
N 960 43640 940 43640 {}
C {lab_pin.sym} 940 43640 0 0 {name=l34906 lab=BL5}
N 960 43600 940 43600 {}
C {lab_pin.sym} 940 43600 0 0 {name=l34907 lab=BLB5}
N 960 43560 940 43560 {}
C {lab_pin.sym} 940 43560 0 0 {name=l34908 lab=WL218}
N 1040 43640 1060 43640 {}
C {lab_pin.sym} 1060 43640 0 0 {name=l34909 lab=VDD}
N 1040 43560 1060 43560 {}
C {lab_pin.sym} 1060 43560 0 0 {name=l34910 lab=VSS}
C {bitcell_6t.sym} 1200 43600 0 0 {name=Xr218c6}
N 1160 43640 1140 43640 {}
C {lab_pin.sym} 1140 43640 0 0 {name=l34911 lab=BL6}
N 1160 43600 1140 43600 {}
C {lab_pin.sym} 1140 43600 0 0 {name=l34912 lab=BLB6}
N 1160 43560 1140 43560 {}
C {lab_pin.sym} 1140 43560 0 0 {name=l34913 lab=WL218}
N 1240 43640 1260 43640 {}
C {lab_pin.sym} 1260 43640 0 0 {name=l34914 lab=VDD}
N 1240 43560 1260 43560 {}
C {lab_pin.sym} 1260 43560 0 0 {name=l34915 lab=VSS}
C {bitcell_6t.sym} 1400 43600 0 0 {name=Xr218c7}
N 1360 43640 1340 43640 {}
C {lab_pin.sym} 1340 43640 0 0 {name=l34916 lab=BL7}
N 1360 43600 1340 43600 {}
C {lab_pin.sym} 1340 43600 0 0 {name=l34917 lab=BLB7}
N 1360 43560 1340 43560 {}
C {lab_pin.sym} 1340 43560 0 0 {name=l34918 lab=WL218}
N 1440 43640 1460 43640 {}
C {lab_pin.sym} 1460 43640 0 0 {name=l34919 lab=VDD}
N 1440 43560 1460 43560 {}
C {lab_pin.sym} 1460 43560 0 0 {name=l34920 lab=VSS}
C {bitcell_6t.sym} 1600 43600 0 0 {name=Xr218c8}
N 1560 43640 1540 43640 {}
C {lab_pin.sym} 1540 43640 0 0 {name=l34921 lab=BL8}
N 1560 43600 1540 43600 {}
C {lab_pin.sym} 1540 43600 0 0 {name=l34922 lab=BLB8}
N 1560 43560 1540 43560 {}
C {lab_pin.sym} 1540 43560 0 0 {name=l34923 lab=WL218}
N 1640 43640 1660 43640 {}
C {lab_pin.sym} 1660 43640 0 0 {name=l34924 lab=VDD}
N 1640 43560 1660 43560 {}
C {lab_pin.sym} 1660 43560 0 0 {name=l34925 lab=VSS}
C {bitcell_6t.sym} 1800 43600 0 0 {name=Xr218c9}
N 1760 43640 1740 43640 {}
C {lab_pin.sym} 1740 43640 0 0 {name=l34926 lab=BL9}
N 1760 43600 1740 43600 {}
C {lab_pin.sym} 1740 43600 0 0 {name=l34927 lab=BLB9}
N 1760 43560 1740 43560 {}
C {lab_pin.sym} 1740 43560 0 0 {name=l34928 lab=WL218}
N 1840 43640 1860 43640 {}
C {lab_pin.sym} 1860 43640 0 0 {name=l34929 lab=VDD}
N 1840 43560 1860 43560 {}
C {lab_pin.sym} 1860 43560 0 0 {name=l34930 lab=VSS}
C {bitcell_6t.sym} 2000 43600 0 0 {name=Xr218c10}
N 1960 43640 1940 43640 {}
C {lab_pin.sym} 1940 43640 0 0 {name=l34931 lab=BL10}
N 1960 43600 1940 43600 {}
C {lab_pin.sym} 1940 43600 0 0 {name=l34932 lab=BLB10}
N 1960 43560 1940 43560 {}
C {lab_pin.sym} 1940 43560 0 0 {name=l34933 lab=WL218}
N 2040 43640 2060 43640 {}
C {lab_pin.sym} 2060 43640 0 0 {name=l34934 lab=VDD}
N 2040 43560 2060 43560 {}
C {lab_pin.sym} 2060 43560 0 0 {name=l34935 lab=VSS}
C {bitcell_6t.sym} 2200 43600 0 0 {name=Xr218c11}
N 2160 43640 2140 43640 {}
C {lab_pin.sym} 2140 43640 0 0 {name=l34936 lab=BL11}
N 2160 43600 2140 43600 {}
C {lab_pin.sym} 2140 43600 0 0 {name=l34937 lab=BLB11}
N 2160 43560 2140 43560 {}
C {lab_pin.sym} 2140 43560 0 0 {name=l34938 lab=WL218}
N 2240 43640 2260 43640 {}
C {lab_pin.sym} 2260 43640 0 0 {name=l34939 lab=VDD}
N 2240 43560 2260 43560 {}
C {lab_pin.sym} 2260 43560 0 0 {name=l34940 lab=VSS}
C {bitcell_6t.sym} 2400 43600 0 0 {name=Xr218c12}
N 2360 43640 2340 43640 {}
C {lab_pin.sym} 2340 43640 0 0 {name=l34941 lab=BL12}
N 2360 43600 2340 43600 {}
C {lab_pin.sym} 2340 43600 0 0 {name=l34942 lab=BLB12}
N 2360 43560 2340 43560 {}
C {lab_pin.sym} 2340 43560 0 0 {name=l34943 lab=WL218}
N 2440 43640 2460 43640 {}
C {lab_pin.sym} 2460 43640 0 0 {name=l34944 lab=VDD}
N 2440 43560 2460 43560 {}
C {lab_pin.sym} 2460 43560 0 0 {name=l34945 lab=VSS}
C {bitcell_6t.sym} 2600 43600 0 0 {name=Xr218c13}
N 2560 43640 2540 43640 {}
C {lab_pin.sym} 2540 43640 0 0 {name=l34946 lab=BL13}
N 2560 43600 2540 43600 {}
C {lab_pin.sym} 2540 43600 0 0 {name=l34947 lab=BLB13}
N 2560 43560 2540 43560 {}
C {lab_pin.sym} 2540 43560 0 0 {name=l34948 lab=WL218}
N 2640 43640 2660 43640 {}
C {lab_pin.sym} 2660 43640 0 0 {name=l34949 lab=VDD}
N 2640 43560 2660 43560 {}
C {lab_pin.sym} 2660 43560 0 0 {name=l34950 lab=VSS}
C {bitcell_6t.sym} 2800 43600 0 0 {name=Xr218c14}
N 2760 43640 2740 43640 {}
C {lab_pin.sym} 2740 43640 0 0 {name=l34951 lab=BL14}
N 2760 43600 2740 43600 {}
C {lab_pin.sym} 2740 43600 0 0 {name=l34952 lab=BLB14}
N 2760 43560 2740 43560 {}
C {lab_pin.sym} 2740 43560 0 0 {name=l34953 lab=WL218}
N 2840 43640 2860 43640 {}
C {lab_pin.sym} 2860 43640 0 0 {name=l34954 lab=VDD}
N 2840 43560 2860 43560 {}
C {lab_pin.sym} 2860 43560 0 0 {name=l34955 lab=VSS}
C {bitcell_6t.sym} 3000 43600 0 0 {name=Xr218c15}
N 2960 43640 2940 43640 {}
C {lab_pin.sym} 2940 43640 0 0 {name=l34956 lab=BL15}
N 2960 43600 2940 43600 {}
C {lab_pin.sym} 2940 43600 0 0 {name=l34957 lab=BLB15}
N 2960 43560 2940 43560 {}
C {lab_pin.sym} 2940 43560 0 0 {name=l34958 lab=WL218}
N 3040 43640 3060 43640 {}
C {lab_pin.sym} 3060 43640 0 0 {name=l34959 lab=VDD}
N 3040 43560 3060 43560 {}
C {lab_pin.sym} 3060 43560 0 0 {name=l34960 lab=VSS}
C {bitcell_6t.sym} 3200 43600 0 0 {name=Xr218c16}
N 3160 43640 3140 43640 {}
C {lab_pin.sym} 3140 43640 0 0 {name=l34961 lab=BL16}
N 3160 43600 3140 43600 {}
C {lab_pin.sym} 3140 43600 0 0 {name=l34962 lab=BLB16}
N 3160 43560 3140 43560 {}
C {lab_pin.sym} 3140 43560 0 0 {name=l34963 lab=WL218}
N 3240 43640 3260 43640 {}
C {lab_pin.sym} 3260 43640 0 0 {name=l34964 lab=VDD}
N 3240 43560 3260 43560 {}
C {lab_pin.sym} 3260 43560 0 0 {name=l34965 lab=VSS}
C {bitcell_6t.sym} 3400 43600 0 0 {name=Xr218c17}
N 3360 43640 3340 43640 {}
C {lab_pin.sym} 3340 43640 0 0 {name=l34966 lab=BL17}
N 3360 43600 3340 43600 {}
C {lab_pin.sym} 3340 43600 0 0 {name=l34967 lab=BLB17}
N 3360 43560 3340 43560 {}
C {lab_pin.sym} 3340 43560 0 0 {name=l34968 lab=WL218}
N 3440 43640 3460 43640 {}
C {lab_pin.sym} 3460 43640 0 0 {name=l34969 lab=VDD}
N 3440 43560 3460 43560 {}
C {lab_pin.sym} 3460 43560 0 0 {name=l34970 lab=VSS}
C {bitcell_6t.sym} 3600 43600 0 0 {name=Xr218c18}
N 3560 43640 3540 43640 {}
C {lab_pin.sym} 3540 43640 0 0 {name=l34971 lab=BL18}
N 3560 43600 3540 43600 {}
C {lab_pin.sym} 3540 43600 0 0 {name=l34972 lab=BLB18}
N 3560 43560 3540 43560 {}
C {lab_pin.sym} 3540 43560 0 0 {name=l34973 lab=WL218}
N 3640 43640 3660 43640 {}
C {lab_pin.sym} 3660 43640 0 0 {name=l34974 lab=VDD}
N 3640 43560 3660 43560 {}
C {lab_pin.sym} 3660 43560 0 0 {name=l34975 lab=VSS}
C {bitcell_6t.sym} 3800 43600 0 0 {name=Xr218c19}
N 3760 43640 3740 43640 {}
C {lab_pin.sym} 3740 43640 0 0 {name=l34976 lab=BL19}
N 3760 43600 3740 43600 {}
C {lab_pin.sym} 3740 43600 0 0 {name=l34977 lab=BLB19}
N 3760 43560 3740 43560 {}
C {lab_pin.sym} 3740 43560 0 0 {name=l34978 lab=WL218}
N 3840 43640 3860 43640 {}
C {lab_pin.sym} 3860 43640 0 0 {name=l34979 lab=VDD}
N 3840 43560 3860 43560 {}
C {lab_pin.sym} 3860 43560 0 0 {name=l34980 lab=VSS}
C {bitcell_6t.sym} 4000 43600 0 0 {name=Xr218c20}
N 3960 43640 3940 43640 {}
C {lab_pin.sym} 3940 43640 0 0 {name=l34981 lab=BL20}
N 3960 43600 3940 43600 {}
C {lab_pin.sym} 3940 43600 0 0 {name=l34982 lab=BLB20}
N 3960 43560 3940 43560 {}
C {lab_pin.sym} 3940 43560 0 0 {name=l34983 lab=WL218}
N 4040 43640 4060 43640 {}
C {lab_pin.sym} 4060 43640 0 0 {name=l34984 lab=VDD}
N 4040 43560 4060 43560 {}
C {lab_pin.sym} 4060 43560 0 0 {name=l34985 lab=VSS}
C {bitcell_6t.sym} 4200 43600 0 0 {name=Xr218c21}
N 4160 43640 4140 43640 {}
C {lab_pin.sym} 4140 43640 0 0 {name=l34986 lab=BL21}
N 4160 43600 4140 43600 {}
C {lab_pin.sym} 4140 43600 0 0 {name=l34987 lab=BLB21}
N 4160 43560 4140 43560 {}
C {lab_pin.sym} 4140 43560 0 0 {name=l34988 lab=WL218}
N 4240 43640 4260 43640 {}
C {lab_pin.sym} 4260 43640 0 0 {name=l34989 lab=VDD}
N 4240 43560 4260 43560 {}
C {lab_pin.sym} 4260 43560 0 0 {name=l34990 lab=VSS}
C {bitcell_6t.sym} 4400 43600 0 0 {name=Xr218c22}
N 4360 43640 4340 43640 {}
C {lab_pin.sym} 4340 43640 0 0 {name=l34991 lab=BL22}
N 4360 43600 4340 43600 {}
C {lab_pin.sym} 4340 43600 0 0 {name=l34992 lab=BLB22}
N 4360 43560 4340 43560 {}
C {lab_pin.sym} 4340 43560 0 0 {name=l34993 lab=WL218}
N 4440 43640 4460 43640 {}
C {lab_pin.sym} 4460 43640 0 0 {name=l34994 lab=VDD}
N 4440 43560 4460 43560 {}
C {lab_pin.sym} 4460 43560 0 0 {name=l34995 lab=VSS}
C {bitcell_6t.sym} 4600 43600 0 0 {name=Xr218c23}
N 4560 43640 4540 43640 {}
C {lab_pin.sym} 4540 43640 0 0 {name=l34996 lab=BL23}
N 4560 43600 4540 43600 {}
C {lab_pin.sym} 4540 43600 0 0 {name=l34997 lab=BLB23}
N 4560 43560 4540 43560 {}
C {lab_pin.sym} 4540 43560 0 0 {name=l34998 lab=WL218}
N 4640 43640 4660 43640 {}
C {lab_pin.sym} 4660 43640 0 0 {name=l34999 lab=VDD}
N 4640 43560 4660 43560 {}
C {lab_pin.sym} 4660 43560 0 0 {name=l35000 lab=VSS}
C {bitcell_6t.sym} 4800 43600 0 0 {name=Xr218c24}
N 4760 43640 4740 43640 {}
C {lab_pin.sym} 4740 43640 0 0 {name=l35001 lab=BL24}
N 4760 43600 4740 43600 {}
C {lab_pin.sym} 4740 43600 0 0 {name=l35002 lab=BLB24}
N 4760 43560 4740 43560 {}
C {lab_pin.sym} 4740 43560 0 0 {name=l35003 lab=WL218}
N 4840 43640 4860 43640 {}
C {lab_pin.sym} 4860 43640 0 0 {name=l35004 lab=VDD}
N 4840 43560 4860 43560 {}
C {lab_pin.sym} 4860 43560 0 0 {name=l35005 lab=VSS}
C {bitcell_6t.sym} 5000 43600 0 0 {name=Xr218c25}
N 4960 43640 4940 43640 {}
C {lab_pin.sym} 4940 43640 0 0 {name=l35006 lab=BL25}
N 4960 43600 4940 43600 {}
C {lab_pin.sym} 4940 43600 0 0 {name=l35007 lab=BLB25}
N 4960 43560 4940 43560 {}
C {lab_pin.sym} 4940 43560 0 0 {name=l35008 lab=WL218}
N 5040 43640 5060 43640 {}
C {lab_pin.sym} 5060 43640 0 0 {name=l35009 lab=VDD}
N 5040 43560 5060 43560 {}
C {lab_pin.sym} 5060 43560 0 0 {name=l35010 lab=VSS}
C {bitcell_6t.sym} 5200 43600 0 0 {name=Xr218c26}
N 5160 43640 5140 43640 {}
C {lab_pin.sym} 5140 43640 0 0 {name=l35011 lab=BL26}
N 5160 43600 5140 43600 {}
C {lab_pin.sym} 5140 43600 0 0 {name=l35012 lab=BLB26}
N 5160 43560 5140 43560 {}
C {lab_pin.sym} 5140 43560 0 0 {name=l35013 lab=WL218}
N 5240 43640 5260 43640 {}
C {lab_pin.sym} 5260 43640 0 0 {name=l35014 lab=VDD}
N 5240 43560 5260 43560 {}
C {lab_pin.sym} 5260 43560 0 0 {name=l35015 lab=VSS}
C {bitcell_6t.sym} 5400 43600 0 0 {name=Xr218c27}
N 5360 43640 5340 43640 {}
C {lab_pin.sym} 5340 43640 0 0 {name=l35016 lab=BL27}
N 5360 43600 5340 43600 {}
C {lab_pin.sym} 5340 43600 0 0 {name=l35017 lab=BLB27}
N 5360 43560 5340 43560 {}
C {lab_pin.sym} 5340 43560 0 0 {name=l35018 lab=WL218}
N 5440 43640 5460 43640 {}
C {lab_pin.sym} 5460 43640 0 0 {name=l35019 lab=VDD}
N 5440 43560 5460 43560 {}
C {lab_pin.sym} 5460 43560 0 0 {name=l35020 lab=VSS}
C {bitcell_6t.sym} 5600 43600 0 0 {name=Xr218c28}
N 5560 43640 5540 43640 {}
C {lab_pin.sym} 5540 43640 0 0 {name=l35021 lab=BL28}
N 5560 43600 5540 43600 {}
C {lab_pin.sym} 5540 43600 0 0 {name=l35022 lab=BLB28}
N 5560 43560 5540 43560 {}
C {lab_pin.sym} 5540 43560 0 0 {name=l35023 lab=WL218}
N 5640 43640 5660 43640 {}
C {lab_pin.sym} 5660 43640 0 0 {name=l35024 lab=VDD}
N 5640 43560 5660 43560 {}
C {lab_pin.sym} 5660 43560 0 0 {name=l35025 lab=VSS}
C {bitcell_6t.sym} 5800 43600 0 0 {name=Xr218c29}
N 5760 43640 5740 43640 {}
C {lab_pin.sym} 5740 43640 0 0 {name=l35026 lab=BL29}
N 5760 43600 5740 43600 {}
C {lab_pin.sym} 5740 43600 0 0 {name=l35027 lab=BLB29}
N 5760 43560 5740 43560 {}
C {lab_pin.sym} 5740 43560 0 0 {name=l35028 lab=WL218}
N 5840 43640 5860 43640 {}
C {lab_pin.sym} 5860 43640 0 0 {name=l35029 lab=VDD}
N 5840 43560 5860 43560 {}
C {lab_pin.sym} 5860 43560 0 0 {name=l35030 lab=VSS}
C {bitcell_6t.sym} 6000 43600 0 0 {name=Xr218c30}
N 5960 43640 5940 43640 {}
C {lab_pin.sym} 5940 43640 0 0 {name=l35031 lab=BL30}
N 5960 43600 5940 43600 {}
C {lab_pin.sym} 5940 43600 0 0 {name=l35032 lab=BLB30}
N 5960 43560 5940 43560 {}
C {lab_pin.sym} 5940 43560 0 0 {name=l35033 lab=WL218}
N 6040 43640 6060 43640 {}
C {lab_pin.sym} 6060 43640 0 0 {name=l35034 lab=VDD}
N 6040 43560 6060 43560 {}
C {lab_pin.sym} 6060 43560 0 0 {name=l35035 lab=VSS}
C {bitcell_6t.sym} 6200 43600 0 0 {name=Xr218c31}
N 6160 43640 6140 43640 {}
C {lab_pin.sym} 6140 43640 0 0 {name=l35036 lab=BL31}
N 6160 43600 6140 43600 {}
C {lab_pin.sym} 6140 43600 0 0 {name=l35037 lab=BLB31}
N 6160 43560 6140 43560 {}
C {lab_pin.sym} 6140 43560 0 0 {name=l35038 lab=WL218}
N 6240 43640 6260 43640 {}
C {lab_pin.sym} 6260 43640 0 0 {name=l35039 lab=VDD}
N 6240 43560 6260 43560 {}
C {lab_pin.sym} 6260 43560 0 0 {name=l35040 lab=VSS}
C {bitcell_6t.sym} 0 43800 0 0 {name=Xr219c0}
N -40 43840 -60 43840 {}
C {lab_pin.sym} -60 43840 0 0 {name=l35041 lab=BL0}
N -40 43800 -60 43800 {}
C {lab_pin.sym} -60 43800 0 0 {name=l35042 lab=BLB0}
N -40 43760 -60 43760 {}
C {lab_pin.sym} -60 43760 0 0 {name=l35043 lab=WL219}
N 40 43840 60 43840 {}
C {lab_pin.sym} 60 43840 0 0 {name=l35044 lab=VDD}
N 40 43760 60 43760 {}
C {lab_pin.sym} 60 43760 0 0 {name=l35045 lab=VSS}
C {bitcell_6t.sym} 200 43800 0 0 {name=Xr219c1}
N 160 43840 140 43840 {}
C {lab_pin.sym} 140 43840 0 0 {name=l35046 lab=BL1}
N 160 43800 140 43800 {}
C {lab_pin.sym} 140 43800 0 0 {name=l35047 lab=BLB1}
N 160 43760 140 43760 {}
C {lab_pin.sym} 140 43760 0 0 {name=l35048 lab=WL219}
N 240 43840 260 43840 {}
C {lab_pin.sym} 260 43840 0 0 {name=l35049 lab=VDD}
N 240 43760 260 43760 {}
C {lab_pin.sym} 260 43760 0 0 {name=l35050 lab=VSS}
C {bitcell_6t.sym} 400 43800 0 0 {name=Xr219c2}
N 360 43840 340 43840 {}
C {lab_pin.sym} 340 43840 0 0 {name=l35051 lab=BL2}
N 360 43800 340 43800 {}
C {lab_pin.sym} 340 43800 0 0 {name=l35052 lab=BLB2}
N 360 43760 340 43760 {}
C {lab_pin.sym} 340 43760 0 0 {name=l35053 lab=WL219}
N 440 43840 460 43840 {}
C {lab_pin.sym} 460 43840 0 0 {name=l35054 lab=VDD}
N 440 43760 460 43760 {}
C {lab_pin.sym} 460 43760 0 0 {name=l35055 lab=VSS}
C {bitcell_6t.sym} 600 43800 0 0 {name=Xr219c3}
N 560 43840 540 43840 {}
C {lab_pin.sym} 540 43840 0 0 {name=l35056 lab=BL3}
N 560 43800 540 43800 {}
C {lab_pin.sym} 540 43800 0 0 {name=l35057 lab=BLB3}
N 560 43760 540 43760 {}
C {lab_pin.sym} 540 43760 0 0 {name=l35058 lab=WL219}
N 640 43840 660 43840 {}
C {lab_pin.sym} 660 43840 0 0 {name=l35059 lab=VDD}
N 640 43760 660 43760 {}
C {lab_pin.sym} 660 43760 0 0 {name=l35060 lab=VSS}
C {bitcell_6t.sym} 800 43800 0 0 {name=Xr219c4}
N 760 43840 740 43840 {}
C {lab_pin.sym} 740 43840 0 0 {name=l35061 lab=BL4}
N 760 43800 740 43800 {}
C {lab_pin.sym} 740 43800 0 0 {name=l35062 lab=BLB4}
N 760 43760 740 43760 {}
C {lab_pin.sym} 740 43760 0 0 {name=l35063 lab=WL219}
N 840 43840 860 43840 {}
C {lab_pin.sym} 860 43840 0 0 {name=l35064 lab=VDD}
N 840 43760 860 43760 {}
C {lab_pin.sym} 860 43760 0 0 {name=l35065 lab=VSS}
C {bitcell_6t.sym} 1000 43800 0 0 {name=Xr219c5}
N 960 43840 940 43840 {}
C {lab_pin.sym} 940 43840 0 0 {name=l35066 lab=BL5}
N 960 43800 940 43800 {}
C {lab_pin.sym} 940 43800 0 0 {name=l35067 lab=BLB5}
N 960 43760 940 43760 {}
C {lab_pin.sym} 940 43760 0 0 {name=l35068 lab=WL219}
N 1040 43840 1060 43840 {}
C {lab_pin.sym} 1060 43840 0 0 {name=l35069 lab=VDD}
N 1040 43760 1060 43760 {}
C {lab_pin.sym} 1060 43760 0 0 {name=l35070 lab=VSS}
C {bitcell_6t.sym} 1200 43800 0 0 {name=Xr219c6}
N 1160 43840 1140 43840 {}
C {lab_pin.sym} 1140 43840 0 0 {name=l35071 lab=BL6}
N 1160 43800 1140 43800 {}
C {lab_pin.sym} 1140 43800 0 0 {name=l35072 lab=BLB6}
N 1160 43760 1140 43760 {}
C {lab_pin.sym} 1140 43760 0 0 {name=l35073 lab=WL219}
N 1240 43840 1260 43840 {}
C {lab_pin.sym} 1260 43840 0 0 {name=l35074 lab=VDD}
N 1240 43760 1260 43760 {}
C {lab_pin.sym} 1260 43760 0 0 {name=l35075 lab=VSS}
C {bitcell_6t.sym} 1400 43800 0 0 {name=Xr219c7}
N 1360 43840 1340 43840 {}
C {lab_pin.sym} 1340 43840 0 0 {name=l35076 lab=BL7}
N 1360 43800 1340 43800 {}
C {lab_pin.sym} 1340 43800 0 0 {name=l35077 lab=BLB7}
N 1360 43760 1340 43760 {}
C {lab_pin.sym} 1340 43760 0 0 {name=l35078 lab=WL219}
N 1440 43840 1460 43840 {}
C {lab_pin.sym} 1460 43840 0 0 {name=l35079 lab=VDD}
N 1440 43760 1460 43760 {}
C {lab_pin.sym} 1460 43760 0 0 {name=l35080 lab=VSS}
C {bitcell_6t.sym} 1600 43800 0 0 {name=Xr219c8}
N 1560 43840 1540 43840 {}
C {lab_pin.sym} 1540 43840 0 0 {name=l35081 lab=BL8}
N 1560 43800 1540 43800 {}
C {lab_pin.sym} 1540 43800 0 0 {name=l35082 lab=BLB8}
N 1560 43760 1540 43760 {}
C {lab_pin.sym} 1540 43760 0 0 {name=l35083 lab=WL219}
N 1640 43840 1660 43840 {}
C {lab_pin.sym} 1660 43840 0 0 {name=l35084 lab=VDD}
N 1640 43760 1660 43760 {}
C {lab_pin.sym} 1660 43760 0 0 {name=l35085 lab=VSS}
C {bitcell_6t.sym} 1800 43800 0 0 {name=Xr219c9}
N 1760 43840 1740 43840 {}
C {lab_pin.sym} 1740 43840 0 0 {name=l35086 lab=BL9}
N 1760 43800 1740 43800 {}
C {lab_pin.sym} 1740 43800 0 0 {name=l35087 lab=BLB9}
N 1760 43760 1740 43760 {}
C {lab_pin.sym} 1740 43760 0 0 {name=l35088 lab=WL219}
N 1840 43840 1860 43840 {}
C {lab_pin.sym} 1860 43840 0 0 {name=l35089 lab=VDD}
N 1840 43760 1860 43760 {}
C {lab_pin.sym} 1860 43760 0 0 {name=l35090 lab=VSS}
C {bitcell_6t.sym} 2000 43800 0 0 {name=Xr219c10}
N 1960 43840 1940 43840 {}
C {lab_pin.sym} 1940 43840 0 0 {name=l35091 lab=BL10}
N 1960 43800 1940 43800 {}
C {lab_pin.sym} 1940 43800 0 0 {name=l35092 lab=BLB10}
N 1960 43760 1940 43760 {}
C {lab_pin.sym} 1940 43760 0 0 {name=l35093 lab=WL219}
N 2040 43840 2060 43840 {}
C {lab_pin.sym} 2060 43840 0 0 {name=l35094 lab=VDD}
N 2040 43760 2060 43760 {}
C {lab_pin.sym} 2060 43760 0 0 {name=l35095 lab=VSS}
C {bitcell_6t.sym} 2200 43800 0 0 {name=Xr219c11}
N 2160 43840 2140 43840 {}
C {lab_pin.sym} 2140 43840 0 0 {name=l35096 lab=BL11}
N 2160 43800 2140 43800 {}
C {lab_pin.sym} 2140 43800 0 0 {name=l35097 lab=BLB11}
N 2160 43760 2140 43760 {}
C {lab_pin.sym} 2140 43760 0 0 {name=l35098 lab=WL219}
N 2240 43840 2260 43840 {}
C {lab_pin.sym} 2260 43840 0 0 {name=l35099 lab=VDD}
N 2240 43760 2260 43760 {}
C {lab_pin.sym} 2260 43760 0 0 {name=l35100 lab=VSS}
C {bitcell_6t.sym} 2400 43800 0 0 {name=Xr219c12}
N 2360 43840 2340 43840 {}
C {lab_pin.sym} 2340 43840 0 0 {name=l35101 lab=BL12}
N 2360 43800 2340 43800 {}
C {lab_pin.sym} 2340 43800 0 0 {name=l35102 lab=BLB12}
N 2360 43760 2340 43760 {}
C {lab_pin.sym} 2340 43760 0 0 {name=l35103 lab=WL219}
N 2440 43840 2460 43840 {}
C {lab_pin.sym} 2460 43840 0 0 {name=l35104 lab=VDD}
N 2440 43760 2460 43760 {}
C {lab_pin.sym} 2460 43760 0 0 {name=l35105 lab=VSS}
C {bitcell_6t.sym} 2600 43800 0 0 {name=Xr219c13}
N 2560 43840 2540 43840 {}
C {lab_pin.sym} 2540 43840 0 0 {name=l35106 lab=BL13}
N 2560 43800 2540 43800 {}
C {lab_pin.sym} 2540 43800 0 0 {name=l35107 lab=BLB13}
N 2560 43760 2540 43760 {}
C {lab_pin.sym} 2540 43760 0 0 {name=l35108 lab=WL219}
N 2640 43840 2660 43840 {}
C {lab_pin.sym} 2660 43840 0 0 {name=l35109 lab=VDD}
N 2640 43760 2660 43760 {}
C {lab_pin.sym} 2660 43760 0 0 {name=l35110 lab=VSS}
C {bitcell_6t.sym} 2800 43800 0 0 {name=Xr219c14}
N 2760 43840 2740 43840 {}
C {lab_pin.sym} 2740 43840 0 0 {name=l35111 lab=BL14}
N 2760 43800 2740 43800 {}
C {lab_pin.sym} 2740 43800 0 0 {name=l35112 lab=BLB14}
N 2760 43760 2740 43760 {}
C {lab_pin.sym} 2740 43760 0 0 {name=l35113 lab=WL219}
N 2840 43840 2860 43840 {}
C {lab_pin.sym} 2860 43840 0 0 {name=l35114 lab=VDD}
N 2840 43760 2860 43760 {}
C {lab_pin.sym} 2860 43760 0 0 {name=l35115 lab=VSS}
C {bitcell_6t.sym} 3000 43800 0 0 {name=Xr219c15}
N 2960 43840 2940 43840 {}
C {lab_pin.sym} 2940 43840 0 0 {name=l35116 lab=BL15}
N 2960 43800 2940 43800 {}
C {lab_pin.sym} 2940 43800 0 0 {name=l35117 lab=BLB15}
N 2960 43760 2940 43760 {}
C {lab_pin.sym} 2940 43760 0 0 {name=l35118 lab=WL219}
N 3040 43840 3060 43840 {}
C {lab_pin.sym} 3060 43840 0 0 {name=l35119 lab=VDD}
N 3040 43760 3060 43760 {}
C {lab_pin.sym} 3060 43760 0 0 {name=l35120 lab=VSS}
C {bitcell_6t.sym} 3200 43800 0 0 {name=Xr219c16}
N 3160 43840 3140 43840 {}
C {lab_pin.sym} 3140 43840 0 0 {name=l35121 lab=BL16}
N 3160 43800 3140 43800 {}
C {lab_pin.sym} 3140 43800 0 0 {name=l35122 lab=BLB16}
N 3160 43760 3140 43760 {}
C {lab_pin.sym} 3140 43760 0 0 {name=l35123 lab=WL219}
N 3240 43840 3260 43840 {}
C {lab_pin.sym} 3260 43840 0 0 {name=l35124 lab=VDD}
N 3240 43760 3260 43760 {}
C {lab_pin.sym} 3260 43760 0 0 {name=l35125 lab=VSS}
C {bitcell_6t.sym} 3400 43800 0 0 {name=Xr219c17}
N 3360 43840 3340 43840 {}
C {lab_pin.sym} 3340 43840 0 0 {name=l35126 lab=BL17}
N 3360 43800 3340 43800 {}
C {lab_pin.sym} 3340 43800 0 0 {name=l35127 lab=BLB17}
N 3360 43760 3340 43760 {}
C {lab_pin.sym} 3340 43760 0 0 {name=l35128 lab=WL219}
N 3440 43840 3460 43840 {}
C {lab_pin.sym} 3460 43840 0 0 {name=l35129 lab=VDD}
N 3440 43760 3460 43760 {}
C {lab_pin.sym} 3460 43760 0 0 {name=l35130 lab=VSS}
C {bitcell_6t.sym} 3600 43800 0 0 {name=Xr219c18}
N 3560 43840 3540 43840 {}
C {lab_pin.sym} 3540 43840 0 0 {name=l35131 lab=BL18}
N 3560 43800 3540 43800 {}
C {lab_pin.sym} 3540 43800 0 0 {name=l35132 lab=BLB18}
N 3560 43760 3540 43760 {}
C {lab_pin.sym} 3540 43760 0 0 {name=l35133 lab=WL219}
N 3640 43840 3660 43840 {}
C {lab_pin.sym} 3660 43840 0 0 {name=l35134 lab=VDD}
N 3640 43760 3660 43760 {}
C {lab_pin.sym} 3660 43760 0 0 {name=l35135 lab=VSS}
C {bitcell_6t.sym} 3800 43800 0 0 {name=Xr219c19}
N 3760 43840 3740 43840 {}
C {lab_pin.sym} 3740 43840 0 0 {name=l35136 lab=BL19}
N 3760 43800 3740 43800 {}
C {lab_pin.sym} 3740 43800 0 0 {name=l35137 lab=BLB19}
N 3760 43760 3740 43760 {}
C {lab_pin.sym} 3740 43760 0 0 {name=l35138 lab=WL219}
N 3840 43840 3860 43840 {}
C {lab_pin.sym} 3860 43840 0 0 {name=l35139 lab=VDD}
N 3840 43760 3860 43760 {}
C {lab_pin.sym} 3860 43760 0 0 {name=l35140 lab=VSS}
C {bitcell_6t.sym} 4000 43800 0 0 {name=Xr219c20}
N 3960 43840 3940 43840 {}
C {lab_pin.sym} 3940 43840 0 0 {name=l35141 lab=BL20}
N 3960 43800 3940 43800 {}
C {lab_pin.sym} 3940 43800 0 0 {name=l35142 lab=BLB20}
N 3960 43760 3940 43760 {}
C {lab_pin.sym} 3940 43760 0 0 {name=l35143 lab=WL219}
N 4040 43840 4060 43840 {}
C {lab_pin.sym} 4060 43840 0 0 {name=l35144 lab=VDD}
N 4040 43760 4060 43760 {}
C {lab_pin.sym} 4060 43760 0 0 {name=l35145 lab=VSS}
C {bitcell_6t.sym} 4200 43800 0 0 {name=Xr219c21}
N 4160 43840 4140 43840 {}
C {lab_pin.sym} 4140 43840 0 0 {name=l35146 lab=BL21}
N 4160 43800 4140 43800 {}
C {lab_pin.sym} 4140 43800 0 0 {name=l35147 lab=BLB21}
N 4160 43760 4140 43760 {}
C {lab_pin.sym} 4140 43760 0 0 {name=l35148 lab=WL219}
N 4240 43840 4260 43840 {}
C {lab_pin.sym} 4260 43840 0 0 {name=l35149 lab=VDD}
N 4240 43760 4260 43760 {}
C {lab_pin.sym} 4260 43760 0 0 {name=l35150 lab=VSS}
C {bitcell_6t.sym} 4400 43800 0 0 {name=Xr219c22}
N 4360 43840 4340 43840 {}
C {lab_pin.sym} 4340 43840 0 0 {name=l35151 lab=BL22}
N 4360 43800 4340 43800 {}
C {lab_pin.sym} 4340 43800 0 0 {name=l35152 lab=BLB22}
N 4360 43760 4340 43760 {}
C {lab_pin.sym} 4340 43760 0 0 {name=l35153 lab=WL219}
N 4440 43840 4460 43840 {}
C {lab_pin.sym} 4460 43840 0 0 {name=l35154 lab=VDD}
N 4440 43760 4460 43760 {}
C {lab_pin.sym} 4460 43760 0 0 {name=l35155 lab=VSS}
C {bitcell_6t.sym} 4600 43800 0 0 {name=Xr219c23}
N 4560 43840 4540 43840 {}
C {lab_pin.sym} 4540 43840 0 0 {name=l35156 lab=BL23}
N 4560 43800 4540 43800 {}
C {lab_pin.sym} 4540 43800 0 0 {name=l35157 lab=BLB23}
N 4560 43760 4540 43760 {}
C {lab_pin.sym} 4540 43760 0 0 {name=l35158 lab=WL219}
N 4640 43840 4660 43840 {}
C {lab_pin.sym} 4660 43840 0 0 {name=l35159 lab=VDD}
N 4640 43760 4660 43760 {}
C {lab_pin.sym} 4660 43760 0 0 {name=l35160 lab=VSS}
C {bitcell_6t.sym} 4800 43800 0 0 {name=Xr219c24}
N 4760 43840 4740 43840 {}
C {lab_pin.sym} 4740 43840 0 0 {name=l35161 lab=BL24}
N 4760 43800 4740 43800 {}
C {lab_pin.sym} 4740 43800 0 0 {name=l35162 lab=BLB24}
N 4760 43760 4740 43760 {}
C {lab_pin.sym} 4740 43760 0 0 {name=l35163 lab=WL219}
N 4840 43840 4860 43840 {}
C {lab_pin.sym} 4860 43840 0 0 {name=l35164 lab=VDD}
N 4840 43760 4860 43760 {}
C {lab_pin.sym} 4860 43760 0 0 {name=l35165 lab=VSS}
C {bitcell_6t.sym} 5000 43800 0 0 {name=Xr219c25}
N 4960 43840 4940 43840 {}
C {lab_pin.sym} 4940 43840 0 0 {name=l35166 lab=BL25}
N 4960 43800 4940 43800 {}
C {lab_pin.sym} 4940 43800 0 0 {name=l35167 lab=BLB25}
N 4960 43760 4940 43760 {}
C {lab_pin.sym} 4940 43760 0 0 {name=l35168 lab=WL219}
N 5040 43840 5060 43840 {}
C {lab_pin.sym} 5060 43840 0 0 {name=l35169 lab=VDD}
N 5040 43760 5060 43760 {}
C {lab_pin.sym} 5060 43760 0 0 {name=l35170 lab=VSS}
C {bitcell_6t.sym} 5200 43800 0 0 {name=Xr219c26}
N 5160 43840 5140 43840 {}
C {lab_pin.sym} 5140 43840 0 0 {name=l35171 lab=BL26}
N 5160 43800 5140 43800 {}
C {lab_pin.sym} 5140 43800 0 0 {name=l35172 lab=BLB26}
N 5160 43760 5140 43760 {}
C {lab_pin.sym} 5140 43760 0 0 {name=l35173 lab=WL219}
N 5240 43840 5260 43840 {}
C {lab_pin.sym} 5260 43840 0 0 {name=l35174 lab=VDD}
N 5240 43760 5260 43760 {}
C {lab_pin.sym} 5260 43760 0 0 {name=l35175 lab=VSS}
C {bitcell_6t.sym} 5400 43800 0 0 {name=Xr219c27}
N 5360 43840 5340 43840 {}
C {lab_pin.sym} 5340 43840 0 0 {name=l35176 lab=BL27}
N 5360 43800 5340 43800 {}
C {lab_pin.sym} 5340 43800 0 0 {name=l35177 lab=BLB27}
N 5360 43760 5340 43760 {}
C {lab_pin.sym} 5340 43760 0 0 {name=l35178 lab=WL219}
N 5440 43840 5460 43840 {}
C {lab_pin.sym} 5460 43840 0 0 {name=l35179 lab=VDD}
N 5440 43760 5460 43760 {}
C {lab_pin.sym} 5460 43760 0 0 {name=l35180 lab=VSS}
C {bitcell_6t.sym} 5600 43800 0 0 {name=Xr219c28}
N 5560 43840 5540 43840 {}
C {lab_pin.sym} 5540 43840 0 0 {name=l35181 lab=BL28}
N 5560 43800 5540 43800 {}
C {lab_pin.sym} 5540 43800 0 0 {name=l35182 lab=BLB28}
N 5560 43760 5540 43760 {}
C {lab_pin.sym} 5540 43760 0 0 {name=l35183 lab=WL219}
N 5640 43840 5660 43840 {}
C {lab_pin.sym} 5660 43840 0 0 {name=l35184 lab=VDD}
N 5640 43760 5660 43760 {}
C {lab_pin.sym} 5660 43760 0 0 {name=l35185 lab=VSS}
C {bitcell_6t.sym} 5800 43800 0 0 {name=Xr219c29}
N 5760 43840 5740 43840 {}
C {lab_pin.sym} 5740 43840 0 0 {name=l35186 lab=BL29}
N 5760 43800 5740 43800 {}
C {lab_pin.sym} 5740 43800 0 0 {name=l35187 lab=BLB29}
N 5760 43760 5740 43760 {}
C {lab_pin.sym} 5740 43760 0 0 {name=l35188 lab=WL219}
N 5840 43840 5860 43840 {}
C {lab_pin.sym} 5860 43840 0 0 {name=l35189 lab=VDD}
N 5840 43760 5860 43760 {}
C {lab_pin.sym} 5860 43760 0 0 {name=l35190 lab=VSS}
C {bitcell_6t.sym} 6000 43800 0 0 {name=Xr219c30}
N 5960 43840 5940 43840 {}
C {lab_pin.sym} 5940 43840 0 0 {name=l35191 lab=BL30}
N 5960 43800 5940 43800 {}
C {lab_pin.sym} 5940 43800 0 0 {name=l35192 lab=BLB30}
N 5960 43760 5940 43760 {}
C {lab_pin.sym} 5940 43760 0 0 {name=l35193 lab=WL219}
N 6040 43840 6060 43840 {}
C {lab_pin.sym} 6060 43840 0 0 {name=l35194 lab=VDD}
N 6040 43760 6060 43760 {}
C {lab_pin.sym} 6060 43760 0 0 {name=l35195 lab=VSS}
C {bitcell_6t.sym} 6200 43800 0 0 {name=Xr219c31}
N 6160 43840 6140 43840 {}
C {lab_pin.sym} 6140 43840 0 0 {name=l35196 lab=BL31}
N 6160 43800 6140 43800 {}
C {lab_pin.sym} 6140 43800 0 0 {name=l35197 lab=BLB31}
N 6160 43760 6140 43760 {}
C {lab_pin.sym} 6140 43760 0 0 {name=l35198 lab=WL219}
N 6240 43840 6260 43840 {}
C {lab_pin.sym} 6260 43840 0 0 {name=l35199 lab=VDD}
N 6240 43760 6260 43760 {}
C {lab_pin.sym} 6260 43760 0 0 {name=l35200 lab=VSS}
C {bitcell_6t.sym} 0 44000 0 0 {name=Xr220c0}
N -40 44040 -60 44040 {}
C {lab_pin.sym} -60 44040 0 0 {name=l35201 lab=BL0}
N -40 44000 -60 44000 {}
C {lab_pin.sym} -60 44000 0 0 {name=l35202 lab=BLB0}
N -40 43960 -60 43960 {}
C {lab_pin.sym} -60 43960 0 0 {name=l35203 lab=WL220}
N 40 44040 60 44040 {}
C {lab_pin.sym} 60 44040 0 0 {name=l35204 lab=VDD}
N 40 43960 60 43960 {}
C {lab_pin.sym} 60 43960 0 0 {name=l35205 lab=VSS}
C {bitcell_6t.sym} 200 44000 0 0 {name=Xr220c1}
N 160 44040 140 44040 {}
C {lab_pin.sym} 140 44040 0 0 {name=l35206 lab=BL1}
N 160 44000 140 44000 {}
C {lab_pin.sym} 140 44000 0 0 {name=l35207 lab=BLB1}
N 160 43960 140 43960 {}
C {lab_pin.sym} 140 43960 0 0 {name=l35208 lab=WL220}
N 240 44040 260 44040 {}
C {lab_pin.sym} 260 44040 0 0 {name=l35209 lab=VDD}
N 240 43960 260 43960 {}
C {lab_pin.sym} 260 43960 0 0 {name=l35210 lab=VSS}
C {bitcell_6t.sym} 400 44000 0 0 {name=Xr220c2}
N 360 44040 340 44040 {}
C {lab_pin.sym} 340 44040 0 0 {name=l35211 lab=BL2}
N 360 44000 340 44000 {}
C {lab_pin.sym} 340 44000 0 0 {name=l35212 lab=BLB2}
N 360 43960 340 43960 {}
C {lab_pin.sym} 340 43960 0 0 {name=l35213 lab=WL220}
N 440 44040 460 44040 {}
C {lab_pin.sym} 460 44040 0 0 {name=l35214 lab=VDD}
N 440 43960 460 43960 {}
C {lab_pin.sym} 460 43960 0 0 {name=l35215 lab=VSS}
C {bitcell_6t.sym} 600 44000 0 0 {name=Xr220c3}
N 560 44040 540 44040 {}
C {lab_pin.sym} 540 44040 0 0 {name=l35216 lab=BL3}
N 560 44000 540 44000 {}
C {lab_pin.sym} 540 44000 0 0 {name=l35217 lab=BLB3}
N 560 43960 540 43960 {}
C {lab_pin.sym} 540 43960 0 0 {name=l35218 lab=WL220}
N 640 44040 660 44040 {}
C {lab_pin.sym} 660 44040 0 0 {name=l35219 lab=VDD}
N 640 43960 660 43960 {}
C {lab_pin.sym} 660 43960 0 0 {name=l35220 lab=VSS}
C {bitcell_6t.sym} 800 44000 0 0 {name=Xr220c4}
N 760 44040 740 44040 {}
C {lab_pin.sym} 740 44040 0 0 {name=l35221 lab=BL4}
N 760 44000 740 44000 {}
C {lab_pin.sym} 740 44000 0 0 {name=l35222 lab=BLB4}
N 760 43960 740 43960 {}
C {lab_pin.sym} 740 43960 0 0 {name=l35223 lab=WL220}
N 840 44040 860 44040 {}
C {lab_pin.sym} 860 44040 0 0 {name=l35224 lab=VDD}
N 840 43960 860 43960 {}
C {lab_pin.sym} 860 43960 0 0 {name=l35225 lab=VSS}
C {bitcell_6t.sym} 1000 44000 0 0 {name=Xr220c5}
N 960 44040 940 44040 {}
C {lab_pin.sym} 940 44040 0 0 {name=l35226 lab=BL5}
N 960 44000 940 44000 {}
C {lab_pin.sym} 940 44000 0 0 {name=l35227 lab=BLB5}
N 960 43960 940 43960 {}
C {lab_pin.sym} 940 43960 0 0 {name=l35228 lab=WL220}
N 1040 44040 1060 44040 {}
C {lab_pin.sym} 1060 44040 0 0 {name=l35229 lab=VDD}
N 1040 43960 1060 43960 {}
C {lab_pin.sym} 1060 43960 0 0 {name=l35230 lab=VSS}
C {bitcell_6t.sym} 1200 44000 0 0 {name=Xr220c6}
N 1160 44040 1140 44040 {}
C {lab_pin.sym} 1140 44040 0 0 {name=l35231 lab=BL6}
N 1160 44000 1140 44000 {}
C {lab_pin.sym} 1140 44000 0 0 {name=l35232 lab=BLB6}
N 1160 43960 1140 43960 {}
C {lab_pin.sym} 1140 43960 0 0 {name=l35233 lab=WL220}
N 1240 44040 1260 44040 {}
C {lab_pin.sym} 1260 44040 0 0 {name=l35234 lab=VDD}
N 1240 43960 1260 43960 {}
C {lab_pin.sym} 1260 43960 0 0 {name=l35235 lab=VSS}
C {bitcell_6t.sym} 1400 44000 0 0 {name=Xr220c7}
N 1360 44040 1340 44040 {}
C {lab_pin.sym} 1340 44040 0 0 {name=l35236 lab=BL7}
N 1360 44000 1340 44000 {}
C {lab_pin.sym} 1340 44000 0 0 {name=l35237 lab=BLB7}
N 1360 43960 1340 43960 {}
C {lab_pin.sym} 1340 43960 0 0 {name=l35238 lab=WL220}
N 1440 44040 1460 44040 {}
C {lab_pin.sym} 1460 44040 0 0 {name=l35239 lab=VDD}
N 1440 43960 1460 43960 {}
C {lab_pin.sym} 1460 43960 0 0 {name=l35240 lab=VSS}
C {bitcell_6t.sym} 1600 44000 0 0 {name=Xr220c8}
N 1560 44040 1540 44040 {}
C {lab_pin.sym} 1540 44040 0 0 {name=l35241 lab=BL8}
N 1560 44000 1540 44000 {}
C {lab_pin.sym} 1540 44000 0 0 {name=l35242 lab=BLB8}
N 1560 43960 1540 43960 {}
C {lab_pin.sym} 1540 43960 0 0 {name=l35243 lab=WL220}
N 1640 44040 1660 44040 {}
C {lab_pin.sym} 1660 44040 0 0 {name=l35244 lab=VDD}
N 1640 43960 1660 43960 {}
C {lab_pin.sym} 1660 43960 0 0 {name=l35245 lab=VSS}
C {bitcell_6t.sym} 1800 44000 0 0 {name=Xr220c9}
N 1760 44040 1740 44040 {}
C {lab_pin.sym} 1740 44040 0 0 {name=l35246 lab=BL9}
N 1760 44000 1740 44000 {}
C {lab_pin.sym} 1740 44000 0 0 {name=l35247 lab=BLB9}
N 1760 43960 1740 43960 {}
C {lab_pin.sym} 1740 43960 0 0 {name=l35248 lab=WL220}
N 1840 44040 1860 44040 {}
C {lab_pin.sym} 1860 44040 0 0 {name=l35249 lab=VDD}
N 1840 43960 1860 43960 {}
C {lab_pin.sym} 1860 43960 0 0 {name=l35250 lab=VSS}
C {bitcell_6t.sym} 2000 44000 0 0 {name=Xr220c10}
N 1960 44040 1940 44040 {}
C {lab_pin.sym} 1940 44040 0 0 {name=l35251 lab=BL10}
N 1960 44000 1940 44000 {}
C {lab_pin.sym} 1940 44000 0 0 {name=l35252 lab=BLB10}
N 1960 43960 1940 43960 {}
C {lab_pin.sym} 1940 43960 0 0 {name=l35253 lab=WL220}
N 2040 44040 2060 44040 {}
C {lab_pin.sym} 2060 44040 0 0 {name=l35254 lab=VDD}
N 2040 43960 2060 43960 {}
C {lab_pin.sym} 2060 43960 0 0 {name=l35255 lab=VSS}
C {bitcell_6t.sym} 2200 44000 0 0 {name=Xr220c11}
N 2160 44040 2140 44040 {}
C {lab_pin.sym} 2140 44040 0 0 {name=l35256 lab=BL11}
N 2160 44000 2140 44000 {}
C {lab_pin.sym} 2140 44000 0 0 {name=l35257 lab=BLB11}
N 2160 43960 2140 43960 {}
C {lab_pin.sym} 2140 43960 0 0 {name=l35258 lab=WL220}
N 2240 44040 2260 44040 {}
C {lab_pin.sym} 2260 44040 0 0 {name=l35259 lab=VDD}
N 2240 43960 2260 43960 {}
C {lab_pin.sym} 2260 43960 0 0 {name=l35260 lab=VSS}
C {bitcell_6t.sym} 2400 44000 0 0 {name=Xr220c12}
N 2360 44040 2340 44040 {}
C {lab_pin.sym} 2340 44040 0 0 {name=l35261 lab=BL12}
N 2360 44000 2340 44000 {}
C {lab_pin.sym} 2340 44000 0 0 {name=l35262 lab=BLB12}
N 2360 43960 2340 43960 {}
C {lab_pin.sym} 2340 43960 0 0 {name=l35263 lab=WL220}
N 2440 44040 2460 44040 {}
C {lab_pin.sym} 2460 44040 0 0 {name=l35264 lab=VDD}
N 2440 43960 2460 43960 {}
C {lab_pin.sym} 2460 43960 0 0 {name=l35265 lab=VSS}
C {bitcell_6t.sym} 2600 44000 0 0 {name=Xr220c13}
N 2560 44040 2540 44040 {}
C {lab_pin.sym} 2540 44040 0 0 {name=l35266 lab=BL13}
N 2560 44000 2540 44000 {}
C {lab_pin.sym} 2540 44000 0 0 {name=l35267 lab=BLB13}
N 2560 43960 2540 43960 {}
C {lab_pin.sym} 2540 43960 0 0 {name=l35268 lab=WL220}
N 2640 44040 2660 44040 {}
C {lab_pin.sym} 2660 44040 0 0 {name=l35269 lab=VDD}
N 2640 43960 2660 43960 {}
C {lab_pin.sym} 2660 43960 0 0 {name=l35270 lab=VSS}
C {bitcell_6t.sym} 2800 44000 0 0 {name=Xr220c14}
N 2760 44040 2740 44040 {}
C {lab_pin.sym} 2740 44040 0 0 {name=l35271 lab=BL14}
N 2760 44000 2740 44000 {}
C {lab_pin.sym} 2740 44000 0 0 {name=l35272 lab=BLB14}
N 2760 43960 2740 43960 {}
C {lab_pin.sym} 2740 43960 0 0 {name=l35273 lab=WL220}
N 2840 44040 2860 44040 {}
C {lab_pin.sym} 2860 44040 0 0 {name=l35274 lab=VDD}
N 2840 43960 2860 43960 {}
C {lab_pin.sym} 2860 43960 0 0 {name=l35275 lab=VSS}
C {bitcell_6t.sym} 3000 44000 0 0 {name=Xr220c15}
N 2960 44040 2940 44040 {}
C {lab_pin.sym} 2940 44040 0 0 {name=l35276 lab=BL15}
N 2960 44000 2940 44000 {}
C {lab_pin.sym} 2940 44000 0 0 {name=l35277 lab=BLB15}
N 2960 43960 2940 43960 {}
C {lab_pin.sym} 2940 43960 0 0 {name=l35278 lab=WL220}
N 3040 44040 3060 44040 {}
C {lab_pin.sym} 3060 44040 0 0 {name=l35279 lab=VDD}
N 3040 43960 3060 43960 {}
C {lab_pin.sym} 3060 43960 0 0 {name=l35280 lab=VSS}
C {bitcell_6t.sym} 3200 44000 0 0 {name=Xr220c16}
N 3160 44040 3140 44040 {}
C {lab_pin.sym} 3140 44040 0 0 {name=l35281 lab=BL16}
N 3160 44000 3140 44000 {}
C {lab_pin.sym} 3140 44000 0 0 {name=l35282 lab=BLB16}
N 3160 43960 3140 43960 {}
C {lab_pin.sym} 3140 43960 0 0 {name=l35283 lab=WL220}
N 3240 44040 3260 44040 {}
C {lab_pin.sym} 3260 44040 0 0 {name=l35284 lab=VDD}
N 3240 43960 3260 43960 {}
C {lab_pin.sym} 3260 43960 0 0 {name=l35285 lab=VSS}
C {bitcell_6t.sym} 3400 44000 0 0 {name=Xr220c17}
N 3360 44040 3340 44040 {}
C {lab_pin.sym} 3340 44040 0 0 {name=l35286 lab=BL17}
N 3360 44000 3340 44000 {}
C {lab_pin.sym} 3340 44000 0 0 {name=l35287 lab=BLB17}
N 3360 43960 3340 43960 {}
C {lab_pin.sym} 3340 43960 0 0 {name=l35288 lab=WL220}
N 3440 44040 3460 44040 {}
C {lab_pin.sym} 3460 44040 0 0 {name=l35289 lab=VDD}
N 3440 43960 3460 43960 {}
C {lab_pin.sym} 3460 43960 0 0 {name=l35290 lab=VSS}
C {bitcell_6t.sym} 3600 44000 0 0 {name=Xr220c18}
N 3560 44040 3540 44040 {}
C {lab_pin.sym} 3540 44040 0 0 {name=l35291 lab=BL18}
N 3560 44000 3540 44000 {}
C {lab_pin.sym} 3540 44000 0 0 {name=l35292 lab=BLB18}
N 3560 43960 3540 43960 {}
C {lab_pin.sym} 3540 43960 0 0 {name=l35293 lab=WL220}
N 3640 44040 3660 44040 {}
C {lab_pin.sym} 3660 44040 0 0 {name=l35294 lab=VDD}
N 3640 43960 3660 43960 {}
C {lab_pin.sym} 3660 43960 0 0 {name=l35295 lab=VSS}
C {bitcell_6t.sym} 3800 44000 0 0 {name=Xr220c19}
N 3760 44040 3740 44040 {}
C {lab_pin.sym} 3740 44040 0 0 {name=l35296 lab=BL19}
N 3760 44000 3740 44000 {}
C {lab_pin.sym} 3740 44000 0 0 {name=l35297 lab=BLB19}
N 3760 43960 3740 43960 {}
C {lab_pin.sym} 3740 43960 0 0 {name=l35298 lab=WL220}
N 3840 44040 3860 44040 {}
C {lab_pin.sym} 3860 44040 0 0 {name=l35299 lab=VDD}
N 3840 43960 3860 43960 {}
C {lab_pin.sym} 3860 43960 0 0 {name=l35300 lab=VSS}
C {bitcell_6t.sym} 4000 44000 0 0 {name=Xr220c20}
N 3960 44040 3940 44040 {}
C {lab_pin.sym} 3940 44040 0 0 {name=l35301 lab=BL20}
N 3960 44000 3940 44000 {}
C {lab_pin.sym} 3940 44000 0 0 {name=l35302 lab=BLB20}
N 3960 43960 3940 43960 {}
C {lab_pin.sym} 3940 43960 0 0 {name=l35303 lab=WL220}
N 4040 44040 4060 44040 {}
C {lab_pin.sym} 4060 44040 0 0 {name=l35304 lab=VDD}
N 4040 43960 4060 43960 {}
C {lab_pin.sym} 4060 43960 0 0 {name=l35305 lab=VSS}
C {bitcell_6t.sym} 4200 44000 0 0 {name=Xr220c21}
N 4160 44040 4140 44040 {}
C {lab_pin.sym} 4140 44040 0 0 {name=l35306 lab=BL21}
N 4160 44000 4140 44000 {}
C {lab_pin.sym} 4140 44000 0 0 {name=l35307 lab=BLB21}
N 4160 43960 4140 43960 {}
C {lab_pin.sym} 4140 43960 0 0 {name=l35308 lab=WL220}
N 4240 44040 4260 44040 {}
C {lab_pin.sym} 4260 44040 0 0 {name=l35309 lab=VDD}
N 4240 43960 4260 43960 {}
C {lab_pin.sym} 4260 43960 0 0 {name=l35310 lab=VSS}
C {bitcell_6t.sym} 4400 44000 0 0 {name=Xr220c22}
N 4360 44040 4340 44040 {}
C {lab_pin.sym} 4340 44040 0 0 {name=l35311 lab=BL22}
N 4360 44000 4340 44000 {}
C {lab_pin.sym} 4340 44000 0 0 {name=l35312 lab=BLB22}
N 4360 43960 4340 43960 {}
C {lab_pin.sym} 4340 43960 0 0 {name=l35313 lab=WL220}
N 4440 44040 4460 44040 {}
C {lab_pin.sym} 4460 44040 0 0 {name=l35314 lab=VDD}
N 4440 43960 4460 43960 {}
C {lab_pin.sym} 4460 43960 0 0 {name=l35315 lab=VSS}
C {bitcell_6t.sym} 4600 44000 0 0 {name=Xr220c23}
N 4560 44040 4540 44040 {}
C {lab_pin.sym} 4540 44040 0 0 {name=l35316 lab=BL23}
N 4560 44000 4540 44000 {}
C {lab_pin.sym} 4540 44000 0 0 {name=l35317 lab=BLB23}
N 4560 43960 4540 43960 {}
C {lab_pin.sym} 4540 43960 0 0 {name=l35318 lab=WL220}
N 4640 44040 4660 44040 {}
C {lab_pin.sym} 4660 44040 0 0 {name=l35319 lab=VDD}
N 4640 43960 4660 43960 {}
C {lab_pin.sym} 4660 43960 0 0 {name=l35320 lab=VSS}
C {bitcell_6t.sym} 4800 44000 0 0 {name=Xr220c24}
N 4760 44040 4740 44040 {}
C {lab_pin.sym} 4740 44040 0 0 {name=l35321 lab=BL24}
N 4760 44000 4740 44000 {}
C {lab_pin.sym} 4740 44000 0 0 {name=l35322 lab=BLB24}
N 4760 43960 4740 43960 {}
C {lab_pin.sym} 4740 43960 0 0 {name=l35323 lab=WL220}
N 4840 44040 4860 44040 {}
C {lab_pin.sym} 4860 44040 0 0 {name=l35324 lab=VDD}
N 4840 43960 4860 43960 {}
C {lab_pin.sym} 4860 43960 0 0 {name=l35325 lab=VSS}
C {bitcell_6t.sym} 5000 44000 0 0 {name=Xr220c25}
N 4960 44040 4940 44040 {}
C {lab_pin.sym} 4940 44040 0 0 {name=l35326 lab=BL25}
N 4960 44000 4940 44000 {}
C {lab_pin.sym} 4940 44000 0 0 {name=l35327 lab=BLB25}
N 4960 43960 4940 43960 {}
C {lab_pin.sym} 4940 43960 0 0 {name=l35328 lab=WL220}
N 5040 44040 5060 44040 {}
C {lab_pin.sym} 5060 44040 0 0 {name=l35329 lab=VDD}
N 5040 43960 5060 43960 {}
C {lab_pin.sym} 5060 43960 0 0 {name=l35330 lab=VSS}
C {bitcell_6t.sym} 5200 44000 0 0 {name=Xr220c26}
N 5160 44040 5140 44040 {}
C {lab_pin.sym} 5140 44040 0 0 {name=l35331 lab=BL26}
N 5160 44000 5140 44000 {}
C {lab_pin.sym} 5140 44000 0 0 {name=l35332 lab=BLB26}
N 5160 43960 5140 43960 {}
C {lab_pin.sym} 5140 43960 0 0 {name=l35333 lab=WL220}
N 5240 44040 5260 44040 {}
C {lab_pin.sym} 5260 44040 0 0 {name=l35334 lab=VDD}
N 5240 43960 5260 43960 {}
C {lab_pin.sym} 5260 43960 0 0 {name=l35335 lab=VSS}
C {bitcell_6t.sym} 5400 44000 0 0 {name=Xr220c27}
N 5360 44040 5340 44040 {}
C {lab_pin.sym} 5340 44040 0 0 {name=l35336 lab=BL27}
N 5360 44000 5340 44000 {}
C {lab_pin.sym} 5340 44000 0 0 {name=l35337 lab=BLB27}
N 5360 43960 5340 43960 {}
C {lab_pin.sym} 5340 43960 0 0 {name=l35338 lab=WL220}
N 5440 44040 5460 44040 {}
C {lab_pin.sym} 5460 44040 0 0 {name=l35339 lab=VDD}
N 5440 43960 5460 43960 {}
C {lab_pin.sym} 5460 43960 0 0 {name=l35340 lab=VSS}
C {bitcell_6t.sym} 5600 44000 0 0 {name=Xr220c28}
N 5560 44040 5540 44040 {}
C {lab_pin.sym} 5540 44040 0 0 {name=l35341 lab=BL28}
N 5560 44000 5540 44000 {}
C {lab_pin.sym} 5540 44000 0 0 {name=l35342 lab=BLB28}
N 5560 43960 5540 43960 {}
C {lab_pin.sym} 5540 43960 0 0 {name=l35343 lab=WL220}
N 5640 44040 5660 44040 {}
C {lab_pin.sym} 5660 44040 0 0 {name=l35344 lab=VDD}
N 5640 43960 5660 43960 {}
C {lab_pin.sym} 5660 43960 0 0 {name=l35345 lab=VSS}
C {bitcell_6t.sym} 5800 44000 0 0 {name=Xr220c29}
N 5760 44040 5740 44040 {}
C {lab_pin.sym} 5740 44040 0 0 {name=l35346 lab=BL29}
N 5760 44000 5740 44000 {}
C {lab_pin.sym} 5740 44000 0 0 {name=l35347 lab=BLB29}
N 5760 43960 5740 43960 {}
C {lab_pin.sym} 5740 43960 0 0 {name=l35348 lab=WL220}
N 5840 44040 5860 44040 {}
C {lab_pin.sym} 5860 44040 0 0 {name=l35349 lab=VDD}
N 5840 43960 5860 43960 {}
C {lab_pin.sym} 5860 43960 0 0 {name=l35350 lab=VSS}
C {bitcell_6t.sym} 6000 44000 0 0 {name=Xr220c30}
N 5960 44040 5940 44040 {}
C {lab_pin.sym} 5940 44040 0 0 {name=l35351 lab=BL30}
N 5960 44000 5940 44000 {}
C {lab_pin.sym} 5940 44000 0 0 {name=l35352 lab=BLB30}
N 5960 43960 5940 43960 {}
C {lab_pin.sym} 5940 43960 0 0 {name=l35353 lab=WL220}
N 6040 44040 6060 44040 {}
C {lab_pin.sym} 6060 44040 0 0 {name=l35354 lab=VDD}
N 6040 43960 6060 43960 {}
C {lab_pin.sym} 6060 43960 0 0 {name=l35355 lab=VSS}
C {bitcell_6t.sym} 6200 44000 0 0 {name=Xr220c31}
N 6160 44040 6140 44040 {}
C {lab_pin.sym} 6140 44040 0 0 {name=l35356 lab=BL31}
N 6160 44000 6140 44000 {}
C {lab_pin.sym} 6140 44000 0 0 {name=l35357 lab=BLB31}
N 6160 43960 6140 43960 {}
C {lab_pin.sym} 6140 43960 0 0 {name=l35358 lab=WL220}
N 6240 44040 6260 44040 {}
C {lab_pin.sym} 6260 44040 0 0 {name=l35359 lab=VDD}
N 6240 43960 6260 43960 {}
C {lab_pin.sym} 6260 43960 0 0 {name=l35360 lab=VSS}
C {bitcell_6t.sym} 0 44200 0 0 {name=Xr221c0}
N -40 44240 -60 44240 {}
C {lab_pin.sym} -60 44240 0 0 {name=l35361 lab=BL0}
N -40 44200 -60 44200 {}
C {lab_pin.sym} -60 44200 0 0 {name=l35362 lab=BLB0}
N -40 44160 -60 44160 {}
C {lab_pin.sym} -60 44160 0 0 {name=l35363 lab=WL221}
N 40 44240 60 44240 {}
C {lab_pin.sym} 60 44240 0 0 {name=l35364 lab=VDD}
N 40 44160 60 44160 {}
C {lab_pin.sym} 60 44160 0 0 {name=l35365 lab=VSS}
C {bitcell_6t.sym} 200 44200 0 0 {name=Xr221c1}
N 160 44240 140 44240 {}
C {lab_pin.sym} 140 44240 0 0 {name=l35366 lab=BL1}
N 160 44200 140 44200 {}
C {lab_pin.sym} 140 44200 0 0 {name=l35367 lab=BLB1}
N 160 44160 140 44160 {}
C {lab_pin.sym} 140 44160 0 0 {name=l35368 lab=WL221}
N 240 44240 260 44240 {}
C {lab_pin.sym} 260 44240 0 0 {name=l35369 lab=VDD}
N 240 44160 260 44160 {}
C {lab_pin.sym} 260 44160 0 0 {name=l35370 lab=VSS}
C {bitcell_6t.sym} 400 44200 0 0 {name=Xr221c2}
N 360 44240 340 44240 {}
C {lab_pin.sym} 340 44240 0 0 {name=l35371 lab=BL2}
N 360 44200 340 44200 {}
C {lab_pin.sym} 340 44200 0 0 {name=l35372 lab=BLB2}
N 360 44160 340 44160 {}
C {lab_pin.sym} 340 44160 0 0 {name=l35373 lab=WL221}
N 440 44240 460 44240 {}
C {lab_pin.sym} 460 44240 0 0 {name=l35374 lab=VDD}
N 440 44160 460 44160 {}
C {lab_pin.sym} 460 44160 0 0 {name=l35375 lab=VSS}
C {bitcell_6t.sym} 600 44200 0 0 {name=Xr221c3}
N 560 44240 540 44240 {}
C {lab_pin.sym} 540 44240 0 0 {name=l35376 lab=BL3}
N 560 44200 540 44200 {}
C {lab_pin.sym} 540 44200 0 0 {name=l35377 lab=BLB3}
N 560 44160 540 44160 {}
C {lab_pin.sym} 540 44160 0 0 {name=l35378 lab=WL221}
N 640 44240 660 44240 {}
C {lab_pin.sym} 660 44240 0 0 {name=l35379 lab=VDD}
N 640 44160 660 44160 {}
C {lab_pin.sym} 660 44160 0 0 {name=l35380 lab=VSS}
C {bitcell_6t.sym} 800 44200 0 0 {name=Xr221c4}
N 760 44240 740 44240 {}
C {lab_pin.sym} 740 44240 0 0 {name=l35381 lab=BL4}
N 760 44200 740 44200 {}
C {lab_pin.sym} 740 44200 0 0 {name=l35382 lab=BLB4}
N 760 44160 740 44160 {}
C {lab_pin.sym} 740 44160 0 0 {name=l35383 lab=WL221}
N 840 44240 860 44240 {}
C {lab_pin.sym} 860 44240 0 0 {name=l35384 lab=VDD}
N 840 44160 860 44160 {}
C {lab_pin.sym} 860 44160 0 0 {name=l35385 lab=VSS}
C {bitcell_6t.sym} 1000 44200 0 0 {name=Xr221c5}
N 960 44240 940 44240 {}
C {lab_pin.sym} 940 44240 0 0 {name=l35386 lab=BL5}
N 960 44200 940 44200 {}
C {lab_pin.sym} 940 44200 0 0 {name=l35387 lab=BLB5}
N 960 44160 940 44160 {}
C {lab_pin.sym} 940 44160 0 0 {name=l35388 lab=WL221}
N 1040 44240 1060 44240 {}
C {lab_pin.sym} 1060 44240 0 0 {name=l35389 lab=VDD}
N 1040 44160 1060 44160 {}
C {lab_pin.sym} 1060 44160 0 0 {name=l35390 lab=VSS}
C {bitcell_6t.sym} 1200 44200 0 0 {name=Xr221c6}
N 1160 44240 1140 44240 {}
C {lab_pin.sym} 1140 44240 0 0 {name=l35391 lab=BL6}
N 1160 44200 1140 44200 {}
C {lab_pin.sym} 1140 44200 0 0 {name=l35392 lab=BLB6}
N 1160 44160 1140 44160 {}
C {lab_pin.sym} 1140 44160 0 0 {name=l35393 lab=WL221}
N 1240 44240 1260 44240 {}
C {lab_pin.sym} 1260 44240 0 0 {name=l35394 lab=VDD}
N 1240 44160 1260 44160 {}
C {lab_pin.sym} 1260 44160 0 0 {name=l35395 lab=VSS}
C {bitcell_6t.sym} 1400 44200 0 0 {name=Xr221c7}
N 1360 44240 1340 44240 {}
C {lab_pin.sym} 1340 44240 0 0 {name=l35396 lab=BL7}
N 1360 44200 1340 44200 {}
C {lab_pin.sym} 1340 44200 0 0 {name=l35397 lab=BLB7}
N 1360 44160 1340 44160 {}
C {lab_pin.sym} 1340 44160 0 0 {name=l35398 lab=WL221}
N 1440 44240 1460 44240 {}
C {lab_pin.sym} 1460 44240 0 0 {name=l35399 lab=VDD}
N 1440 44160 1460 44160 {}
C {lab_pin.sym} 1460 44160 0 0 {name=l35400 lab=VSS}
C {bitcell_6t.sym} 1600 44200 0 0 {name=Xr221c8}
N 1560 44240 1540 44240 {}
C {lab_pin.sym} 1540 44240 0 0 {name=l35401 lab=BL8}
N 1560 44200 1540 44200 {}
C {lab_pin.sym} 1540 44200 0 0 {name=l35402 lab=BLB8}
N 1560 44160 1540 44160 {}
C {lab_pin.sym} 1540 44160 0 0 {name=l35403 lab=WL221}
N 1640 44240 1660 44240 {}
C {lab_pin.sym} 1660 44240 0 0 {name=l35404 lab=VDD}
N 1640 44160 1660 44160 {}
C {lab_pin.sym} 1660 44160 0 0 {name=l35405 lab=VSS}
C {bitcell_6t.sym} 1800 44200 0 0 {name=Xr221c9}
N 1760 44240 1740 44240 {}
C {lab_pin.sym} 1740 44240 0 0 {name=l35406 lab=BL9}
N 1760 44200 1740 44200 {}
C {lab_pin.sym} 1740 44200 0 0 {name=l35407 lab=BLB9}
N 1760 44160 1740 44160 {}
C {lab_pin.sym} 1740 44160 0 0 {name=l35408 lab=WL221}
N 1840 44240 1860 44240 {}
C {lab_pin.sym} 1860 44240 0 0 {name=l35409 lab=VDD}
N 1840 44160 1860 44160 {}
C {lab_pin.sym} 1860 44160 0 0 {name=l35410 lab=VSS}
C {bitcell_6t.sym} 2000 44200 0 0 {name=Xr221c10}
N 1960 44240 1940 44240 {}
C {lab_pin.sym} 1940 44240 0 0 {name=l35411 lab=BL10}
N 1960 44200 1940 44200 {}
C {lab_pin.sym} 1940 44200 0 0 {name=l35412 lab=BLB10}
N 1960 44160 1940 44160 {}
C {lab_pin.sym} 1940 44160 0 0 {name=l35413 lab=WL221}
N 2040 44240 2060 44240 {}
C {lab_pin.sym} 2060 44240 0 0 {name=l35414 lab=VDD}
N 2040 44160 2060 44160 {}
C {lab_pin.sym} 2060 44160 0 0 {name=l35415 lab=VSS}
C {bitcell_6t.sym} 2200 44200 0 0 {name=Xr221c11}
N 2160 44240 2140 44240 {}
C {lab_pin.sym} 2140 44240 0 0 {name=l35416 lab=BL11}
N 2160 44200 2140 44200 {}
C {lab_pin.sym} 2140 44200 0 0 {name=l35417 lab=BLB11}
N 2160 44160 2140 44160 {}
C {lab_pin.sym} 2140 44160 0 0 {name=l35418 lab=WL221}
N 2240 44240 2260 44240 {}
C {lab_pin.sym} 2260 44240 0 0 {name=l35419 lab=VDD}
N 2240 44160 2260 44160 {}
C {lab_pin.sym} 2260 44160 0 0 {name=l35420 lab=VSS}
C {bitcell_6t.sym} 2400 44200 0 0 {name=Xr221c12}
N 2360 44240 2340 44240 {}
C {lab_pin.sym} 2340 44240 0 0 {name=l35421 lab=BL12}
N 2360 44200 2340 44200 {}
C {lab_pin.sym} 2340 44200 0 0 {name=l35422 lab=BLB12}
N 2360 44160 2340 44160 {}
C {lab_pin.sym} 2340 44160 0 0 {name=l35423 lab=WL221}
N 2440 44240 2460 44240 {}
C {lab_pin.sym} 2460 44240 0 0 {name=l35424 lab=VDD}
N 2440 44160 2460 44160 {}
C {lab_pin.sym} 2460 44160 0 0 {name=l35425 lab=VSS}
C {bitcell_6t.sym} 2600 44200 0 0 {name=Xr221c13}
N 2560 44240 2540 44240 {}
C {lab_pin.sym} 2540 44240 0 0 {name=l35426 lab=BL13}
N 2560 44200 2540 44200 {}
C {lab_pin.sym} 2540 44200 0 0 {name=l35427 lab=BLB13}
N 2560 44160 2540 44160 {}
C {lab_pin.sym} 2540 44160 0 0 {name=l35428 lab=WL221}
N 2640 44240 2660 44240 {}
C {lab_pin.sym} 2660 44240 0 0 {name=l35429 lab=VDD}
N 2640 44160 2660 44160 {}
C {lab_pin.sym} 2660 44160 0 0 {name=l35430 lab=VSS}
C {bitcell_6t.sym} 2800 44200 0 0 {name=Xr221c14}
N 2760 44240 2740 44240 {}
C {lab_pin.sym} 2740 44240 0 0 {name=l35431 lab=BL14}
N 2760 44200 2740 44200 {}
C {lab_pin.sym} 2740 44200 0 0 {name=l35432 lab=BLB14}
N 2760 44160 2740 44160 {}
C {lab_pin.sym} 2740 44160 0 0 {name=l35433 lab=WL221}
N 2840 44240 2860 44240 {}
C {lab_pin.sym} 2860 44240 0 0 {name=l35434 lab=VDD}
N 2840 44160 2860 44160 {}
C {lab_pin.sym} 2860 44160 0 0 {name=l35435 lab=VSS}
C {bitcell_6t.sym} 3000 44200 0 0 {name=Xr221c15}
N 2960 44240 2940 44240 {}
C {lab_pin.sym} 2940 44240 0 0 {name=l35436 lab=BL15}
N 2960 44200 2940 44200 {}
C {lab_pin.sym} 2940 44200 0 0 {name=l35437 lab=BLB15}
N 2960 44160 2940 44160 {}
C {lab_pin.sym} 2940 44160 0 0 {name=l35438 lab=WL221}
N 3040 44240 3060 44240 {}
C {lab_pin.sym} 3060 44240 0 0 {name=l35439 lab=VDD}
N 3040 44160 3060 44160 {}
C {lab_pin.sym} 3060 44160 0 0 {name=l35440 lab=VSS}
C {bitcell_6t.sym} 3200 44200 0 0 {name=Xr221c16}
N 3160 44240 3140 44240 {}
C {lab_pin.sym} 3140 44240 0 0 {name=l35441 lab=BL16}
N 3160 44200 3140 44200 {}
C {lab_pin.sym} 3140 44200 0 0 {name=l35442 lab=BLB16}
N 3160 44160 3140 44160 {}
C {lab_pin.sym} 3140 44160 0 0 {name=l35443 lab=WL221}
N 3240 44240 3260 44240 {}
C {lab_pin.sym} 3260 44240 0 0 {name=l35444 lab=VDD}
N 3240 44160 3260 44160 {}
C {lab_pin.sym} 3260 44160 0 0 {name=l35445 lab=VSS}
C {bitcell_6t.sym} 3400 44200 0 0 {name=Xr221c17}
N 3360 44240 3340 44240 {}
C {lab_pin.sym} 3340 44240 0 0 {name=l35446 lab=BL17}
N 3360 44200 3340 44200 {}
C {lab_pin.sym} 3340 44200 0 0 {name=l35447 lab=BLB17}
N 3360 44160 3340 44160 {}
C {lab_pin.sym} 3340 44160 0 0 {name=l35448 lab=WL221}
N 3440 44240 3460 44240 {}
C {lab_pin.sym} 3460 44240 0 0 {name=l35449 lab=VDD}
N 3440 44160 3460 44160 {}
C {lab_pin.sym} 3460 44160 0 0 {name=l35450 lab=VSS}
C {bitcell_6t.sym} 3600 44200 0 0 {name=Xr221c18}
N 3560 44240 3540 44240 {}
C {lab_pin.sym} 3540 44240 0 0 {name=l35451 lab=BL18}
N 3560 44200 3540 44200 {}
C {lab_pin.sym} 3540 44200 0 0 {name=l35452 lab=BLB18}
N 3560 44160 3540 44160 {}
C {lab_pin.sym} 3540 44160 0 0 {name=l35453 lab=WL221}
N 3640 44240 3660 44240 {}
C {lab_pin.sym} 3660 44240 0 0 {name=l35454 lab=VDD}
N 3640 44160 3660 44160 {}
C {lab_pin.sym} 3660 44160 0 0 {name=l35455 lab=VSS}
C {bitcell_6t.sym} 3800 44200 0 0 {name=Xr221c19}
N 3760 44240 3740 44240 {}
C {lab_pin.sym} 3740 44240 0 0 {name=l35456 lab=BL19}
N 3760 44200 3740 44200 {}
C {lab_pin.sym} 3740 44200 0 0 {name=l35457 lab=BLB19}
N 3760 44160 3740 44160 {}
C {lab_pin.sym} 3740 44160 0 0 {name=l35458 lab=WL221}
N 3840 44240 3860 44240 {}
C {lab_pin.sym} 3860 44240 0 0 {name=l35459 lab=VDD}
N 3840 44160 3860 44160 {}
C {lab_pin.sym} 3860 44160 0 0 {name=l35460 lab=VSS}
C {bitcell_6t.sym} 4000 44200 0 0 {name=Xr221c20}
N 3960 44240 3940 44240 {}
C {lab_pin.sym} 3940 44240 0 0 {name=l35461 lab=BL20}
N 3960 44200 3940 44200 {}
C {lab_pin.sym} 3940 44200 0 0 {name=l35462 lab=BLB20}
N 3960 44160 3940 44160 {}
C {lab_pin.sym} 3940 44160 0 0 {name=l35463 lab=WL221}
N 4040 44240 4060 44240 {}
C {lab_pin.sym} 4060 44240 0 0 {name=l35464 lab=VDD}
N 4040 44160 4060 44160 {}
C {lab_pin.sym} 4060 44160 0 0 {name=l35465 lab=VSS}
C {bitcell_6t.sym} 4200 44200 0 0 {name=Xr221c21}
N 4160 44240 4140 44240 {}
C {lab_pin.sym} 4140 44240 0 0 {name=l35466 lab=BL21}
N 4160 44200 4140 44200 {}
C {lab_pin.sym} 4140 44200 0 0 {name=l35467 lab=BLB21}
N 4160 44160 4140 44160 {}
C {lab_pin.sym} 4140 44160 0 0 {name=l35468 lab=WL221}
N 4240 44240 4260 44240 {}
C {lab_pin.sym} 4260 44240 0 0 {name=l35469 lab=VDD}
N 4240 44160 4260 44160 {}
C {lab_pin.sym} 4260 44160 0 0 {name=l35470 lab=VSS}
C {bitcell_6t.sym} 4400 44200 0 0 {name=Xr221c22}
N 4360 44240 4340 44240 {}
C {lab_pin.sym} 4340 44240 0 0 {name=l35471 lab=BL22}
N 4360 44200 4340 44200 {}
C {lab_pin.sym} 4340 44200 0 0 {name=l35472 lab=BLB22}
N 4360 44160 4340 44160 {}
C {lab_pin.sym} 4340 44160 0 0 {name=l35473 lab=WL221}
N 4440 44240 4460 44240 {}
C {lab_pin.sym} 4460 44240 0 0 {name=l35474 lab=VDD}
N 4440 44160 4460 44160 {}
C {lab_pin.sym} 4460 44160 0 0 {name=l35475 lab=VSS}
C {bitcell_6t.sym} 4600 44200 0 0 {name=Xr221c23}
N 4560 44240 4540 44240 {}
C {lab_pin.sym} 4540 44240 0 0 {name=l35476 lab=BL23}
N 4560 44200 4540 44200 {}
C {lab_pin.sym} 4540 44200 0 0 {name=l35477 lab=BLB23}
N 4560 44160 4540 44160 {}
C {lab_pin.sym} 4540 44160 0 0 {name=l35478 lab=WL221}
N 4640 44240 4660 44240 {}
C {lab_pin.sym} 4660 44240 0 0 {name=l35479 lab=VDD}
N 4640 44160 4660 44160 {}
C {lab_pin.sym} 4660 44160 0 0 {name=l35480 lab=VSS}
C {bitcell_6t.sym} 4800 44200 0 0 {name=Xr221c24}
N 4760 44240 4740 44240 {}
C {lab_pin.sym} 4740 44240 0 0 {name=l35481 lab=BL24}
N 4760 44200 4740 44200 {}
C {lab_pin.sym} 4740 44200 0 0 {name=l35482 lab=BLB24}
N 4760 44160 4740 44160 {}
C {lab_pin.sym} 4740 44160 0 0 {name=l35483 lab=WL221}
N 4840 44240 4860 44240 {}
C {lab_pin.sym} 4860 44240 0 0 {name=l35484 lab=VDD}
N 4840 44160 4860 44160 {}
C {lab_pin.sym} 4860 44160 0 0 {name=l35485 lab=VSS}
C {bitcell_6t.sym} 5000 44200 0 0 {name=Xr221c25}
N 4960 44240 4940 44240 {}
C {lab_pin.sym} 4940 44240 0 0 {name=l35486 lab=BL25}
N 4960 44200 4940 44200 {}
C {lab_pin.sym} 4940 44200 0 0 {name=l35487 lab=BLB25}
N 4960 44160 4940 44160 {}
C {lab_pin.sym} 4940 44160 0 0 {name=l35488 lab=WL221}
N 5040 44240 5060 44240 {}
C {lab_pin.sym} 5060 44240 0 0 {name=l35489 lab=VDD}
N 5040 44160 5060 44160 {}
C {lab_pin.sym} 5060 44160 0 0 {name=l35490 lab=VSS}
C {bitcell_6t.sym} 5200 44200 0 0 {name=Xr221c26}
N 5160 44240 5140 44240 {}
C {lab_pin.sym} 5140 44240 0 0 {name=l35491 lab=BL26}
N 5160 44200 5140 44200 {}
C {lab_pin.sym} 5140 44200 0 0 {name=l35492 lab=BLB26}
N 5160 44160 5140 44160 {}
C {lab_pin.sym} 5140 44160 0 0 {name=l35493 lab=WL221}
N 5240 44240 5260 44240 {}
C {lab_pin.sym} 5260 44240 0 0 {name=l35494 lab=VDD}
N 5240 44160 5260 44160 {}
C {lab_pin.sym} 5260 44160 0 0 {name=l35495 lab=VSS}
C {bitcell_6t.sym} 5400 44200 0 0 {name=Xr221c27}
N 5360 44240 5340 44240 {}
C {lab_pin.sym} 5340 44240 0 0 {name=l35496 lab=BL27}
N 5360 44200 5340 44200 {}
C {lab_pin.sym} 5340 44200 0 0 {name=l35497 lab=BLB27}
N 5360 44160 5340 44160 {}
C {lab_pin.sym} 5340 44160 0 0 {name=l35498 lab=WL221}
N 5440 44240 5460 44240 {}
C {lab_pin.sym} 5460 44240 0 0 {name=l35499 lab=VDD}
N 5440 44160 5460 44160 {}
C {lab_pin.sym} 5460 44160 0 0 {name=l35500 lab=VSS}
C {bitcell_6t.sym} 5600 44200 0 0 {name=Xr221c28}
N 5560 44240 5540 44240 {}
C {lab_pin.sym} 5540 44240 0 0 {name=l35501 lab=BL28}
N 5560 44200 5540 44200 {}
C {lab_pin.sym} 5540 44200 0 0 {name=l35502 lab=BLB28}
N 5560 44160 5540 44160 {}
C {lab_pin.sym} 5540 44160 0 0 {name=l35503 lab=WL221}
N 5640 44240 5660 44240 {}
C {lab_pin.sym} 5660 44240 0 0 {name=l35504 lab=VDD}
N 5640 44160 5660 44160 {}
C {lab_pin.sym} 5660 44160 0 0 {name=l35505 lab=VSS}
C {bitcell_6t.sym} 5800 44200 0 0 {name=Xr221c29}
N 5760 44240 5740 44240 {}
C {lab_pin.sym} 5740 44240 0 0 {name=l35506 lab=BL29}
N 5760 44200 5740 44200 {}
C {lab_pin.sym} 5740 44200 0 0 {name=l35507 lab=BLB29}
N 5760 44160 5740 44160 {}
C {lab_pin.sym} 5740 44160 0 0 {name=l35508 lab=WL221}
N 5840 44240 5860 44240 {}
C {lab_pin.sym} 5860 44240 0 0 {name=l35509 lab=VDD}
N 5840 44160 5860 44160 {}
C {lab_pin.sym} 5860 44160 0 0 {name=l35510 lab=VSS}
C {bitcell_6t.sym} 6000 44200 0 0 {name=Xr221c30}
N 5960 44240 5940 44240 {}
C {lab_pin.sym} 5940 44240 0 0 {name=l35511 lab=BL30}
N 5960 44200 5940 44200 {}
C {lab_pin.sym} 5940 44200 0 0 {name=l35512 lab=BLB30}
N 5960 44160 5940 44160 {}
C {lab_pin.sym} 5940 44160 0 0 {name=l35513 lab=WL221}
N 6040 44240 6060 44240 {}
C {lab_pin.sym} 6060 44240 0 0 {name=l35514 lab=VDD}
N 6040 44160 6060 44160 {}
C {lab_pin.sym} 6060 44160 0 0 {name=l35515 lab=VSS}
C {bitcell_6t.sym} 6200 44200 0 0 {name=Xr221c31}
N 6160 44240 6140 44240 {}
C {lab_pin.sym} 6140 44240 0 0 {name=l35516 lab=BL31}
N 6160 44200 6140 44200 {}
C {lab_pin.sym} 6140 44200 0 0 {name=l35517 lab=BLB31}
N 6160 44160 6140 44160 {}
C {lab_pin.sym} 6140 44160 0 0 {name=l35518 lab=WL221}
N 6240 44240 6260 44240 {}
C {lab_pin.sym} 6260 44240 0 0 {name=l35519 lab=VDD}
N 6240 44160 6260 44160 {}
C {lab_pin.sym} 6260 44160 0 0 {name=l35520 lab=VSS}
C {bitcell_6t.sym} 0 44400 0 0 {name=Xr222c0}
N -40 44440 -60 44440 {}
C {lab_pin.sym} -60 44440 0 0 {name=l35521 lab=BL0}
N -40 44400 -60 44400 {}
C {lab_pin.sym} -60 44400 0 0 {name=l35522 lab=BLB0}
N -40 44360 -60 44360 {}
C {lab_pin.sym} -60 44360 0 0 {name=l35523 lab=WL222}
N 40 44440 60 44440 {}
C {lab_pin.sym} 60 44440 0 0 {name=l35524 lab=VDD}
N 40 44360 60 44360 {}
C {lab_pin.sym} 60 44360 0 0 {name=l35525 lab=VSS}
C {bitcell_6t.sym} 200 44400 0 0 {name=Xr222c1}
N 160 44440 140 44440 {}
C {lab_pin.sym} 140 44440 0 0 {name=l35526 lab=BL1}
N 160 44400 140 44400 {}
C {lab_pin.sym} 140 44400 0 0 {name=l35527 lab=BLB1}
N 160 44360 140 44360 {}
C {lab_pin.sym} 140 44360 0 0 {name=l35528 lab=WL222}
N 240 44440 260 44440 {}
C {lab_pin.sym} 260 44440 0 0 {name=l35529 lab=VDD}
N 240 44360 260 44360 {}
C {lab_pin.sym} 260 44360 0 0 {name=l35530 lab=VSS}
C {bitcell_6t.sym} 400 44400 0 0 {name=Xr222c2}
N 360 44440 340 44440 {}
C {lab_pin.sym} 340 44440 0 0 {name=l35531 lab=BL2}
N 360 44400 340 44400 {}
C {lab_pin.sym} 340 44400 0 0 {name=l35532 lab=BLB2}
N 360 44360 340 44360 {}
C {lab_pin.sym} 340 44360 0 0 {name=l35533 lab=WL222}
N 440 44440 460 44440 {}
C {lab_pin.sym} 460 44440 0 0 {name=l35534 lab=VDD}
N 440 44360 460 44360 {}
C {lab_pin.sym} 460 44360 0 0 {name=l35535 lab=VSS}
C {bitcell_6t.sym} 600 44400 0 0 {name=Xr222c3}
N 560 44440 540 44440 {}
C {lab_pin.sym} 540 44440 0 0 {name=l35536 lab=BL3}
N 560 44400 540 44400 {}
C {lab_pin.sym} 540 44400 0 0 {name=l35537 lab=BLB3}
N 560 44360 540 44360 {}
C {lab_pin.sym} 540 44360 0 0 {name=l35538 lab=WL222}
N 640 44440 660 44440 {}
C {lab_pin.sym} 660 44440 0 0 {name=l35539 lab=VDD}
N 640 44360 660 44360 {}
C {lab_pin.sym} 660 44360 0 0 {name=l35540 lab=VSS}
C {bitcell_6t.sym} 800 44400 0 0 {name=Xr222c4}
N 760 44440 740 44440 {}
C {lab_pin.sym} 740 44440 0 0 {name=l35541 lab=BL4}
N 760 44400 740 44400 {}
C {lab_pin.sym} 740 44400 0 0 {name=l35542 lab=BLB4}
N 760 44360 740 44360 {}
C {lab_pin.sym} 740 44360 0 0 {name=l35543 lab=WL222}
N 840 44440 860 44440 {}
C {lab_pin.sym} 860 44440 0 0 {name=l35544 lab=VDD}
N 840 44360 860 44360 {}
C {lab_pin.sym} 860 44360 0 0 {name=l35545 lab=VSS}
C {bitcell_6t.sym} 1000 44400 0 0 {name=Xr222c5}
N 960 44440 940 44440 {}
C {lab_pin.sym} 940 44440 0 0 {name=l35546 lab=BL5}
N 960 44400 940 44400 {}
C {lab_pin.sym} 940 44400 0 0 {name=l35547 lab=BLB5}
N 960 44360 940 44360 {}
C {lab_pin.sym} 940 44360 0 0 {name=l35548 lab=WL222}
N 1040 44440 1060 44440 {}
C {lab_pin.sym} 1060 44440 0 0 {name=l35549 lab=VDD}
N 1040 44360 1060 44360 {}
C {lab_pin.sym} 1060 44360 0 0 {name=l35550 lab=VSS}
C {bitcell_6t.sym} 1200 44400 0 0 {name=Xr222c6}
N 1160 44440 1140 44440 {}
C {lab_pin.sym} 1140 44440 0 0 {name=l35551 lab=BL6}
N 1160 44400 1140 44400 {}
C {lab_pin.sym} 1140 44400 0 0 {name=l35552 lab=BLB6}
N 1160 44360 1140 44360 {}
C {lab_pin.sym} 1140 44360 0 0 {name=l35553 lab=WL222}
N 1240 44440 1260 44440 {}
C {lab_pin.sym} 1260 44440 0 0 {name=l35554 lab=VDD}
N 1240 44360 1260 44360 {}
C {lab_pin.sym} 1260 44360 0 0 {name=l35555 lab=VSS}
C {bitcell_6t.sym} 1400 44400 0 0 {name=Xr222c7}
N 1360 44440 1340 44440 {}
C {lab_pin.sym} 1340 44440 0 0 {name=l35556 lab=BL7}
N 1360 44400 1340 44400 {}
C {lab_pin.sym} 1340 44400 0 0 {name=l35557 lab=BLB7}
N 1360 44360 1340 44360 {}
C {lab_pin.sym} 1340 44360 0 0 {name=l35558 lab=WL222}
N 1440 44440 1460 44440 {}
C {lab_pin.sym} 1460 44440 0 0 {name=l35559 lab=VDD}
N 1440 44360 1460 44360 {}
C {lab_pin.sym} 1460 44360 0 0 {name=l35560 lab=VSS}
C {bitcell_6t.sym} 1600 44400 0 0 {name=Xr222c8}
N 1560 44440 1540 44440 {}
C {lab_pin.sym} 1540 44440 0 0 {name=l35561 lab=BL8}
N 1560 44400 1540 44400 {}
C {lab_pin.sym} 1540 44400 0 0 {name=l35562 lab=BLB8}
N 1560 44360 1540 44360 {}
C {lab_pin.sym} 1540 44360 0 0 {name=l35563 lab=WL222}
N 1640 44440 1660 44440 {}
C {lab_pin.sym} 1660 44440 0 0 {name=l35564 lab=VDD}
N 1640 44360 1660 44360 {}
C {lab_pin.sym} 1660 44360 0 0 {name=l35565 lab=VSS}
C {bitcell_6t.sym} 1800 44400 0 0 {name=Xr222c9}
N 1760 44440 1740 44440 {}
C {lab_pin.sym} 1740 44440 0 0 {name=l35566 lab=BL9}
N 1760 44400 1740 44400 {}
C {lab_pin.sym} 1740 44400 0 0 {name=l35567 lab=BLB9}
N 1760 44360 1740 44360 {}
C {lab_pin.sym} 1740 44360 0 0 {name=l35568 lab=WL222}
N 1840 44440 1860 44440 {}
C {lab_pin.sym} 1860 44440 0 0 {name=l35569 lab=VDD}
N 1840 44360 1860 44360 {}
C {lab_pin.sym} 1860 44360 0 0 {name=l35570 lab=VSS}
C {bitcell_6t.sym} 2000 44400 0 0 {name=Xr222c10}
N 1960 44440 1940 44440 {}
C {lab_pin.sym} 1940 44440 0 0 {name=l35571 lab=BL10}
N 1960 44400 1940 44400 {}
C {lab_pin.sym} 1940 44400 0 0 {name=l35572 lab=BLB10}
N 1960 44360 1940 44360 {}
C {lab_pin.sym} 1940 44360 0 0 {name=l35573 lab=WL222}
N 2040 44440 2060 44440 {}
C {lab_pin.sym} 2060 44440 0 0 {name=l35574 lab=VDD}
N 2040 44360 2060 44360 {}
C {lab_pin.sym} 2060 44360 0 0 {name=l35575 lab=VSS}
C {bitcell_6t.sym} 2200 44400 0 0 {name=Xr222c11}
N 2160 44440 2140 44440 {}
C {lab_pin.sym} 2140 44440 0 0 {name=l35576 lab=BL11}
N 2160 44400 2140 44400 {}
C {lab_pin.sym} 2140 44400 0 0 {name=l35577 lab=BLB11}
N 2160 44360 2140 44360 {}
C {lab_pin.sym} 2140 44360 0 0 {name=l35578 lab=WL222}
N 2240 44440 2260 44440 {}
C {lab_pin.sym} 2260 44440 0 0 {name=l35579 lab=VDD}
N 2240 44360 2260 44360 {}
C {lab_pin.sym} 2260 44360 0 0 {name=l35580 lab=VSS}
C {bitcell_6t.sym} 2400 44400 0 0 {name=Xr222c12}
N 2360 44440 2340 44440 {}
C {lab_pin.sym} 2340 44440 0 0 {name=l35581 lab=BL12}
N 2360 44400 2340 44400 {}
C {lab_pin.sym} 2340 44400 0 0 {name=l35582 lab=BLB12}
N 2360 44360 2340 44360 {}
C {lab_pin.sym} 2340 44360 0 0 {name=l35583 lab=WL222}
N 2440 44440 2460 44440 {}
C {lab_pin.sym} 2460 44440 0 0 {name=l35584 lab=VDD}
N 2440 44360 2460 44360 {}
C {lab_pin.sym} 2460 44360 0 0 {name=l35585 lab=VSS}
C {bitcell_6t.sym} 2600 44400 0 0 {name=Xr222c13}
N 2560 44440 2540 44440 {}
C {lab_pin.sym} 2540 44440 0 0 {name=l35586 lab=BL13}
N 2560 44400 2540 44400 {}
C {lab_pin.sym} 2540 44400 0 0 {name=l35587 lab=BLB13}
N 2560 44360 2540 44360 {}
C {lab_pin.sym} 2540 44360 0 0 {name=l35588 lab=WL222}
N 2640 44440 2660 44440 {}
C {lab_pin.sym} 2660 44440 0 0 {name=l35589 lab=VDD}
N 2640 44360 2660 44360 {}
C {lab_pin.sym} 2660 44360 0 0 {name=l35590 lab=VSS}
C {bitcell_6t.sym} 2800 44400 0 0 {name=Xr222c14}
N 2760 44440 2740 44440 {}
C {lab_pin.sym} 2740 44440 0 0 {name=l35591 lab=BL14}
N 2760 44400 2740 44400 {}
C {lab_pin.sym} 2740 44400 0 0 {name=l35592 lab=BLB14}
N 2760 44360 2740 44360 {}
C {lab_pin.sym} 2740 44360 0 0 {name=l35593 lab=WL222}
N 2840 44440 2860 44440 {}
C {lab_pin.sym} 2860 44440 0 0 {name=l35594 lab=VDD}
N 2840 44360 2860 44360 {}
C {lab_pin.sym} 2860 44360 0 0 {name=l35595 lab=VSS}
C {bitcell_6t.sym} 3000 44400 0 0 {name=Xr222c15}
N 2960 44440 2940 44440 {}
C {lab_pin.sym} 2940 44440 0 0 {name=l35596 lab=BL15}
N 2960 44400 2940 44400 {}
C {lab_pin.sym} 2940 44400 0 0 {name=l35597 lab=BLB15}
N 2960 44360 2940 44360 {}
C {lab_pin.sym} 2940 44360 0 0 {name=l35598 lab=WL222}
N 3040 44440 3060 44440 {}
C {lab_pin.sym} 3060 44440 0 0 {name=l35599 lab=VDD}
N 3040 44360 3060 44360 {}
C {lab_pin.sym} 3060 44360 0 0 {name=l35600 lab=VSS}
C {bitcell_6t.sym} 3200 44400 0 0 {name=Xr222c16}
N 3160 44440 3140 44440 {}
C {lab_pin.sym} 3140 44440 0 0 {name=l35601 lab=BL16}
N 3160 44400 3140 44400 {}
C {lab_pin.sym} 3140 44400 0 0 {name=l35602 lab=BLB16}
N 3160 44360 3140 44360 {}
C {lab_pin.sym} 3140 44360 0 0 {name=l35603 lab=WL222}
N 3240 44440 3260 44440 {}
C {lab_pin.sym} 3260 44440 0 0 {name=l35604 lab=VDD}
N 3240 44360 3260 44360 {}
C {lab_pin.sym} 3260 44360 0 0 {name=l35605 lab=VSS}
C {bitcell_6t.sym} 3400 44400 0 0 {name=Xr222c17}
N 3360 44440 3340 44440 {}
C {lab_pin.sym} 3340 44440 0 0 {name=l35606 lab=BL17}
N 3360 44400 3340 44400 {}
C {lab_pin.sym} 3340 44400 0 0 {name=l35607 lab=BLB17}
N 3360 44360 3340 44360 {}
C {lab_pin.sym} 3340 44360 0 0 {name=l35608 lab=WL222}
N 3440 44440 3460 44440 {}
C {lab_pin.sym} 3460 44440 0 0 {name=l35609 lab=VDD}
N 3440 44360 3460 44360 {}
C {lab_pin.sym} 3460 44360 0 0 {name=l35610 lab=VSS}
C {bitcell_6t.sym} 3600 44400 0 0 {name=Xr222c18}
N 3560 44440 3540 44440 {}
C {lab_pin.sym} 3540 44440 0 0 {name=l35611 lab=BL18}
N 3560 44400 3540 44400 {}
C {lab_pin.sym} 3540 44400 0 0 {name=l35612 lab=BLB18}
N 3560 44360 3540 44360 {}
C {lab_pin.sym} 3540 44360 0 0 {name=l35613 lab=WL222}
N 3640 44440 3660 44440 {}
C {lab_pin.sym} 3660 44440 0 0 {name=l35614 lab=VDD}
N 3640 44360 3660 44360 {}
C {lab_pin.sym} 3660 44360 0 0 {name=l35615 lab=VSS}
C {bitcell_6t.sym} 3800 44400 0 0 {name=Xr222c19}
N 3760 44440 3740 44440 {}
C {lab_pin.sym} 3740 44440 0 0 {name=l35616 lab=BL19}
N 3760 44400 3740 44400 {}
C {lab_pin.sym} 3740 44400 0 0 {name=l35617 lab=BLB19}
N 3760 44360 3740 44360 {}
C {lab_pin.sym} 3740 44360 0 0 {name=l35618 lab=WL222}
N 3840 44440 3860 44440 {}
C {lab_pin.sym} 3860 44440 0 0 {name=l35619 lab=VDD}
N 3840 44360 3860 44360 {}
C {lab_pin.sym} 3860 44360 0 0 {name=l35620 lab=VSS}
C {bitcell_6t.sym} 4000 44400 0 0 {name=Xr222c20}
N 3960 44440 3940 44440 {}
C {lab_pin.sym} 3940 44440 0 0 {name=l35621 lab=BL20}
N 3960 44400 3940 44400 {}
C {lab_pin.sym} 3940 44400 0 0 {name=l35622 lab=BLB20}
N 3960 44360 3940 44360 {}
C {lab_pin.sym} 3940 44360 0 0 {name=l35623 lab=WL222}
N 4040 44440 4060 44440 {}
C {lab_pin.sym} 4060 44440 0 0 {name=l35624 lab=VDD}
N 4040 44360 4060 44360 {}
C {lab_pin.sym} 4060 44360 0 0 {name=l35625 lab=VSS}
C {bitcell_6t.sym} 4200 44400 0 0 {name=Xr222c21}
N 4160 44440 4140 44440 {}
C {lab_pin.sym} 4140 44440 0 0 {name=l35626 lab=BL21}
N 4160 44400 4140 44400 {}
C {lab_pin.sym} 4140 44400 0 0 {name=l35627 lab=BLB21}
N 4160 44360 4140 44360 {}
C {lab_pin.sym} 4140 44360 0 0 {name=l35628 lab=WL222}
N 4240 44440 4260 44440 {}
C {lab_pin.sym} 4260 44440 0 0 {name=l35629 lab=VDD}
N 4240 44360 4260 44360 {}
C {lab_pin.sym} 4260 44360 0 0 {name=l35630 lab=VSS}
C {bitcell_6t.sym} 4400 44400 0 0 {name=Xr222c22}
N 4360 44440 4340 44440 {}
C {lab_pin.sym} 4340 44440 0 0 {name=l35631 lab=BL22}
N 4360 44400 4340 44400 {}
C {lab_pin.sym} 4340 44400 0 0 {name=l35632 lab=BLB22}
N 4360 44360 4340 44360 {}
C {lab_pin.sym} 4340 44360 0 0 {name=l35633 lab=WL222}
N 4440 44440 4460 44440 {}
C {lab_pin.sym} 4460 44440 0 0 {name=l35634 lab=VDD}
N 4440 44360 4460 44360 {}
C {lab_pin.sym} 4460 44360 0 0 {name=l35635 lab=VSS}
C {bitcell_6t.sym} 4600 44400 0 0 {name=Xr222c23}
N 4560 44440 4540 44440 {}
C {lab_pin.sym} 4540 44440 0 0 {name=l35636 lab=BL23}
N 4560 44400 4540 44400 {}
C {lab_pin.sym} 4540 44400 0 0 {name=l35637 lab=BLB23}
N 4560 44360 4540 44360 {}
C {lab_pin.sym} 4540 44360 0 0 {name=l35638 lab=WL222}
N 4640 44440 4660 44440 {}
C {lab_pin.sym} 4660 44440 0 0 {name=l35639 lab=VDD}
N 4640 44360 4660 44360 {}
C {lab_pin.sym} 4660 44360 0 0 {name=l35640 lab=VSS}
C {bitcell_6t.sym} 4800 44400 0 0 {name=Xr222c24}
N 4760 44440 4740 44440 {}
C {lab_pin.sym} 4740 44440 0 0 {name=l35641 lab=BL24}
N 4760 44400 4740 44400 {}
C {lab_pin.sym} 4740 44400 0 0 {name=l35642 lab=BLB24}
N 4760 44360 4740 44360 {}
C {lab_pin.sym} 4740 44360 0 0 {name=l35643 lab=WL222}
N 4840 44440 4860 44440 {}
C {lab_pin.sym} 4860 44440 0 0 {name=l35644 lab=VDD}
N 4840 44360 4860 44360 {}
C {lab_pin.sym} 4860 44360 0 0 {name=l35645 lab=VSS}
C {bitcell_6t.sym} 5000 44400 0 0 {name=Xr222c25}
N 4960 44440 4940 44440 {}
C {lab_pin.sym} 4940 44440 0 0 {name=l35646 lab=BL25}
N 4960 44400 4940 44400 {}
C {lab_pin.sym} 4940 44400 0 0 {name=l35647 lab=BLB25}
N 4960 44360 4940 44360 {}
C {lab_pin.sym} 4940 44360 0 0 {name=l35648 lab=WL222}
N 5040 44440 5060 44440 {}
C {lab_pin.sym} 5060 44440 0 0 {name=l35649 lab=VDD}
N 5040 44360 5060 44360 {}
C {lab_pin.sym} 5060 44360 0 0 {name=l35650 lab=VSS}
C {bitcell_6t.sym} 5200 44400 0 0 {name=Xr222c26}
N 5160 44440 5140 44440 {}
C {lab_pin.sym} 5140 44440 0 0 {name=l35651 lab=BL26}
N 5160 44400 5140 44400 {}
C {lab_pin.sym} 5140 44400 0 0 {name=l35652 lab=BLB26}
N 5160 44360 5140 44360 {}
C {lab_pin.sym} 5140 44360 0 0 {name=l35653 lab=WL222}
N 5240 44440 5260 44440 {}
C {lab_pin.sym} 5260 44440 0 0 {name=l35654 lab=VDD}
N 5240 44360 5260 44360 {}
C {lab_pin.sym} 5260 44360 0 0 {name=l35655 lab=VSS}
C {bitcell_6t.sym} 5400 44400 0 0 {name=Xr222c27}
N 5360 44440 5340 44440 {}
C {lab_pin.sym} 5340 44440 0 0 {name=l35656 lab=BL27}
N 5360 44400 5340 44400 {}
C {lab_pin.sym} 5340 44400 0 0 {name=l35657 lab=BLB27}
N 5360 44360 5340 44360 {}
C {lab_pin.sym} 5340 44360 0 0 {name=l35658 lab=WL222}
N 5440 44440 5460 44440 {}
C {lab_pin.sym} 5460 44440 0 0 {name=l35659 lab=VDD}
N 5440 44360 5460 44360 {}
C {lab_pin.sym} 5460 44360 0 0 {name=l35660 lab=VSS}
C {bitcell_6t.sym} 5600 44400 0 0 {name=Xr222c28}
N 5560 44440 5540 44440 {}
C {lab_pin.sym} 5540 44440 0 0 {name=l35661 lab=BL28}
N 5560 44400 5540 44400 {}
C {lab_pin.sym} 5540 44400 0 0 {name=l35662 lab=BLB28}
N 5560 44360 5540 44360 {}
C {lab_pin.sym} 5540 44360 0 0 {name=l35663 lab=WL222}
N 5640 44440 5660 44440 {}
C {lab_pin.sym} 5660 44440 0 0 {name=l35664 lab=VDD}
N 5640 44360 5660 44360 {}
C {lab_pin.sym} 5660 44360 0 0 {name=l35665 lab=VSS}
C {bitcell_6t.sym} 5800 44400 0 0 {name=Xr222c29}
N 5760 44440 5740 44440 {}
C {lab_pin.sym} 5740 44440 0 0 {name=l35666 lab=BL29}
N 5760 44400 5740 44400 {}
C {lab_pin.sym} 5740 44400 0 0 {name=l35667 lab=BLB29}
N 5760 44360 5740 44360 {}
C {lab_pin.sym} 5740 44360 0 0 {name=l35668 lab=WL222}
N 5840 44440 5860 44440 {}
C {lab_pin.sym} 5860 44440 0 0 {name=l35669 lab=VDD}
N 5840 44360 5860 44360 {}
C {lab_pin.sym} 5860 44360 0 0 {name=l35670 lab=VSS}
C {bitcell_6t.sym} 6000 44400 0 0 {name=Xr222c30}
N 5960 44440 5940 44440 {}
C {lab_pin.sym} 5940 44440 0 0 {name=l35671 lab=BL30}
N 5960 44400 5940 44400 {}
C {lab_pin.sym} 5940 44400 0 0 {name=l35672 lab=BLB30}
N 5960 44360 5940 44360 {}
C {lab_pin.sym} 5940 44360 0 0 {name=l35673 lab=WL222}
N 6040 44440 6060 44440 {}
C {lab_pin.sym} 6060 44440 0 0 {name=l35674 lab=VDD}
N 6040 44360 6060 44360 {}
C {lab_pin.sym} 6060 44360 0 0 {name=l35675 lab=VSS}
C {bitcell_6t.sym} 6200 44400 0 0 {name=Xr222c31}
N 6160 44440 6140 44440 {}
C {lab_pin.sym} 6140 44440 0 0 {name=l35676 lab=BL31}
N 6160 44400 6140 44400 {}
C {lab_pin.sym} 6140 44400 0 0 {name=l35677 lab=BLB31}
N 6160 44360 6140 44360 {}
C {lab_pin.sym} 6140 44360 0 0 {name=l35678 lab=WL222}
N 6240 44440 6260 44440 {}
C {lab_pin.sym} 6260 44440 0 0 {name=l35679 lab=VDD}
N 6240 44360 6260 44360 {}
C {lab_pin.sym} 6260 44360 0 0 {name=l35680 lab=VSS}
C {bitcell_6t.sym} 0 44600 0 0 {name=Xr223c0}
N -40 44640 -60 44640 {}
C {lab_pin.sym} -60 44640 0 0 {name=l35681 lab=BL0}
N -40 44600 -60 44600 {}
C {lab_pin.sym} -60 44600 0 0 {name=l35682 lab=BLB0}
N -40 44560 -60 44560 {}
C {lab_pin.sym} -60 44560 0 0 {name=l35683 lab=WL223}
N 40 44640 60 44640 {}
C {lab_pin.sym} 60 44640 0 0 {name=l35684 lab=VDD}
N 40 44560 60 44560 {}
C {lab_pin.sym} 60 44560 0 0 {name=l35685 lab=VSS}
C {bitcell_6t.sym} 200 44600 0 0 {name=Xr223c1}
N 160 44640 140 44640 {}
C {lab_pin.sym} 140 44640 0 0 {name=l35686 lab=BL1}
N 160 44600 140 44600 {}
C {lab_pin.sym} 140 44600 0 0 {name=l35687 lab=BLB1}
N 160 44560 140 44560 {}
C {lab_pin.sym} 140 44560 0 0 {name=l35688 lab=WL223}
N 240 44640 260 44640 {}
C {lab_pin.sym} 260 44640 0 0 {name=l35689 lab=VDD}
N 240 44560 260 44560 {}
C {lab_pin.sym} 260 44560 0 0 {name=l35690 lab=VSS}
C {bitcell_6t.sym} 400 44600 0 0 {name=Xr223c2}
N 360 44640 340 44640 {}
C {lab_pin.sym} 340 44640 0 0 {name=l35691 lab=BL2}
N 360 44600 340 44600 {}
C {lab_pin.sym} 340 44600 0 0 {name=l35692 lab=BLB2}
N 360 44560 340 44560 {}
C {lab_pin.sym} 340 44560 0 0 {name=l35693 lab=WL223}
N 440 44640 460 44640 {}
C {lab_pin.sym} 460 44640 0 0 {name=l35694 lab=VDD}
N 440 44560 460 44560 {}
C {lab_pin.sym} 460 44560 0 0 {name=l35695 lab=VSS}
C {bitcell_6t.sym} 600 44600 0 0 {name=Xr223c3}
N 560 44640 540 44640 {}
C {lab_pin.sym} 540 44640 0 0 {name=l35696 lab=BL3}
N 560 44600 540 44600 {}
C {lab_pin.sym} 540 44600 0 0 {name=l35697 lab=BLB3}
N 560 44560 540 44560 {}
C {lab_pin.sym} 540 44560 0 0 {name=l35698 lab=WL223}
N 640 44640 660 44640 {}
C {lab_pin.sym} 660 44640 0 0 {name=l35699 lab=VDD}
N 640 44560 660 44560 {}
C {lab_pin.sym} 660 44560 0 0 {name=l35700 lab=VSS}
C {bitcell_6t.sym} 800 44600 0 0 {name=Xr223c4}
N 760 44640 740 44640 {}
C {lab_pin.sym} 740 44640 0 0 {name=l35701 lab=BL4}
N 760 44600 740 44600 {}
C {lab_pin.sym} 740 44600 0 0 {name=l35702 lab=BLB4}
N 760 44560 740 44560 {}
C {lab_pin.sym} 740 44560 0 0 {name=l35703 lab=WL223}
N 840 44640 860 44640 {}
C {lab_pin.sym} 860 44640 0 0 {name=l35704 lab=VDD}
N 840 44560 860 44560 {}
C {lab_pin.sym} 860 44560 0 0 {name=l35705 lab=VSS}
C {bitcell_6t.sym} 1000 44600 0 0 {name=Xr223c5}
N 960 44640 940 44640 {}
C {lab_pin.sym} 940 44640 0 0 {name=l35706 lab=BL5}
N 960 44600 940 44600 {}
C {lab_pin.sym} 940 44600 0 0 {name=l35707 lab=BLB5}
N 960 44560 940 44560 {}
C {lab_pin.sym} 940 44560 0 0 {name=l35708 lab=WL223}
N 1040 44640 1060 44640 {}
C {lab_pin.sym} 1060 44640 0 0 {name=l35709 lab=VDD}
N 1040 44560 1060 44560 {}
C {lab_pin.sym} 1060 44560 0 0 {name=l35710 lab=VSS}
C {bitcell_6t.sym} 1200 44600 0 0 {name=Xr223c6}
N 1160 44640 1140 44640 {}
C {lab_pin.sym} 1140 44640 0 0 {name=l35711 lab=BL6}
N 1160 44600 1140 44600 {}
C {lab_pin.sym} 1140 44600 0 0 {name=l35712 lab=BLB6}
N 1160 44560 1140 44560 {}
C {lab_pin.sym} 1140 44560 0 0 {name=l35713 lab=WL223}
N 1240 44640 1260 44640 {}
C {lab_pin.sym} 1260 44640 0 0 {name=l35714 lab=VDD}
N 1240 44560 1260 44560 {}
C {lab_pin.sym} 1260 44560 0 0 {name=l35715 lab=VSS}
C {bitcell_6t.sym} 1400 44600 0 0 {name=Xr223c7}
N 1360 44640 1340 44640 {}
C {lab_pin.sym} 1340 44640 0 0 {name=l35716 lab=BL7}
N 1360 44600 1340 44600 {}
C {lab_pin.sym} 1340 44600 0 0 {name=l35717 lab=BLB7}
N 1360 44560 1340 44560 {}
C {lab_pin.sym} 1340 44560 0 0 {name=l35718 lab=WL223}
N 1440 44640 1460 44640 {}
C {lab_pin.sym} 1460 44640 0 0 {name=l35719 lab=VDD}
N 1440 44560 1460 44560 {}
C {lab_pin.sym} 1460 44560 0 0 {name=l35720 lab=VSS}
C {bitcell_6t.sym} 1600 44600 0 0 {name=Xr223c8}
N 1560 44640 1540 44640 {}
C {lab_pin.sym} 1540 44640 0 0 {name=l35721 lab=BL8}
N 1560 44600 1540 44600 {}
C {lab_pin.sym} 1540 44600 0 0 {name=l35722 lab=BLB8}
N 1560 44560 1540 44560 {}
C {lab_pin.sym} 1540 44560 0 0 {name=l35723 lab=WL223}
N 1640 44640 1660 44640 {}
C {lab_pin.sym} 1660 44640 0 0 {name=l35724 lab=VDD}
N 1640 44560 1660 44560 {}
C {lab_pin.sym} 1660 44560 0 0 {name=l35725 lab=VSS}
C {bitcell_6t.sym} 1800 44600 0 0 {name=Xr223c9}
N 1760 44640 1740 44640 {}
C {lab_pin.sym} 1740 44640 0 0 {name=l35726 lab=BL9}
N 1760 44600 1740 44600 {}
C {lab_pin.sym} 1740 44600 0 0 {name=l35727 lab=BLB9}
N 1760 44560 1740 44560 {}
C {lab_pin.sym} 1740 44560 0 0 {name=l35728 lab=WL223}
N 1840 44640 1860 44640 {}
C {lab_pin.sym} 1860 44640 0 0 {name=l35729 lab=VDD}
N 1840 44560 1860 44560 {}
C {lab_pin.sym} 1860 44560 0 0 {name=l35730 lab=VSS}
C {bitcell_6t.sym} 2000 44600 0 0 {name=Xr223c10}
N 1960 44640 1940 44640 {}
C {lab_pin.sym} 1940 44640 0 0 {name=l35731 lab=BL10}
N 1960 44600 1940 44600 {}
C {lab_pin.sym} 1940 44600 0 0 {name=l35732 lab=BLB10}
N 1960 44560 1940 44560 {}
C {lab_pin.sym} 1940 44560 0 0 {name=l35733 lab=WL223}
N 2040 44640 2060 44640 {}
C {lab_pin.sym} 2060 44640 0 0 {name=l35734 lab=VDD}
N 2040 44560 2060 44560 {}
C {lab_pin.sym} 2060 44560 0 0 {name=l35735 lab=VSS}
C {bitcell_6t.sym} 2200 44600 0 0 {name=Xr223c11}
N 2160 44640 2140 44640 {}
C {lab_pin.sym} 2140 44640 0 0 {name=l35736 lab=BL11}
N 2160 44600 2140 44600 {}
C {lab_pin.sym} 2140 44600 0 0 {name=l35737 lab=BLB11}
N 2160 44560 2140 44560 {}
C {lab_pin.sym} 2140 44560 0 0 {name=l35738 lab=WL223}
N 2240 44640 2260 44640 {}
C {lab_pin.sym} 2260 44640 0 0 {name=l35739 lab=VDD}
N 2240 44560 2260 44560 {}
C {lab_pin.sym} 2260 44560 0 0 {name=l35740 lab=VSS}
C {bitcell_6t.sym} 2400 44600 0 0 {name=Xr223c12}
N 2360 44640 2340 44640 {}
C {lab_pin.sym} 2340 44640 0 0 {name=l35741 lab=BL12}
N 2360 44600 2340 44600 {}
C {lab_pin.sym} 2340 44600 0 0 {name=l35742 lab=BLB12}
N 2360 44560 2340 44560 {}
C {lab_pin.sym} 2340 44560 0 0 {name=l35743 lab=WL223}
N 2440 44640 2460 44640 {}
C {lab_pin.sym} 2460 44640 0 0 {name=l35744 lab=VDD}
N 2440 44560 2460 44560 {}
C {lab_pin.sym} 2460 44560 0 0 {name=l35745 lab=VSS}
C {bitcell_6t.sym} 2600 44600 0 0 {name=Xr223c13}
N 2560 44640 2540 44640 {}
C {lab_pin.sym} 2540 44640 0 0 {name=l35746 lab=BL13}
N 2560 44600 2540 44600 {}
C {lab_pin.sym} 2540 44600 0 0 {name=l35747 lab=BLB13}
N 2560 44560 2540 44560 {}
C {lab_pin.sym} 2540 44560 0 0 {name=l35748 lab=WL223}
N 2640 44640 2660 44640 {}
C {lab_pin.sym} 2660 44640 0 0 {name=l35749 lab=VDD}
N 2640 44560 2660 44560 {}
C {lab_pin.sym} 2660 44560 0 0 {name=l35750 lab=VSS}
C {bitcell_6t.sym} 2800 44600 0 0 {name=Xr223c14}
N 2760 44640 2740 44640 {}
C {lab_pin.sym} 2740 44640 0 0 {name=l35751 lab=BL14}
N 2760 44600 2740 44600 {}
C {lab_pin.sym} 2740 44600 0 0 {name=l35752 lab=BLB14}
N 2760 44560 2740 44560 {}
C {lab_pin.sym} 2740 44560 0 0 {name=l35753 lab=WL223}
N 2840 44640 2860 44640 {}
C {lab_pin.sym} 2860 44640 0 0 {name=l35754 lab=VDD}
N 2840 44560 2860 44560 {}
C {lab_pin.sym} 2860 44560 0 0 {name=l35755 lab=VSS}
C {bitcell_6t.sym} 3000 44600 0 0 {name=Xr223c15}
N 2960 44640 2940 44640 {}
C {lab_pin.sym} 2940 44640 0 0 {name=l35756 lab=BL15}
N 2960 44600 2940 44600 {}
C {lab_pin.sym} 2940 44600 0 0 {name=l35757 lab=BLB15}
N 2960 44560 2940 44560 {}
C {lab_pin.sym} 2940 44560 0 0 {name=l35758 lab=WL223}
N 3040 44640 3060 44640 {}
C {lab_pin.sym} 3060 44640 0 0 {name=l35759 lab=VDD}
N 3040 44560 3060 44560 {}
C {lab_pin.sym} 3060 44560 0 0 {name=l35760 lab=VSS}
C {bitcell_6t.sym} 3200 44600 0 0 {name=Xr223c16}
N 3160 44640 3140 44640 {}
C {lab_pin.sym} 3140 44640 0 0 {name=l35761 lab=BL16}
N 3160 44600 3140 44600 {}
C {lab_pin.sym} 3140 44600 0 0 {name=l35762 lab=BLB16}
N 3160 44560 3140 44560 {}
C {lab_pin.sym} 3140 44560 0 0 {name=l35763 lab=WL223}
N 3240 44640 3260 44640 {}
C {lab_pin.sym} 3260 44640 0 0 {name=l35764 lab=VDD}
N 3240 44560 3260 44560 {}
C {lab_pin.sym} 3260 44560 0 0 {name=l35765 lab=VSS}
C {bitcell_6t.sym} 3400 44600 0 0 {name=Xr223c17}
N 3360 44640 3340 44640 {}
C {lab_pin.sym} 3340 44640 0 0 {name=l35766 lab=BL17}
N 3360 44600 3340 44600 {}
C {lab_pin.sym} 3340 44600 0 0 {name=l35767 lab=BLB17}
N 3360 44560 3340 44560 {}
C {lab_pin.sym} 3340 44560 0 0 {name=l35768 lab=WL223}
N 3440 44640 3460 44640 {}
C {lab_pin.sym} 3460 44640 0 0 {name=l35769 lab=VDD}
N 3440 44560 3460 44560 {}
C {lab_pin.sym} 3460 44560 0 0 {name=l35770 lab=VSS}
C {bitcell_6t.sym} 3600 44600 0 0 {name=Xr223c18}
N 3560 44640 3540 44640 {}
C {lab_pin.sym} 3540 44640 0 0 {name=l35771 lab=BL18}
N 3560 44600 3540 44600 {}
C {lab_pin.sym} 3540 44600 0 0 {name=l35772 lab=BLB18}
N 3560 44560 3540 44560 {}
C {lab_pin.sym} 3540 44560 0 0 {name=l35773 lab=WL223}
N 3640 44640 3660 44640 {}
C {lab_pin.sym} 3660 44640 0 0 {name=l35774 lab=VDD}
N 3640 44560 3660 44560 {}
C {lab_pin.sym} 3660 44560 0 0 {name=l35775 lab=VSS}
C {bitcell_6t.sym} 3800 44600 0 0 {name=Xr223c19}
N 3760 44640 3740 44640 {}
C {lab_pin.sym} 3740 44640 0 0 {name=l35776 lab=BL19}
N 3760 44600 3740 44600 {}
C {lab_pin.sym} 3740 44600 0 0 {name=l35777 lab=BLB19}
N 3760 44560 3740 44560 {}
C {lab_pin.sym} 3740 44560 0 0 {name=l35778 lab=WL223}
N 3840 44640 3860 44640 {}
C {lab_pin.sym} 3860 44640 0 0 {name=l35779 lab=VDD}
N 3840 44560 3860 44560 {}
C {lab_pin.sym} 3860 44560 0 0 {name=l35780 lab=VSS}
C {bitcell_6t.sym} 4000 44600 0 0 {name=Xr223c20}
N 3960 44640 3940 44640 {}
C {lab_pin.sym} 3940 44640 0 0 {name=l35781 lab=BL20}
N 3960 44600 3940 44600 {}
C {lab_pin.sym} 3940 44600 0 0 {name=l35782 lab=BLB20}
N 3960 44560 3940 44560 {}
C {lab_pin.sym} 3940 44560 0 0 {name=l35783 lab=WL223}
N 4040 44640 4060 44640 {}
C {lab_pin.sym} 4060 44640 0 0 {name=l35784 lab=VDD}
N 4040 44560 4060 44560 {}
C {lab_pin.sym} 4060 44560 0 0 {name=l35785 lab=VSS}
C {bitcell_6t.sym} 4200 44600 0 0 {name=Xr223c21}
N 4160 44640 4140 44640 {}
C {lab_pin.sym} 4140 44640 0 0 {name=l35786 lab=BL21}
N 4160 44600 4140 44600 {}
C {lab_pin.sym} 4140 44600 0 0 {name=l35787 lab=BLB21}
N 4160 44560 4140 44560 {}
C {lab_pin.sym} 4140 44560 0 0 {name=l35788 lab=WL223}
N 4240 44640 4260 44640 {}
C {lab_pin.sym} 4260 44640 0 0 {name=l35789 lab=VDD}
N 4240 44560 4260 44560 {}
C {lab_pin.sym} 4260 44560 0 0 {name=l35790 lab=VSS}
C {bitcell_6t.sym} 4400 44600 0 0 {name=Xr223c22}
N 4360 44640 4340 44640 {}
C {lab_pin.sym} 4340 44640 0 0 {name=l35791 lab=BL22}
N 4360 44600 4340 44600 {}
C {lab_pin.sym} 4340 44600 0 0 {name=l35792 lab=BLB22}
N 4360 44560 4340 44560 {}
C {lab_pin.sym} 4340 44560 0 0 {name=l35793 lab=WL223}
N 4440 44640 4460 44640 {}
C {lab_pin.sym} 4460 44640 0 0 {name=l35794 lab=VDD}
N 4440 44560 4460 44560 {}
C {lab_pin.sym} 4460 44560 0 0 {name=l35795 lab=VSS}
C {bitcell_6t.sym} 4600 44600 0 0 {name=Xr223c23}
N 4560 44640 4540 44640 {}
C {lab_pin.sym} 4540 44640 0 0 {name=l35796 lab=BL23}
N 4560 44600 4540 44600 {}
C {lab_pin.sym} 4540 44600 0 0 {name=l35797 lab=BLB23}
N 4560 44560 4540 44560 {}
C {lab_pin.sym} 4540 44560 0 0 {name=l35798 lab=WL223}
N 4640 44640 4660 44640 {}
C {lab_pin.sym} 4660 44640 0 0 {name=l35799 lab=VDD}
N 4640 44560 4660 44560 {}
C {lab_pin.sym} 4660 44560 0 0 {name=l35800 lab=VSS}
C {bitcell_6t.sym} 4800 44600 0 0 {name=Xr223c24}
N 4760 44640 4740 44640 {}
C {lab_pin.sym} 4740 44640 0 0 {name=l35801 lab=BL24}
N 4760 44600 4740 44600 {}
C {lab_pin.sym} 4740 44600 0 0 {name=l35802 lab=BLB24}
N 4760 44560 4740 44560 {}
C {lab_pin.sym} 4740 44560 0 0 {name=l35803 lab=WL223}
N 4840 44640 4860 44640 {}
C {lab_pin.sym} 4860 44640 0 0 {name=l35804 lab=VDD}
N 4840 44560 4860 44560 {}
C {lab_pin.sym} 4860 44560 0 0 {name=l35805 lab=VSS}
C {bitcell_6t.sym} 5000 44600 0 0 {name=Xr223c25}
N 4960 44640 4940 44640 {}
C {lab_pin.sym} 4940 44640 0 0 {name=l35806 lab=BL25}
N 4960 44600 4940 44600 {}
C {lab_pin.sym} 4940 44600 0 0 {name=l35807 lab=BLB25}
N 4960 44560 4940 44560 {}
C {lab_pin.sym} 4940 44560 0 0 {name=l35808 lab=WL223}
N 5040 44640 5060 44640 {}
C {lab_pin.sym} 5060 44640 0 0 {name=l35809 lab=VDD}
N 5040 44560 5060 44560 {}
C {lab_pin.sym} 5060 44560 0 0 {name=l35810 lab=VSS}
C {bitcell_6t.sym} 5200 44600 0 0 {name=Xr223c26}
N 5160 44640 5140 44640 {}
C {lab_pin.sym} 5140 44640 0 0 {name=l35811 lab=BL26}
N 5160 44600 5140 44600 {}
C {lab_pin.sym} 5140 44600 0 0 {name=l35812 lab=BLB26}
N 5160 44560 5140 44560 {}
C {lab_pin.sym} 5140 44560 0 0 {name=l35813 lab=WL223}
N 5240 44640 5260 44640 {}
C {lab_pin.sym} 5260 44640 0 0 {name=l35814 lab=VDD}
N 5240 44560 5260 44560 {}
C {lab_pin.sym} 5260 44560 0 0 {name=l35815 lab=VSS}
C {bitcell_6t.sym} 5400 44600 0 0 {name=Xr223c27}
N 5360 44640 5340 44640 {}
C {lab_pin.sym} 5340 44640 0 0 {name=l35816 lab=BL27}
N 5360 44600 5340 44600 {}
C {lab_pin.sym} 5340 44600 0 0 {name=l35817 lab=BLB27}
N 5360 44560 5340 44560 {}
C {lab_pin.sym} 5340 44560 0 0 {name=l35818 lab=WL223}
N 5440 44640 5460 44640 {}
C {lab_pin.sym} 5460 44640 0 0 {name=l35819 lab=VDD}
N 5440 44560 5460 44560 {}
C {lab_pin.sym} 5460 44560 0 0 {name=l35820 lab=VSS}
C {bitcell_6t.sym} 5600 44600 0 0 {name=Xr223c28}
N 5560 44640 5540 44640 {}
C {lab_pin.sym} 5540 44640 0 0 {name=l35821 lab=BL28}
N 5560 44600 5540 44600 {}
C {lab_pin.sym} 5540 44600 0 0 {name=l35822 lab=BLB28}
N 5560 44560 5540 44560 {}
C {lab_pin.sym} 5540 44560 0 0 {name=l35823 lab=WL223}
N 5640 44640 5660 44640 {}
C {lab_pin.sym} 5660 44640 0 0 {name=l35824 lab=VDD}
N 5640 44560 5660 44560 {}
C {lab_pin.sym} 5660 44560 0 0 {name=l35825 lab=VSS}
C {bitcell_6t.sym} 5800 44600 0 0 {name=Xr223c29}
N 5760 44640 5740 44640 {}
C {lab_pin.sym} 5740 44640 0 0 {name=l35826 lab=BL29}
N 5760 44600 5740 44600 {}
C {lab_pin.sym} 5740 44600 0 0 {name=l35827 lab=BLB29}
N 5760 44560 5740 44560 {}
C {lab_pin.sym} 5740 44560 0 0 {name=l35828 lab=WL223}
N 5840 44640 5860 44640 {}
C {lab_pin.sym} 5860 44640 0 0 {name=l35829 lab=VDD}
N 5840 44560 5860 44560 {}
C {lab_pin.sym} 5860 44560 0 0 {name=l35830 lab=VSS}
C {bitcell_6t.sym} 6000 44600 0 0 {name=Xr223c30}
N 5960 44640 5940 44640 {}
C {lab_pin.sym} 5940 44640 0 0 {name=l35831 lab=BL30}
N 5960 44600 5940 44600 {}
C {lab_pin.sym} 5940 44600 0 0 {name=l35832 lab=BLB30}
N 5960 44560 5940 44560 {}
C {lab_pin.sym} 5940 44560 0 0 {name=l35833 lab=WL223}
N 6040 44640 6060 44640 {}
C {lab_pin.sym} 6060 44640 0 0 {name=l35834 lab=VDD}
N 6040 44560 6060 44560 {}
C {lab_pin.sym} 6060 44560 0 0 {name=l35835 lab=VSS}
C {bitcell_6t.sym} 6200 44600 0 0 {name=Xr223c31}
N 6160 44640 6140 44640 {}
C {lab_pin.sym} 6140 44640 0 0 {name=l35836 lab=BL31}
N 6160 44600 6140 44600 {}
C {lab_pin.sym} 6140 44600 0 0 {name=l35837 lab=BLB31}
N 6160 44560 6140 44560 {}
C {lab_pin.sym} 6140 44560 0 0 {name=l35838 lab=WL223}
N 6240 44640 6260 44640 {}
C {lab_pin.sym} 6260 44640 0 0 {name=l35839 lab=VDD}
N 6240 44560 6260 44560 {}
C {lab_pin.sym} 6260 44560 0 0 {name=l35840 lab=VSS}
C {bitcell_6t.sym} 0 44800 0 0 {name=Xr224c0}
N -40 44840 -60 44840 {}
C {lab_pin.sym} -60 44840 0 0 {name=l35841 lab=BL0}
N -40 44800 -60 44800 {}
C {lab_pin.sym} -60 44800 0 0 {name=l35842 lab=BLB0}
N -40 44760 -60 44760 {}
C {lab_pin.sym} -60 44760 0 0 {name=l35843 lab=WL224}
N 40 44840 60 44840 {}
C {lab_pin.sym} 60 44840 0 0 {name=l35844 lab=VDD}
N 40 44760 60 44760 {}
C {lab_pin.sym} 60 44760 0 0 {name=l35845 lab=VSS}
C {bitcell_6t.sym} 200 44800 0 0 {name=Xr224c1}
N 160 44840 140 44840 {}
C {lab_pin.sym} 140 44840 0 0 {name=l35846 lab=BL1}
N 160 44800 140 44800 {}
C {lab_pin.sym} 140 44800 0 0 {name=l35847 lab=BLB1}
N 160 44760 140 44760 {}
C {lab_pin.sym} 140 44760 0 0 {name=l35848 lab=WL224}
N 240 44840 260 44840 {}
C {lab_pin.sym} 260 44840 0 0 {name=l35849 lab=VDD}
N 240 44760 260 44760 {}
C {lab_pin.sym} 260 44760 0 0 {name=l35850 lab=VSS}
C {bitcell_6t.sym} 400 44800 0 0 {name=Xr224c2}
N 360 44840 340 44840 {}
C {lab_pin.sym} 340 44840 0 0 {name=l35851 lab=BL2}
N 360 44800 340 44800 {}
C {lab_pin.sym} 340 44800 0 0 {name=l35852 lab=BLB2}
N 360 44760 340 44760 {}
C {lab_pin.sym} 340 44760 0 0 {name=l35853 lab=WL224}
N 440 44840 460 44840 {}
C {lab_pin.sym} 460 44840 0 0 {name=l35854 lab=VDD}
N 440 44760 460 44760 {}
C {lab_pin.sym} 460 44760 0 0 {name=l35855 lab=VSS}
C {bitcell_6t.sym} 600 44800 0 0 {name=Xr224c3}
N 560 44840 540 44840 {}
C {lab_pin.sym} 540 44840 0 0 {name=l35856 lab=BL3}
N 560 44800 540 44800 {}
C {lab_pin.sym} 540 44800 0 0 {name=l35857 lab=BLB3}
N 560 44760 540 44760 {}
C {lab_pin.sym} 540 44760 0 0 {name=l35858 lab=WL224}
N 640 44840 660 44840 {}
C {lab_pin.sym} 660 44840 0 0 {name=l35859 lab=VDD}
N 640 44760 660 44760 {}
C {lab_pin.sym} 660 44760 0 0 {name=l35860 lab=VSS}
C {bitcell_6t.sym} 800 44800 0 0 {name=Xr224c4}
N 760 44840 740 44840 {}
C {lab_pin.sym} 740 44840 0 0 {name=l35861 lab=BL4}
N 760 44800 740 44800 {}
C {lab_pin.sym} 740 44800 0 0 {name=l35862 lab=BLB4}
N 760 44760 740 44760 {}
C {lab_pin.sym} 740 44760 0 0 {name=l35863 lab=WL224}
N 840 44840 860 44840 {}
C {lab_pin.sym} 860 44840 0 0 {name=l35864 lab=VDD}
N 840 44760 860 44760 {}
C {lab_pin.sym} 860 44760 0 0 {name=l35865 lab=VSS}
C {bitcell_6t.sym} 1000 44800 0 0 {name=Xr224c5}
N 960 44840 940 44840 {}
C {lab_pin.sym} 940 44840 0 0 {name=l35866 lab=BL5}
N 960 44800 940 44800 {}
C {lab_pin.sym} 940 44800 0 0 {name=l35867 lab=BLB5}
N 960 44760 940 44760 {}
C {lab_pin.sym} 940 44760 0 0 {name=l35868 lab=WL224}
N 1040 44840 1060 44840 {}
C {lab_pin.sym} 1060 44840 0 0 {name=l35869 lab=VDD}
N 1040 44760 1060 44760 {}
C {lab_pin.sym} 1060 44760 0 0 {name=l35870 lab=VSS}
C {bitcell_6t.sym} 1200 44800 0 0 {name=Xr224c6}
N 1160 44840 1140 44840 {}
C {lab_pin.sym} 1140 44840 0 0 {name=l35871 lab=BL6}
N 1160 44800 1140 44800 {}
C {lab_pin.sym} 1140 44800 0 0 {name=l35872 lab=BLB6}
N 1160 44760 1140 44760 {}
C {lab_pin.sym} 1140 44760 0 0 {name=l35873 lab=WL224}
N 1240 44840 1260 44840 {}
C {lab_pin.sym} 1260 44840 0 0 {name=l35874 lab=VDD}
N 1240 44760 1260 44760 {}
C {lab_pin.sym} 1260 44760 0 0 {name=l35875 lab=VSS}
C {bitcell_6t.sym} 1400 44800 0 0 {name=Xr224c7}
N 1360 44840 1340 44840 {}
C {lab_pin.sym} 1340 44840 0 0 {name=l35876 lab=BL7}
N 1360 44800 1340 44800 {}
C {lab_pin.sym} 1340 44800 0 0 {name=l35877 lab=BLB7}
N 1360 44760 1340 44760 {}
C {lab_pin.sym} 1340 44760 0 0 {name=l35878 lab=WL224}
N 1440 44840 1460 44840 {}
C {lab_pin.sym} 1460 44840 0 0 {name=l35879 lab=VDD}
N 1440 44760 1460 44760 {}
C {lab_pin.sym} 1460 44760 0 0 {name=l35880 lab=VSS}
C {bitcell_6t.sym} 1600 44800 0 0 {name=Xr224c8}
N 1560 44840 1540 44840 {}
C {lab_pin.sym} 1540 44840 0 0 {name=l35881 lab=BL8}
N 1560 44800 1540 44800 {}
C {lab_pin.sym} 1540 44800 0 0 {name=l35882 lab=BLB8}
N 1560 44760 1540 44760 {}
C {lab_pin.sym} 1540 44760 0 0 {name=l35883 lab=WL224}
N 1640 44840 1660 44840 {}
C {lab_pin.sym} 1660 44840 0 0 {name=l35884 lab=VDD}
N 1640 44760 1660 44760 {}
C {lab_pin.sym} 1660 44760 0 0 {name=l35885 lab=VSS}
C {bitcell_6t.sym} 1800 44800 0 0 {name=Xr224c9}
N 1760 44840 1740 44840 {}
C {lab_pin.sym} 1740 44840 0 0 {name=l35886 lab=BL9}
N 1760 44800 1740 44800 {}
C {lab_pin.sym} 1740 44800 0 0 {name=l35887 lab=BLB9}
N 1760 44760 1740 44760 {}
C {lab_pin.sym} 1740 44760 0 0 {name=l35888 lab=WL224}
N 1840 44840 1860 44840 {}
C {lab_pin.sym} 1860 44840 0 0 {name=l35889 lab=VDD}
N 1840 44760 1860 44760 {}
C {lab_pin.sym} 1860 44760 0 0 {name=l35890 lab=VSS}
C {bitcell_6t.sym} 2000 44800 0 0 {name=Xr224c10}
N 1960 44840 1940 44840 {}
C {lab_pin.sym} 1940 44840 0 0 {name=l35891 lab=BL10}
N 1960 44800 1940 44800 {}
C {lab_pin.sym} 1940 44800 0 0 {name=l35892 lab=BLB10}
N 1960 44760 1940 44760 {}
C {lab_pin.sym} 1940 44760 0 0 {name=l35893 lab=WL224}
N 2040 44840 2060 44840 {}
C {lab_pin.sym} 2060 44840 0 0 {name=l35894 lab=VDD}
N 2040 44760 2060 44760 {}
C {lab_pin.sym} 2060 44760 0 0 {name=l35895 lab=VSS}
C {bitcell_6t.sym} 2200 44800 0 0 {name=Xr224c11}
N 2160 44840 2140 44840 {}
C {lab_pin.sym} 2140 44840 0 0 {name=l35896 lab=BL11}
N 2160 44800 2140 44800 {}
C {lab_pin.sym} 2140 44800 0 0 {name=l35897 lab=BLB11}
N 2160 44760 2140 44760 {}
C {lab_pin.sym} 2140 44760 0 0 {name=l35898 lab=WL224}
N 2240 44840 2260 44840 {}
C {lab_pin.sym} 2260 44840 0 0 {name=l35899 lab=VDD}
N 2240 44760 2260 44760 {}
C {lab_pin.sym} 2260 44760 0 0 {name=l35900 lab=VSS}
C {bitcell_6t.sym} 2400 44800 0 0 {name=Xr224c12}
N 2360 44840 2340 44840 {}
C {lab_pin.sym} 2340 44840 0 0 {name=l35901 lab=BL12}
N 2360 44800 2340 44800 {}
C {lab_pin.sym} 2340 44800 0 0 {name=l35902 lab=BLB12}
N 2360 44760 2340 44760 {}
C {lab_pin.sym} 2340 44760 0 0 {name=l35903 lab=WL224}
N 2440 44840 2460 44840 {}
C {lab_pin.sym} 2460 44840 0 0 {name=l35904 lab=VDD}
N 2440 44760 2460 44760 {}
C {lab_pin.sym} 2460 44760 0 0 {name=l35905 lab=VSS}
C {bitcell_6t.sym} 2600 44800 0 0 {name=Xr224c13}
N 2560 44840 2540 44840 {}
C {lab_pin.sym} 2540 44840 0 0 {name=l35906 lab=BL13}
N 2560 44800 2540 44800 {}
C {lab_pin.sym} 2540 44800 0 0 {name=l35907 lab=BLB13}
N 2560 44760 2540 44760 {}
C {lab_pin.sym} 2540 44760 0 0 {name=l35908 lab=WL224}
N 2640 44840 2660 44840 {}
C {lab_pin.sym} 2660 44840 0 0 {name=l35909 lab=VDD}
N 2640 44760 2660 44760 {}
C {lab_pin.sym} 2660 44760 0 0 {name=l35910 lab=VSS}
C {bitcell_6t.sym} 2800 44800 0 0 {name=Xr224c14}
N 2760 44840 2740 44840 {}
C {lab_pin.sym} 2740 44840 0 0 {name=l35911 lab=BL14}
N 2760 44800 2740 44800 {}
C {lab_pin.sym} 2740 44800 0 0 {name=l35912 lab=BLB14}
N 2760 44760 2740 44760 {}
C {lab_pin.sym} 2740 44760 0 0 {name=l35913 lab=WL224}
N 2840 44840 2860 44840 {}
C {lab_pin.sym} 2860 44840 0 0 {name=l35914 lab=VDD}
N 2840 44760 2860 44760 {}
C {lab_pin.sym} 2860 44760 0 0 {name=l35915 lab=VSS}
C {bitcell_6t.sym} 3000 44800 0 0 {name=Xr224c15}
N 2960 44840 2940 44840 {}
C {lab_pin.sym} 2940 44840 0 0 {name=l35916 lab=BL15}
N 2960 44800 2940 44800 {}
C {lab_pin.sym} 2940 44800 0 0 {name=l35917 lab=BLB15}
N 2960 44760 2940 44760 {}
C {lab_pin.sym} 2940 44760 0 0 {name=l35918 lab=WL224}
N 3040 44840 3060 44840 {}
C {lab_pin.sym} 3060 44840 0 0 {name=l35919 lab=VDD}
N 3040 44760 3060 44760 {}
C {lab_pin.sym} 3060 44760 0 0 {name=l35920 lab=VSS}
C {bitcell_6t.sym} 3200 44800 0 0 {name=Xr224c16}
N 3160 44840 3140 44840 {}
C {lab_pin.sym} 3140 44840 0 0 {name=l35921 lab=BL16}
N 3160 44800 3140 44800 {}
C {lab_pin.sym} 3140 44800 0 0 {name=l35922 lab=BLB16}
N 3160 44760 3140 44760 {}
C {lab_pin.sym} 3140 44760 0 0 {name=l35923 lab=WL224}
N 3240 44840 3260 44840 {}
C {lab_pin.sym} 3260 44840 0 0 {name=l35924 lab=VDD}
N 3240 44760 3260 44760 {}
C {lab_pin.sym} 3260 44760 0 0 {name=l35925 lab=VSS}
C {bitcell_6t.sym} 3400 44800 0 0 {name=Xr224c17}
N 3360 44840 3340 44840 {}
C {lab_pin.sym} 3340 44840 0 0 {name=l35926 lab=BL17}
N 3360 44800 3340 44800 {}
C {lab_pin.sym} 3340 44800 0 0 {name=l35927 lab=BLB17}
N 3360 44760 3340 44760 {}
C {lab_pin.sym} 3340 44760 0 0 {name=l35928 lab=WL224}
N 3440 44840 3460 44840 {}
C {lab_pin.sym} 3460 44840 0 0 {name=l35929 lab=VDD}
N 3440 44760 3460 44760 {}
C {lab_pin.sym} 3460 44760 0 0 {name=l35930 lab=VSS}
C {bitcell_6t.sym} 3600 44800 0 0 {name=Xr224c18}
N 3560 44840 3540 44840 {}
C {lab_pin.sym} 3540 44840 0 0 {name=l35931 lab=BL18}
N 3560 44800 3540 44800 {}
C {lab_pin.sym} 3540 44800 0 0 {name=l35932 lab=BLB18}
N 3560 44760 3540 44760 {}
C {lab_pin.sym} 3540 44760 0 0 {name=l35933 lab=WL224}
N 3640 44840 3660 44840 {}
C {lab_pin.sym} 3660 44840 0 0 {name=l35934 lab=VDD}
N 3640 44760 3660 44760 {}
C {lab_pin.sym} 3660 44760 0 0 {name=l35935 lab=VSS}
C {bitcell_6t.sym} 3800 44800 0 0 {name=Xr224c19}
N 3760 44840 3740 44840 {}
C {lab_pin.sym} 3740 44840 0 0 {name=l35936 lab=BL19}
N 3760 44800 3740 44800 {}
C {lab_pin.sym} 3740 44800 0 0 {name=l35937 lab=BLB19}
N 3760 44760 3740 44760 {}
C {lab_pin.sym} 3740 44760 0 0 {name=l35938 lab=WL224}
N 3840 44840 3860 44840 {}
C {lab_pin.sym} 3860 44840 0 0 {name=l35939 lab=VDD}
N 3840 44760 3860 44760 {}
C {lab_pin.sym} 3860 44760 0 0 {name=l35940 lab=VSS}
C {bitcell_6t.sym} 4000 44800 0 0 {name=Xr224c20}
N 3960 44840 3940 44840 {}
C {lab_pin.sym} 3940 44840 0 0 {name=l35941 lab=BL20}
N 3960 44800 3940 44800 {}
C {lab_pin.sym} 3940 44800 0 0 {name=l35942 lab=BLB20}
N 3960 44760 3940 44760 {}
C {lab_pin.sym} 3940 44760 0 0 {name=l35943 lab=WL224}
N 4040 44840 4060 44840 {}
C {lab_pin.sym} 4060 44840 0 0 {name=l35944 lab=VDD}
N 4040 44760 4060 44760 {}
C {lab_pin.sym} 4060 44760 0 0 {name=l35945 lab=VSS}
C {bitcell_6t.sym} 4200 44800 0 0 {name=Xr224c21}
N 4160 44840 4140 44840 {}
C {lab_pin.sym} 4140 44840 0 0 {name=l35946 lab=BL21}
N 4160 44800 4140 44800 {}
C {lab_pin.sym} 4140 44800 0 0 {name=l35947 lab=BLB21}
N 4160 44760 4140 44760 {}
C {lab_pin.sym} 4140 44760 0 0 {name=l35948 lab=WL224}
N 4240 44840 4260 44840 {}
C {lab_pin.sym} 4260 44840 0 0 {name=l35949 lab=VDD}
N 4240 44760 4260 44760 {}
C {lab_pin.sym} 4260 44760 0 0 {name=l35950 lab=VSS}
C {bitcell_6t.sym} 4400 44800 0 0 {name=Xr224c22}
N 4360 44840 4340 44840 {}
C {lab_pin.sym} 4340 44840 0 0 {name=l35951 lab=BL22}
N 4360 44800 4340 44800 {}
C {lab_pin.sym} 4340 44800 0 0 {name=l35952 lab=BLB22}
N 4360 44760 4340 44760 {}
C {lab_pin.sym} 4340 44760 0 0 {name=l35953 lab=WL224}
N 4440 44840 4460 44840 {}
C {lab_pin.sym} 4460 44840 0 0 {name=l35954 lab=VDD}
N 4440 44760 4460 44760 {}
C {lab_pin.sym} 4460 44760 0 0 {name=l35955 lab=VSS}
C {bitcell_6t.sym} 4600 44800 0 0 {name=Xr224c23}
N 4560 44840 4540 44840 {}
C {lab_pin.sym} 4540 44840 0 0 {name=l35956 lab=BL23}
N 4560 44800 4540 44800 {}
C {lab_pin.sym} 4540 44800 0 0 {name=l35957 lab=BLB23}
N 4560 44760 4540 44760 {}
C {lab_pin.sym} 4540 44760 0 0 {name=l35958 lab=WL224}
N 4640 44840 4660 44840 {}
C {lab_pin.sym} 4660 44840 0 0 {name=l35959 lab=VDD}
N 4640 44760 4660 44760 {}
C {lab_pin.sym} 4660 44760 0 0 {name=l35960 lab=VSS}
C {bitcell_6t.sym} 4800 44800 0 0 {name=Xr224c24}
N 4760 44840 4740 44840 {}
C {lab_pin.sym} 4740 44840 0 0 {name=l35961 lab=BL24}
N 4760 44800 4740 44800 {}
C {lab_pin.sym} 4740 44800 0 0 {name=l35962 lab=BLB24}
N 4760 44760 4740 44760 {}
C {lab_pin.sym} 4740 44760 0 0 {name=l35963 lab=WL224}
N 4840 44840 4860 44840 {}
C {lab_pin.sym} 4860 44840 0 0 {name=l35964 lab=VDD}
N 4840 44760 4860 44760 {}
C {lab_pin.sym} 4860 44760 0 0 {name=l35965 lab=VSS}
C {bitcell_6t.sym} 5000 44800 0 0 {name=Xr224c25}
N 4960 44840 4940 44840 {}
C {lab_pin.sym} 4940 44840 0 0 {name=l35966 lab=BL25}
N 4960 44800 4940 44800 {}
C {lab_pin.sym} 4940 44800 0 0 {name=l35967 lab=BLB25}
N 4960 44760 4940 44760 {}
C {lab_pin.sym} 4940 44760 0 0 {name=l35968 lab=WL224}
N 5040 44840 5060 44840 {}
C {lab_pin.sym} 5060 44840 0 0 {name=l35969 lab=VDD}
N 5040 44760 5060 44760 {}
C {lab_pin.sym} 5060 44760 0 0 {name=l35970 lab=VSS}
C {bitcell_6t.sym} 5200 44800 0 0 {name=Xr224c26}
N 5160 44840 5140 44840 {}
C {lab_pin.sym} 5140 44840 0 0 {name=l35971 lab=BL26}
N 5160 44800 5140 44800 {}
C {lab_pin.sym} 5140 44800 0 0 {name=l35972 lab=BLB26}
N 5160 44760 5140 44760 {}
C {lab_pin.sym} 5140 44760 0 0 {name=l35973 lab=WL224}
N 5240 44840 5260 44840 {}
C {lab_pin.sym} 5260 44840 0 0 {name=l35974 lab=VDD}
N 5240 44760 5260 44760 {}
C {lab_pin.sym} 5260 44760 0 0 {name=l35975 lab=VSS}
C {bitcell_6t.sym} 5400 44800 0 0 {name=Xr224c27}
N 5360 44840 5340 44840 {}
C {lab_pin.sym} 5340 44840 0 0 {name=l35976 lab=BL27}
N 5360 44800 5340 44800 {}
C {lab_pin.sym} 5340 44800 0 0 {name=l35977 lab=BLB27}
N 5360 44760 5340 44760 {}
C {lab_pin.sym} 5340 44760 0 0 {name=l35978 lab=WL224}
N 5440 44840 5460 44840 {}
