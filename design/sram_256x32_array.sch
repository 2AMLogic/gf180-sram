C {lab_pin.sym} 4540 28200 0 0 {name=l22677 lab=BLB23}
N 4560 28160 4540 28160 {}
C {lab_pin.sym} 4540 28160 0 0 {name=l22678 lab=WL141}
N 4640 28240 4660 28240 {}
C {lab_pin.sym} 4660 28240 0 0 {name=l22679 lab=VDD}
N 4640 28160 4660 28160 {}
C {lab_pin.sym} 4660 28160 0 0 {name=l22680 lab=VSS}
C {bitcell_6t.sym} 4800 28200 0 0 {name=Xr141c24}
N 4760 28240 4740 28240 {}
C {lab_pin.sym} 4740 28240 0 0 {name=l22681 lab=BL24}
N 4760 28200 4740 28200 {}
C {lab_pin.sym} 4740 28200 0 0 {name=l22682 lab=BLB24}
N 4760 28160 4740 28160 {}
C {lab_pin.sym} 4740 28160 0 0 {name=l22683 lab=WL141}
N 4840 28240 4860 28240 {}
C {lab_pin.sym} 4860 28240 0 0 {name=l22684 lab=VDD}
N 4840 28160 4860 28160 {}
C {lab_pin.sym} 4860 28160 0 0 {name=l22685 lab=VSS}
C {bitcell_6t.sym} 5000 28200 0 0 {name=Xr141c25}
N 4960 28240 4940 28240 {}
C {lab_pin.sym} 4940 28240 0 0 {name=l22686 lab=BL25}
N 4960 28200 4940 28200 {}
C {lab_pin.sym} 4940 28200 0 0 {name=l22687 lab=BLB25}
N 4960 28160 4940 28160 {}
C {lab_pin.sym} 4940 28160 0 0 {name=l22688 lab=WL141}
N 5040 28240 5060 28240 {}
C {lab_pin.sym} 5060 28240 0 0 {name=l22689 lab=VDD}
N 5040 28160 5060 28160 {}
C {lab_pin.sym} 5060 28160 0 0 {name=l22690 lab=VSS}
C {bitcell_6t.sym} 5200 28200 0 0 {name=Xr141c26}
N 5160 28240 5140 28240 {}
C {lab_pin.sym} 5140 28240 0 0 {name=l22691 lab=BL26}
N 5160 28200 5140 28200 {}
C {lab_pin.sym} 5140 28200 0 0 {name=l22692 lab=BLB26}
N 5160 28160 5140 28160 {}
C {lab_pin.sym} 5140 28160 0 0 {name=l22693 lab=WL141}
N 5240 28240 5260 28240 {}
C {lab_pin.sym} 5260 28240 0 0 {name=l22694 lab=VDD}
N 5240 28160 5260 28160 {}
C {lab_pin.sym} 5260 28160 0 0 {name=l22695 lab=VSS}
C {bitcell_6t.sym} 5400 28200 0 0 {name=Xr141c27}
N 5360 28240 5340 28240 {}
C {lab_pin.sym} 5340 28240 0 0 {name=l22696 lab=BL27}
N 5360 28200 5340 28200 {}
C {lab_pin.sym} 5340 28200 0 0 {name=l22697 lab=BLB27}
N 5360 28160 5340 28160 {}
C {lab_pin.sym} 5340 28160 0 0 {name=l22698 lab=WL141}
N 5440 28240 5460 28240 {}
C {lab_pin.sym} 5460 28240 0 0 {name=l22699 lab=VDD}
N 5440 28160 5460 28160 {}
C {lab_pin.sym} 5460 28160 0 0 {name=l22700 lab=VSS}
C {bitcell_6t.sym} 5600 28200 0 0 {name=Xr141c28}
N 5560 28240 5540 28240 {}
C {lab_pin.sym} 5540 28240 0 0 {name=l22701 lab=BL28}
N 5560 28200 5540 28200 {}
C {lab_pin.sym} 5540 28200 0 0 {name=l22702 lab=BLB28}
N 5560 28160 5540 28160 {}
C {lab_pin.sym} 5540 28160 0 0 {name=l22703 lab=WL141}
N 5640 28240 5660 28240 {}
C {lab_pin.sym} 5660 28240 0 0 {name=l22704 lab=VDD}
N 5640 28160 5660 28160 {}
C {lab_pin.sym} 5660 28160 0 0 {name=l22705 lab=VSS}
C {bitcell_6t.sym} 5800 28200 0 0 {name=Xr141c29}
N 5760 28240 5740 28240 {}
C {lab_pin.sym} 5740 28240 0 0 {name=l22706 lab=BL29}
N 5760 28200 5740 28200 {}
C {lab_pin.sym} 5740 28200 0 0 {name=l22707 lab=BLB29}
N 5760 28160 5740 28160 {}
C {lab_pin.sym} 5740 28160 0 0 {name=l22708 lab=WL141}
N 5840 28240 5860 28240 {}
C {lab_pin.sym} 5860 28240 0 0 {name=l22709 lab=VDD}
N 5840 28160 5860 28160 {}
C {lab_pin.sym} 5860 28160 0 0 {name=l22710 lab=VSS}
C {bitcell_6t.sym} 6000 28200 0 0 {name=Xr141c30}
N 5960 28240 5940 28240 {}
C {lab_pin.sym} 5940 28240 0 0 {name=l22711 lab=BL30}
N 5960 28200 5940 28200 {}
C {lab_pin.sym} 5940 28200 0 0 {name=l22712 lab=BLB30}
N 5960 28160 5940 28160 {}
C {lab_pin.sym} 5940 28160 0 0 {name=l22713 lab=WL141}
N 6040 28240 6060 28240 {}
C {lab_pin.sym} 6060 28240 0 0 {name=l22714 lab=VDD}
N 6040 28160 6060 28160 {}
C {lab_pin.sym} 6060 28160 0 0 {name=l22715 lab=VSS}
C {bitcell_6t.sym} 6200 28200 0 0 {name=Xr141c31}
N 6160 28240 6140 28240 {}
C {lab_pin.sym} 6140 28240 0 0 {name=l22716 lab=BL31}
N 6160 28200 6140 28200 {}
C {lab_pin.sym} 6140 28200 0 0 {name=l22717 lab=BLB31}
N 6160 28160 6140 28160 {}
C {lab_pin.sym} 6140 28160 0 0 {name=l22718 lab=WL141}
N 6240 28240 6260 28240 {}
C {lab_pin.sym} 6260 28240 0 0 {name=l22719 lab=VDD}
N 6240 28160 6260 28160 {}
C {lab_pin.sym} 6260 28160 0 0 {name=l22720 lab=VSS}
C {bitcell_6t.sym} 0 28400 0 0 {name=Xr142c0}
N -40 28440 -60 28440 {}
C {lab_pin.sym} -60 28440 0 0 {name=l22721 lab=BL0}
N -40 28400 -60 28400 {}
C {lab_pin.sym} -60 28400 0 0 {name=l22722 lab=BLB0}
N -40 28360 -60 28360 {}
C {lab_pin.sym} -60 28360 0 0 {name=l22723 lab=WL142}
N 40 28440 60 28440 {}
C {lab_pin.sym} 60 28440 0 0 {name=l22724 lab=VDD}
N 40 28360 60 28360 {}
C {lab_pin.sym} 60 28360 0 0 {name=l22725 lab=VSS}
C {bitcell_6t.sym} 200 28400 0 0 {name=Xr142c1}
N 160 28440 140 28440 {}
C {lab_pin.sym} 140 28440 0 0 {name=l22726 lab=BL1}
N 160 28400 140 28400 {}
C {lab_pin.sym} 140 28400 0 0 {name=l22727 lab=BLB1}
N 160 28360 140 28360 {}
C {lab_pin.sym} 140 28360 0 0 {name=l22728 lab=WL142}
N 240 28440 260 28440 {}
C {lab_pin.sym} 260 28440 0 0 {name=l22729 lab=VDD}
N 240 28360 260 28360 {}
C {lab_pin.sym} 260 28360 0 0 {name=l22730 lab=VSS}
C {bitcell_6t.sym} 400 28400 0 0 {name=Xr142c2}
N 360 28440 340 28440 {}
C {lab_pin.sym} 340 28440 0 0 {name=l22731 lab=BL2}
N 360 28400 340 28400 {}
C {lab_pin.sym} 340 28400 0 0 {name=l22732 lab=BLB2}
N 360 28360 340 28360 {}
C {lab_pin.sym} 340 28360 0 0 {name=l22733 lab=WL142}
N 440 28440 460 28440 {}
C {lab_pin.sym} 460 28440 0 0 {name=l22734 lab=VDD}
N 440 28360 460 28360 {}
C {lab_pin.sym} 460 28360 0 0 {name=l22735 lab=VSS}
C {bitcell_6t.sym} 600 28400 0 0 {name=Xr142c3}
N 560 28440 540 28440 {}
C {lab_pin.sym} 540 28440 0 0 {name=l22736 lab=BL3}
N 560 28400 540 28400 {}
C {lab_pin.sym} 540 28400 0 0 {name=l22737 lab=BLB3}
N 560 28360 540 28360 {}
C {lab_pin.sym} 540 28360 0 0 {name=l22738 lab=WL142}
N 640 28440 660 28440 {}
C {lab_pin.sym} 660 28440 0 0 {name=l22739 lab=VDD}
N 640 28360 660 28360 {}
C {lab_pin.sym} 660 28360 0 0 {name=l22740 lab=VSS}
C {bitcell_6t.sym} 800 28400 0 0 {name=Xr142c4}
N 760 28440 740 28440 {}
C {lab_pin.sym} 740 28440 0 0 {name=l22741 lab=BL4}
N 760 28400 740 28400 {}
C {lab_pin.sym} 740 28400 0 0 {name=l22742 lab=BLB4}
N 760 28360 740 28360 {}
C {lab_pin.sym} 740 28360 0 0 {name=l22743 lab=WL142}
N 840 28440 860 28440 {}
C {lab_pin.sym} 860 28440 0 0 {name=l22744 lab=VDD}
N 840 28360 860 28360 {}
C {lab_pin.sym} 860 28360 0 0 {name=l22745 lab=VSS}
C {bitcell_6t.sym} 1000 28400 0 0 {name=Xr142c5}
N 960 28440 940 28440 {}
C {lab_pin.sym} 940 28440 0 0 {name=l22746 lab=BL5}
N 960 28400 940 28400 {}
C {lab_pin.sym} 940 28400 0 0 {name=l22747 lab=BLB5}
N 960 28360 940 28360 {}
C {lab_pin.sym} 940 28360 0 0 {name=l22748 lab=WL142}
N 1040 28440 1060 28440 {}
C {lab_pin.sym} 1060 28440 0 0 {name=l22749 lab=VDD}
N 1040 28360 1060 28360 {}
C {lab_pin.sym} 1060 28360 0 0 {name=l22750 lab=VSS}
C {bitcell_6t.sym} 1200 28400 0 0 {name=Xr142c6}
N 1160 28440 1140 28440 {}
C {lab_pin.sym} 1140 28440 0 0 {name=l22751 lab=BL6}
N 1160 28400 1140 28400 {}
C {lab_pin.sym} 1140 28400 0 0 {name=l22752 lab=BLB6}
N 1160 28360 1140 28360 {}
C {lab_pin.sym} 1140 28360 0 0 {name=l22753 lab=WL142}
N 1240 28440 1260 28440 {}
C {lab_pin.sym} 1260 28440 0 0 {name=l22754 lab=VDD}
N 1240 28360 1260 28360 {}
C {lab_pin.sym} 1260 28360 0 0 {name=l22755 lab=VSS}
C {bitcell_6t.sym} 1400 28400 0 0 {name=Xr142c7}
N 1360 28440 1340 28440 {}
C {lab_pin.sym} 1340 28440 0 0 {name=l22756 lab=BL7}
N 1360 28400 1340 28400 {}
C {lab_pin.sym} 1340 28400 0 0 {name=l22757 lab=BLB7}
N 1360 28360 1340 28360 {}
C {lab_pin.sym} 1340 28360 0 0 {name=l22758 lab=WL142}
N 1440 28440 1460 28440 {}
C {lab_pin.sym} 1460 28440 0 0 {name=l22759 lab=VDD}
N 1440 28360 1460 28360 {}
C {lab_pin.sym} 1460 28360 0 0 {name=l22760 lab=VSS}
C {bitcell_6t.sym} 1600 28400 0 0 {name=Xr142c8}
N 1560 28440 1540 28440 {}
C {lab_pin.sym} 1540 28440 0 0 {name=l22761 lab=BL8}
N 1560 28400 1540 28400 {}
C {lab_pin.sym} 1540 28400 0 0 {name=l22762 lab=BLB8}
N 1560 28360 1540 28360 {}
C {lab_pin.sym} 1540 28360 0 0 {name=l22763 lab=WL142}
N 1640 28440 1660 28440 {}
C {lab_pin.sym} 1660 28440 0 0 {name=l22764 lab=VDD}
N 1640 28360 1660 28360 {}
C {lab_pin.sym} 1660 28360 0 0 {name=l22765 lab=VSS}
C {bitcell_6t.sym} 1800 28400 0 0 {name=Xr142c9}
N 1760 28440 1740 28440 {}
C {lab_pin.sym} 1740 28440 0 0 {name=l22766 lab=BL9}
N 1760 28400 1740 28400 {}
C {lab_pin.sym} 1740 28400 0 0 {name=l22767 lab=BLB9}
N 1760 28360 1740 28360 {}
C {lab_pin.sym} 1740 28360 0 0 {name=l22768 lab=WL142}
N 1840 28440 1860 28440 {}
C {lab_pin.sym} 1860 28440 0 0 {name=l22769 lab=VDD}
N 1840 28360 1860 28360 {}
C {lab_pin.sym} 1860 28360 0 0 {name=l22770 lab=VSS}
C {bitcell_6t.sym} 2000 28400 0 0 {name=Xr142c10}
N 1960 28440 1940 28440 {}
C {lab_pin.sym} 1940 28440 0 0 {name=l22771 lab=BL10}
N 1960 28400 1940 28400 {}
C {lab_pin.sym} 1940 28400 0 0 {name=l22772 lab=BLB10}
N 1960 28360 1940 28360 {}
C {lab_pin.sym} 1940 28360 0 0 {name=l22773 lab=WL142}
N 2040 28440 2060 28440 {}
C {lab_pin.sym} 2060 28440 0 0 {name=l22774 lab=VDD}
N 2040 28360 2060 28360 {}
C {lab_pin.sym} 2060 28360 0 0 {name=l22775 lab=VSS}
C {bitcell_6t.sym} 2200 28400 0 0 {name=Xr142c11}
N 2160 28440 2140 28440 {}
C {lab_pin.sym} 2140 28440 0 0 {name=l22776 lab=BL11}
N 2160 28400 2140 28400 {}
C {lab_pin.sym} 2140 28400 0 0 {name=l22777 lab=BLB11}
N 2160 28360 2140 28360 {}
C {lab_pin.sym} 2140 28360 0 0 {name=l22778 lab=WL142}
N 2240 28440 2260 28440 {}
C {lab_pin.sym} 2260 28440 0 0 {name=l22779 lab=VDD}
N 2240 28360 2260 28360 {}
C {lab_pin.sym} 2260 28360 0 0 {name=l22780 lab=VSS}
C {bitcell_6t.sym} 2400 28400 0 0 {name=Xr142c12}
N 2360 28440 2340 28440 {}
C {lab_pin.sym} 2340 28440 0 0 {name=l22781 lab=BL12}
N 2360 28400 2340 28400 {}
C {lab_pin.sym} 2340 28400 0 0 {name=l22782 lab=BLB12}
N 2360 28360 2340 28360 {}
C {lab_pin.sym} 2340 28360 0 0 {name=l22783 lab=WL142}
N 2440 28440 2460 28440 {}
C {lab_pin.sym} 2460 28440 0 0 {name=l22784 lab=VDD}
N 2440 28360 2460 28360 {}
C {lab_pin.sym} 2460 28360 0 0 {name=l22785 lab=VSS}
C {bitcell_6t.sym} 2600 28400 0 0 {name=Xr142c13}
N 2560 28440 2540 28440 {}
C {lab_pin.sym} 2540 28440 0 0 {name=l22786 lab=BL13}
N 2560 28400 2540 28400 {}
C {lab_pin.sym} 2540 28400 0 0 {name=l22787 lab=BLB13}
N 2560 28360 2540 28360 {}
C {lab_pin.sym} 2540 28360 0 0 {name=l22788 lab=WL142}
N 2640 28440 2660 28440 {}
C {lab_pin.sym} 2660 28440 0 0 {name=l22789 lab=VDD}
N 2640 28360 2660 28360 {}
C {lab_pin.sym} 2660 28360 0 0 {name=l22790 lab=VSS}
C {bitcell_6t.sym} 2800 28400 0 0 {name=Xr142c14}
N 2760 28440 2740 28440 {}
C {lab_pin.sym} 2740 28440 0 0 {name=l22791 lab=BL14}
N 2760 28400 2740 28400 {}
C {lab_pin.sym} 2740 28400 0 0 {name=l22792 lab=BLB14}
N 2760 28360 2740 28360 {}
C {lab_pin.sym} 2740 28360 0 0 {name=l22793 lab=WL142}
N 2840 28440 2860 28440 {}
C {lab_pin.sym} 2860 28440 0 0 {name=l22794 lab=VDD}
N 2840 28360 2860 28360 {}
C {lab_pin.sym} 2860 28360 0 0 {name=l22795 lab=VSS}
C {bitcell_6t.sym} 3000 28400 0 0 {name=Xr142c15}
N 2960 28440 2940 28440 {}
C {lab_pin.sym} 2940 28440 0 0 {name=l22796 lab=BL15}
N 2960 28400 2940 28400 {}
C {lab_pin.sym} 2940 28400 0 0 {name=l22797 lab=BLB15}
N 2960 28360 2940 28360 {}
C {lab_pin.sym} 2940 28360 0 0 {name=l22798 lab=WL142}
N 3040 28440 3060 28440 {}
C {lab_pin.sym} 3060 28440 0 0 {name=l22799 lab=VDD}
N 3040 28360 3060 28360 {}
C {lab_pin.sym} 3060 28360 0 0 {name=l22800 lab=VSS}
C {bitcell_6t.sym} 3200 28400 0 0 {name=Xr142c16}
N 3160 28440 3140 28440 {}
C {lab_pin.sym} 3140 28440 0 0 {name=l22801 lab=BL16}
N 3160 28400 3140 28400 {}
C {lab_pin.sym} 3140 28400 0 0 {name=l22802 lab=BLB16}
N 3160 28360 3140 28360 {}
C {lab_pin.sym} 3140 28360 0 0 {name=l22803 lab=WL142}
N 3240 28440 3260 28440 {}
C {lab_pin.sym} 3260 28440 0 0 {name=l22804 lab=VDD}
N 3240 28360 3260 28360 {}
C {lab_pin.sym} 3260 28360 0 0 {name=l22805 lab=VSS}
C {bitcell_6t.sym} 3400 28400 0 0 {name=Xr142c17}
N 3360 28440 3340 28440 {}
C {lab_pin.sym} 3340 28440 0 0 {name=l22806 lab=BL17}
N 3360 28400 3340 28400 {}
C {lab_pin.sym} 3340 28400 0 0 {name=l22807 lab=BLB17}
N 3360 28360 3340 28360 {}
C {lab_pin.sym} 3340 28360 0 0 {name=l22808 lab=WL142}
N 3440 28440 3460 28440 {}
C {lab_pin.sym} 3460 28440 0 0 {name=l22809 lab=VDD}
N 3440 28360 3460 28360 {}
C {lab_pin.sym} 3460 28360 0 0 {name=l22810 lab=VSS}
C {bitcell_6t.sym} 3600 28400 0 0 {name=Xr142c18}
N 3560 28440 3540 28440 {}
C {lab_pin.sym} 3540 28440 0 0 {name=l22811 lab=BL18}
N 3560 28400 3540 28400 {}
C {lab_pin.sym} 3540 28400 0 0 {name=l22812 lab=BLB18}
N 3560 28360 3540 28360 {}
C {lab_pin.sym} 3540 28360 0 0 {name=l22813 lab=WL142}
N 3640 28440 3660 28440 {}
C {lab_pin.sym} 3660 28440 0 0 {name=l22814 lab=VDD}
N 3640 28360 3660 28360 {}
C {lab_pin.sym} 3660 28360 0 0 {name=l22815 lab=VSS}
C {bitcell_6t.sym} 3800 28400 0 0 {name=Xr142c19}
N 3760 28440 3740 28440 {}
C {lab_pin.sym} 3740 28440 0 0 {name=l22816 lab=BL19}
N 3760 28400 3740 28400 {}
C {lab_pin.sym} 3740 28400 0 0 {name=l22817 lab=BLB19}
N 3760 28360 3740 28360 {}
C {lab_pin.sym} 3740 28360 0 0 {name=l22818 lab=WL142}
N 3840 28440 3860 28440 {}
C {lab_pin.sym} 3860 28440 0 0 {name=l22819 lab=VDD}
N 3840 28360 3860 28360 {}
C {lab_pin.sym} 3860 28360 0 0 {name=l22820 lab=VSS}
C {bitcell_6t.sym} 4000 28400 0 0 {name=Xr142c20}
N 3960 28440 3940 28440 {}
C {lab_pin.sym} 3940 28440 0 0 {name=l22821 lab=BL20}
N 3960 28400 3940 28400 {}
C {lab_pin.sym} 3940 28400 0 0 {name=l22822 lab=BLB20}
N 3960 28360 3940 28360 {}
C {lab_pin.sym} 3940 28360 0 0 {name=l22823 lab=WL142}
N 4040 28440 4060 28440 {}
C {lab_pin.sym} 4060 28440 0 0 {name=l22824 lab=VDD}
N 4040 28360 4060 28360 {}
C {lab_pin.sym} 4060 28360 0 0 {name=l22825 lab=VSS}
C {bitcell_6t.sym} 4200 28400 0 0 {name=Xr142c21}
N 4160 28440 4140 28440 {}
C {lab_pin.sym} 4140 28440 0 0 {name=l22826 lab=BL21}
N 4160 28400 4140 28400 {}
C {lab_pin.sym} 4140 28400 0 0 {name=l22827 lab=BLB21}
N 4160 28360 4140 28360 {}
C {lab_pin.sym} 4140 28360 0 0 {name=l22828 lab=WL142}
N 4240 28440 4260 28440 {}
C {lab_pin.sym} 4260 28440 0 0 {name=l22829 lab=VDD}
N 4240 28360 4260 28360 {}
C {lab_pin.sym} 4260 28360 0 0 {name=l22830 lab=VSS}
C {bitcell_6t.sym} 4400 28400 0 0 {name=Xr142c22}
N 4360 28440 4340 28440 {}
C {lab_pin.sym} 4340 28440 0 0 {name=l22831 lab=BL22}
N 4360 28400 4340 28400 {}
C {lab_pin.sym} 4340 28400 0 0 {name=l22832 lab=BLB22}
N 4360 28360 4340 28360 {}
C {lab_pin.sym} 4340 28360 0 0 {name=l22833 lab=WL142}
N 4440 28440 4460 28440 {}
C {lab_pin.sym} 4460 28440 0 0 {name=l22834 lab=VDD}
N 4440 28360 4460 28360 {}
C {lab_pin.sym} 4460 28360 0 0 {name=l22835 lab=VSS}
C {bitcell_6t.sym} 4600 28400 0 0 {name=Xr142c23}
N 4560 28440 4540 28440 {}
C {lab_pin.sym} 4540 28440 0 0 {name=l22836 lab=BL23}
N 4560 28400 4540 28400 {}
C {lab_pin.sym} 4540 28400 0 0 {name=l22837 lab=BLB23}
N 4560 28360 4540 28360 {}
C {lab_pin.sym} 4540 28360 0 0 {name=l22838 lab=WL142}
N 4640 28440 4660 28440 {}
C {lab_pin.sym} 4660 28440 0 0 {name=l22839 lab=VDD}
N 4640 28360 4660 28360 {}
C {lab_pin.sym} 4660 28360 0 0 {name=l22840 lab=VSS}
C {bitcell_6t.sym} 4800 28400 0 0 {name=Xr142c24}
N 4760 28440 4740 28440 {}
C {lab_pin.sym} 4740 28440 0 0 {name=l22841 lab=BL24}
N 4760 28400 4740 28400 {}
C {lab_pin.sym} 4740 28400 0 0 {name=l22842 lab=BLB24}
N 4760 28360 4740 28360 {}
C {lab_pin.sym} 4740 28360 0 0 {name=l22843 lab=WL142}
N 4840 28440 4860 28440 {}
C {lab_pin.sym} 4860 28440 0 0 {name=l22844 lab=VDD}
N 4840 28360 4860 28360 {}
C {lab_pin.sym} 4860 28360 0 0 {name=l22845 lab=VSS}
C {bitcell_6t.sym} 5000 28400 0 0 {name=Xr142c25}
N 4960 28440 4940 28440 {}
C {lab_pin.sym} 4940 28440 0 0 {name=l22846 lab=BL25}
N 4960 28400 4940 28400 {}
C {lab_pin.sym} 4940 28400 0 0 {name=l22847 lab=BLB25}
N 4960 28360 4940 28360 {}
C {lab_pin.sym} 4940 28360 0 0 {name=l22848 lab=WL142}
N 5040 28440 5060 28440 {}
C {lab_pin.sym} 5060 28440 0 0 {name=l22849 lab=VDD}
N 5040 28360 5060 28360 {}
C {lab_pin.sym} 5060 28360 0 0 {name=l22850 lab=VSS}
C {bitcell_6t.sym} 5200 28400 0 0 {name=Xr142c26}
N 5160 28440 5140 28440 {}
C {lab_pin.sym} 5140 28440 0 0 {name=l22851 lab=BL26}
N 5160 28400 5140 28400 {}
C {lab_pin.sym} 5140 28400 0 0 {name=l22852 lab=BLB26}
N 5160 28360 5140 28360 {}
C {lab_pin.sym} 5140 28360 0 0 {name=l22853 lab=WL142}
N 5240 28440 5260 28440 {}
C {lab_pin.sym} 5260 28440 0 0 {name=l22854 lab=VDD}
N 5240 28360 5260 28360 {}
C {lab_pin.sym} 5260 28360 0 0 {name=l22855 lab=VSS}
C {bitcell_6t.sym} 5400 28400 0 0 {name=Xr142c27}
N 5360 28440 5340 28440 {}
C {lab_pin.sym} 5340 28440 0 0 {name=l22856 lab=BL27}
N 5360 28400 5340 28400 {}
C {lab_pin.sym} 5340 28400 0 0 {name=l22857 lab=BLB27}
N 5360 28360 5340 28360 {}
C {lab_pin.sym} 5340 28360 0 0 {name=l22858 lab=WL142}
N 5440 28440 5460 28440 {}
C {lab_pin.sym} 5460 28440 0 0 {name=l22859 lab=VDD}
N 5440 28360 5460 28360 {}
C {lab_pin.sym} 5460 28360 0 0 {name=l22860 lab=VSS}
C {bitcell_6t.sym} 5600 28400 0 0 {name=Xr142c28}
N 5560 28440 5540 28440 {}
C {lab_pin.sym} 5540 28440 0 0 {name=l22861 lab=BL28}
N 5560 28400 5540 28400 {}
C {lab_pin.sym} 5540 28400 0 0 {name=l22862 lab=BLB28}
N 5560 28360 5540 28360 {}
C {lab_pin.sym} 5540 28360 0 0 {name=l22863 lab=WL142}
N 5640 28440 5660 28440 {}
C {lab_pin.sym} 5660 28440 0 0 {name=l22864 lab=VDD}
N 5640 28360 5660 28360 {}
C {lab_pin.sym} 5660 28360 0 0 {name=l22865 lab=VSS}
C {bitcell_6t.sym} 5800 28400 0 0 {name=Xr142c29}
N 5760 28440 5740 28440 {}
C {lab_pin.sym} 5740 28440 0 0 {name=l22866 lab=BL29}
N 5760 28400 5740 28400 {}
C {lab_pin.sym} 5740 28400 0 0 {name=l22867 lab=BLB29}
N 5760 28360 5740 28360 {}
C {lab_pin.sym} 5740 28360 0 0 {name=l22868 lab=WL142}
N 5840 28440 5860 28440 {}
C {lab_pin.sym} 5860 28440 0 0 {name=l22869 lab=VDD}
N 5840 28360 5860 28360 {}
C {lab_pin.sym} 5860 28360 0 0 {name=l22870 lab=VSS}
C {bitcell_6t.sym} 6000 28400 0 0 {name=Xr142c30}
N 5960 28440 5940 28440 {}
C {lab_pin.sym} 5940 28440 0 0 {name=l22871 lab=BL30}
N 5960 28400 5940 28400 {}
C {lab_pin.sym} 5940 28400 0 0 {name=l22872 lab=BLB30}
N 5960 28360 5940 28360 {}
C {lab_pin.sym} 5940 28360 0 0 {name=l22873 lab=WL142}
N 6040 28440 6060 28440 {}
C {lab_pin.sym} 6060 28440 0 0 {name=l22874 lab=VDD}
N 6040 28360 6060 28360 {}
C {lab_pin.sym} 6060 28360 0 0 {name=l22875 lab=VSS}
C {bitcell_6t.sym} 6200 28400 0 0 {name=Xr142c31}
N 6160 28440 6140 28440 {}
C {lab_pin.sym} 6140 28440 0 0 {name=l22876 lab=BL31}
N 6160 28400 6140 28400 {}
C {lab_pin.sym} 6140 28400 0 0 {name=l22877 lab=BLB31}
N 6160 28360 6140 28360 {}
C {lab_pin.sym} 6140 28360 0 0 {name=l22878 lab=WL142}
N 6240 28440 6260 28440 {}
C {lab_pin.sym} 6260 28440 0 0 {name=l22879 lab=VDD}
N 6240 28360 6260 28360 {}
C {lab_pin.sym} 6260 28360 0 0 {name=l22880 lab=VSS}
C {bitcell_6t.sym} 0 28600 0 0 {name=Xr143c0}
N -40 28640 -60 28640 {}
C {lab_pin.sym} -60 28640 0 0 {name=l22881 lab=BL0}
N -40 28600 -60 28600 {}
C {lab_pin.sym} -60 28600 0 0 {name=l22882 lab=BLB0}
N -40 28560 -60 28560 {}
C {lab_pin.sym} -60 28560 0 0 {name=l22883 lab=WL143}
N 40 28640 60 28640 {}
C {lab_pin.sym} 60 28640 0 0 {name=l22884 lab=VDD}
N 40 28560 60 28560 {}
C {lab_pin.sym} 60 28560 0 0 {name=l22885 lab=VSS}
C {bitcell_6t.sym} 200 28600 0 0 {name=Xr143c1}
N 160 28640 140 28640 {}
C {lab_pin.sym} 140 28640 0 0 {name=l22886 lab=BL1}
N 160 28600 140 28600 {}
C {lab_pin.sym} 140 28600 0 0 {name=l22887 lab=BLB1}
N 160 28560 140 28560 {}
C {lab_pin.sym} 140 28560 0 0 {name=l22888 lab=WL143}
N 240 28640 260 28640 {}
C {lab_pin.sym} 260 28640 0 0 {name=l22889 lab=VDD}
N 240 28560 260 28560 {}
C {lab_pin.sym} 260 28560 0 0 {name=l22890 lab=VSS}
C {bitcell_6t.sym} 400 28600 0 0 {name=Xr143c2}
N 360 28640 340 28640 {}
C {lab_pin.sym} 340 28640 0 0 {name=l22891 lab=BL2}
N 360 28600 340 28600 {}
C {lab_pin.sym} 340 28600 0 0 {name=l22892 lab=BLB2}
N 360 28560 340 28560 {}
C {lab_pin.sym} 340 28560 0 0 {name=l22893 lab=WL143}
N 440 28640 460 28640 {}
C {lab_pin.sym} 460 28640 0 0 {name=l22894 lab=VDD}
N 440 28560 460 28560 {}
C {lab_pin.sym} 460 28560 0 0 {name=l22895 lab=VSS}
C {bitcell_6t.sym} 600 28600 0 0 {name=Xr143c3}
N 560 28640 540 28640 {}
C {lab_pin.sym} 540 28640 0 0 {name=l22896 lab=BL3}
N 560 28600 540 28600 {}
C {lab_pin.sym} 540 28600 0 0 {name=l22897 lab=BLB3}
N 560 28560 540 28560 {}
C {lab_pin.sym} 540 28560 0 0 {name=l22898 lab=WL143}
N 640 28640 660 28640 {}
C {lab_pin.sym} 660 28640 0 0 {name=l22899 lab=VDD}
N 640 28560 660 28560 {}
C {lab_pin.sym} 660 28560 0 0 {name=l22900 lab=VSS}
C {bitcell_6t.sym} 800 28600 0 0 {name=Xr143c4}
N 760 28640 740 28640 {}
C {lab_pin.sym} 740 28640 0 0 {name=l22901 lab=BL4}
N 760 28600 740 28600 {}
C {lab_pin.sym} 740 28600 0 0 {name=l22902 lab=BLB4}
N 760 28560 740 28560 {}
C {lab_pin.sym} 740 28560 0 0 {name=l22903 lab=WL143}
N 840 28640 860 28640 {}
C {lab_pin.sym} 860 28640 0 0 {name=l22904 lab=VDD}
N 840 28560 860 28560 {}
C {lab_pin.sym} 860 28560 0 0 {name=l22905 lab=VSS}
C {bitcell_6t.sym} 1000 28600 0 0 {name=Xr143c5}
N 960 28640 940 28640 {}
C {lab_pin.sym} 940 28640 0 0 {name=l22906 lab=BL5}
N 960 28600 940 28600 {}
C {lab_pin.sym} 940 28600 0 0 {name=l22907 lab=BLB5}
N 960 28560 940 28560 {}
C {lab_pin.sym} 940 28560 0 0 {name=l22908 lab=WL143}
N 1040 28640 1060 28640 {}
C {lab_pin.sym} 1060 28640 0 0 {name=l22909 lab=VDD}
N 1040 28560 1060 28560 {}
C {lab_pin.sym} 1060 28560 0 0 {name=l22910 lab=VSS}
C {bitcell_6t.sym} 1200 28600 0 0 {name=Xr143c6}
N 1160 28640 1140 28640 {}
C {lab_pin.sym} 1140 28640 0 0 {name=l22911 lab=BL6}
N 1160 28600 1140 28600 {}
C {lab_pin.sym} 1140 28600 0 0 {name=l22912 lab=BLB6}
N 1160 28560 1140 28560 {}
C {lab_pin.sym} 1140 28560 0 0 {name=l22913 lab=WL143}
N 1240 28640 1260 28640 {}
C {lab_pin.sym} 1260 28640 0 0 {name=l22914 lab=VDD}
N 1240 28560 1260 28560 {}
C {lab_pin.sym} 1260 28560 0 0 {name=l22915 lab=VSS}
C {bitcell_6t.sym} 1400 28600 0 0 {name=Xr143c7}
N 1360 28640 1340 28640 {}
C {lab_pin.sym} 1340 28640 0 0 {name=l22916 lab=BL7}
N 1360 28600 1340 28600 {}
C {lab_pin.sym} 1340 28600 0 0 {name=l22917 lab=BLB7}
N 1360 28560 1340 28560 {}
C {lab_pin.sym} 1340 28560 0 0 {name=l22918 lab=WL143}
N 1440 28640 1460 28640 {}
C {lab_pin.sym} 1460 28640 0 0 {name=l22919 lab=VDD}
N 1440 28560 1460 28560 {}
C {lab_pin.sym} 1460 28560 0 0 {name=l22920 lab=VSS}
C {bitcell_6t.sym} 1600 28600 0 0 {name=Xr143c8}
N 1560 28640 1540 28640 {}
C {lab_pin.sym} 1540 28640 0 0 {name=l22921 lab=BL8}
N 1560 28600 1540 28600 {}
C {lab_pin.sym} 1540 28600 0 0 {name=l22922 lab=BLB8}
N 1560 28560 1540 28560 {}
C {lab_pin.sym} 1540 28560 0 0 {name=l22923 lab=WL143}
N 1640 28640 1660 28640 {}
C {lab_pin.sym} 1660 28640 0 0 {name=l22924 lab=VDD}
N 1640 28560 1660 28560 {}
C {lab_pin.sym} 1660 28560 0 0 {name=l22925 lab=VSS}
C {bitcell_6t.sym} 1800 28600 0 0 {name=Xr143c9}
N 1760 28640 1740 28640 {}
C {lab_pin.sym} 1740 28640 0 0 {name=l22926 lab=BL9}
N 1760 28600 1740 28600 {}
C {lab_pin.sym} 1740 28600 0 0 {name=l22927 lab=BLB9}
N 1760 28560 1740 28560 {}
C {lab_pin.sym} 1740 28560 0 0 {name=l22928 lab=WL143}
N 1840 28640 1860 28640 {}
C {lab_pin.sym} 1860 28640 0 0 {name=l22929 lab=VDD}
N 1840 28560 1860 28560 {}
C {lab_pin.sym} 1860 28560 0 0 {name=l22930 lab=VSS}
C {bitcell_6t.sym} 2000 28600 0 0 {name=Xr143c10}
N 1960 28640 1940 28640 {}
C {lab_pin.sym} 1940 28640 0 0 {name=l22931 lab=BL10}
N 1960 28600 1940 28600 {}
C {lab_pin.sym} 1940 28600 0 0 {name=l22932 lab=BLB10}
N 1960 28560 1940 28560 {}
C {lab_pin.sym} 1940 28560 0 0 {name=l22933 lab=WL143}
N 2040 28640 2060 28640 {}
C {lab_pin.sym} 2060 28640 0 0 {name=l22934 lab=VDD}
N 2040 28560 2060 28560 {}
C {lab_pin.sym} 2060 28560 0 0 {name=l22935 lab=VSS}
C {bitcell_6t.sym} 2200 28600 0 0 {name=Xr143c11}
N 2160 28640 2140 28640 {}
C {lab_pin.sym} 2140 28640 0 0 {name=l22936 lab=BL11}
N 2160 28600 2140 28600 {}
C {lab_pin.sym} 2140 28600 0 0 {name=l22937 lab=BLB11}
N 2160 28560 2140 28560 {}
C {lab_pin.sym} 2140 28560 0 0 {name=l22938 lab=WL143}
N 2240 28640 2260 28640 {}
C {lab_pin.sym} 2260 28640 0 0 {name=l22939 lab=VDD}
N 2240 28560 2260 28560 {}
C {lab_pin.sym} 2260 28560 0 0 {name=l22940 lab=VSS}
C {bitcell_6t.sym} 2400 28600 0 0 {name=Xr143c12}
N 2360 28640 2340 28640 {}
C {lab_pin.sym} 2340 28640 0 0 {name=l22941 lab=BL12}
N 2360 28600 2340 28600 {}
C {lab_pin.sym} 2340 28600 0 0 {name=l22942 lab=BLB12}
N 2360 28560 2340 28560 {}
C {lab_pin.sym} 2340 28560 0 0 {name=l22943 lab=WL143}
N 2440 28640 2460 28640 {}
C {lab_pin.sym} 2460 28640 0 0 {name=l22944 lab=VDD}
N 2440 28560 2460 28560 {}
C {lab_pin.sym} 2460 28560 0 0 {name=l22945 lab=VSS}
C {bitcell_6t.sym} 2600 28600 0 0 {name=Xr143c13}
N 2560 28640 2540 28640 {}
C {lab_pin.sym} 2540 28640 0 0 {name=l22946 lab=BL13}
N 2560 28600 2540 28600 {}
C {lab_pin.sym} 2540 28600 0 0 {name=l22947 lab=BLB13}
N 2560 28560 2540 28560 {}
C {lab_pin.sym} 2540 28560 0 0 {name=l22948 lab=WL143}
N 2640 28640 2660 28640 {}
C {lab_pin.sym} 2660 28640 0 0 {name=l22949 lab=VDD}
N 2640 28560 2660 28560 {}
C {lab_pin.sym} 2660 28560 0 0 {name=l22950 lab=VSS}
C {bitcell_6t.sym} 2800 28600 0 0 {name=Xr143c14}
N 2760 28640 2740 28640 {}
C {lab_pin.sym} 2740 28640 0 0 {name=l22951 lab=BL14}
N 2760 28600 2740 28600 {}
C {lab_pin.sym} 2740 28600 0 0 {name=l22952 lab=BLB14}
N 2760 28560 2740 28560 {}
C {lab_pin.sym} 2740 28560 0 0 {name=l22953 lab=WL143}
N 2840 28640 2860 28640 {}
C {lab_pin.sym} 2860 28640 0 0 {name=l22954 lab=VDD}
N 2840 28560 2860 28560 {}
C {lab_pin.sym} 2860 28560 0 0 {name=l22955 lab=VSS}
C {bitcell_6t.sym} 3000 28600 0 0 {name=Xr143c15}
N 2960 28640 2940 28640 {}
C {lab_pin.sym} 2940 28640 0 0 {name=l22956 lab=BL15}
N 2960 28600 2940 28600 {}
C {lab_pin.sym} 2940 28600 0 0 {name=l22957 lab=BLB15}
N 2960 28560 2940 28560 {}
C {lab_pin.sym} 2940 28560 0 0 {name=l22958 lab=WL143}
N 3040 28640 3060 28640 {}
C {lab_pin.sym} 3060 28640 0 0 {name=l22959 lab=VDD}
N 3040 28560 3060 28560 {}
C {lab_pin.sym} 3060 28560 0 0 {name=l22960 lab=VSS}
C {bitcell_6t.sym} 3200 28600 0 0 {name=Xr143c16}
N 3160 28640 3140 28640 {}
C {lab_pin.sym} 3140 28640 0 0 {name=l22961 lab=BL16}
N 3160 28600 3140 28600 {}
C {lab_pin.sym} 3140 28600 0 0 {name=l22962 lab=BLB16}
N 3160 28560 3140 28560 {}
C {lab_pin.sym} 3140 28560 0 0 {name=l22963 lab=WL143}
N 3240 28640 3260 28640 {}
C {lab_pin.sym} 3260 28640 0 0 {name=l22964 lab=VDD}
N 3240 28560 3260 28560 {}
C {lab_pin.sym} 3260 28560 0 0 {name=l22965 lab=VSS}
C {bitcell_6t.sym} 3400 28600 0 0 {name=Xr143c17}
N 3360 28640 3340 28640 {}
C {lab_pin.sym} 3340 28640 0 0 {name=l22966 lab=BL17}
N 3360 28600 3340 28600 {}
C {lab_pin.sym} 3340 28600 0 0 {name=l22967 lab=BLB17}
N 3360 28560 3340 28560 {}
C {lab_pin.sym} 3340 28560 0 0 {name=l22968 lab=WL143}
N 3440 28640 3460 28640 {}
C {lab_pin.sym} 3460 28640 0 0 {name=l22969 lab=VDD}
N 3440 28560 3460 28560 {}
C {lab_pin.sym} 3460 28560 0 0 {name=l22970 lab=VSS}
C {bitcell_6t.sym} 3600 28600 0 0 {name=Xr143c18}
N 3560 28640 3540 28640 {}
C {lab_pin.sym} 3540 28640 0 0 {name=l22971 lab=BL18}
N 3560 28600 3540 28600 {}
C {lab_pin.sym} 3540 28600 0 0 {name=l22972 lab=BLB18}
N 3560 28560 3540 28560 {}
C {lab_pin.sym} 3540 28560 0 0 {name=l22973 lab=WL143}
N 3640 28640 3660 28640 {}
C {lab_pin.sym} 3660 28640 0 0 {name=l22974 lab=VDD}
N 3640 28560 3660 28560 {}
C {lab_pin.sym} 3660 28560 0 0 {name=l22975 lab=VSS}
C {bitcell_6t.sym} 3800 28600 0 0 {name=Xr143c19}
N 3760 28640 3740 28640 {}
C {lab_pin.sym} 3740 28640 0 0 {name=l22976 lab=BL19}
N 3760 28600 3740 28600 {}
C {lab_pin.sym} 3740 28600 0 0 {name=l22977 lab=BLB19}
N 3760 28560 3740 28560 {}
C {lab_pin.sym} 3740 28560 0 0 {name=l22978 lab=WL143}
N 3840 28640 3860 28640 {}
C {lab_pin.sym} 3860 28640 0 0 {name=l22979 lab=VDD}
N 3840 28560 3860 28560 {}
C {lab_pin.sym} 3860 28560 0 0 {name=l22980 lab=VSS}
C {bitcell_6t.sym} 4000 28600 0 0 {name=Xr143c20}
N 3960 28640 3940 28640 {}
C {lab_pin.sym} 3940 28640 0 0 {name=l22981 lab=BL20}
N 3960 28600 3940 28600 {}
C {lab_pin.sym} 3940 28600 0 0 {name=l22982 lab=BLB20}
N 3960 28560 3940 28560 {}
C {lab_pin.sym} 3940 28560 0 0 {name=l22983 lab=WL143}
N 4040 28640 4060 28640 {}
C {lab_pin.sym} 4060 28640 0 0 {name=l22984 lab=VDD}
N 4040 28560 4060 28560 {}
C {lab_pin.sym} 4060 28560 0 0 {name=l22985 lab=VSS}
C {bitcell_6t.sym} 4200 28600 0 0 {name=Xr143c21}
N 4160 28640 4140 28640 {}
C {lab_pin.sym} 4140 28640 0 0 {name=l22986 lab=BL21}
N 4160 28600 4140 28600 {}
C {lab_pin.sym} 4140 28600 0 0 {name=l22987 lab=BLB21}
N 4160 28560 4140 28560 {}
C {lab_pin.sym} 4140 28560 0 0 {name=l22988 lab=WL143}
N 4240 28640 4260 28640 {}
C {lab_pin.sym} 4260 28640 0 0 {name=l22989 lab=VDD}
N 4240 28560 4260 28560 {}
C {lab_pin.sym} 4260 28560 0 0 {name=l22990 lab=VSS}
C {bitcell_6t.sym} 4400 28600 0 0 {name=Xr143c22}
N 4360 28640 4340 28640 {}
C {lab_pin.sym} 4340 28640 0 0 {name=l22991 lab=BL22}
N 4360 28600 4340 28600 {}
C {lab_pin.sym} 4340 28600 0 0 {name=l22992 lab=BLB22}
N 4360 28560 4340 28560 {}
C {lab_pin.sym} 4340 28560 0 0 {name=l22993 lab=WL143}
N 4440 28640 4460 28640 {}
C {lab_pin.sym} 4460 28640 0 0 {name=l22994 lab=VDD}
N 4440 28560 4460 28560 {}
C {lab_pin.sym} 4460 28560 0 0 {name=l22995 lab=VSS}
C {bitcell_6t.sym} 4600 28600 0 0 {name=Xr143c23}
N 4560 28640 4540 28640 {}
C {lab_pin.sym} 4540 28640 0 0 {name=l22996 lab=BL23}
N 4560 28600 4540 28600 {}
C {lab_pin.sym} 4540 28600 0 0 {name=l22997 lab=BLB23}
N 4560 28560 4540 28560 {}
C {lab_pin.sym} 4540 28560 0 0 {name=l22998 lab=WL143}
N 4640 28640 4660 28640 {}
C {lab_pin.sym} 4660 28640 0 0 {name=l22999 lab=VDD}
N 4640 28560 4660 28560 {}
C {lab_pin.sym} 4660 28560 0 0 {name=l23000 lab=VSS}
C {bitcell_6t.sym} 4800 28600 0 0 {name=Xr143c24}
N 4760 28640 4740 28640 {}
C {lab_pin.sym} 4740 28640 0 0 {name=l23001 lab=BL24}
N 4760 28600 4740 28600 {}
C {lab_pin.sym} 4740 28600 0 0 {name=l23002 lab=BLB24}
N 4760 28560 4740 28560 {}
C {lab_pin.sym} 4740 28560 0 0 {name=l23003 lab=WL143}
N 4840 28640 4860 28640 {}
C {lab_pin.sym} 4860 28640 0 0 {name=l23004 lab=VDD}
N 4840 28560 4860 28560 {}
C {lab_pin.sym} 4860 28560 0 0 {name=l23005 lab=VSS}
C {bitcell_6t.sym} 5000 28600 0 0 {name=Xr143c25}
N 4960 28640 4940 28640 {}
C {lab_pin.sym} 4940 28640 0 0 {name=l23006 lab=BL25}
N 4960 28600 4940 28600 {}
C {lab_pin.sym} 4940 28600 0 0 {name=l23007 lab=BLB25}
N 4960 28560 4940 28560 {}
C {lab_pin.sym} 4940 28560 0 0 {name=l23008 lab=WL143}
N 5040 28640 5060 28640 {}
C {lab_pin.sym} 5060 28640 0 0 {name=l23009 lab=VDD}
N 5040 28560 5060 28560 {}
C {lab_pin.sym} 5060 28560 0 0 {name=l23010 lab=VSS}
C {bitcell_6t.sym} 5200 28600 0 0 {name=Xr143c26}
N 5160 28640 5140 28640 {}
C {lab_pin.sym} 5140 28640 0 0 {name=l23011 lab=BL26}
N 5160 28600 5140 28600 {}
C {lab_pin.sym} 5140 28600 0 0 {name=l23012 lab=BLB26}
N 5160 28560 5140 28560 {}
C {lab_pin.sym} 5140 28560 0 0 {name=l23013 lab=WL143}
N 5240 28640 5260 28640 {}
C {lab_pin.sym} 5260 28640 0 0 {name=l23014 lab=VDD}
N 5240 28560 5260 28560 {}
C {lab_pin.sym} 5260 28560 0 0 {name=l23015 lab=VSS}
C {bitcell_6t.sym} 5400 28600 0 0 {name=Xr143c27}
N 5360 28640 5340 28640 {}
C {lab_pin.sym} 5340 28640 0 0 {name=l23016 lab=BL27}
N 5360 28600 5340 28600 {}
C {lab_pin.sym} 5340 28600 0 0 {name=l23017 lab=BLB27}
N 5360 28560 5340 28560 {}
C {lab_pin.sym} 5340 28560 0 0 {name=l23018 lab=WL143}
N 5440 28640 5460 28640 {}
C {lab_pin.sym} 5460 28640 0 0 {name=l23019 lab=VDD}
N 5440 28560 5460 28560 {}
C {lab_pin.sym} 5460 28560 0 0 {name=l23020 lab=VSS}
C {bitcell_6t.sym} 5600 28600 0 0 {name=Xr143c28}
N 5560 28640 5540 28640 {}
C {lab_pin.sym} 5540 28640 0 0 {name=l23021 lab=BL28}
N 5560 28600 5540 28600 {}
C {lab_pin.sym} 5540 28600 0 0 {name=l23022 lab=BLB28}
N 5560 28560 5540 28560 {}
C {lab_pin.sym} 5540 28560 0 0 {name=l23023 lab=WL143}
N 5640 28640 5660 28640 {}
C {lab_pin.sym} 5660 28640 0 0 {name=l23024 lab=VDD}
N 5640 28560 5660 28560 {}
C {lab_pin.sym} 5660 28560 0 0 {name=l23025 lab=VSS}
C {bitcell_6t.sym} 5800 28600 0 0 {name=Xr143c29}
N 5760 28640 5740 28640 {}
C {lab_pin.sym} 5740 28640 0 0 {name=l23026 lab=BL29}
N 5760 28600 5740 28600 {}
C {lab_pin.sym} 5740 28600 0 0 {name=l23027 lab=BLB29}
N 5760 28560 5740 28560 {}
C {lab_pin.sym} 5740 28560 0 0 {name=l23028 lab=WL143}
N 5840 28640 5860 28640 {}
C {lab_pin.sym} 5860 28640 0 0 {name=l23029 lab=VDD}
N 5840 28560 5860 28560 {}
C {lab_pin.sym} 5860 28560 0 0 {name=l23030 lab=VSS}
C {bitcell_6t.sym} 6000 28600 0 0 {name=Xr143c30}
N 5960 28640 5940 28640 {}
C {lab_pin.sym} 5940 28640 0 0 {name=l23031 lab=BL30}
N 5960 28600 5940 28600 {}
C {lab_pin.sym} 5940 28600 0 0 {name=l23032 lab=BLB30}
N 5960 28560 5940 28560 {}
C {lab_pin.sym} 5940 28560 0 0 {name=l23033 lab=WL143}
N 6040 28640 6060 28640 {}
C {lab_pin.sym} 6060 28640 0 0 {name=l23034 lab=VDD}
N 6040 28560 6060 28560 {}
C {lab_pin.sym} 6060 28560 0 0 {name=l23035 lab=VSS}
C {bitcell_6t.sym} 6200 28600 0 0 {name=Xr143c31}
N 6160 28640 6140 28640 {}
C {lab_pin.sym} 6140 28640 0 0 {name=l23036 lab=BL31}
N 6160 28600 6140 28600 {}
C {lab_pin.sym} 6140 28600 0 0 {name=l23037 lab=BLB31}
N 6160 28560 6140 28560 {}
C {lab_pin.sym} 6140 28560 0 0 {name=l23038 lab=WL143}
N 6240 28640 6260 28640 {}
C {lab_pin.sym} 6260 28640 0 0 {name=l23039 lab=VDD}
N 6240 28560 6260 28560 {}
C {lab_pin.sym} 6260 28560 0 0 {name=l23040 lab=VSS}
C {bitcell_6t.sym} 0 28800 0 0 {name=Xr144c0}
N -40 28840 -60 28840 {}
C {lab_pin.sym} -60 28840 0 0 {name=l23041 lab=BL0}
N -40 28800 -60 28800 {}
C {lab_pin.sym} -60 28800 0 0 {name=l23042 lab=BLB0}
N -40 28760 -60 28760 {}
C {lab_pin.sym} -60 28760 0 0 {name=l23043 lab=WL144}
N 40 28840 60 28840 {}
C {lab_pin.sym} 60 28840 0 0 {name=l23044 lab=VDD}
N 40 28760 60 28760 {}
C {lab_pin.sym} 60 28760 0 0 {name=l23045 lab=VSS}
C {bitcell_6t.sym} 200 28800 0 0 {name=Xr144c1}
N 160 28840 140 28840 {}
C {lab_pin.sym} 140 28840 0 0 {name=l23046 lab=BL1}
N 160 28800 140 28800 {}
C {lab_pin.sym} 140 28800 0 0 {name=l23047 lab=BLB1}
N 160 28760 140 28760 {}
C {lab_pin.sym} 140 28760 0 0 {name=l23048 lab=WL144}
N 240 28840 260 28840 {}
C {lab_pin.sym} 260 28840 0 0 {name=l23049 lab=VDD}
N 240 28760 260 28760 {}
C {lab_pin.sym} 260 28760 0 0 {name=l23050 lab=VSS}
C {bitcell_6t.sym} 400 28800 0 0 {name=Xr144c2}
N 360 28840 340 28840 {}
C {lab_pin.sym} 340 28840 0 0 {name=l23051 lab=BL2}
N 360 28800 340 28800 {}
C {lab_pin.sym} 340 28800 0 0 {name=l23052 lab=BLB2}
N 360 28760 340 28760 {}
C {lab_pin.sym} 340 28760 0 0 {name=l23053 lab=WL144}
N 440 28840 460 28840 {}
C {lab_pin.sym} 460 28840 0 0 {name=l23054 lab=VDD}
N 440 28760 460 28760 {}
C {lab_pin.sym} 460 28760 0 0 {name=l23055 lab=VSS}
C {bitcell_6t.sym} 600 28800 0 0 {name=Xr144c3}
N 560 28840 540 28840 {}
C {lab_pin.sym} 540 28840 0 0 {name=l23056 lab=BL3}
N 560 28800 540 28800 {}
C {lab_pin.sym} 540 28800 0 0 {name=l23057 lab=BLB3}
N 560 28760 540 28760 {}
C {lab_pin.sym} 540 28760 0 0 {name=l23058 lab=WL144}
N 640 28840 660 28840 {}
C {lab_pin.sym} 660 28840 0 0 {name=l23059 lab=VDD}
N 640 28760 660 28760 {}
C {lab_pin.sym} 660 28760 0 0 {name=l23060 lab=VSS}
C {bitcell_6t.sym} 800 28800 0 0 {name=Xr144c4}
N 760 28840 740 28840 {}
C {lab_pin.sym} 740 28840 0 0 {name=l23061 lab=BL4}
N 760 28800 740 28800 {}
C {lab_pin.sym} 740 28800 0 0 {name=l23062 lab=BLB4}
N 760 28760 740 28760 {}
C {lab_pin.sym} 740 28760 0 0 {name=l23063 lab=WL144}
N 840 28840 860 28840 {}
C {lab_pin.sym} 860 28840 0 0 {name=l23064 lab=VDD}
N 840 28760 860 28760 {}
C {lab_pin.sym} 860 28760 0 0 {name=l23065 lab=VSS}
C {bitcell_6t.sym} 1000 28800 0 0 {name=Xr144c5}
N 960 28840 940 28840 {}
C {lab_pin.sym} 940 28840 0 0 {name=l23066 lab=BL5}
N 960 28800 940 28800 {}
C {lab_pin.sym} 940 28800 0 0 {name=l23067 lab=BLB5}
N 960 28760 940 28760 {}
C {lab_pin.sym} 940 28760 0 0 {name=l23068 lab=WL144}
N 1040 28840 1060 28840 {}
C {lab_pin.sym} 1060 28840 0 0 {name=l23069 lab=VDD}
N 1040 28760 1060 28760 {}
C {lab_pin.sym} 1060 28760 0 0 {name=l23070 lab=VSS}
C {bitcell_6t.sym} 1200 28800 0 0 {name=Xr144c6}
N 1160 28840 1140 28840 {}
C {lab_pin.sym} 1140 28840 0 0 {name=l23071 lab=BL6}
N 1160 28800 1140 28800 {}
C {lab_pin.sym} 1140 28800 0 0 {name=l23072 lab=BLB6}
N 1160 28760 1140 28760 {}
C {lab_pin.sym} 1140 28760 0 0 {name=l23073 lab=WL144}
N 1240 28840 1260 28840 {}
C {lab_pin.sym} 1260 28840 0 0 {name=l23074 lab=VDD}
N 1240 28760 1260 28760 {}
C {lab_pin.sym} 1260 28760 0 0 {name=l23075 lab=VSS}
C {bitcell_6t.sym} 1400 28800 0 0 {name=Xr144c7}
N 1360 28840 1340 28840 {}
C {lab_pin.sym} 1340 28840 0 0 {name=l23076 lab=BL7}
N 1360 28800 1340 28800 {}
C {lab_pin.sym} 1340 28800 0 0 {name=l23077 lab=BLB7}
N 1360 28760 1340 28760 {}
C {lab_pin.sym} 1340 28760 0 0 {name=l23078 lab=WL144}
N 1440 28840 1460 28840 {}
C {lab_pin.sym} 1460 28840 0 0 {name=l23079 lab=VDD}
N 1440 28760 1460 28760 {}
C {lab_pin.sym} 1460 28760 0 0 {name=l23080 lab=VSS}
C {bitcell_6t.sym} 1600 28800 0 0 {name=Xr144c8}
N 1560 28840 1540 28840 {}
C {lab_pin.sym} 1540 28840 0 0 {name=l23081 lab=BL8}
N 1560 28800 1540 28800 {}
C {lab_pin.sym} 1540 28800 0 0 {name=l23082 lab=BLB8}
N 1560 28760 1540 28760 {}
C {lab_pin.sym} 1540 28760 0 0 {name=l23083 lab=WL144}
N 1640 28840 1660 28840 {}
C {lab_pin.sym} 1660 28840 0 0 {name=l23084 lab=VDD}
N 1640 28760 1660 28760 {}
C {lab_pin.sym} 1660 28760 0 0 {name=l23085 lab=VSS}
C {bitcell_6t.sym} 1800 28800 0 0 {name=Xr144c9}
N 1760 28840 1740 28840 {}
C {lab_pin.sym} 1740 28840 0 0 {name=l23086 lab=BL9}
N 1760 28800 1740 28800 {}
C {lab_pin.sym} 1740 28800 0 0 {name=l23087 lab=BLB9}
N 1760 28760 1740 28760 {}
C {lab_pin.sym} 1740 28760 0 0 {name=l23088 lab=WL144}
N 1840 28840 1860 28840 {}
C {lab_pin.sym} 1860 28840 0 0 {name=l23089 lab=VDD}
N 1840 28760 1860 28760 {}
C {lab_pin.sym} 1860 28760 0 0 {name=l23090 lab=VSS}
C {bitcell_6t.sym} 2000 28800 0 0 {name=Xr144c10}
N 1960 28840 1940 28840 {}
C {lab_pin.sym} 1940 28840 0 0 {name=l23091 lab=BL10}
N 1960 28800 1940 28800 {}
C {lab_pin.sym} 1940 28800 0 0 {name=l23092 lab=BLB10}
N 1960 28760 1940 28760 {}
C {lab_pin.sym} 1940 28760 0 0 {name=l23093 lab=WL144}
N 2040 28840 2060 28840 {}
C {lab_pin.sym} 2060 28840 0 0 {name=l23094 lab=VDD}
N 2040 28760 2060 28760 {}
C {lab_pin.sym} 2060 28760 0 0 {name=l23095 lab=VSS}
C {bitcell_6t.sym} 2200 28800 0 0 {name=Xr144c11}
N 2160 28840 2140 28840 {}
C {lab_pin.sym} 2140 28840 0 0 {name=l23096 lab=BL11}
N 2160 28800 2140 28800 {}
C {lab_pin.sym} 2140 28800 0 0 {name=l23097 lab=BLB11}
N 2160 28760 2140 28760 {}
C {lab_pin.sym} 2140 28760 0 0 {name=l23098 lab=WL144}
N 2240 28840 2260 28840 {}
C {lab_pin.sym} 2260 28840 0 0 {name=l23099 lab=VDD}
N 2240 28760 2260 28760 {}
C {lab_pin.sym} 2260 28760 0 0 {name=l23100 lab=VSS}
C {bitcell_6t.sym} 2400 28800 0 0 {name=Xr144c12}
N 2360 28840 2340 28840 {}
C {lab_pin.sym} 2340 28840 0 0 {name=l23101 lab=BL12}
N 2360 28800 2340 28800 {}
C {lab_pin.sym} 2340 28800 0 0 {name=l23102 lab=BLB12}
N 2360 28760 2340 28760 {}
C {lab_pin.sym} 2340 28760 0 0 {name=l23103 lab=WL144}
N 2440 28840 2460 28840 {}
C {lab_pin.sym} 2460 28840 0 0 {name=l23104 lab=VDD}
N 2440 28760 2460 28760 {}
C {lab_pin.sym} 2460 28760 0 0 {name=l23105 lab=VSS}
C {bitcell_6t.sym} 2600 28800 0 0 {name=Xr144c13}
N 2560 28840 2540 28840 {}
C {lab_pin.sym} 2540 28840 0 0 {name=l23106 lab=BL13}
N 2560 28800 2540 28800 {}
C {lab_pin.sym} 2540 28800 0 0 {name=l23107 lab=BLB13}
N 2560 28760 2540 28760 {}
C {lab_pin.sym} 2540 28760 0 0 {name=l23108 lab=WL144}
N 2640 28840 2660 28840 {}
C {lab_pin.sym} 2660 28840 0 0 {name=l23109 lab=VDD}
N 2640 28760 2660 28760 {}
C {lab_pin.sym} 2660 28760 0 0 {name=l23110 lab=VSS}
C {bitcell_6t.sym} 2800 28800 0 0 {name=Xr144c14}
N 2760 28840 2740 28840 {}
C {lab_pin.sym} 2740 28840 0 0 {name=l23111 lab=BL14}
N 2760 28800 2740 28800 {}
C {lab_pin.sym} 2740 28800 0 0 {name=l23112 lab=BLB14}
N 2760 28760 2740 28760 {}
C {lab_pin.sym} 2740 28760 0 0 {name=l23113 lab=WL144}
N 2840 28840 2860 28840 {}
C {lab_pin.sym} 2860 28840 0 0 {name=l23114 lab=VDD}
N 2840 28760 2860 28760 {}
C {lab_pin.sym} 2860 28760 0 0 {name=l23115 lab=VSS}
C {bitcell_6t.sym} 3000 28800 0 0 {name=Xr144c15}
N 2960 28840 2940 28840 {}
C {lab_pin.sym} 2940 28840 0 0 {name=l23116 lab=BL15}
N 2960 28800 2940 28800 {}
C {lab_pin.sym} 2940 28800 0 0 {name=l23117 lab=BLB15}
N 2960 28760 2940 28760 {}
C {lab_pin.sym} 2940 28760 0 0 {name=l23118 lab=WL144}
N 3040 28840 3060 28840 {}
C {lab_pin.sym} 3060 28840 0 0 {name=l23119 lab=VDD}
N 3040 28760 3060 28760 {}
C {lab_pin.sym} 3060 28760 0 0 {name=l23120 lab=VSS}
C {bitcell_6t.sym} 3200 28800 0 0 {name=Xr144c16}
N 3160 28840 3140 28840 {}
C {lab_pin.sym} 3140 28840 0 0 {name=l23121 lab=BL16}
N 3160 28800 3140 28800 {}
C {lab_pin.sym} 3140 28800 0 0 {name=l23122 lab=BLB16}
N 3160 28760 3140 28760 {}
C {lab_pin.sym} 3140 28760 0 0 {name=l23123 lab=WL144}
N 3240 28840 3260 28840 {}
C {lab_pin.sym} 3260 28840 0 0 {name=l23124 lab=VDD}
N 3240 28760 3260 28760 {}
C {lab_pin.sym} 3260 28760 0 0 {name=l23125 lab=VSS}
C {bitcell_6t.sym} 3400 28800 0 0 {name=Xr144c17}
N 3360 28840 3340 28840 {}
C {lab_pin.sym} 3340 28840 0 0 {name=l23126 lab=BL17}
N 3360 28800 3340 28800 {}
C {lab_pin.sym} 3340 28800 0 0 {name=l23127 lab=BLB17}
N 3360 28760 3340 28760 {}
C {lab_pin.sym} 3340 28760 0 0 {name=l23128 lab=WL144}
N 3440 28840 3460 28840 {}
C {lab_pin.sym} 3460 28840 0 0 {name=l23129 lab=VDD}
N 3440 28760 3460 28760 {}
C {lab_pin.sym} 3460 28760 0 0 {name=l23130 lab=VSS}
C {bitcell_6t.sym} 3600 28800 0 0 {name=Xr144c18}
N 3560 28840 3540 28840 {}
C {lab_pin.sym} 3540 28840 0 0 {name=l23131 lab=BL18}
N 3560 28800 3540 28800 {}
C {lab_pin.sym} 3540 28800 0 0 {name=l23132 lab=BLB18}
N 3560 28760 3540 28760 {}
C {lab_pin.sym} 3540 28760 0 0 {name=l23133 lab=WL144}
N 3640 28840 3660 28840 {}
C {lab_pin.sym} 3660 28840 0 0 {name=l23134 lab=VDD}
N 3640 28760 3660 28760 {}
C {lab_pin.sym} 3660 28760 0 0 {name=l23135 lab=VSS}
C {bitcell_6t.sym} 3800 28800 0 0 {name=Xr144c19}
N 3760 28840 3740 28840 {}
C {lab_pin.sym} 3740 28840 0 0 {name=l23136 lab=BL19}
N 3760 28800 3740 28800 {}
C {lab_pin.sym} 3740 28800 0 0 {name=l23137 lab=BLB19}
N 3760 28760 3740 28760 {}
C {lab_pin.sym} 3740 28760 0 0 {name=l23138 lab=WL144}
N 3840 28840 3860 28840 {}
C {lab_pin.sym} 3860 28840 0 0 {name=l23139 lab=VDD}
N 3840 28760 3860 28760 {}
C {lab_pin.sym} 3860 28760 0 0 {name=l23140 lab=VSS}
C {bitcell_6t.sym} 4000 28800 0 0 {name=Xr144c20}
N 3960 28840 3940 28840 {}
C {lab_pin.sym} 3940 28840 0 0 {name=l23141 lab=BL20}
N 3960 28800 3940 28800 {}
C {lab_pin.sym} 3940 28800 0 0 {name=l23142 lab=BLB20}
N 3960 28760 3940 28760 {}
C {lab_pin.sym} 3940 28760 0 0 {name=l23143 lab=WL144}
N 4040 28840 4060 28840 {}
C {lab_pin.sym} 4060 28840 0 0 {name=l23144 lab=VDD}
N 4040 28760 4060 28760 {}
C {lab_pin.sym} 4060 28760 0 0 {name=l23145 lab=VSS}
C {bitcell_6t.sym} 4200 28800 0 0 {name=Xr144c21}
N 4160 28840 4140 28840 {}
C {lab_pin.sym} 4140 28840 0 0 {name=l23146 lab=BL21}
N 4160 28800 4140 28800 {}
C {lab_pin.sym} 4140 28800 0 0 {name=l23147 lab=BLB21}
N 4160 28760 4140 28760 {}
C {lab_pin.sym} 4140 28760 0 0 {name=l23148 lab=WL144}
N 4240 28840 4260 28840 {}
C {lab_pin.sym} 4260 28840 0 0 {name=l23149 lab=VDD}
N 4240 28760 4260 28760 {}
C {lab_pin.sym} 4260 28760 0 0 {name=l23150 lab=VSS}
C {bitcell_6t.sym} 4400 28800 0 0 {name=Xr144c22}
N 4360 28840 4340 28840 {}
C {lab_pin.sym} 4340 28840 0 0 {name=l23151 lab=BL22}
N 4360 28800 4340 28800 {}
C {lab_pin.sym} 4340 28800 0 0 {name=l23152 lab=BLB22}
N 4360 28760 4340 28760 {}
C {lab_pin.sym} 4340 28760 0 0 {name=l23153 lab=WL144}
N 4440 28840 4460 28840 {}
C {lab_pin.sym} 4460 28840 0 0 {name=l23154 lab=VDD}
N 4440 28760 4460 28760 {}
C {lab_pin.sym} 4460 28760 0 0 {name=l23155 lab=VSS}
C {bitcell_6t.sym} 4600 28800 0 0 {name=Xr144c23}
N 4560 28840 4540 28840 {}
C {lab_pin.sym} 4540 28840 0 0 {name=l23156 lab=BL23}
N 4560 28800 4540 28800 {}
C {lab_pin.sym} 4540 28800 0 0 {name=l23157 lab=BLB23}
N 4560 28760 4540 28760 {}
C {lab_pin.sym} 4540 28760 0 0 {name=l23158 lab=WL144}
N 4640 28840 4660 28840 {}
C {lab_pin.sym} 4660 28840 0 0 {name=l23159 lab=VDD}
N 4640 28760 4660 28760 {}
C {lab_pin.sym} 4660 28760 0 0 {name=l23160 lab=VSS}
C {bitcell_6t.sym} 4800 28800 0 0 {name=Xr144c24}
N 4760 28840 4740 28840 {}
C {lab_pin.sym} 4740 28840 0 0 {name=l23161 lab=BL24}
N 4760 28800 4740 28800 {}
C {lab_pin.sym} 4740 28800 0 0 {name=l23162 lab=BLB24}
N 4760 28760 4740 28760 {}
C {lab_pin.sym} 4740 28760 0 0 {name=l23163 lab=WL144}
N 4840 28840 4860 28840 {}
C {lab_pin.sym} 4860 28840 0 0 {name=l23164 lab=VDD}
N 4840 28760 4860 28760 {}
C {lab_pin.sym} 4860 28760 0 0 {name=l23165 lab=VSS}
C {bitcell_6t.sym} 5000 28800 0 0 {name=Xr144c25}
N 4960 28840 4940 28840 {}
C {lab_pin.sym} 4940 28840 0 0 {name=l23166 lab=BL25}
N 4960 28800 4940 28800 {}
C {lab_pin.sym} 4940 28800 0 0 {name=l23167 lab=BLB25}
N 4960 28760 4940 28760 {}
C {lab_pin.sym} 4940 28760 0 0 {name=l23168 lab=WL144}
N 5040 28840 5060 28840 {}
C {lab_pin.sym} 5060 28840 0 0 {name=l23169 lab=VDD}
N 5040 28760 5060 28760 {}
C {lab_pin.sym} 5060 28760 0 0 {name=l23170 lab=VSS}
C {bitcell_6t.sym} 5200 28800 0 0 {name=Xr144c26}
N 5160 28840 5140 28840 {}
C {lab_pin.sym} 5140 28840 0 0 {name=l23171 lab=BL26}
N 5160 28800 5140 28800 {}
C {lab_pin.sym} 5140 28800 0 0 {name=l23172 lab=BLB26}
N 5160 28760 5140 28760 {}
C {lab_pin.sym} 5140 28760 0 0 {name=l23173 lab=WL144}
N 5240 28840 5260 28840 {}
C {lab_pin.sym} 5260 28840 0 0 {name=l23174 lab=VDD}
N 5240 28760 5260 28760 {}
C {lab_pin.sym} 5260 28760 0 0 {name=l23175 lab=VSS}
C {bitcell_6t.sym} 5400 28800 0 0 {name=Xr144c27}
N 5360 28840 5340 28840 {}
C {lab_pin.sym} 5340 28840 0 0 {name=l23176 lab=BL27}
N 5360 28800 5340 28800 {}
C {lab_pin.sym} 5340 28800 0 0 {name=l23177 lab=BLB27}
N 5360 28760 5340 28760 {}
C {lab_pin.sym} 5340 28760 0 0 {name=l23178 lab=WL144}
N 5440 28840 5460 28840 {}
C {lab_pin.sym} 5460 28840 0 0 {name=l23179 lab=VDD}
N 5440 28760 5460 28760 {}
C {lab_pin.sym} 5460 28760 0 0 {name=l23180 lab=VSS}
C {bitcell_6t.sym} 5600 28800 0 0 {name=Xr144c28}
N 5560 28840 5540 28840 {}
C {lab_pin.sym} 5540 28840 0 0 {name=l23181 lab=BL28}
N 5560 28800 5540 28800 {}
C {lab_pin.sym} 5540 28800 0 0 {name=l23182 lab=BLB28}
N 5560 28760 5540 28760 {}
C {lab_pin.sym} 5540 28760 0 0 {name=l23183 lab=WL144}
N 5640 28840 5660 28840 {}
C {lab_pin.sym} 5660 28840 0 0 {name=l23184 lab=VDD}
N 5640 28760 5660 28760 {}
C {lab_pin.sym} 5660 28760 0 0 {name=l23185 lab=VSS}
C {bitcell_6t.sym} 5800 28800 0 0 {name=Xr144c29}
N 5760 28840 5740 28840 {}
C {lab_pin.sym} 5740 28840 0 0 {name=l23186 lab=BL29}
N 5760 28800 5740 28800 {}
C {lab_pin.sym} 5740 28800 0 0 {name=l23187 lab=BLB29}
N 5760 28760 5740 28760 {}
C {lab_pin.sym} 5740 28760 0 0 {name=l23188 lab=WL144}
N 5840 28840 5860 28840 {}
C {lab_pin.sym} 5860 28840 0 0 {name=l23189 lab=VDD}
N 5840 28760 5860 28760 {}
C {lab_pin.sym} 5860 28760 0 0 {name=l23190 lab=VSS}
C {bitcell_6t.sym} 6000 28800 0 0 {name=Xr144c30}
N 5960 28840 5940 28840 {}
C {lab_pin.sym} 5940 28840 0 0 {name=l23191 lab=BL30}
N 5960 28800 5940 28800 {}
C {lab_pin.sym} 5940 28800 0 0 {name=l23192 lab=BLB30}
N 5960 28760 5940 28760 {}
C {lab_pin.sym} 5940 28760 0 0 {name=l23193 lab=WL144}
N 6040 28840 6060 28840 {}
C {lab_pin.sym} 6060 28840 0 0 {name=l23194 lab=VDD}
N 6040 28760 6060 28760 {}
C {lab_pin.sym} 6060 28760 0 0 {name=l23195 lab=VSS}
C {bitcell_6t.sym} 6200 28800 0 0 {name=Xr144c31}
N 6160 28840 6140 28840 {}
C {lab_pin.sym} 6140 28840 0 0 {name=l23196 lab=BL31}
N 6160 28800 6140 28800 {}
C {lab_pin.sym} 6140 28800 0 0 {name=l23197 lab=BLB31}
N 6160 28760 6140 28760 {}
C {lab_pin.sym} 6140 28760 0 0 {name=l23198 lab=WL144}
N 6240 28840 6260 28840 {}
C {lab_pin.sym} 6260 28840 0 0 {name=l23199 lab=VDD}
N 6240 28760 6260 28760 {}
C {lab_pin.sym} 6260 28760 0 0 {name=l23200 lab=VSS}
C {bitcell_6t.sym} 0 29000 0 0 {name=Xr145c0}
N -40 29040 -60 29040 {}
C {lab_pin.sym} -60 29040 0 0 {name=l23201 lab=BL0}
N -40 29000 -60 29000 {}
C {lab_pin.sym} -60 29000 0 0 {name=l23202 lab=BLB0}
N -40 28960 -60 28960 {}
C {lab_pin.sym} -60 28960 0 0 {name=l23203 lab=WL145}
N 40 29040 60 29040 {}
C {lab_pin.sym} 60 29040 0 0 {name=l23204 lab=VDD}
N 40 28960 60 28960 {}
C {lab_pin.sym} 60 28960 0 0 {name=l23205 lab=VSS}
C {bitcell_6t.sym} 200 29000 0 0 {name=Xr145c1}
N 160 29040 140 29040 {}
C {lab_pin.sym} 140 29040 0 0 {name=l23206 lab=BL1}
N 160 29000 140 29000 {}
C {lab_pin.sym} 140 29000 0 0 {name=l23207 lab=BLB1}
N 160 28960 140 28960 {}
C {lab_pin.sym} 140 28960 0 0 {name=l23208 lab=WL145}
N 240 29040 260 29040 {}
C {lab_pin.sym} 260 29040 0 0 {name=l23209 lab=VDD}
N 240 28960 260 28960 {}
C {lab_pin.sym} 260 28960 0 0 {name=l23210 lab=VSS}
C {bitcell_6t.sym} 400 29000 0 0 {name=Xr145c2}
N 360 29040 340 29040 {}
C {lab_pin.sym} 340 29040 0 0 {name=l23211 lab=BL2}
N 360 29000 340 29000 {}
C {lab_pin.sym} 340 29000 0 0 {name=l23212 lab=BLB2}
N 360 28960 340 28960 {}
C {lab_pin.sym} 340 28960 0 0 {name=l23213 lab=WL145}
N 440 29040 460 29040 {}
C {lab_pin.sym} 460 29040 0 0 {name=l23214 lab=VDD}
N 440 28960 460 28960 {}
C {lab_pin.sym} 460 28960 0 0 {name=l23215 lab=VSS}
C {bitcell_6t.sym} 600 29000 0 0 {name=Xr145c3}
N 560 29040 540 29040 {}
C {lab_pin.sym} 540 29040 0 0 {name=l23216 lab=BL3}
N 560 29000 540 29000 {}
C {lab_pin.sym} 540 29000 0 0 {name=l23217 lab=BLB3}
N 560 28960 540 28960 {}
C {lab_pin.sym} 540 28960 0 0 {name=l23218 lab=WL145}
N 640 29040 660 29040 {}
C {lab_pin.sym} 660 29040 0 0 {name=l23219 lab=VDD}
N 640 28960 660 28960 {}
C {lab_pin.sym} 660 28960 0 0 {name=l23220 lab=VSS}
C {bitcell_6t.sym} 800 29000 0 0 {name=Xr145c4}
N 760 29040 740 29040 {}
C {lab_pin.sym} 740 29040 0 0 {name=l23221 lab=BL4}
N 760 29000 740 29000 {}
C {lab_pin.sym} 740 29000 0 0 {name=l23222 lab=BLB4}
N 760 28960 740 28960 {}
C {lab_pin.sym} 740 28960 0 0 {name=l23223 lab=WL145}
N 840 29040 860 29040 {}
C {lab_pin.sym} 860 29040 0 0 {name=l23224 lab=VDD}
N 840 28960 860 28960 {}
C {lab_pin.sym} 860 28960 0 0 {name=l23225 lab=VSS}
C {bitcell_6t.sym} 1000 29000 0 0 {name=Xr145c5}
N 960 29040 940 29040 {}
C {lab_pin.sym} 940 29040 0 0 {name=l23226 lab=BL5}
N 960 29000 940 29000 {}
C {lab_pin.sym} 940 29000 0 0 {name=l23227 lab=BLB5}
N 960 28960 940 28960 {}
C {lab_pin.sym} 940 28960 0 0 {name=l23228 lab=WL145}
N 1040 29040 1060 29040 {}
C {lab_pin.sym} 1060 29040 0 0 {name=l23229 lab=VDD}
N 1040 28960 1060 28960 {}
C {lab_pin.sym} 1060 28960 0 0 {name=l23230 lab=VSS}
C {bitcell_6t.sym} 1200 29000 0 0 {name=Xr145c6}
N 1160 29040 1140 29040 {}
C {lab_pin.sym} 1140 29040 0 0 {name=l23231 lab=BL6}
N 1160 29000 1140 29000 {}
C {lab_pin.sym} 1140 29000 0 0 {name=l23232 lab=BLB6}
N 1160 28960 1140 28960 {}
C {lab_pin.sym} 1140 28960 0 0 {name=l23233 lab=WL145}
N 1240 29040 1260 29040 {}
C {lab_pin.sym} 1260 29040 0 0 {name=l23234 lab=VDD}
N 1240 28960 1260 28960 {}
C {lab_pin.sym} 1260 28960 0 0 {name=l23235 lab=VSS}
C {bitcell_6t.sym} 1400 29000 0 0 {name=Xr145c7}
N 1360 29040 1340 29040 {}
C {lab_pin.sym} 1340 29040 0 0 {name=l23236 lab=BL7}
N 1360 29000 1340 29000 {}
C {lab_pin.sym} 1340 29000 0 0 {name=l23237 lab=BLB7}
N 1360 28960 1340 28960 {}
C {lab_pin.sym} 1340 28960 0 0 {name=l23238 lab=WL145}
N 1440 29040 1460 29040 {}
C {lab_pin.sym} 1460 29040 0 0 {name=l23239 lab=VDD}
N 1440 28960 1460 28960 {}
C {lab_pin.sym} 1460 28960 0 0 {name=l23240 lab=VSS}
C {bitcell_6t.sym} 1600 29000 0 0 {name=Xr145c8}
N 1560 29040 1540 29040 {}
C {lab_pin.sym} 1540 29040 0 0 {name=l23241 lab=BL8}
N 1560 29000 1540 29000 {}
C {lab_pin.sym} 1540 29000 0 0 {name=l23242 lab=BLB8}
N 1560 28960 1540 28960 {}
C {lab_pin.sym} 1540 28960 0 0 {name=l23243 lab=WL145}
N 1640 29040 1660 29040 {}
C {lab_pin.sym} 1660 29040 0 0 {name=l23244 lab=VDD}
N 1640 28960 1660 28960 {}
C {lab_pin.sym} 1660 28960 0 0 {name=l23245 lab=VSS}
C {bitcell_6t.sym} 1800 29000 0 0 {name=Xr145c9}
N 1760 29040 1740 29040 {}
C {lab_pin.sym} 1740 29040 0 0 {name=l23246 lab=BL9}
N 1760 29000 1740 29000 {}
C {lab_pin.sym} 1740 29000 0 0 {name=l23247 lab=BLB9}
N 1760 28960 1740 28960 {}
C {lab_pin.sym} 1740 28960 0 0 {name=l23248 lab=WL145}
N 1840 29040 1860 29040 {}
C {lab_pin.sym} 1860 29040 0 0 {name=l23249 lab=VDD}
N 1840 28960 1860 28960 {}
C {lab_pin.sym} 1860 28960 0 0 {name=l23250 lab=VSS}
C {bitcell_6t.sym} 2000 29000 0 0 {name=Xr145c10}
N 1960 29040 1940 29040 {}
C {lab_pin.sym} 1940 29040 0 0 {name=l23251 lab=BL10}
N 1960 29000 1940 29000 {}
C {lab_pin.sym} 1940 29000 0 0 {name=l23252 lab=BLB10}
N 1960 28960 1940 28960 {}
C {lab_pin.sym} 1940 28960 0 0 {name=l23253 lab=WL145}
N 2040 29040 2060 29040 {}
C {lab_pin.sym} 2060 29040 0 0 {name=l23254 lab=VDD}
N 2040 28960 2060 28960 {}
C {lab_pin.sym} 2060 28960 0 0 {name=l23255 lab=VSS}
C {bitcell_6t.sym} 2200 29000 0 0 {name=Xr145c11}
N 2160 29040 2140 29040 {}
C {lab_pin.sym} 2140 29040 0 0 {name=l23256 lab=BL11}
N 2160 29000 2140 29000 {}
C {lab_pin.sym} 2140 29000 0 0 {name=l23257 lab=BLB11}
N 2160 28960 2140 28960 {}
C {lab_pin.sym} 2140 28960 0 0 {name=l23258 lab=WL145}
N 2240 29040 2260 29040 {}
C {lab_pin.sym} 2260 29040 0 0 {name=l23259 lab=VDD}
N 2240 28960 2260 28960 {}
C {lab_pin.sym} 2260 28960 0 0 {name=l23260 lab=VSS}
C {bitcell_6t.sym} 2400 29000 0 0 {name=Xr145c12}
N 2360 29040 2340 29040 {}
C {lab_pin.sym} 2340 29040 0 0 {name=l23261 lab=BL12}
N 2360 29000 2340 29000 {}
C {lab_pin.sym} 2340 29000 0 0 {name=l23262 lab=BLB12}
N 2360 28960 2340 28960 {}
C {lab_pin.sym} 2340 28960 0 0 {name=l23263 lab=WL145}
N 2440 29040 2460 29040 {}
C {lab_pin.sym} 2460 29040 0 0 {name=l23264 lab=VDD}
N 2440 28960 2460 28960 {}
C {lab_pin.sym} 2460 28960 0 0 {name=l23265 lab=VSS}
C {bitcell_6t.sym} 2600 29000 0 0 {name=Xr145c13}
N 2560 29040 2540 29040 {}
C {lab_pin.sym} 2540 29040 0 0 {name=l23266 lab=BL13}
N 2560 29000 2540 29000 {}
C {lab_pin.sym} 2540 29000 0 0 {name=l23267 lab=BLB13}
N 2560 28960 2540 28960 {}
C {lab_pin.sym} 2540 28960 0 0 {name=l23268 lab=WL145}
N 2640 29040 2660 29040 {}
C {lab_pin.sym} 2660 29040 0 0 {name=l23269 lab=VDD}
N 2640 28960 2660 28960 {}
C {lab_pin.sym} 2660 28960 0 0 {name=l23270 lab=VSS}
C {bitcell_6t.sym} 2800 29000 0 0 {name=Xr145c14}
N 2760 29040 2740 29040 {}
C {lab_pin.sym} 2740 29040 0 0 {name=l23271 lab=BL14}
N 2760 29000 2740 29000 {}
C {lab_pin.sym} 2740 29000 0 0 {name=l23272 lab=BLB14}
N 2760 28960 2740 28960 {}
C {lab_pin.sym} 2740 28960 0 0 {name=l23273 lab=WL145}
N 2840 29040 2860 29040 {}
C {lab_pin.sym} 2860 29040 0 0 {name=l23274 lab=VDD}
N 2840 28960 2860 28960 {}
C {lab_pin.sym} 2860 28960 0 0 {name=l23275 lab=VSS}
C {bitcell_6t.sym} 3000 29000 0 0 {name=Xr145c15}
N 2960 29040 2940 29040 {}
C {lab_pin.sym} 2940 29040 0 0 {name=l23276 lab=BL15}
N 2960 29000 2940 29000 {}
C {lab_pin.sym} 2940 29000 0 0 {name=l23277 lab=BLB15}
N 2960 28960 2940 28960 {}
C {lab_pin.sym} 2940 28960 0 0 {name=l23278 lab=WL145}
N 3040 29040 3060 29040 {}
C {lab_pin.sym} 3060 29040 0 0 {name=l23279 lab=VDD}
N 3040 28960 3060 28960 {}
C {lab_pin.sym} 3060 28960 0 0 {name=l23280 lab=VSS}
C {bitcell_6t.sym} 3200 29000 0 0 {name=Xr145c16}
N 3160 29040 3140 29040 {}
C {lab_pin.sym} 3140 29040 0 0 {name=l23281 lab=BL16}
N 3160 29000 3140 29000 {}
C {lab_pin.sym} 3140 29000 0 0 {name=l23282 lab=BLB16}
N 3160 28960 3140 28960 {}
C {lab_pin.sym} 3140 28960 0 0 {name=l23283 lab=WL145}
N 3240 29040 3260 29040 {}
C {lab_pin.sym} 3260 29040 0 0 {name=l23284 lab=VDD}
N 3240 28960 3260 28960 {}
C {lab_pin.sym} 3260 28960 0 0 {name=l23285 lab=VSS}
C {bitcell_6t.sym} 3400 29000 0 0 {name=Xr145c17}
N 3360 29040 3340 29040 {}
C {lab_pin.sym} 3340 29040 0 0 {name=l23286 lab=BL17}
N 3360 29000 3340 29000 {}
C {lab_pin.sym} 3340 29000 0 0 {name=l23287 lab=BLB17}
N 3360 28960 3340 28960 {}
C {lab_pin.sym} 3340 28960 0 0 {name=l23288 lab=WL145}
N 3440 29040 3460 29040 {}
C {lab_pin.sym} 3460 29040 0 0 {name=l23289 lab=VDD}
N 3440 28960 3460 28960 {}
C {lab_pin.sym} 3460 28960 0 0 {name=l23290 lab=VSS}
C {bitcell_6t.sym} 3600 29000 0 0 {name=Xr145c18}
N 3560 29040 3540 29040 {}
C {lab_pin.sym} 3540 29040 0 0 {name=l23291 lab=BL18}
N 3560 29000 3540 29000 {}
C {lab_pin.sym} 3540 29000 0 0 {name=l23292 lab=BLB18}
N 3560 28960 3540 28960 {}
C {lab_pin.sym} 3540 28960 0 0 {name=l23293 lab=WL145}
N 3640 29040 3660 29040 {}
C {lab_pin.sym} 3660 29040 0 0 {name=l23294 lab=VDD}
N 3640 28960 3660 28960 {}
C {lab_pin.sym} 3660 28960 0 0 {name=l23295 lab=VSS}
C {bitcell_6t.sym} 3800 29000 0 0 {name=Xr145c19}
N 3760 29040 3740 29040 {}
C {lab_pin.sym} 3740 29040 0 0 {name=l23296 lab=BL19}
N 3760 29000 3740 29000 {}
C {lab_pin.sym} 3740 29000 0 0 {name=l23297 lab=BLB19}
N 3760 28960 3740 28960 {}
C {lab_pin.sym} 3740 28960 0 0 {name=l23298 lab=WL145}
N 3840 29040 3860 29040 {}
C {lab_pin.sym} 3860 29040 0 0 {name=l23299 lab=VDD}
N 3840 28960 3860 28960 {}
C {lab_pin.sym} 3860 28960 0 0 {name=l23300 lab=VSS}
C {bitcell_6t.sym} 4000 29000 0 0 {name=Xr145c20}
N 3960 29040 3940 29040 {}
C {lab_pin.sym} 3940 29040 0 0 {name=l23301 lab=BL20}
N 3960 29000 3940 29000 {}
C {lab_pin.sym} 3940 29000 0 0 {name=l23302 lab=BLB20}
N 3960 28960 3940 28960 {}
C {lab_pin.sym} 3940 28960 0 0 {name=l23303 lab=WL145}
N 4040 29040 4060 29040 {}
C {lab_pin.sym} 4060 29040 0 0 {name=l23304 lab=VDD}
N 4040 28960 4060 28960 {}
C {lab_pin.sym} 4060 28960 0 0 {name=l23305 lab=VSS}
C {bitcell_6t.sym} 4200 29000 0 0 {name=Xr145c21}
N 4160 29040 4140 29040 {}
C {lab_pin.sym} 4140 29040 0 0 {name=l23306 lab=BL21}
N 4160 29000 4140 29000 {}
C {lab_pin.sym} 4140 29000 0 0 {name=l23307 lab=BLB21}
N 4160 28960 4140 28960 {}
C {lab_pin.sym} 4140 28960 0 0 {name=l23308 lab=WL145}
N 4240 29040 4260 29040 {}
C {lab_pin.sym} 4260 29040 0 0 {name=l23309 lab=VDD}
N 4240 28960 4260 28960 {}
C {lab_pin.sym} 4260 28960 0 0 {name=l23310 lab=VSS}
C {bitcell_6t.sym} 4400 29000 0 0 {name=Xr145c22}
N 4360 29040 4340 29040 {}
C {lab_pin.sym} 4340 29040 0 0 {name=l23311 lab=BL22}
N 4360 29000 4340 29000 {}
C {lab_pin.sym} 4340 29000 0 0 {name=l23312 lab=BLB22}
N 4360 28960 4340 28960 {}
C {lab_pin.sym} 4340 28960 0 0 {name=l23313 lab=WL145}
N 4440 29040 4460 29040 {}
C {lab_pin.sym} 4460 29040 0 0 {name=l23314 lab=VDD}
N 4440 28960 4460 28960 {}
C {lab_pin.sym} 4460 28960 0 0 {name=l23315 lab=VSS}
C {bitcell_6t.sym} 4600 29000 0 0 {name=Xr145c23}
N 4560 29040 4540 29040 {}
C {lab_pin.sym} 4540 29040 0 0 {name=l23316 lab=BL23}
N 4560 29000 4540 29000 {}
C {lab_pin.sym} 4540 29000 0 0 {name=l23317 lab=BLB23}
N 4560 28960 4540 28960 {}
C {lab_pin.sym} 4540 28960 0 0 {name=l23318 lab=WL145}
N 4640 29040 4660 29040 {}
C {lab_pin.sym} 4660 29040 0 0 {name=l23319 lab=VDD}
N 4640 28960 4660 28960 {}
C {lab_pin.sym} 4660 28960 0 0 {name=l23320 lab=VSS}
C {bitcell_6t.sym} 4800 29000 0 0 {name=Xr145c24}
N 4760 29040 4740 29040 {}
C {lab_pin.sym} 4740 29040 0 0 {name=l23321 lab=BL24}
N 4760 29000 4740 29000 {}
C {lab_pin.sym} 4740 29000 0 0 {name=l23322 lab=BLB24}
N 4760 28960 4740 28960 {}
C {lab_pin.sym} 4740 28960 0 0 {name=l23323 lab=WL145}
N 4840 29040 4860 29040 {}
C {lab_pin.sym} 4860 29040 0 0 {name=l23324 lab=VDD}
N 4840 28960 4860 28960 {}
C {lab_pin.sym} 4860 28960 0 0 {name=l23325 lab=VSS}
C {bitcell_6t.sym} 5000 29000 0 0 {name=Xr145c25}
N 4960 29040 4940 29040 {}
C {lab_pin.sym} 4940 29040 0 0 {name=l23326 lab=BL25}
N 4960 29000 4940 29000 {}
C {lab_pin.sym} 4940 29000 0 0 {name=l23327 lab=BLB25}
N 4960 28960 4940 28960 {}
C {lab_pin.sym} 4940 28960 0 0 {name=l23328 lab=WL145}
N 5040 29040 5060 29040 {}
C {lab_pin.sym} 5060 29040 0 0 {name=l23329 lab=VDD}
N 5040 28960 5060 28960 {}
C {lab_pin.sym} 5060 28960 0 0 {name=l23330 lab=VSS}
C {bitcell_6t.sym} 5200 29000 0 0 {name=Xr145c26}
N 5160 29040 5140 29040 {}
C {lab_pin.sym} 5140 29040 0 0 {name=l23331 lab=BL26}
N 5160 29000 5140 29000 {}
C {lab_pin.sym} 5140 29000 0 0 {name=l23332 lab=BLB26}
N 5160 28960 5140 28960 {}
C {lab_pin.sym} 5140 28960 0 0 {name=l23333 lab=WL145}
N 5240 29040 5260 29040 {}
C {lab_pin.sym} 5260 29040 0 0 {name=l23334 lab=VDD}
N 5240 28960 5260 28960 {}
C {lab_pin.sym} 5260 28960 0 0 {name=l23335 lab=VSS}
C {bitcell_6t.sym} 5400 29000 0 0 {name=Xr145c27}
N 5360 29040 5340 29040 {}
C {lab_pin.sym} 5340 29040 0 0 {name=l23336 lab=BL27}
N 5360 29000 5340 29000 {}
C {lab_pin.sym} 5340 29000 0 0 {name=l23337 lab=BLB27}
N 5360 28960 5340 28960 {}
C {lab_pin.sym} 5340 28960 0 0 {name=l23338 lab=WL145}
N 5440 29040 5460 29040 {}
C {lab_pin.sym} 5460 29040 0 0 {name=l23339 lab=VDD}
N 5440 28960 5460 28960 {}
C {lab_pin.sym} 5460 28960 0 0 {name=l23340 lab=VSS}
C {bitcell_6t.sym} 5600 29000 0 0 {name=Xr145c28}
N 5560 29040 5540 29040 {}
C {lab_pin.sym} 5540 29040 0 0 {name=l23341 lab=BL28}
N 5560 29000 5540 29000 {}
C {lab_pin.sym} 5540 29000 0 0 {name=l23342 lab=BLB28}
N 5560 28960 5540 28960 {}
C {lab_pin.sym} 5540 28960 0 0 {name=l23343 lab=WL145}
N 5640 29040 5660 29040 {}
C {lab_pin.sym} 5660 29040 0 0 {name=l23344 lab=VDD}
N 5640 28960 5660 28960 {}
C {lab_pin.sym} 5660 28960 0 0 {name=l23345 lab=VSS}
C {bitcell_6t.sym} 5800 29000 0 0 {name=Xr145c29}
N 5760 29040 5740 29040 {}
C {lab_pin.sym} 5740 29040 0 0 {name=l23346 lab=BL29}
N 5760 29000 5740 29000 {}
C {lab_pin.sym} 5740 29000 0 0 {name=l23347 lab=BLB29}
N 5760 28960 5740 28960 {}
C {lab_pin.sym} 5740 28960 0 0 {name=l23348 lab=WL145}
N 5840 29040 5860 29040 {}
C {lab_pin.sym} 5860 29040 0 0 {name=l23349 lab=VDD}
N 5840 28960 5860 28960 {}
C {lab_pin.sym} 5860 28960 0 0 {name=l23350 lab=VSS}
C {bitcell_6t.sym} 6000 29000 0 0 {name=Xr145c30}
N 5960 29040 5940 29040 {}
C {lab_pin.sym} 5940 29040 0 0 {name=l23351 lab=BL30}
N 5960 29000 5940 29000 {}
C {lab_pin.sym} 5940 29000 0 0 {name=l23352 lab=BLB30}
N 5960 28960 5940 28960 {}
C {lab_pin.sym} 5940 28960 0 0 {name=l23353 lab=WL145}
N 6040 29040 6060 29040 {}
C {lab_pin.sym} 6060 29040 0 0 {name=l23354 lab=VDD}
N 6040 28960 6060 28960 {}
C {lab_pin.sym} 6060 28960 0 0 {name=l23355 lab=VSS}
C {bitcell_6t.sym} 6200 29000 0 0 {name=Xr145c31}
N 6160 29040 6140 29040 {}
C {lab_pin.sym} 6140 29040 0 0 {name=l23356 lab=BL31}
N 6160 29000 6140 29000 {}
C {lab_pin.sym} 6140 29000 0 0 {name=l23357 lab=BLB31}
N 6160 28960 6140 28960 {}
C {lab_pin.sym} 6140 28960 0 0 {name=l23358 lab=WL145}
N 6240 29040 6260 29040 {}
C {lab_pin.sym} 6260 29040 0 0 {name=l23359 lab=VDD}
N 6240 28960 6260 28960 {}
C {lab_pin.sym} 6260 28960 0 0 {name=l23360 lab=VSS}
C {bitcell_6t.sym} 0 29200 0 0 {name=Xr146c0}
N -40 29240 -60 29240 {}
C {lab_pin.sym} -60 29240 0 0 {name=l23361 lab=BL0}
N -40 29200 -60 29200 {}
C {lab_pin.sym} -60 29200 0 0 {name=l23362 lab=BLB0}
N -40 29160 -60 29160 {}
C {lab_pin.sym} -60 29160 0 0 {name=l23363 lab=WL146}
N 40 29240 60 29240 {}
C {lab_pin.sym} 60 29240 0 0 {name=l23364 lab=VDD}
N 40 29160 60 29160 {}
C {lab_pin.sym} 60 29160 0 0 {name=l23365 lab=VSS}
C {bitcell_6t.sym} 200 29200 0 0 {name=Xr146c1}
N 160 29240 140 29240 {}
C {lab_pin.sym} 140 29240 0 0 {name=l23366 lab=BL1}
N 160 29200 140 29200 {}
C {lab_pin.sym} 140 29200 0 0 {name=l23367 lab=BLB1}
N 160 29160 140 29160 {}
C {lab_pin.sym} 140 29160 0 0 {name=l23368 lab=WL146}
N 240 29240 260 29240 {}
C {lab_pin.sym} 260 29240 0 0 {name=l23369 lab=VDD}
N 240 29160 260 29160 {}
C {lab_pin.sym} 260 29160 0 0 {name=l23370 lab=VSS}
C {bitcell_6t.sym} 400 29200 0 0 {name=Xr146c2}
N 360 29240 340 29240 {}
C {lab_pin.sym} 340 29240 0 0 {name=l23371 lab=BL2}
N 360 29200 340 29200 {}
C {lab_pin.sym} 340 29200 0 0 {name=l23372 lab=BLB2}
N 360 29160 340 29160 {}
C {lab_pin.sym} 340 29160 0 0 {name=l23373 lab=WL146}
N 440 29240 460 29240 {}
C {lab_pin.sym} 460 29240 0 0 {name=l23374 lab=VDD}
N 440 29160 460 29160 {}
C {lab_pin.sym} 460 29160 0 0 {name=l23375 lab=VSS}
C {bitcell_6t.sym} 600 29200 0 0 {name=Xr146c3}
N 560 29240 540 29240 {}
C {lab_pin.sym} 540 29240 0 0 {name=l23376 lab=BL3}
N 560 29200 540 29200 {}
C {lab_pin.sym} 540 29200 0 0 {name=l23377 lab=BLB3}
N 560 29160 540 29160 {}
C {lab_pin.sym} 540 29160 0 0 {name=l23378 lab=WL146}
N 640 29240 660 29240 {}
C {lab_pin.sym} 660 29240 0 0 {name=l23379 lab=VDD}
N 640 29160 660 29160 {}
C {lab_pin.sym} 660 29160 0 0 {name=l23380 lab=VSS}
C {bitcell_6t.sym} 800 29200 0 0 {name=Xr146c4}
N 760 29240 740 29240 {}
C {lab_pin.sym} 740 29240 0 0 {name=l23381 lab=BL4}
N 760 29200 740 29200 {}
C {lab_pin.sym} 740 29200 0 0 {name=l23382 lab=BLB4}
N 760 29160 740 29160 {}
C {lab_pin.sym} 740 29160 0 0 {name=l23383 lab=WL146}
N 840 29240 860 29240 {}
C {lab_pin.sym} 860 29240 0 0 {name=l23384 lab=VDD}
N 840 29160 860 29160 {}
C {lab_pin.sym} 860 29160 0 0 {name=l23385 lab=VSS}
C {bitcell_6t.sym} 1000 29200 0 0 {name=Xr146c5}
N 960 29240 940 29240 {}
C {lab_pin.sym} 940 29240 0 0 {name=l23386 lab=BL5}
N 960 29200 940 29200 {}
C {lab_pin.sym} 940 29200 0 0 {name=l23387 lab=BLB5}
N 960 29160 940 29160 {}
C {lab_pin.sym} 940 29160 0 0 {name=l23388 lab=WL146}
N 1040 29240 1060 29240 {}
C {lab_pin.sym} 1060 29240 0 0 {name=l23389 lab=VDD}
N 1040 29160 1060 29160 {}
C {lab_pin.sym} 1060 29160 0 0 {name=l23390 lab=VSS}
C {bitcell_6t.sym} 1200 29200 0 0 {name=Xr146c6}
N 1160 29240 1140 29240 {}
C {lab_pin.sym} 1140 29240 0 0 {name=l23391 lab=BL6}
N 1160 29200 1140 29200 {}
C {lab_pin.sym} 1140 29200 0 0 {name=l23392 lab=BLB6}
N 1160 29160 1140 29160 {}
C {lab_pin.sym} 1140 29160 0 0 {name=l23393 lab=WL146}
N 1240 29240 1260 29240 {}
C {lab_pin.sym} 1260 29240 0 0 {name=l23394 lab=VDD}
N 1240 29160 1260 29160 {}
C {lab_pin.sym} 1260 29160 0 0 {name=l23395 lab=VSS}
C {bitcell_6t.sym} 1400 29200 0 0 {name=Xr146c7}
N 1360 29240 1340 29240 {}
C {lab_pin.sym} 1340 29240 0 0 {name=l23396 lab=BL7}
N 1360 29200 1340 29200 {}
C {lab_pin.sym} 1340 29200 0 0 {name=l23397 lab=BLB7}
N 1360 29160 1340 29160 {}
C {lab_pin.sym} 1340 29160 0 0 {name=l23398 lab=WL146}
N 1440 29240 1460 29240 {}
C {lab_pin.sym} 1460 29240 0 0 {name=l23399 lab=VDD}
N 1440 29160 1460 29160 {}
C {lab_pin.sym} 1460 29160 0 0 {name=l23400 lab=VSS}
C {bitcell_6t.sym} 1600 29200 0 0 {name=Xr146c8}
N 1560 29240 1540 29240 {}
C {lab_pin.sym} 1540 29240 0 0 {name=l23401 lab=BL8}
N 1560 29200 1540 29200 {}
C {lab_pin.sym} 1540 29200 0 0 {name=l23402 lab=BLB8}
N 1560 29160 1540 29160 {}
C {lab_pin.sym} 1540 29160 0 0 {name=l23403 lab=WL146}
N 1640 29240 1660 29240 {}
C {lab_pin.sym} 1660 29240 0 0 {name=l23404 lab=VDD}
N 1640 29160 1660 29160 {}
C {lab_pin.sym} 1660 29160 0 0 {name=l23405 lab=VSS}
C {bitcell_6t.sym} 1800 29200 0 0 {name=Xr146c9}
N 1760 29240 1740 29240 {}
C {lab_pin.sym} 1740 29240 0 0 {name=l23406 lab=BL9}
N 1760 29200 1740 29200 {}
C {lab_pin.sym} 1740 29200 0 0 {name=l23407 lab=BLB9}
N 1760 29160 1740 29160 {}
C {lab_pin.sym} 1740 29160 0 0 {name=l23408 lab=WL146}
N 1840 29240 1860 29240 {}
C {lab_pin.sym} 1860 29240 0 0 {name=l23409 lab=VDD}
N 1840 29160 1860 29160 {}
C {lab_pin.sym} 1860 29160 0 0 {name=l23410 lab=VSS}
C {bitcell_6t.sym} 2000 29200 0 0 {name=Xr146c10}
N 1960 29240 1940 29240 {}
C {lab_pin.sym} 1940 29240 0 0 {name=l23411 lab=BL10}
N 1960 29200 1940 29200 {}
C {lab_pin.sym} 1940 29200 0 0 {name=l23412 lab=BLB10}
N 1960 29160 1940 29160 {}
C {lab_pin.sym} 1940 29160 0 0 {name=l23413 lab=WL146}
N 2040 29240 2060 29240 {}
C {lab_pin.sym} 2060 29240 0 0 {name=l23414 lab=VDD}
N 2040 29160 2060 29160 {}
C {lab_pin.sym} 2060 29160 0 0 {name=l23415 lab=VSS}
C {bitcell_6t.sym} 2200 29200 0 0 {name=Xr146c11}
N 2160 29240 2140 29240 {}
C {lab_pin.sym} 2140 29240 0 0 {name=l23416 lab=BL11}
N 2160 29200 2140 29200 {}
C {lab_pin.sym} 2140 29200 0 0 {name=l23417 lab=BLB11}
N 2160 29160 2140 29160 {}
C {lab_pin.sym} 2140 29160 0 0 {name=l23418 lab=WL146}
N 2240 29240 2260 29240 {}
C {lab_pin.sym} 2260 29240 0 0 {name=l23419 lab=VDD}
N 2240 29160 2260 29160 {}
C {lab_pin.sym} 2260 29160 0 0 {name=l23420 lab=VSS}
C {bitcell_6t.sym} 2400 29200 0 0 {name=Xr146c12}
N 2360 29240 2340 29240 {}
C {lab_pin.sym} 2340 29240 0 0 {name=l23421 lab=BL12}
N 2360 29200 2340 29200 {}
C {lab_pin.sym} 2340 29200 0 0 {name=l23422 lab=BLB12}
N 2360 29160 2340 29160 {}
C {lab_pin.sym} 2340 29160 0 0 {name=l23423 lab=WL146}
N 2440 29240 2460 29240 {}
C {lab_pin.sym} 2460 29240 0 0 {name=l23424 lab=VDD}
N 2440 29160 2460 29160 {}
C {lab_pin.sym} 2460 29160 0 0 {name=l23425 lab=VSS}
C {bitcell_6t.sym} 2600 29200 0 0 {name=Xr146c13}
N 2560 29240 2540 29240 {}
C {lab_pin.sym} 2540 29240 0 0 {name=l23426 lab=BL13}
N 2560 29200 2540 29200 {}
C {lab_pin.sym} 2540 29200 0 0 {name=l23427 lab=BLB13}
N 2560 29160 2540 29160 {}
C {lab_pin.sym} 2540 29160 0 0 {name=l23428 lab=WL146}
N 2640 29240 2660 29240 {}
C {lab_pin.sym} 2660 29240 0 0 {name=l23429 lab=VDD}
N 2640 29160 2660 29160 {}
C {lab_pin.sym} 2660 29160 0 0 {name=l23430 lab=VSS}
C {bitcell_6t.sym} 2800 29200 0 0 {name=Xr146c14}
N 2760 29240 2740 29240 {}
C {lab_pin.sym} 2740 29240 0 0 {name=l23431 lab=BL14}
N 2760 29200 2740 29200 {}
C {lab_pin.sym} 2740 29200 0 0 {name=l23432 lab=BLB14}
N 2760 29160 2740 29160 {}
C {lab_pin.sym} 2740 29160 0 0 {name=l23433 lab=WL146}
N 2840 29240 2860 29240 {}
C {lab_pin.sym} 2860 29240 0 0 {name=l23434 lab=VDD}
N 2840 29160 2860 29160 {}
C {lab_pin.sym} 2860 29160 0 0 {name=l23435 lab=VSS}
C {bitcell_6t.sym} 3000 29200 0 0 {name=Xr146c15}
N 2960 29240 2940 29240 {}
C {lab_pin.sym} 2940 29240 0 0 {name=l23436 lab=BL15}
N 2960 29200 2940 29200 {}
C {lab_pin.sym} 2940 29200 0 0 {name=l23437 lab=BLB15}
N 2960 29160 2940 29160 {}
C {lab_pin.sym} 2940 29160 0 0 {name=l23438 lab=WL146}
N 3040 29240 3060 29240 {}
C {lab_pin.sym} 3060 29240 0 0 {name=l23439 lab=VDD}
N 3040 29160 3060 29160 {}
C {lab_pin.sym} 3060 29160 0 0 {name=l23440 lab=VSS}
C {bitcell_6t.sym} 3200 29200 0 0 {name=Xr146c16}
N 3160 29240 3140 29240 {}
C {lab_pin.sym} 3140 29240 0 0 {name=l23441 lab=BL16}
N 3160 29200 3140 29200 {}
C {lab_pin.sym} 3140 29200 0 0 {name=l23442 lab=BLB16}
N 3160 29160 3140 29160 {}
C {lab_pin.sym} 3140 29160 0 0 {name=l23443 lab=WL146}
N 3240 29240 3260 29240 {}
C {lab_pin.sym} 3260 29240 0 0 {name=l23444 lab=VDD}
N 3240 29160 3260 29160 {}
C {lab_pin.sym} 3260 29160 0 0 {name=l23445 lab=VSS}
C {bitcell_6t.sym} 3400 29200 0 0 {name=Xr146c17}
N 3360 29240 3340 29240 {}
C {lab_pin.sym} 3340 29240 0 0 {name=l23446 lab=BL17}
N 3360 29200 3340 29200 {}
C {lab_pin.sym} 3340 29200 0 0 {name=l23447 lab=BLB17}
N 3360 29160 3340 29160 {}
C {lab_pin.sym} 3340 29160 0 0 {name=l23448 lab=WL146}
N 3440 29240 3460 29240 {}
C {lab_pin.sym} 3460 29240 0 0 {name=l23449 lab=VDD}
N 3440 29160 3460 29160 {}
C {lab_pin.sym} 3460 29160 0 0 {name=l23450 lab=VSS}
C {bitcell_6t.sym} 3600 29200 0 0 {name=Xr146c18}
N 3560 29240 3540 29240 {}
C {lab_pin.sym} 3540 29240 0 0 {name=l23451 lab=BL18}
N 3560 29200 3540 29200 {}
C {lab_pin.sym} 3540 29200 0 0 {name=l23452 lab=BLB18}
N 3560 29160 3540 29160 {}
C {lab_pin.sym} 3540 29160 0 0 {name=l23453 lab=WL146}
N 3640 29240 3660 29240 {}
C {lab_pin.sym} 3660 29240 0 0 {name=l23454 lab=VDD}
N 3640 29160 3660 29160 {}
C {lab_pin.sym} 3660 29160 0 0 {name=l23455 lab=VSS}
C {bitcell_6t.sym} 3800 29200 0 0 {name=Xr146c19}
N 3760 29240 3740 29240 {}
C {lab_pin.sym} 3740 29240 0 0 {name=l23456 lab=BL19}
N 3760 29200 3740 29200 {}
C {lab_pin.sym} 3740 29200 0 0 {name=l23457 lab=BLB19}
N 3760 29160 3740 29160 {}
C {lab_pin.sym} 3740 29160 0 0 {name=l23458 lab=WL146}
N 3840 29240 3860 29240 {}
C {lab_pin.sym} 3860 29240 0 0 {name=l23459 lab=VDD}
N 3840 29160 3860 29160 {}
C {lab_pin.sym} 3860 29160 0 0 {name=l23460 lab=VSS}
C {bitcell_6t.sym} 4000 29200 0 0 {name=Xr146c20}
N 3960 29240 3940 29240 {}
C {lab_pin.sym} 3940 29240 0 0 {name=l23461 lab=BL20}
N 3960 29200 3940 29200 {}
C {lab_pin.sym} 3940 29200 0 0 {name=l23462 lab=BLB20}
N 3960 29160 3940 29160 {}
C {lab_pin.sym} 3940 29160 0 0 {name=l23463 lab=WL146}
N 4040 29240 4060 29240 {}
C {lab_pin.sym} 4060 29240 0 0 {name=l23464 lab=VDD}
N 4040 29160 4060 29160 {}
C {lab_pin.sym} 4060 29160 0 0 {name=l23465 lab=VSS}
C {bitcell_6t.sym} 4200 29200 0 0 {name=Xr146c21}
N 4160 29240 4140 29240 {}
C {lab_pin.sym} 4140 29240 0 0 {name=l23466 lab=BL21}
N 4160 29200 4140 29200 {}
C {lab_pin.sym} 4140 29200 0 0 {name=l23467 lab=BLB21}
N 4160 29160 4140 29160 {}
C {lab_pin.sym} 4140 29160 0 0 {name=l23468 lab=WL146}
N 4240 29240 4260 29240 {}
C {lab_pin.sym} 4260 29240 0 0 {name=l23469 lab=VDD}
N 4240 29160 4260 29160 {}
C {lab_pin.sym} 4260 29160 0 0 {name=l23470 lab=VSS}
C {bitcell_6t.sym} 4400 29200 0 0 {name=Xr146c22}
N 4360 29240 4340 29240 {}
C {lab_pin.sym} 4340 29240 0 0 {name=l23471 lab=BL22}
N 4360 29200 4340 29200 {}
C {lab_pin.sym} 4340 29200 0 0 {name=l23472 lab=BLB22}
N 4360 29160 4340 29160 {}
C {lab_pin.sym} 4340 29160 0 0 {name=l23473 lab=WL146}
N 4440 29240 4460 29240 {}
C {lab_pin.sym} 4460 29240 0 0 {name=l23474 lab=VDD}
N 4440 29160 4460 29160 {}
C {lab_pin.sym} 4460 29160 0 0 {name=l23475 lab=VSS}
C {bitcell_6t.sym} 4600 29200 0 0 {name=Xr146c23}
N 4560 29240 4540 29240 {}
C {lab_pin.sym} 4540 29240 0 0 {name=l23476 lab=BL23}
N 4560 29200 4540 29200 {}
C {lab_pin.sym} 4540 29200 0 0 {name=l23477 lab=BLB23}
N 4560 29160 4540 29160 {}
C {lab_pin.sym} 4540 29160 0 0 {name=l23478 lab=WL146}
N 4640 29240 4660 29240 {}
C {lab_pin.sym} 4660 29240 0 0 {name=l23479 lab=VDD}
N 4640 29160 4660 29160 {}
C {lab_pin.sym} 4660 29160 0 0 {name=l23480 lab=VSS}
C {bitcell_6t.sym} 4800 29200 0 0 {name=Xr146c24}
N 4760 29240 4740 29240 {}
C {lab_pin.sym} 4740 29240 0 0 {name=l23481 lab=BL24}
N 4760 29200 4740 29200 {}
C {lab_pin.sym} 4740 29200 0 0 {name=l23482 lab=BLB24}
N 4760 29160 4740 29160 {}
C {lab_pin.sym} 4740 29160 0 0 {name=l23483 lab=WL146}
N 4840 29240 4860 29240 {}
C {lab_pin.sym} 4860 29240 0 0 {name=l23484 lab=VDD}
N 4840 29160 4860 29160 {}
C {lab_pin.sym} 4860 29160 0 0 {name=l23485 lab=VSS}
C {bitcell_6t.sym} 5000 29200 0 0 {name=Xr146c25}
N 4960 29240 4940 29240 {}
C {lab_pin.sym} 4940 29240 0 0 {name=l23486 lab=BL25}
N 4960 29200 4940 29200 {}
C {lab_pin.sym} 4940 29200 0 0 {name=l23487 lab=BLB25}
N 4960 29160 4940 29160 {}
C {lab_pin.sym} 4940 29160 0 0 {name=l23488 lab=WL146}
N 5040 29240 5060 29240 {}
C {lab_pin.sym} 5060 29240 0 0 {name=l23489 lab=VDD}
N 5040 29160 5060 29160 {}
C {lab_pin.sym} 5060 29160 0 0 {name=l23490 lab=VSS}
C {bitcell_6t.sym} 5200 29200 0 0 {name=Xr146c26}
N 5160 29240 5140 29240 {}
C {lab_pin.sym} 5140 29240 0 0 {name=l23491 lab=BL26}
N 5160 29200 5140 29200 {}
C {lab_pin.sym} 5140 29200 0 0 {name=l23492 lab=BLB26}
N 5160 29160 5140 29160 {}
C {lab_pin.sym} 5140 29160 0 0 {name=l23493 lab=WL146}
N 5240 29240 5260 29240 {}
C {lab_pin.sym} 5260 29240 0 0 {name=l23494 lab=VDD}
N 5240 29160 5260 29160 {}
C {lab_pin.sym} 5260 29160 0 0 {name=l23495 lab=VSS}
C {bitcell_6t.sym} 5400 29200 0 0 {name=Xr146c27}
N 5360 29240 5340 29240 {}
C {lab_pin.sym} 5340 29240 0 0 {name=l23496 lab=BL27}
N 5360 29200 5340 29200 {}
C {lab_pin.sym} 5340 29200 0 0 {name=l23497 lab=BLB27}
N 5360 29160 5340 29160 {}
C {lab_pin.sym} 5340 29160 0 0 {name=l23498 lab=WL146}
N 5440 29240 5460 29240 {}
C {lab_pin.sym} 5460 29240 0 0 {name=l23499 lab=VDD}
N 5440 29160 5460 29160 {}
C {lab_pin.sym} 5460 29160 0 0 {name=l23500 lab=VSS}
C {bitcell_6t.sym} 5600 29200 0 0 {name=Xr146c28}
N 5560 29240 5540 29240 {}
C {lab_pin.sym} 5540 29240 0 0 {name=l23501 lab=BL28}
N 5560 29200 5540 29200 {}
C {lab_pin.sym} 5540 29200 0 0 {name=l23502 lab=BLB28}
N 5560 29160 5540 29160 {}
C {lab_pin.sym} 5540 29160 0 0 {name=l23503 lab=WL146}
N 5640 29240 5660 29240 {}
C {lab_pin.sym} 5660 29240 0 0 {name=l23504 lab=VDD}
N 5640 29160 5660 29160 {}
C {lab_pin.sym} 5660 29160 0 0 {name=l23505 lab=VSS}
C {bitcell_6t.sym} 5800 29200 0 0 {name=Xr146c29}
N 5760 29240 5740 29240 {}
C {lab_pin.sym} 5740 29240 0 0 {name=l23506 lab=BL29}
N 5760 29200 5740 29200 {}
C {lab_pin.sym} 5740 29200 0 0 {name=l23507 lab=BLB29}
N 5760 29160 5740 29160 {}
C {lab_pin.sym} 5740 29160 0 0 {name=l23508 lab=WL146}
N 5840 29240 5860 29240 {}
C {lab_pin.sym} 5860 29240 0 0 {name=l23509 lab=VDD}
N 5840 29160 5860 29160 {}
C {lab_pin.sym} 5860 29160 0 0 {name=l23510 lab=VSS}
C {bitcell_6t.sym} 6000 29200 0 0 {name=Xr146c30}
N 5960 29240 5940 29240 {}
C {lab_pin.sym} 5940 29240 0 0 {name=l23511 lab=BL30}
N 5960 29200 5940 29200 {}
C {lab_pin.sym} 5940 29200 0 0 {name=l23512 lab=BLB30}
N 5960 29160 5940 29160 {}
C {lab_pin.sym} 5940 29160 0 0 {name=l23513 lab=WL146}
N 6040 29240 6060 29240 {}
C {lab_pin.sym} 6060 29240 0 0 {name=l23514 lab=VDD}
N 6040 29160 6060 29160 {}
C {lab_pin.sym} 6060 29160 0 0 {name=l23515 lab=VSS}
C {bitcell_6t.sym} 6200 29200 0 0 {name=Xr146c31}
N 6160 29240 6140 29240 {}
C {lab_pin.sym} 6140 29240 0 0 {name=l23516 lab=BL31}
N 6160 29200 6140 29200 {}
C {lab_pin.sym} 6140 29200 0 0 {name=l23517 lab=BLB31}
N 6160 29160 6140 29160 {}
C {lab_pin.sym} 6140 29160 0 0 {name=l23518 lab=WL146}
N 6240 29240 6260 29240 {}
C {lab_pin.sym} 6260 29240 0 0 {name=l23519 lab=VDD}
N 6240 29160 6260 29160 {}
C {lab_pin.sym} 6260 29160 0 0 {name=l23520 lab=VSS}
C {bitcell_6t.sym} 0 29400 0 0 {name=Xr147c0}
N -40 29440 -60 29440 {}
C {lab_pin.sym} -60 29440 0 0 {name=l23521 lab=BL0}
N -40 29400 -60 29400 {}
C {lab_pin.sym} -60 29400 0 0 {name=l23522 lab=BLB0}
N -40 29360 -60 29360 {}
C {lab_pin.sym} -60 29360 0 0 {name=l23523 lab=WL147}
N 40 29440 60 29440 {}
C {lab_pin.sym} 60 29440 0 0 {name=l23524 lab=VDD}
N 40 29360 60 29360 {}
C {lab_pin.sym} 60 29360 0 0 {name=l23525 lab=VSS}
C {bitcell_6t.sym} 200 29400 0 0 {name=Xr147c1}
N 160 29440 140 29440 {}
C {lab_pin.sym} 140 29440 0 0 {name=l23526 lab=BL1}
N 160 29400 140 29400 {}
C {lab_pin.sym} 140 29400 0 0 {name=l23527 lab=BLB1}
N 160 29360 140 29360 {}
C {lab_pin.sym} 140 29360 0 0 {name=l23528 lab=WL147}
N 240 29440 260 29440 {}
C {lab_pin.sym} 260 29440 0 0 {name=l23529 lab=VDD}
N 240 29360 260 29360 {}
C {lab_pin.sym} 260 29360 0 0 {name=l23530 lab=VSS}
C {bitcell_6t.sym} 400 29400 0 0 {name=Xr147c2}
N 360 29440 340 29440 {}
C {lab_pin.sym} 340 29440 0 0 {name=l23531 lab=BL2}
N 360 29400 340 29400 {}
C {lab_pin.sym} 340 29400 0 0 {name=l23532 lab=BLB2}
N 360 29360 340 29360 {}
C {lab_pin.sym} 340 29360 0 0 {name=l23533 lab=WL147}
N 440 29440 460 29440 {}
C {lab_pin.sym} 460 29440 0 0 {name=l23534 lab=VDD}
N 440 29360 460 29360 {}
C {lab_pin.sym} 460 29360 0 0 {name=l23535 lab=VSS}
C {bitcell_6t.sym} 600 29400 0 0 {name=Xr147c3}
N 560 29440 540 29440 {}
C {lab_pin.sym} 540 29440 0 0 {name=l23536 lab=BL3}
N 560 29400 540 29400 {}
C {lab_pin.sym} 540 29400 0 0 {name=l23537 lab=BLB3}
N 560 29360 540 29360 {}
C {lab_pin.sym} 540 29360 0 0 {name=l23538 lab=WL147}
N 640 29440 660 29440 {}
C {lab_pin.sym} 660 29440 0 0 {name=l23539 lab=VDD}
N 640 29360 660 29360 {}
C {lab_pin.sym} 660 29360 0 0 {name=l23540 lab=VSS}
C {bitcell_6t.sym} 800 29400 0 0 {name=Xr147c4}
N 760 29440 740 29440 {}
C {lab_pin.sym} 740 29440 0 0 {name=l23541 lab=BL4}
N 760 29400 740 29400 {}
C {lab_pin.sym} 740 29400 0 0 {name=l23542 lab=BLB4}
N 760 29360 740 29360 {}
C {lab_pin.sym} 740 29360 0 0 {name=l23543 lab=WL147}
N 840 29440 860 29440 {}
C {lab_pin.sym} 860 29440 0 0 {name=l23544 lab=VDD}
N 840 29360 860 29360 {}
C {lab_pin.sym} 860 29360 0 0 {name=l23545 lab=VSS}
C {bitcell_6t.sym} 1000 29400 0 0 {name=Xr147c5}
N 960 29440 940 29440 {}
C {lab_pin.sym} 940 29440 0 0 {name=l23546 lab=BL5}
N 960 29400 940 29400 {}
C {lab_pin.sym} 940 29400 0 0 {name=l23547 lab=BLB5}
N 960 29360 940 29360 {}
C {lab_pin.sym} 940 29360 0 0 {name=l23548 lab=WL147}
N 1040 29440 1060 29440 {}
C {lab_pin.sym} 1060 29440 0 0 {name=l23549 lab=VDD}
N 1040 29360 1060 29360 {}
C {lab_pin.sym} 1060 29360 0 0 {name=l23550 lab=VSS}
C {bitcell_6t.sym} 1200 29400 0 0 {name=Xr147c6}
N 1160 29440 1140 29440 {}
C {lab_pin.sym} 1140 29440 0 0 {name=l23551 lab=BL6}
N 1160 29400 1140 29400 {}
C {lab_pin.sym} 1140 29400 0 0 {name=l23552 lab=BLB6}
N 1160 29360 1140 29360 {}
C {lab_pin.sym} 1140 29360 0 0 {name=l23553 lab=WL147}
N 1240 29440 1260 29440 {}
C {lab_pin.sym} 1260 29440 0 0 {name=l23554 lab=VDD}
N 1240 29360 1260 29360 {}
C {lab_pin.sym} 1260 29360 0 0 {name=l23555 lab=VSS}
C {bitcell_6t.sym} 1400 29400 0 0 {name=Xr147c7}
N 1360 29440 1340 29440 {}
C {lab_pin.sym} 1340 29440 0 0 {name=l23556 lab=BL7}
N 1360 29400 1340 29400 {}
C {lab_pin.sym} 1340 29400 0 0 {name=l23557 lab=BLB7}
N 1360 29360 1340 29360 {}
C {lab_pin.sym} 1340 29360 0 0 {name=l23558 lab=WL147}
N 1440 29440 1460 29440 {}
C {lab_pin.sym} 1460 29440 0 0 {name=l23559 lab=VDD}
N 1440 29360 1460 29360 {}
C {lab_pin.sym} 1460 29360 0 0 {name=l23560 lab=VSS}
C {bitcell_6t.sym} 1600 29400 0 0 {name=Xr147c8}
N 1560 29440 1540 29440 {}
C {lab_pin.sym} 1540 29440 0 0 {name=l23561 lab=BL8}
N 1560 29400 1540 29400 {}
C {lab_pin.sym} 1540 29400 0 0 {name=l23562 lab=BLB8}
N 1560 29360 1540 29360 {}
C {lab_pin.sym} 1540 29360 0 0 {name=l23563 lab=WL147}
N 1640 29440 1660 29440 {}
C {lab_pin.sym} 1660 29440 0 0 {name=l23564 lab=VDD}
N 1640 29360 1660 29360 {}
C {lab_pin.sym} 1660 29360 0 0 {name=l23565 lab=VSS}
C {bitcell_6t.sym} 1800 29400 0 0 {name=Xr147c9}
N 1760 29440 1740 29440 {}
C {lab_pin.sym} 1740 29440 0 0 {name=l23566 lab=BL9}
N 1760 29400 1740 29400 {}
C {lab_pin.sym} 1740 29400 0 0 {name=l23567 lab=BLB9}
N 1760 29360 1740 29360 {}
C {lab_pin.sym} 1740 29360 0 0 {name=l23568 lab=WL147}
N 1840 29440 1860 29440 {}
C {lab_pin.sym} 1860 29440 0 0 {name=l23569 lab=VDD}
N 1840 29360 1860 29360 {}
C {lab_pin.sym} 1860 29360 0 0 {name=l23570 lab=VSS}
C {bitcell_6t.sym} 2000 29400 0 0 {name=Xr147c10}
N 1960 29440 1940 29440 {}
C {lab_pin.sym} 1940 29440 0 0 {name=l23571 lab=BL10}
N 1960 29400 1940 29400 {}
C {lab_pin.sym} 1940 29400 0 0 {name=l23572 lab=BLB10}
N 1960 29360 1940 29360 {}
C {lab_pin.sym} 1940 29360 0 0 {name=l23573 lab=WL147}
N 2040 29440 2060 29440 {}
C {lab_pin.sym} 2060 29440 0 0 {name=l23574 lab=VDD}
N 2040 29360 2060 29360 {}
C {lab_pin.sym} 2060 29360 0 0 {name=l23575 lab=VSS}
C {bitcell_6t.sym} 2200 29400 0 0 {name=Xr147c11}
N 2160 29440 2140 29440 {}
C {lab_pin.sym} 2140 29440 0 0 {name=l23576 lab=BL11}
N 2160 29400 2140 29400 {}
C {lab_pin.sym} 2140 29400 0 0 {name=l23577 lab=BLB11}
N 2160 29360 2140 29360 {}
C {lab_pin.sym} 2140 29360 0 0 {name=l23578 lab=WL147}
N 2240 29440 2260 29440 {}
C {lab_pin.sym} 2260 29440 0 0 {name=l23579 lab=VDD}
N 2240 29360 2260 29360 {}
C {lab_pin.sym} 2260 29360 0 0 {name=l23580 lab=VSS}
C {bitcell_6t.sym} 2400 29400 0 0 {name=Xr147c12}
N 2360 29440 2340 29440 {}
C {lab_pin.sym} 2340 29440 0 0 {name=l23581 lab=BL12}
N 2360 29400 2340 29400 {}
C {lab_pin.sym} 2340 29400 0 0 {name=l23582 lab=BLB12}
N 2360 29360 2340 29360 {}
C {lab_pin.sym} 2340 29360 0 0 {name=l23583 lab=WL147}
N 2440 29440 2460 29440 {}
C {lab_pin.sym} 2460 29440 0 0 {name=l23584 lab=VDD}
N 2440 29360 2460 29360 {}
C {lab_pin.sym} 2460 29360 0 0 {name=l23585 lab=VSS}
C {bitcell_6t.sym} 2600 29400 0 0 {name=Xr147c13}
N 2560 29440 2540 29440 {}
C {lab_pin.sym} 2540 29440 0 0 {name=l23586 lab=BL13}
N 2560 29400 2540 29400 {}
C {lab_pin.sym} 2540 29400 0 0 {name=l23587 lab=BLB13}
N 2560 29360 2540 29360 {}
C {lab_pin.sym} 2540 29360 0 0 {name=l23588 lab=WL147}
N 2640 29440 2660 29440 {}
C {lab_pin.sym} 2660 29440 0 0 {name=l23589 lab=VDD}
N 2640 29360 2660 29360 {}
C {lab_pin.sym} 2660 29360 0 0 {name=l23590 lab=VSS}
C {bitcell_6t.sym} 2800 29400 0 0 {name=Xr147c14}
N 2760 29440 2740 29440 {}
C {lab_pin.sym} 2740 29440 0 0 {name=l23591 lab=BL14}
N 2760 29400 2740 29400 {}
C {lab_pin.sym} 2740 29400 0 0 {name=l23592 lab=BLB14}
N 2760 29360 2740 29360 {}
C {lab_pin.sym} 2740 29360 0 0 {name=l23593 lab=WL147}
N 2840 29440 2860 29440 {}
C {lab_pin.sym} 2860 29440 0 0 {name=l23594 lab=VDD}
N 2840 29360 2860 29360 {}
C {lab_pin.sym} 2860 29360 0 0 {name=l23595 lab=VSS}
C {bitcell_6t.sym} 3000 29400 0 0 {name=Xr147c15}
N 2960 29440 2940 29440 {}
C {lab_pin.sym} 2940 29440 0 0 {name=l23596 lab=BL15}
N 2960 29400 2940 29400 {}
C {lab_pin.sym} 2940 29400 0 0 {name=l23597 lab=BLB15}
N 2960 29360 2940 29360 {}
C {lab_pin.sym} 2940 29360 0 0 {name=l23598 lab=WL147}
N 3040 29440 3060 29440 {}
C {lab_pin.sym} 3060 29440 0 0 {name=l23599 lab=VDD}
N 3040 29360 3060 29360 {}
C {lab_pin.sym} 3060 29360 0 0 {name=l23600 lab=VSS}
C {bitcell_6t.sym} 3200 29400 0 0 {name=Xr147c16}
N 3160 29440 3140 29440 {}
C {lab_pin.sym} 3140 29440 0 0 {name=l23601 lab=BL16}
N 3160 29400 3140 29400 {}
C {lab_pin.sym} 3140 29400 0 0 {name=l23602 lab=BLB16}
N 3160 29360 3140 29360 {}
C {lab_pin.sym} 3140 29360 0 0 {name=l23603 lab=WL147}
N 3240 29440 3260 29440 {}
C {lab_pin.sym} 3260 29440 0 0 {name=l23604 lab=VDD}
N 3240 29360 3260 29360 {}
C {lab_pin.sym} 3260 29360 0 0 {name=l23605 lab=VSS}
C {bitcell_6t.sym} 3400 29400 0 0 {name=Xr147c17}
N 3360 29440 3340 29440 {}
C {lab_pin.sym} 3340 29440 0 0 {name=l23606 lab=BL17}
N 3360 29400 3340 29400 {}
C {lab_pin.sym} 3340 29400 0 0 {name=l23607 lab=BLB17}
N 3360 29360 3340 29360 {}
C {lab_pin.sym} 3340 29360 0 0 {name=l23608 lab=WL147}
N 3440 29440 3460 29440 {}
C {lab_pin.sym} 3460 29440 0 0 {name=l23609 lab=VDD}
N 3440 29360 3460 29360 {}
C {lab_pin.sym} 3460 29360 0 0 {name=l23610 lab=VSS}
C {bitcell_6t.sym} 3600 29400 0 0 {name=Xr147c18}
N 3560 29440 3540 29440 {}
C {lab_pin.sym} 3540 29440 0 0 {name=l23611 lab=BL18}
N 3560 29400 3540 29400 {}
C {lab_pin.sym} 3540 29400 0 0 {name=l23612 lab=BLB18}
N 3560 29360 3540 29360 {}
C {lab_pin.sym} 3540 29360 0 0 {name=l23613 lab=WL147}
N 3640 29440 3660 29440 {}
C {lab_pin.sym} 3660 29440 0 0 {name=l23614 lab=VDD}
N 3640 29360 3660 29360 {}
C {lab_pin.sym} 3660 29360 0 0 {name=l23615 lab=VSS}
C {bitcell_6t.sym} 3800 29400 0 0 {name=Xr147c19}
N 3760 29440 3740 29440 {}
C {lab_pin.sym} 3740 29440 0 0 {name=l23616 lab=BL19}
N 3760 29400 3740 29400 {}
C {lab_pin.sym} 3740 29400 0 0 {name=l23617 lab=BLB19}
N 3760 29360 3740 29360 {}
C {lab_pin.sym} 3740 29360 0 0 {name=l23618 lab=WL147}
N 3840 29440 3860 29440 {}
C {lab_pin.sym} 3860 29440 0 0 {name=l23619 lab=VDD}
N 3840 29360 3860 29360 {}
C {lab_pin.sym} 3860 29360 0 0 {name=l23620 lab=VSS}
C {bitcell_6t.sym} 4000 29400 0 0 {name=Xr147c20}
N 3960 29440 3940 29440 {}
C {lab_pin.sym} 3940 29440 0 0 {name=l23621 lab=BL20}
N 3960 29400 3940 29400 {}
C {lab_pin.sym} 3940 29400 0 0 {name=l23622 lab=BLB20}
N 3960 29360 3940 29360 {}
C {lab_pin.sym} 3940 29360 0 0 {name=l23623 lab=WL147}
N 4040 29440 4060 29440 {}
C {lab_pin.sym} 4060 29440 0 0 {name=l23624 lab=VDD}
N 4040 29360 4060 29360 {}
C {lab_pin.sym} 4060 29360 0 0 {name=l23625 lab=VSS}
C {bitcell_6t.sym} 4200 29400 0 0 {name=Xr147c21}
N 4160 29440 4140 29440 {}
C {lab_pin.sym} 4140 29440 0 0 {name=l23626 lab=BL21}
N 4160 29400 4140 29400 {}
C {lab_pin.sym} 4140 29400 0 0 {name=l23627 lab=BLB21}
N 4160 29360 4140 29360 {}
C {lab_pin.sym} 4140 29360 0 0 {name=l23628 lab=WL147}
N 4240 29440 4260 29440 {}
C {lab_pin.sym} 4260 29440 0 0 {name=l23629 lab=VDD}
N 4240 29360 4260 29360 {}
C {lab_pin.sym} 4260 29360 0 0 {name=l23630 lab=VSS}
C {bitcell_6t.sym} 4400 29400 0 0 {name=Xr147c22}
N 4360 29440 4340 29440 {}
C {lab_pin.sym} 4340 29440 0 0 {name=l23631 lab=BL22}
N 4360 29400 4340 29400 {}
C {lab_pin.sym} 4340 29400 0 0 {name=l23632 lab=BLB22}
N 4360 29360 4340 29360 {}
C {lab_pin.sym} 4340 29360 0 0 {name=l23633 lab=WL147}
N 4440 29440 4460 29440 {}
C {lab_pin.sym} 4460 29440 0 0 {name=l23634 lab=VDD}
N 4440 29360 4460 29360 {}
C {lab_pin.sym} 4460 29360 0 0 {name=l23635 lab=VSS}
C {bitcell_6t.sym} 4600 29400 0 0 {name=Xr147c23}
N 4560 29440 4540 29440 {}
C {lab_pin.sym} 4540 29440 0 0 {name=l23636 lab=BL23}
N 4560 29400 4540 29400 {}
C {lab_pin.sym} 4540 29400 0 0 {name=l23637 lab=BLB23}
N 4560 29360 4540 29360 {}
C {lab_pin.sym} 4540 29360 0 0 {name=l23638 lab=WL147}
N 4640 29440 4660 29440 {}
C {lab_pin.sym} 4660 29440 0 0 {name=l23639 lab=VDD}
N 4640 29360 4660 29360 {}
C {lab_pin.sym} 4660 29360 0 0 {name=l23640 lab=VSS}
C {bitcell_6t.sym} 4800 29400 0 0 {name=Xr147c24}
N 4760 29440 4740 29440 {}
C {lab_pin.sym} 4740 29440 0 0 {name=l23641 lab=BL24}
N 4760 29400 4740 29400 {}
C {lab_pin.sym} 4740 29400 0 0 {name=l23642 lab=BLB24}
N 4760 29360 4740 29360 {}
C {lab_pin.sym} 4740 29360 0 0 {name=l23643 lab=WL147}
N 4840 29440 4860 29440 {}
C {lab_pin.sym} 4860 29440 0 0 {name=l23644 lab=VDD}
N 4840 29360 4860 29360 {}
C {lab_pin.sym} 4860 29360 0 0 {name=l23645 lab=VSS}
C {bitcell_6t.sym} 5000 29400 0 0 {name=Xr147c25}
N 4960 29440 4940 29440 {}
C {lab_pin.sym} 4940 29440 0 0 {name=l23646 lab=BL25}
N 4960 29400 4940 29400 {}
C {lab_pin.sym} 4940 29400 0 0 {name=l23647 lab=BLB25}
N 4960 29360 4940 29360 {}
C {lab_pin.sym} 4940 29360 0 0 {name=l23648 lab=WL147}
N 5040 29440 5060 29440 {}
C {lab_pin.sym} 5060 29440 0 0 {name=l23649 lab=VDD}
N 5040 29360 5060 29360 {}
C {lab_pin.sym} 5060 29360 0 0 {name=l23650 lab=VSS}
C {bitcell_6t.sym} 5200 29400 0 0 {name=Xr147c26}
N 5160 29440 5140 29440 {}
C {lab_pin.sym} 5140 29440 0 0 {name=l23651 lab=BL26}
N 5160 29400 5140 29400 {}
C {lab_pin.sym} 5140 29400 0 0 {name=l23652 lab=BLB26}
N 5160 29360 5140 29360 {}
C {lab_pin.sym} 5140 29360 0 0 {name=l23653 lab=WL147}
N 5240 29440 5260 29440 {}
C {lab_pin.sym} 5260 29440 0 0 {name=l23654 lab=VDD}
N 5240 29360 5260 29360 {}
C {lab_pin.sym} 5260 29360 0 0 {name=l23655 lab=VSS}
C {bitcell_6t.sym} 5400 29400 0 0 {name=Xr147c27}
N 5360 29440 5340 29440 {}
C {lab_pin.sym} 5340 29440 0 0 {name=l23656 lab=BL27}
N 5360 29400 5340 29400 {}
C {lab_pin.sym} 5340 29400 0 0 {name=l23657 lab=BLB27}
N 5360 29360 5340 29360 {}
C {lab_pin.sym} 5340 29360 0 0 {name=l23658 lab=WL147}
N 5440 29440 5460 29440 {}
C {lab_pin.sym} 5460 29440 0 0 {name=l23659 lab=VDD}
N 5440 29360 5460 29360 {}
C {lab_pin.sym} 5460 29360 0 0 {name=l23660 lab=VSS}
C {bitcell_6t.sym} 5600 29400 0 0 {name=Xr147c28}
N 5560 29440 5540 29440 {}
C {lab_pin.sym} 5540 29440 0 0 {name=l23661 lab=BL28}
N 5560 29400 5540 29400 {}
C {lab_pin.sym} 5540 29400 0 0 {name=l23662 lab=BLB28}
N 5560 29360 5540 29360 {}
C {lab_pin.sym} 5540 29360 0 0 {name=l23663 lab=WL147}
N 5640 29440 5660 29440 {}
C {lab_pin.sym} 5660 29440 0 0 {name=l23664 lab=VDD}
N 5640 29360 5660 29360 {}
C {lab_pin.sym} 5660 29360 0 0 {name=l23665 lab=VSS}
C {bitcell_6t.sym} 5800 29400 0 0 {name=Xr147c29}
N 5760 29440 5740 29440 {}
C {lab_pin.sym} 5740 29440 0 0 {name=l23666 lab=BL29}
N 5760 29400 5740 29400 {}
C {lab_pin.sym} 5740 29400 0 0 {name=l23667 lab=BLB29}
N 5760 29360 5740 29360 {}
C {lab_pin.sym} 5740 29360 0 0 {name=l23668 lab=WL147}
N 5840 29440 5860 29440 {}
C {lab_pin.sym} 5860 29440 0 0 {name=l23669 lab=VDD}
N 5840 29360 5860 29360 {}
C {lab_pin.sym} 5860 29360 0 0 {name=l23670 lab=VSS}
C {bitcell_6t.sym} 6000 29400 0 0 {name=Xr147c30}
N 5960 29440 5940 29440 {}
C {lab_pin.sym} 5940 29440 0 0 {name=l23671 lab=BL30}
N 5960 29400 5940 29400 {}
C {lab_pin.sym} 5940 29400 0 0 {name=l23672 lab=BLB30}
N 5960 29360 5940 29360 {}
C {lab_pin.sym} 5940 29360 0 0 {name=l23673 lab=WL147}
N 6040 29440 6060 29440 {}
C {lab_pin.sym} 6060 29440 0 0 {name=l23674 lab=VDD}
N 6040 29360 6060 29360 {}
C {lab_pin.sym} 6060 29360 0 0 {name=l23675 lab=VSS}
C {bitcell_6t.sym} 6200 29400 0 0 {name=Xr147c31}
N 6160 29440 6140 29440 {}
C {lab_pin.sym} 6140 29440 0 0 {name=l23676 lab=BL31}
N 6160 29400 6140 29400 {}
C {lab_pin.sym} 6140 29400 0 0 {name=l23677 lab=BLB31}
N 6160 29360 6140 29360 {}
C {lab_pin.sym} 6140 29360 0 0 {name=l23678 lab=WL147}
N 6240 29440 6260 29440 {}
C {lab_pin.sym} 6260 29440 0 0 {name=l23679 lab=VDD}
N 6240 29360 6260 29360 {}
C {lab_pin.sym} 6260 29360 0 0 {name=l23680 lab=VSS}
C {bitcell_6t.sym} 0 29600 0 0 {name=Xr148c0}
N -40 29640 -60 29640 {}
C {lab_pin.sym} -60 29640 0 0 {name=l23681 lab=BL0}
N -40 29600 -60 29600 {}
C {lab_pin.sym} -60 29600 0 0 {name=l23682 lab=BLB0}
N -40 29560 -60 29560 {}
C {lab_pin.sym} -60 29560 0 0 {name=l23683 lab=WL148}
N 40 29640 60 29640 {}
C {lab_pin.sym} 60 29640 0 0 {name=l23684 lab=VDD}
N 40 29560 60 29560 {}
C {lab_pin.sym} 60 29560 0 0 {name=l23685 lab=VSS}
C {bitcell_6t.sym} 200 29600 0 0 {name=Xr148c1}
N 160 29640 140 29640 {}
C {lab_pin.sym} 140 29640 0 0 {name=l23686 lab=BL1}
N 160 29600 140 29600 {}
C {lab_pin.sym} 140 29600 0 0 {name=l23687 lab=BLB1}
N 160 29560 140 29560 {}
C {lab_pin.sym} 140 29560 0 0 {name=l23688 lab=WL148}
N 240 29640 260 29640 {}
C {lab_pin.sym} 260 29640 0 0 {name=l23689 lab=VDD}
N 240 29560 260 29560 {}
C {lab_pin.sym} 260 29560 0 0 {name=l23690 lab=VSS}
C {bitcell_6t.sym} 400 29600 0 0 {name=Xr148c2}
N 360 29640 340 29640 {}
C {lab_pin.sym} 340 29640 0 0 {name=l23691 lab=BL2}
N 360 29600 340 29600 {}
C {lab_pin.sym} 340 29600 0 0 {name=l23692 lab=BLB2}
N 360 29560 340 29560 {}
C {lab_pin.sym} 340 29560 0 0 {name=l23693 lab=WL148}
N 440 29640 460 29640 {}
C {lab_pin.sym} 460 29640 0 0 {name=l23694 lab=VDD}
N 440 29560 460 29560 {}
C {lab_pin.sym} 460 29560 0 0 {name=l23695 lab=VSS}
C {bitcell_6t.sym} 600 29600 0 0 {name=Xr148c3}
N 560 29640 540 29640 {}
C {lab_pin.sym} 540 29640 0 0 {name=l23696 lab=BL3}
N 560 29600 540 29600 {}
C {lab_pin.sym} 540 29600 0 0 {name=l23697 lab=BLB3}
N 560 29560 540 29560 {}
C {lab_pin.sym} 540 29560 0 0 {name=l23698 lab=WL148}
N 640 29640 660 29640 {}
C {lab_pin.sym} 660 29640 0 0 {name=l23699 lab=VDD}
N 640 29560 660 29560 {}
C {lab_pin.sym} 660 29560 0 0 {name=l23700 lab=VSS}
C {bitcell_6t.sym} 800 29600 0 0 {name=Xr148c4}
N 760 29640 740 29640 {}
C {lab_pin.sym} 740 29640 0 0 {name=l23701 lab=BL4}
N 760 29600 740 29600 {}
C {lab_pin.sym} 740 29600 0 0 {name=l23702 lab=BLB4}
N 760 29560 740 29560 {}
C {lab_pin.sym} 740 29560 0 0 {name=l23703 lab=WL148}
N 840 29640 860 29640 {}
C {lab_pin.sym} 860 29640 0 0 {name=l23704 lab=VDD}
N 840 29560 860 29560 {}
C {lab_pin.sym} 860 29560 0 0 {name=l23705 lab=VSS}
C {bitcell_6t.sym} 1000 29600 0 0 {name=Xr148c5}
N 960 29640 940 29640 {}
C {lab_pin.sym} 940 29640 0 0 {name=l23706 lab=BL5}
N 960 29600 940 29600 {}
C {lab_pin.sym} 940 29600 0 0 {name=l23707 lab=BLB5}
N 960 29560 940 29560 {}
C {lab_pin.sym} 940 29560 0 0 {name=l23708 lab=WL148}
N 1040 29640 1060 29640 {}
C {lab_pin.sym} 1060 29640 0 0 {name=l23709 lab=VDD}
N 1040 29560 1060 29560 {}
C {lab_pin.sym} 1060 29560 0 0 {name=l23710 lab=VSS}
C {bitcell_6t.sym} 1200 29600 0 0 {name=Xr148c6}
N 1160 29640 1140 29640 {}
C {lab_pin.sym} 1140 29640 0 0 {name=l23711 lab=BL6}
N 1160 29600 1140 29600 {}
C {lab_pin.sym} 1140 29600 0 0 {name=l23712 lab=BLB6}
N 1160 29560 1140 29560 {}
C {lab_pin.sym} 1140 29560 0 0 {name=l23713 lab=WL148}
N 1240 29640 1260 29640 {}
C {lab_pin.sym} 1260 29640 0 0 {name=l23714 lab=VDD}
N 1240 29560 1260 29560 {}
C {lab_pin.sym} 1260 29560 0 0 {name=l23715 lab=VSS}
C {bitcell_6t.sym} 1400 29600 0 0 {name=Xr148c7}
N 1360 29640 1340 29640 {}
C {lab_pin.sym} 1340 29640 0 0 {name=l23716 lab=BL7}
N 1360 29600 1340 29600 {}
C {lab_pin.sym} 1340 29600 0 0 {name=l23717 lab=BLB7}
N 1360 29560 1340 29560 {}
C {lab_pin.sym} 1340 29560 0 0 {name=l23718 lab=WL148}
N 1440 29640 1460 29640 {}
C {lab_pin.sym} 1460 29640 0 0 {name=l23719 lab=VDD}
N 1440 29560 1460 29560 {}
C {lab_pin.sym} 1460 29560 0 0 {name=l23720 lab=VSS}
C {bitcell_6t.sym} 1600 29600 0 0 {name=Xr148c8}
N 1560 29640 1540 29640 {}
C {lab_pin.sym} 1540 29640 0 0 {name=l23721 lab=BL8}
N 1560 29600 1540 29600 {}
C {lab_pin.sym} 1540 29600 0 0 {name=l23722 lab=BLB8}
N 1560 29560 1540 29560 {}
C {lab_pin.sym} 1540 29560 0 0 {name=l23723 lab=WL148}
N 1640 29640 1660 29640 {}
C {lab_pin.sym} 1660 29640 0 0 {name=l23724 lab=VDD}
N 1640 29560 1660 29560 {}
C {lab_pin.sym} 1660 29560 0 0 {name=l23725 lab=VSS}
C {bitcell_6t.sym} 1800 29600 0 0 {name=Xr148c9}
N 1760 29640 1740 29640 {}
C {lab_pin.sym} 1740 29640 0 0 {name=l23726 lab=BL9}
N 1760 29600 1740 29600 {}
C {lab_pin.sym} 1740 29600 0 0 {name=l23727 lab=BLB9}
N 1760 29560 1740 29560 {}
C {lab_pin.sym} 1740 29560 0 0 {name=l23728 lab=WL148}
N 1840 29640 1860 29640 {}
C {lab_pin.sym} 1860 29640 0 0 {name=l23729 lab=VDD}
N 1840 29560 1860 29560 {}
C {lab_pin.sym} 1860 29560 0 0 {name=l23730 lab=VSS}
C {bitcell_6t.sym} 2000 29600 0 0 {name=Xr148c10}
N 1960 29640 1940 29640 {}
C {lab_pin.sym} 1940 29640 0 0 {name=l23731 lab=BL10}
N 1960 29600 1940 29600 {}
C {lab_pin.sym} 1940 29600 0 0 {name=l23732 lab=BLB10}
N 1960 29560 1940 29560 {}
C {lab_pin.sym} 1940 29560 0 0 {name=l23733 lab=WL148}
N 2040 29640 2060 29640 {}
C {lab_pin.sym} 2060 29640 0 0 {name=l23734 lab=VDD}
N 2040 29560 2060 29560 {}
C {lab_pin.sym} 2060 29560 0 0 {name=l23735 lab=VSS}
C {bitcell_6t.sym} 2200 29600 0 0 {name=Xr148c11}
N 2160 29640 2140 29640 {}
C {lab_pin.sym} 2140 29640 0 0 {name=l23736 lab=BL11}
N 2160 29600 2140 29600 {}
C {lab_pin.sym} 2140 29600 0 0 {name=l23737 lab=BLB11}
N 2160 29560 2140 29560 {}
C {lab_pin.sym} 2140 29560 0 0 {name=l23738 lab=WL148}
N 2240 29640 2260 29640 {}
C {lab_pin.sym} 2260 29640 0 0 {name=l23739 lab=VDD}
N 2240 29560 2260 29560 {}
C {lab_pin.sym} 2260 29560 0 0 {name=l23740 lab=VSS}
C {bitcell_6t.sym} 2400 29600 0 0 {name=Xr148c12}
N 2360 29640 2340 29640 {}
C {lab_pin.sym} 2340 29640 0 0 {name=l23741 lab=BL12}
N 2360 29600 2340 29600 {}
C {lab_pin.sym} 2340 29600 0 0 {name=l23742 lab=BLB12}
N 2360 29560 2340 29560 {}
C {lab_pin.sym} 2340 29560 0 0 {name=l23743 lab=WL148}
N 2440 29640 2460 29640 {}
C {lab_pin.sym} 2460 29640 0 0 {name=l23744 lab=VDD}
N 2440 29560 2460 29560 {}
C {lab_pin.sym} 2460 29560 0 0 {name=l23745 lab=VSS}
C {bitcell_6t.sym} 2600 29600 0 0 {name=Xr148c13}
N 2560 29640 2540 29640 {}
C {lab_pin.sym} 2540 29640 0 0 {name=l23746 lab=BL13}
N 2560 29600 2540 29600 {}
C {lab_pin.sym} 2540 29600 0 0 {name=l23747 lab=BLB13}
N 2560 29560 2540 29560 {}
C {lab_pin.sym} 2540 29560 0 0 {name=l23748 lab=WL148}
N 2640 29640 2660 29640 {}
C {lab_pin.sym} 2660 29640 0 0 {name=l23749 lab=VDD}
N 2640 29560 2660 29560 {}
C {lab_pin.sym} 2660 29560 0 0 {name=l23750 lab=VSS}
C {bitcell_6t.sym} 2800 29600 0 0 {name=Xr148c14}
N 2760 29640 2740 29640 {}
C {lab_pin.sym} 2740 29640 0 0 {name=l23751 lab=BL14}
N 2760 29600 2740 29600 {}
C {lab_pin.sym} 2740 29600 0 0 {name=l23752 lab=BLB14}
N 2760 29560 2740 29560 {}
C {lab_pin.sym} 2740 29560 0 0 {name=l23753 lab=WL148}
N 2840 29640 2860 29640 {}
C {lab_pin.sym} 2860 29640 0 0 {name=l23754 lab=VDD}
N 2840 29560 2860 29560 {}
C {lab_pin.sym} 2860 29560 0 0 {name=l23755 lab=VSS}
C {bitcell_6t.sym} 3000 29600 0 0 {name=Xr148c15}
N 2960 29640 2940 29640 {}
C {lab_pin.sym} 2940 29640 0 0 {name=l23756 lab=BL15}
N 2960 29600 2940 29600 {}
C {lab_pin.sym} 2940 29600 0 0 {name=l23757 lab=BLB15}
N 2960 29560 2940 29560 {}
C {lab_pin.sym} 2940 29560 0 0 {name=l23758 lab=WL148}
N 3040 29640 3060 29640 {}
C {lab_pin.sym} 3060 29640 0 0 {name=l23759 lab=VDD}
N 3040 29560 3060 29560 {}
C {lab_pin.sym} 3060 29560 0 0 {name=l23760 lab=VSS}
C {bitcell_6t.sym} 3200 29600 0 0 {name=Xr148c16}
N 3160 29640 3140 29640 {}
C {lab_pin.sym} 3140 29640 0 0 {name=l23761 lab=BL16}
N 3160 29600 3140 29600 {}
C {lab_pin.sym} 3140 29600 0 0 {name=l23762 lab=BLB16}
N 3160 29560 3140 29560 {}
C {lab_pin.sym} 3140 29560 0 0 {name=l23763 lab=WL148}
N 3240 29640 3260 29640 {}
C {lab_pin.sym} 3260 29640 0 0 {name=l23764 lab=VDD}
N 3240 29560 3260 29560 {}
C {lab_pin.sym} 3260 29560 0 0 {name=l23765 lab=VSS}
C {bitcell_6t.sym} 3400 29600 0 0 {name=Xr148c17}
N 3360 29640 3340 29640 {}
C {lab_pin.sym} 3340 29640 0 0 {name=l23766 lab=BL17}
N 3360 29600 3340 29600 {}
C {lab_pin.sym} 3340 29600 0 0 {name=l23767 lab=BLB17}
N 3360 29560 3340 29560 {}
C {lab_pin.sym} 3340 29560 0 0 {name=l23768 lab=WL148}
N 3440 29640 3460 29640 {}
C {lab_pin.sym} 3460 29640 0 0 {name=l23769 lab=VDD}
N 3440 29560 3460 29560 {}
C {lab_pin.sym} 3460 29560 0 0 {name=l23770 lab=VSS}
C {bitcell_6t.sym} 3600 29600 0 0 {name=Xr148c18}
N 3560 29640 3540 29640 {}
C {lab_pin.sym} 3540 29640 0 0 {name=l23771 lab=BL18}
N 3560 29600 3540 29600 {}
C {lab_pin.sym} 3540 29600 0 0 {name=l23772 lab=BLB18}
N 3560 29560 3540 29560 {}
C {lab_pin.sym} 3540 29560 0 0 {name=l23773 lab=WL148}
N 3640 29640 3660 29640 {}
C {lab_pin.sym} 3660 29640 0 0 {name=l23774 lab=VDD}
N 3640 29560 3660 29560 {}
C {lab_pin.sym} 3660 29560 0 0 {name=l23775 lab=VSS}
C {bitcell_6t.sym} 3800 29600 0 0 {name=Xr148c19}
N 3760 29640 3740 29640 {}
C {lab_pin.sym} 3740 29640 0 0 {name=l23776 lab=BL19}
N 3760 29600 3740 29600 {}
C {lab_pin.sym} 3740 29600 0 0 {name=l23777 lab=BLB19}
N 3760 29560 3740 29560 {}
C {lab_pin.sym} 3740 29560 0 0 {name=l23778 lab=WL148}
N 3840 29640 3860 29640 {}
C {lab_pin.sym} 3860 29640 0 0 {name=l23779 lab=VDD}
N 3840 29560 3860 29560 {}
C {lab_pin.sym} 3860 29560 0 0 {name=l23780 lab=VSS}
C {bitcell_6t.sym} 4000 29600 0 0 {name=Xr148c20}
N 3960 29640 3940 29640 {}
C {lab_pin.sym} 3940 29640 0 0 {name=l23781 lab=BL20}
N 3960 29600 3940 29600 {}
C {lab_pin.sym} 3940 29600 0 0 {name=l23782 lab=BLB20}
N 3960 29560 3940 29560 {}
C {lab_pin.sym} 3940 29560 0 0 {name=l23783 lab=WL148}
N 4040 29640 4060 29640 {}
C {lab_pin.sym} 4060 29640 0 0 {name=l23784 lab=VDD}
N 4040 29560 4060 29560 {}
C {lab_pin.sym} 4060 29560 0 0 {name=l23785 lab=VSS}
C {bitcell_6t.sym} 4200 29600 0 0 {name=Xr148c21}
N 4160 29640 4140 29640 {}
C {lab_pin.sym} 4140 29640 0 0 {name=l23786 lab=BL21}
N 4160 29600 4140 29600 {}
C {lab_pin.sym} 4140 29600 0 0 {name=l23787 lab=BLB21}
N 4160 29560 4140 29560 {}
C {lab_pin.sym} 4140 29560 0 0 {name=l23788 lab=WL148}
N 4240 29640 4260 29640 {}
C {lab_pin.sym} 4260 29640 0 0 {name=l23789 lab=VDD}
N 4240 29560 4260 29560 {}
C {lab_pin.sym} 4260 29560 0 0 {name=l23790 lab=VSS}
C {bitcell_6t.sym} 4400 29600 0 0 {name=Xr148c22}
N 4360 29640 4340 29640 {}
C {lab_pin.sym} 4340 29640 0 0 {name=l23791 lab=BL22}
N 4360 29600 4340 29600 {}
C {lab_pin.sym} 4340 29600 0 0 {name=l23792 lab=BLB22}
N 4360 29560 4340 29560 {}
C {lab_pin.sym} 4340 29560 0 0 {name=l23793 lab=WL148}
N 4440 29640 4460 29640 {}
C {lab_pin.sym} 4460 29640 0 0 {name=l23794 lab=VDD}
N 4440 29560 4460 29560 {}
C {lab_pin.sym} 4460 29560 0 0 {name=l23795 lab=VSS}
C {bitcell_6t.sym} 4600 29600 0 0 {name=Xr148c23}
N 4560 29640 4540 29640 {}
C {lab_pin.sym} 4540 29640 0 0 {name=l23796 lab=BL23}
N 4560 29600 4540 29600 {}
C {lab_pin.sym} 4540 29600 0 0 {name=l23797 lab=BLB23}
N 4560 29560 4540 29560 {}
C {lab_pin.sym} 4540 29560 0 0 {name=l23798 lab=WL148}
N 4640 29640 4660 29640 {}
C {lab_pin.sym} 4660 29640 0 0 {name=l23799 lab=VDD}
N 4640 29560 4660 29560 {}
C {lab_pin.sym} 4660 29560 0 0 {name=l23800 lab=VSS}
C {bitcell_6t.sym} 4800 29600 0 0 {name=Xr148c24}
N 4760 29640 4740 29640 {}
C {lab_pin.sym} 4740 29640 0 0 {name=l23801 lab=BL24}
N 4760 29600 4740 29600 {}
C {lab_pin.sym} 4740 29600 0 0 {name=l23802 lab=BLB24}
N 4760 29560 4740 29560 {}
C {lab_pin.sym} 4740 29560 0 0 {name=l23803 lab=WL148}
N 4840 29640 4860 29640 {}
C {lab_pin.sym} 4860 29640 0 0 {name=l23804 lab=VDD}
N 4840 29560 4860 29560 {}
C {lab_pin.sym} 4860 29560 0 0 {name=l23805 lab=VSS}
C {bitcell_6t.sym} 5000 29600 0 0 {name=Xr148c25}
N 4960 29640 4940 29640 {}
C {lab_pin.sym} 4940 29640 0 0 {name=l23806 lab=BL25}
N 4960 29600 4940 29600 {}
C {lab_pin.sym} 4940 29600 0 0 {name=l23807 lab=BLB25}
N 4960 29560 4940 29560 {}
C {lab_pin.sym} 4940 29560 0 0 {name=l23808 lab=WL148}
N 5040 29640 5060 29640 {}
C {lab_pin.sym} 5060 29640 0 0 {name=l23809 lab=VDD}
N 5040 29560 5060 29560 {}
C {lab_pin.sym} 5060 29560 0 0 {name=l23810 lab=VSS}
C {bitcell_6t.sym} 5200 29600 0 0 {name=Xr148c26}
N 5160 29640 5140 29640 {}
C {lab_pin.sym} 5140 29640 0 0 {name=l23811 lab=BL26}
N 5160 29600 5140 29600 {}
C {lab_pin.sym} 5140 29600 0 0 {name=l23812 lab=BLB26}
N 5160 29560 5140 29560 {}
C {lab_pin.sym} 5140 29560 0 0 {name=l23813 lab=WL148}
N 5240 29640 5260 29640 {}
C {lab_pin.sym} 5260 29640 0 0 {name=l23814 lab=VDD}
N 5240 29560 5260 29560 {}
C {lab_pin.sym} 5260 29560 0 0 {name=l23815 lab=VSS}
C {bitcell_6t.sym} 5400 29600 0 0 {name=Xr148c27}
N 5360 29640 5340 29640 {}
C {lab_pin.sym} 5340 29640 0 0 {name=l23816 lab=BL27}
N 5360 29600 5340 29600 {}
C {lab_pin.sym} 5340 29600 0 0 {name=l23817 lab=BLB27}
N 5360 29560 5340 29560 {}
C {lab_pin.sym} 5340 29560 0 0 {name=l23818 lab=WL148}
N 5440 29640 5460 29640 {}
C {lab_pin.sym} 5460 29640 0 0 {name=l23819 lab=VDD}
N 5440 29560 5460 29560 {}
C {lab_pin.sym} 5460 29560 0 0 {name=l23820 lab=VSS}
C {bitcell_6t.sym} 5600 29600 0 0 {name=Xr148c28}
N 5560 29640 5540 29640 {}
C {lab_pin.sym} 5540 29640 0 0 {name=l23821 lab=BL28}
N 5560 29600 5540 29600 {}
C {lab_pin.sym} 5540 29600 0 0 {name=l23822 lab=BLB28}
N 5560 29560 5540 29560 {}
C {lab_pin.sym} 5540 29560 0 0 {name=l23823 lab=WL148}
N 5640 29640 5660 29640 {}
C {lab_pin.sym} 5660 29640 0 0 {name=l23824 lab=VDD}
N 5640 29560 5660 29560 {}
C {lab_pin.sym} 5660 29560 0 0 {name=l23825 lab=VSS}
C {bitcell_6t.sym} 5800 29600 0 0 {name=Xr148c29}
N 5760 29640 5740 29640 {}
C {lab_pin.sym} 5740 29640 0 0 {name=l23826 lab=BL29}
N 5760 29600 5740 29600 {}
C {lab_pin.sym} 5740 29600 0 0 {name=l23827 lab=BLB29}
N 5760 29560 5740 29560 {}
C {lab_pin.sym} 5740 29560 0 0 {name=l23828 lab=WL148}
N 5840 29640 5860 29640 {}
C {lab_pin.sym} 5860 29640 0 0 {name=l23829 lab=VDD}
N 5840 29560 5860 29560 {}
C {lab_pin.sym} 5860 29560 0 0 {name=l23830 lab=VSS}
C {bitcell_6t.sym} 6000 29600 0 0 {name=Xr148c30}
N 5960 29640 5940 29640 {}
C {lab_pin.sym} 5940 29640 0 0 {name=l23831 lab=BL30}
N 5960 29600 5940 29600 {}
C {lab_pin.sym} 5940 29600 0 0 {name=l23832 lab=BLB30}
N 5960 29560 5940 29560 {}
C {lab_pin.sym} 5940 29560 0 0 {name=l23833 lab=WL148}
N 6040 29640 6060 29640 {}
C {lab_pin.sym} 6060 29640 0 0 {name=l23834 lab=VDD}
N 6040 29560 6060 29560 {}
C {lab_pin.sym} 6060 29560 0 0 {name=l23835 lab=VSS}
C {bitcell_6t.sym} 6200 29600 0 0 {name=Xr148c31}
N 6160 29640 6140 29640 {}
C {lab_pin.sym} 6140 29640 0 0 {name=l23836 lab=BL31}
N 6160 29600 6140 29600 {}
C {lab_pin.sym} 6140 29600 0 0 {name=l23837 lab=BLB31}
N 6160 29560 6140 29560 {}
C {lab_pin.sym} 6140 29560 0 0 {name=l23838 lab=WL148}
N 6240 29640 6260 29640 {}
C {lab_pin.sym} 6260 29640 0 0 {name=l23839 lab=VDD}
N 6240 29560 6260 29560 {}
C {lab_pin.sym} 6260 29560 0 0 {name=l23840 lab=VSS}
C {bitcell_6t.sym} 0 29800 0 0 {name=Xr149c0}
N -40 29840 -60 29840 {}
C {lab_pin.sym} -60 29840 0 0 {name=l23841 lab=BL0}
N -40 29800 -60 29800 {}
C {lab_pin.sym} -60 29800 0 0 {name=l23842 lab=BLB0}
N -40 29760 -60 29760 {}
C {lab_pin.sym} -60 29760 0 0 {name=l23843 lab=WL149}
N 40 29840 60 29840 {}
C {lab_pin.sym} 60 29840 0 0 {name=l23844 lab=VDD}
N 40 29760 60 29760 {}
C {lab_pin.sym} 60 29760 0 0 {name=l23845 lab=VSS}
C {bitcell_6t.sym} 200 29800 0 0 {name=Xr149c1}
N 160 29840 140 29840 {}
C {lab_pin.sym} 140 29840 0 0 {name=l23846 lab=BL1}
N 160 29800 140 29800 {}
C {lab_pin.sym} 140 29800 0 0 {name=l23847 lab=BLB1}
N 160 29760 140 29760 {}
C {lab_pin.sym} 140 29760 0 0 {name=l23848 lab=WL149}
N 240 29840 260 29840 {}
C {lab_pin.sym} 260 29840 0 0 {name=l23849 lab=VDD}
N 240 29760 260 29760 {}
C {lab_pin.sym} 260 29760 0 0 {name=l23850 lab=VSS}
C {bitcell_6t.sym} 400 29800 0 0 {name=Xr149c2}
N 360 29840 340 29840 {}
C {lab_pin.sym} 340 29840 0 0 {name=l23851 lab=BL2}
N 360 29800 340 29800 {}
C {lab_pin.sym} 340 29800 0 0 {name=l23852 lab=BLB2}
N 360 29760 340 29760 {}
C {lab_pin.sym} 340 29760 0 0 {name=l23853 lab=WL149}
N 440 29840 460 29840 {}
C {lab_pin.sym} 460 29840 0 0 {name=l23854 lab=VDD}
N 440 29760 460 29760 {}
C {lab_pin.sym} 460 29760 0 0 {name=l23855 lab=VSS}
C {bitcell_6t.sym} 600 29800 0 0 {name=Xr149c3}
N 560 29840 540 29840 {}
C {lab_pin.sym} 540 29840 0 0 {name=l23856 lab=BL3}
N 560 29800 540 29800 {}
C {lab_pin.sym} 540 29800 0 0 {name=l23857 lab=BLB3}
N 560 29760 540 29760 {}
C {lab_pin.sym} 540 29760 0 0 {name=l23858 lab=WL149}
N 640 29840 660 29840 {}
C {lab_pin.sym} 660 29840 0 0 {name=l23859 lab=VDD}
N 640 29760 660 29760 {}
C {lab_pin.sym} 660 29760 0 0 {name=l23860 lab=VSS}
C {bitcell_6t.sym} 800 29800 0 0 {name=Xr149c4}
N 760 29840 740 29840 {}
C {lab_pin.sym} 740 29840 0 0 {name=l23861 lab=BL4}
N 760 29800 740 29800 {}
C {lab_pin.sym} 740 29800 0 0 {name=l23862 lab=BLB4}
N 760 29760 740 29760 {}
C {lab_pin.sym} 740 29760 0 0 {name=l23863 lab=WL149}
N 840 29840 860 29840 {}
C {lab_pin.sym} 860 29840 0 0 {name=l23864 lab=VDD}
N 840 29760 860 29760 {}
C {lab_pin.sym} 860 29760 0 0 {name=l23865 lab=VSS}
C {bitcell_6t.sym} 1000 29800 0 0 {name=Xr149c5}
N 960 29840 940 29840 {}
C {lab_pin.sym} 940 29840 0 0 {name=l23866 lab=BL5}
N 960 29800 940 29800 {}
C {lab_pin.sym} 940 29800 0 0 {name=l23867 lab=BLB5}
N 960 29760 940 29760 {}
C {lab_pin.sym} 940 29760 0 0 {name=l23868 lab=WL149}
N 1040 29840 1060 29840 {}
C {lab_pin.sym} 1060 29840 0 0 {name=l23869 lab=VDD}
N 1040 29760 1060 29760 {}
C {lab_pin.sym} 1060 29760 0 0 {name=l23870 lab=VSS}
C {bitcell_6t.sym} 1200 29800 0 0 {name=Xr149c6}
N 1160 29840 1140 29840 {}
C {lab_pin.sym} 1140 29840 0 0 {name=l23871 lab=BL6}
N 1160 29800 1140 29800 {}
C {lab_pin.sym} 1140 29800 0 0 {name=l23872 lab=BLB6}
N 1160 29760 1140 29760 {}
C {lab_pin.sym} 1140 29760 0 0 {name=l23873 lab=WL149}
N 1240 29840 1260 29840 {}
C {lab_pin.sym} 1260 29840 0 0 {name=l23874 lab=VDD}
N 1240 29760 1260 29760 {}
C {lab_pin.sym} 1260 29760 0 0 {name=l23875 lab=VSS}
C {bitcell_6t.sym} 1400 29800 0 0 {name=Xr149c7}
N 1360 29840 1340 29840 {}
C {lab_pin.sym} 1340 29840 0 0 {name=l23876 lab=BL7}
N 1360 29800 1340 29800 {}
C {lab_pin.sym} 1340 29800 0 0 {name=l23877 lab=BLB7}
N 1360 29760 1340 29760 {}
C {lab_pin.sym} 1340 29760 0 0 {name=l23878 lab=WL149}
N 1440 29840 1460 29840 {}
C {lab_pin.sym} 1460 29840 0 0 {name=l23879 lab=VDD}
N 1440 29760 1460 29760 {}
C {lab_pin.sym} 1460 29760 0 0 {name=l23880 lab=VSS}
C {bitcell_6t.sym} 1600 29800 0 0 {name=Xr149c8}
N 1560 29840 1540 29840 {}
C {lab_pin.sym} 1540 29840 0 0 {name=l23881 lab=BL8}
N 1560 29800 1540 29800 {}
C {lab_pin.sym} 1540 29800 0 0 {name=l23882 lab=BLB8}
N 1560 29760 1540 29760 {}
C {lab_pin.sym} 1540 29760 0 0 {name=l23883 lab=WL149}
N 1640 29840 1660 29840 {}
C {lab_pin.sym} 1660 29840 0 0 {name=l23884 lab=VDD}
N 1640 29760 1660 29760 {}
C {lab_pin.sym} 1660 29760 0 0 {name=l23885 lab=VSS}
C {bitcell_6t.sym} 1800 29800 0 0 {name=Xr149c9}
N 1760 29840 1740 29840 {}
C {lab_pin.sym} 1740 29840 0 0 {name=l23886 lab=BL9}
N 1760 29800 1740 29800 {}
C {lab_pin.sym} 1740 29800 0 0 {name=l23887 lab=BLB9}
N 1760 29760 1740 29760 {}
C {lab_pin.sym} 1740 29760 0 0 {name=l23888 lab=WL149}
N 1840 29840 1860 29840 {}
C {lab_pin.sym} 1860 29840 0 0 {name=l23889 lab=VDD}
N 1840 29760 1860 29760 {}
C {lab_pin.sym} 1860 29760 0 0 {name=l23890 lab=VSS}
C {bitcell_6t.sym} 2000 29800 0 0 {name=Xr149c10}
N 1960 29840 1940 29840 {}
C {lab_pin.sym} 1940 29840 0 0 {name=l23891 lab=BL10}
N 1960 29800 1940 29800 {}
C {lab_pin.sym} 1940 29800 0 0 {name=l23892 lab=BLB10}
N 1960 29760 1940 29760 {}
C {lab_pin.sym} 1940 29760 0 0 {name=l23893 lab=WL149}
N 2040 29840 2060 29840 {}
C {lab_pin.sym} 2060 29840 0 0 {name=l23894 lab=VDD}
N 2040 29760 2060 29760 {}
C {lab_pin.sym} 2060 29760 0 0 {name=l23895 lab=VSS}
C {bitcell_6t.sym} 2200 29800 0 0 {name=Xr149c11}
N 2160 29840 2140 29840 {}
C {lab_pin.sym} 2140 29840 0 0 {name=l23896 lab=BL11}
N 2160 29800 2140 29800 {}
C {lab_pin.sym} 2140 29800 0 0 {name=l23897 lab=BLB11}
N 2160 29760 2140 29760 {}
C {lab_pin.sym} 2140 29760 0 0 {name=l23898 lab=WL149}
N 2240 29840 2260 29840 {}
C {lab_pin.sym} 2260 29840 0 0 {name=l23899 lab=VDD}
N 2240 29760 2260 29760 {}
C {lab_pin.sym} 2260 29760 0 0 {name=l23900 lab=VSS}
C {bitcell_6t.sym} 2400 29800 0 0 {name=Xr149c12}
N 2360 29840 2340 29840 {}
C {lab_pin.sym} 2340 29840 0 0 {name=l23901 lab=BL12}
N 2360 29800 2340 29800 {}
C {lab_pin.sym} 2340 29800 0 0 {name=l23902 lab=BLB12}
N 2360 29760 2340 29760 {}
C {lab_pin.sym} 2340 29760 0 0 {name=l23903 lab=WL149}
N 2440 29840 2460 29840 {}
C {lab_pin.sym} 2460 29840 0 0 {name=l23904 lab=VDD}
N 2440 29760 2460 29760 {}
C {lab_pin.sym} 2460 29760 0 0 {name=l23905 lab=VSS}
C {bitcell_6t.sym} 2600 29800 0 0 {name=Xr149c13}
N 2560 29840 2540 29840 {}
C {lab_pin.sym} 2540 29840 0 0 {name=l23906 lab=BL13}
N 2560 29800 2540 29800 {}
C {lab_pin.sym} 2540 29800 0 0 {name=l23907 lab=BLB13}
N 2560 29760 2540 29760 {}
C {lab_pin.sym} 2540 29760 0 0 {name=l23908 lab=WL149}
N 2640 29840 2660 29840 {}
C {lab_pin.sym} 2660 29840 0 0 {name=l23909 lab=VDD}
N 2640 29760 2660 29760 {}
C {lab_pin.sym} 2660 29760 0 0 {name=l23910 lab=VSS}
C {bitcell_6t.sym} 2800 29800 0 0 {name=Xr149c14}
N 2760 29840 2740 29840 {}
C {lab_pin.sym} 2740 29840 0 0 {name=l23911 lab=BL14}
N 2760 29800 2740 29800 {}
C {lab_pin.sym} 2740 29800 0 0 {name=l23912 lab=BLB14}
N 2760 29760 2740 29760 {}
C {lab_pin.sym} 2740 29760 0 0 {name=l23913 lab=WL149}
N 2840 29840 2860 29840 {}
C {lab_pin.sym} 2860 29840 0 0 {name=l23914 lab=VDD}
N 2840 29760 2860 29760 {}
C {lab_pin.sym} 2860 29760 0 0 {name=l23915 lab=VSS}
C {bitcell_6t.sym} 3000 29800 0 0 {name=Xr149c15}
N 2960 29840 2940 29840 {}
C {lab_pin.sym} 2940 29840 0 0 {name=l23916 lab=BL15}
N 2960 29800 2940 29800 {}
C {lab_pin.sym} 2940 29800 0 0 {name=l23917 lab=BLB15}
N 2960 29760 2940 29760 {}
C {lab_pin.sym} 2940 29760 0 0 {name=l23918 lab=WL149}
N 3040 29840 3060 29840 {}
C {lab_pin.sym} 3060 29840 0 0 {name=l23919 lab=VDD}
N 3040 29760 3060 29760 {}
C {lab_pin.sym} 3060 29760 0 0 {name=l23920 lab=VSS}
C {bitcell_6t.sym} 3200 29800 0 0 {name=Xr149c16}
N 3160 29840 3140 29840 {}
C {lab_pin.sym} 3140 29840 0 0 {name=l23921 lab=BL16}
N 3160 29800 3140 29800 {}
C {lab_pin.sym} 3140 29800 0 0 {name=l23922 lab=BLB16}
N 3160 29760 3140 29760 {}
C {lab_pin.sym} 3140 29760 0 0 {name=l23923 lab=WL149}
N 3240 29840 3260 29840 {}
C {lab_pin.sym} 3260 29840 0 0 {name=l23924 lab=VDD}
N 3240 29760 3260 29760 {}
C {lab_pin.sym} 3260 29760 0 0 {name=l23925 lab=VSS}
C {bitcell_6t.sym} 3400 29800 0 0 {name=Xr149c17}
N 3360 29840 3340 29840 {}
C {lab_pin.sym} 3340 29840 0 0 {name=l23926 lab=BL17}
N 3360 29800 3340 29800 {}
C {lab_pin.sym} 3340 29800 0 0 {name=l23927 lab=BLB17}
N 3360 29760 3340 29760 {}
C {lab_pin.sym} 3340 29760 0 0 {name=l23928 lab=WL149}
N 3440 29840 3460 29840 {}
C {lab_pin.sym} 3460 29840 0 0 {name=l23929 lab=VDD}
N 3440 29760 3460 29760 {}
C {lab_pin.sym} 3460 29760 0 0 {name=l23930 lab=VSS}
C {bitcell_6t.sym} 3600 29800 0 0 {name=Xr149c18}
N 3560 29840 3540 29840 {}
C {lab_pin.sym} 3540 29840 0 0 {name=l23931 lab=BL18}
N 3560 29800 3540 29800 {}
C {lab_pin.sym} 3540 29800 0 0 {name=l23932 lab=BLB18}
N 3560 29760 3540 29760 {}
C {lab_pin.sym} 3540 29760 0 0 {name=l23933 lab=WL149}
N 3640 29840 3660 29840 {}
C {lab_pin.sym} 3660 29840 0 0 {name=l23934 lab=VDD}
N 3640 29760 3660 29760 {}
C {lab_pin.sym} 3660 29760 0 0 {name=l23935 lab=VSS}
C {bitcell_6t.sym} 3800 29800 0 0 {name=Xr149c19}
N 3760 29840 3740 29840 {}
C {lab_pin.sym} 3740 29840 0 0 {name=l23936 lab=BL19}
N 3760 29800 3740 29800 {}
C {lab_pin.sym} 3740 29800 0 0 {name=l23937 lab=BLB19}
N 3760 29760 3740 29760 {}
C {lab_pin.sym} 3740 29760 0 0 {name=l23938 lab=WL149}
N 3840 29840 3860 29840 {}
C {lab_pin.sym} 3860 29840 0 0 {name=l23939 lab=VDD}
N 3840 29760 3860 29760 {}
C {lab_pin.sym} 3860 29760 0 0 {name=l23940 lab=VSS}
C {bitcell_6t.sym} 4000 29800 0 0 {name=Xr149c20}
N 3960 29840 3940 29840 {}
C {lab_pin.sym} 3940 29840 0 0 {name=l23941 lab=BL20}
N 3960 29800 3940 29800 {}
C {lab_pin.sym} 3940 29800 0 0 {name=l23942 lab=BLB20}
N 3960 29760 3940 29760 {}
C {lab_pin.sym} 3940 29760 0 0 {name=l23943 lab=WL149}
N 4040 29840 4060 29840 {}
C {lab_pin.sym} 4060 29840 0 0 {name=l23944 lab=VDD}
N 4040 29760 4060 29760 {}
C {lab_pin.sym} 4060 29760 0 0 {name=l23945 lab=VSS}
C {bitcell_6t.sym} 4200 29800 0 0 {name=Xr149c21}
N 4160 29840 4140 29840 {}
C {lab_pin.sym} 4140 29840 0 0 {name=l23946 lab=BL21}
N 4160 29800 4140 29800 {}
C {lab_pin.sym} 4140 29800 0 0 {name=l23947 lab=BLB21}
N 4160 29760 4140 29760 {}
C {lab_pin.sym} 4140 29760 0 0 {name=l23948 lab=WL149}
N 4240 29840 4260 29840 {}
C {lab_pin.sym} 4260 29840 0 0 {name=l23949 lab=VDD}
N 4240 29760 4260 29760 {}
C {lab_pin.sym} 4260 29760 0 0 {name=l23950 lab=VSS}
C {bitcell_6t.sym} 4400 29800 0 0 {name=Xr149c22}
N 4360 29840 4340 29840 {}
C {lab_pin.sym} 4340 29840 0 0 {name=l23951 lab=BL22}
N 4360 29800 4340 29800 {}
C {lab_pin.sym} 4340 29800 0 0 {name=l23952 lab=BLB22}
N 4360 29760 4340 29760 {}
C {lab_pin.sym} 4340 29760 0 0 {name=l23953 lab=WL149}
N 4440 29840 4460 29840 {}
C {lab_pin.sym} 4460 29840 0 0 {name=l23954 lab=VDD}
N 4440 29760 4460 29760 {}
C {lab_pin.sym} 4460 29760 0 0 {name=l23955 lab=VSS}
C {bitcell_6t.sym} 4600 29800 0 0 {name=Xr149c23}
N 4560 29840 4540 29840 {}
C {lab_pin.sym} 4540 29840 0 0 {name=l23956 lab=BL23}
N 4560 29800 4540 29800 {}
C {lab_pin.sym} 4540 29800 0 0 {name=l23957 lab=BLB23}
N 4560 29760 4540 29760 {}
C {lab_pin.sym} 4540 29760 0 0 {name=l23958 lab=WL149}
N 4640 29840 4660 29840 {}
C {lab_pin.sym} 4660 29840 0 0 {name=l23959 lab=VDD}
N 4640 29760 4660 29760 {}
C {lab_pin.sym} 4660 29760 0 0 {name=l23960 lab=VSS}
C {bitcell_6t.sym} 4800 29800 0 0 {name=Xr149c24}
N 4760 29840 4740 29840 {}
C {lab_pin.sym} 4740 29840 0 0 {name=l23961 lab=BL24}
N 4760 29800 4740 29800 {}
C {lab_pin.sym} 4740 29800 0 0 {name=l23962 lab=BLB24}
N 4760 29760 4740 29760 {}
C {lab_pin.sym} 4740 29760 0 0 {name=l23963 lab=WL149}
N 4840 29840 4860 29840 {}
C {lab_pin.sym} 4860 29840 0 0 {name=l23964 lab=VDD}
N 4840 29760 4860 29760 {}
C {lab_pin.sym} 4860 29760 0 0 {name=l23965 lab=VSS}
C {bitcell_6t.sym} 5000 29800 0 0 {name=Xr149c25}
N 4960 29840 4940 29840 {}
C {lab_pin.sym} 4940 29840 0 0 {name=l23966 lab=BL25}
N 4960 29800 4940 29800 {}
C {lab_pin.sym} 4940 29800 0 0 {name=l23967 lab=BLB25}
N 4960 29760 4940 29760 {}
C {lab_pin.sym} 4940 29760 0 0 {name=l23968 lab=WL149}
N 5040 29840 5060 29840 {}
C {lab_pin.sym} 5060 29840 0 0 {name=l23969 lab=VDD}
N 5040 29760 5060 29760 {}
C {lab_pin.sym} 5060 29760 0 0 {name=l23970 lab=VSS}
C {bitcell_6t.sym} 5200 29800 0 0 {name=Xr149c26}
N 5160 29840 5140 29840 {}
C {lab_pin.sym} 5140 29840 0 0 {name=l23971 lab=BL26}
N 5160 29800 5140 29800 {}
C {lab_pin.sym} 5140 29800 0 0 {name=l23972 lab=BLB26}
N 5160 29760 5140 29760 {}
C {lab_pin.sym} 5140 29760 0 0 {name=l23973 lab=WL149}
N 5240 29840 5260 29840 {}
C {lab_pin.sym} 5260 29840 0 0 {name=l23974 lab=VDD}
N 5240 29760 5260 29760 {}
C {lab_pin.sym} 5260 29760 0 0 {name=l23975 lab=VSS}
C {bitcell_6t.sym} 5400 29800 0 0 {name=Xr149c27}
N 5360 29840 5340 29840 {}
C {lab_pin.sym} 5340 29840 0 0 {name=l23976 lab=BL27}
N 5360 29800 5340 29800 {}
C {lab_pin.sym} 5340 29800 0 0 {name=l23977 lab=BLB27}
N 5360 29760 5340 29760 {}
C {lab_pin.sym} 5340 29760 0 0 {name=l23978 lab=WL149}
N 5440 29840 5460 29840 {}
C {lab_pin.sym} 5460 29840 0 0 {name=l23979 lab=VDD}
N 5440 29760 5460 29760 {}
C {lab_pin.sym} 5460 29760 0 0 {name=l23980 lab=VSS}
C {bitcell_6t.sym} 5600 29800 0 0 {name=Xr149c28}
N 5560 29840 5540 29840 {}
C {lab_pin.sym} 5540 29840 0 0 {name=l23981 lab=BL28}
N 5560 29800 5540 29800 {}
C {lab_pin.sym} 5540 29800 0 0 {name=l23982 lab=BLB28}
N 5560 29760 5540 29760 {}
C {lab_pin.sym} 5540 29760 0 0 {name=l23983 lab=WL149}
N 5640 29840 5660 29840 {}
C {lab_pin.sym} 5660 29840 0 0 {name=l23984 lab=VDD}
N 5640 29760 5660 29760 {}
C {lab_pin.sym} 5660 29760 0 0 {name=l23985 lab=VSS}
C {bitcell_6t.sym} 5800 29800 0 0 {name=Xr149c29}
N 5760 29840 5740 29840 {}
C {lab_pin.sym} 5740 29840 0 0 {name=l23986 lab=BL29}
N 5760 29800 5740 29800 {}
C {lab_pin.sym} 5740 29800 0 0 {name=l23987 lab=BLB29}
N 5760 29760 5740 29760 {}
C {lab_pin.sym} 5740 29760 0 0 {name=l23988 lab=WL149}
N 5840 29840 5860 29840 {}
C {lab_pin.sym} 5860 29840 0 0 {name=l23989 lab=VDD}
N 5840 29760 5860 29760 {}
C {lab_pin.sym} 5860 29760 0 0 {name=l23990 lab=VSS}
C {bitcell_6t.sym} 6000 29800 0 0 {name=Xr149c30}
N 5960 29840 5940 29840 {}
C {lab_pin.sym} 5940 29840 0 0 {name=l23991 lab=BL30}
N 5960 29800 5940 29800 {}
C {lab_pin.sym} 5940 29800 0 0 {name=l23992 lab=BLB30}
N 5960 29760 5940 29760 {}
C {lab_pin.sym} 5940 29760 0 0 {name=l23993 lab=WL149}
N 6040 29840 6060 29840 {}
C {lab_pin.sym} 6060 29840 0 0 {name=l23994 lab=VDD}
N 6040 29760 6060 29760 {}
C {lab_pin.sym} 6060 29760 0 0 {name=l23995 lab=VSS}
C {bitcell_6t.sym} 6200 29800 0 0 {name=Xr149c31}
N 6160 29840 6140 29840 {}
C {lab_pin.sym} 6140 29840 0 0 {name=l23996 lab=BL31}
N 6160 29800 6140 29800 {}
C {lab_pin.sym} 6140 29800 0 0 {name=l23997 lab=BLB31}
N 6160 29760 6140 29760 {}
C {lab_pin.sym} 6140 29760 0 0 {name=l23998 lab=WL149}
N 6240 29840 6260 29840 {}
C {lab_pin.sym} 6260 29840 0 0 {name=l23999 lab=VDD}
N 6240 29760 6260 29760 {}
C {lab_pin.sym} 6260 29760 0 0 {name=l24000 lab=VSS}
C {bitcell_6t.sym} 0 30000 0 0 {name=Xr150c0}
N -40 30040 -60 30040 {}
C {lab_pin.sym} -60 30040 0 0 {name=l24001 lab=BL0}
N -40 30000 -60 30000 {}
C {lab_pin.sym} -60 30000 0 0 {name=l24002 lab=BLB0}
N -40 29960 -60 29960 {}
C {lab_pin.sym} -60 29960 0 0 {name=l24003 lab=WL150}
N 40 30040 60 30040 {}
C {lab_pin.sym} 60 30040 0 0 {name=l24004 lab=VDD}
N 40 29960 60 29960 {}
C {lab_pin.sym} 60 29960 0 0 {name=l24005 lab=VSS}
C {bitcell_6t.sym} 200 30000 0 0 {name=Xr150c1}
N 160 30040 140 30040 {}
C {lab_pin.sym} 140 30040 0 0 {name=l24006 lab=BL1}
N 160 30000 140 30000 {}
C {lab_pin.sym} 140 30000 0 0 {name=l24007 lab=BLB1}
N 160 29960 140 29960 {}
C {lab_pin.sym} 140 29960 0 0 {name=l24008 lab=WL150}
N 240 30040 260 30040 {}
C {lab_pin.sym} 260 30040 0 0 {name=l24009 lab=VDD}
N 240 29960 260 29960 {}
C {lab_pin.sym} 260 29960 0 0 {name=l24010 lab=VSS}
C {bitcell_6t.sym} 400 30000 0 0 {name=Xr150c2}
N 360 30040 340 30040 {}
C {lab_pin.sym} 340 30040 0 0 {name=l24011 lab=BL2}
N 360 30000 340 30000 {}
C {lab_pin.sym} 340 30000 0 0 {name=l24012 lab=BLB2}
N 360 29960 340 29960 {}
C {lab_pin.sym} 340 29960 0 0 {name=l24013 lab=WL150}
N 440 30040 460 30040 {}
C {lab_pin.sym} 460 30040 0 0 {name=l24014 lab=VDD}
N 440 29960 460 29960 {}
C {lab_pin.sym} 460 29960 0 0 {name=l24015 lab=VSS}
C {bitcell_6t.sym} 600 30000 0 0 {name=Xr150c3}
N 560 30040 540 30040 {}
C {lab_pin.sym} 540 30040 0 0 {name=l24016 lab=BL3}
N 560 30000 540 30000 {}
C {lab_pin.sym} 540 30000 0 0 {name=l24017 lab=BLB3}
N 560 29960 540 29960 {}
C {lab_pin.sym} 540 29960 0 0 {name=l24018 lab=WL150}
N 640 30040 660 30040 {}
C {lab_pin.sym} 660 30040 0 0 {name=l24019 lab=VDD}
N 640 29960 660 29960 {}
C {lab_pin.sym} 660 29960 0 0 {name=l24020 lab=VSS}
C {bitcell_6t.sym} 800 30000 0 0 {name=Xr150c4}
N 760 30040 740 30040 {}
C {lab_pin.sym} 740 30040 0 0 {name=l24021 lab=BL4}
N 760 30000 740 30000 {}
C {lab_pin.sym} 740 30000 0 0 {name=l24022 lab=BLB4}
N 760 29960 740 29960 {}
C {lab_pin.sym} 740 29960 0 0 {name=l24023 lab=WL150}
N 840 30040 860 30040 {}
C {lab_pin.sym} 860 30040 0 0 {name=l24024 lab=VDD}
N 840 29960 860 29960 {}
C {lab_pin.sym} 860 29960 0 0 {name=l24025 lab=VSS}
C {bitcell_6t.sym} 1000 30000 0 0 {name=Xr150c5}
N 960 30040 940 30040 {}
C {lab_pin.sym} 940 30040 0 0 {name=l24026 lab=BL5}
N 960 30000 940 30000 {}
C {lab_pin.sym} 940 30000 0 0 {name=l24027 lab=BLB5}
N 960 29960 940 29960 {}
C {lab_pin.sym} 940 29960 0 0 {name=l24028 lab=WL150}
N 1040 30040 1060 30040 {}
C {lab_pin.sym} 1060 30040 0 0 {name=l24029 lab=VDD}
N 1040 29960 1060 29960 {}
C {lab_pin.sym} 1060 29960 0 0 {name=l24030 lab=VSS}
C {bitcell_6t.sym} 1200 30000 0 0 {name=Xr150c6}
N 1160 30040 1140 30040 {}
C {lab_pin.sym} 1140 30040 0 0 {name=l24031 lab=BL6}
N 1160 30000 1140 30000 {}
C {lab_pin.sym} 1140 30000 0 0 {name=l24032 lab=BLB6}
N 1160 29960 1140 29960 {}
C {lab_pin.sym} 1140 29960 0 0 {name=l24033 lab=WL150}
N 1240 30040 1260 30040 {}
C {lab_pin.sym} 1260 30040 0 0 {name=l24034 lab=VDD}
N 1240 29960 1260 29960 {}
C {lab_pin.sym} 1260 29960 0 0 {name=l24035 lab=VSS}
C {bitcell_6t.sym} 1400 30000 0 0 {name=Xr150c7}
N 1360 30040 1340 30040 {}
C {lab_pin.sym} 1340 30040 0 0 {name=l24036 lab=BL7}
N 1360 30000 1340 30000 {}
C {lab_pin.sym} 1340 30000 0 0 {name=l24037 lab=BLB7}
N 1360 29960 1340 29960 {}
C {lab_pin.sym} 1340 29960 0 0 {name=l24038 lab=WL150}
N 1440 30040 1460 30040 {}
C {lab_pin.sym} 1460 30040 0 0 {name=l24039 lab=VDD}
N 1440 29960 1460 29960 {}
C {lab_pin.sym} 1460 29960 0 0 {name=l24040 lab=VSS}
C {bitcell_6t.sym} 1600 30000 0 0 {name=Xr150c8}
N 1560 30040 1540 30040 {}
C {lab_pin.sym} 1540 30040 0 0 {name=l24041 lab=BL8}
N 1560 30000 1540 30000 {}
C {lab_pin.sym} 1540 30000 0 0 {name=l24042 lab=BLB8}
N 1560 29960 1540 29960 {}
C {lab_pin.sym} 1540 29960 0 0 {name=l24043 lab=WL150}
N 1640 30040 1660 30040 {}
C {lab_pin.sym} 1660 30040 0 0 {name=l24044 lab=VDD}
N 1640 29960 1660 29960 {}
C {lab_pin.sym} 1660 29960 0 0 {name=l24045 lab=VSS}
C {bitcell_6t.sym} 1800 30000 0 0 {name=Xr150c9}
N 1760 30040 1740 30040 {}
C {lab_pin.sym} 1740 30040 0 0 {name=l24046 lab=BL9}
N 1760 30000 1740 30000 {}
C {lab_pin.sym} 1740 30000 0 0 {name=l24047 lab=BLB9}
N 1760 29960 1740 29960 {}
C {lab_pin.sym} 1740 29960 0 0 {name=l24048 lab=WL150}
N 1840 30040 1860 30040 {}
C {lab_pin.sym} 1860 30040 0 0 {name=l24049 lab=VDD}
N 1840 29960 1860 29960 {}
C {lab_pin.sym} 1860 29960 0 0 {name=l24050 lab=VSS}
C {bitcell_6t.sym} 2000 30000 0 0 {name=Xr150c10}
N 1960 30040 1940 30040 {}
C {lab_pin.sym} 1940 30040 0 0 {name=l24051 lab=BL10}
N 1960 30000 1940 30000 {}
C {lab_pin.sym} 1940 30000 0 0 {name=l24052 lab=BLB10}
N 1960 29960 1940 29960 {}
C {lab_pin.sym} 1940 29960 0 0 {name=l24053 lab=WL150}
N 2040 30040 2060 30040 {}
C {lab_pin.sym} 2060 30040 0 0 {name=l24054 lab=VDD}
N 2040 29960 2060 29960 {}
C {lab_pin.sym} 2060 29960 0 0 {name=l24055 lab=VSS}
C {bitcell_6t.sym} 2200 30000 0 0 {name=Xr150c11}
N 2160 30040 2140 30040 {}
C {lab_pin.sym} 2140 30040 0 0 {name=l24056 lab=BL11}
N 2160 30000 2140 30000 {}
C {lab_pin.sym} 2140 30000 0 0 {name=l24057 lab=BLB11}
N 2160 29960 2140 29960 {}
C {lab_pin.sym} 2140 29960 0 0 {name=l24058 lab=WL150}
N 2240 30040 2260 30040 {}
C {lab_pin.sym} 2260 30040 0 0 {name=l24059 lab=VDD}
N 2240 29960 2260 29960 {}
C {lab_pin.sym} 2260 29960 0 0 {name=l24060 lab=VSS}
C {bitcell_6t.sym} 2400 30000 0 0 {name=Xr150c12}
N 2360 30040 2340 30040 {}
C {lab_pin.sym} 2340 30040 0 0 {name=l24061 lab=BL12}
N 2360 30000 2340 30000 {}
C {lab_pin.sym} 2340 30000 0 0 {name=l24062 lab=BLB12}
N 2360 29960 2340 29960 {}
C {lab_pin.sym} 2340 29960 0 0 {name=l24063 lab=WL150}
N 2440 30040 2460 30040 {}
C {lab_pin.sym} 2460 30040 0 0 {name=l24064 lab=VDD}
N 2440 29960 2460 29960 {}
C {lab_pin.sym} 2460 29960 0 0 {name=l24065 lab=VSS}
C {bitcell_6t.sym} 2600 30000 0 0 {name=Xr150c13}
N 2560 30040 2540 30040 {}
C {lab_pin.sym} 2540 30040 0 0 {name=l24066 lab=BL13}
N 2560 30000 2540 30000 {}
C {lab_pin.sym} 2540 30000 0 0 {name=l24067 lab=BLB13}
N 2560 29960 2540 29960 {}
C {lab_pin.sym} 2540 29960 0 0 {name=l24068 lab=WL150}
N 2640 30040 2660 30040 {}
C {lab_pin.sym} 2660 30040 0 0 {name=l24069 lab=VDD}
N 2640 29960 2660 29960 {}
C {lab_pin.sym} 2660 29960 0 0 {name=l24070 lab=VSS}
C {bitcell_6t.sym} 2800 30000 0 0 {name=Xr150c14}
N 2760 30040 2740 30040 {}
C {lab_pin.sym} 2740 30040 0 0 {name=l24071 lab=BL14}
N 2760 30000 2740 30000 {}
C {lab_pin.sym} 2740 30000 0 0 {name=l24072 lab=BLB14}
N 2760 29960 2740 29960 {}
C {lab_pin.sym} 2740 29960 0 0 {name=l24073 lab=WL150}
N 2840 30040 2860 30040 {}
C {lab_pin.sym} 2860 30040 0 0 {name=l24074 lab=VDD}
N 2840 29960 2860 29960 {}
C {lab_pin.sym} 2860 29960 0 0 {name=l24075 lab=VSS}
C {bitcell_6t.sym} 3000 30000 0 0 {name=Xr150c15}
N 2960 30040 2940 30040 {}
C {lab_pin.sym} 2940 30040 0 0 {name=l24076 lab=BL15}
N 2960 30000 2940 30000 {}
C {lab_pin.sym} 2940 30000 0 0 {name=l24077 lab=BLB15}
N 2960 29960 2940 29960 {}
C {lab_pin.sym} 2940 29960 0 0 {name=l24078 lab=WL150}
N 3040 30040 3060 30040 {}
C {lab_pin.sym} 3060 30040 0 0 {name=l24079 lab=VDD}
N 3040 29960 3060 29960 {}
C {lab_pin.sym} 3060 29960 0 0 {name=l24080 lab=VSS}
C {bitcell_6t.sym} 3200 30000 0 0 {name=Xr150c16}
N 3160 30040 3140 30040 {}
C {lab_pin.sym} 3140 30040 0 0 {name=l24081 lab=BL16}
N 3160 30000 3140 30000 {}
C {lab_pin.sym} 3140 30000 0 0 {name=l24082 lab=BLB16}
N 3160 29960 3140 29960 {}
C {lab_pin.sym} 3140 29960 0 0 {name=l24083 lab=WL150}
N 3240 30040 3260 30040 {}
C {lab_pin.sym} 3260 30040 0 0 {name=l24084 lab=VDD}
N 3240 29960 3260 29960 {}
C {lab_pin.sym} 3260 29960 0 0 {name=l24085 lab=VSS}
C {bitcell_6t.sym} 3400 30000 0 0 {name=Xr150c17}
N 3360 30040 3340 30040 {}
C {lab_pin.sym} 3340 30040 0 0 {name=l24086 lab=BL17}
N 3360 30000 3340 30000 {}
C {lab_pin.sym} 3340 30000 0 0 {name=l24087 lab=BLB17}
N 3360 29960 3340 29960 {}
C {lab_pin.sym} 3340 29960 0 0 {name=l24088 lab=WL150}
N 3440 30040 3460 30040 {}
C {lab_pin.sym} 3460 30040 0 0 {name=l24089 lab=VDD}
N 3440 29960 3460 29960 {}
C {lab_pin.sym} 3460 29960 0 0 {name=l24090 lab=VSS}
C {bitcell_6t.sym} 3600 30000 0 0 {name=Xr150c18}
N 3560 30040 3540 30040 {}
C {lab_pin.sym} 3540 30040 0 0 {name=l24091 lab=BL18}
N 3560 30000 3540 30000 {}
C {lab_pin.sym} 3540 30000 0 0 {name=l24092 lab=BLB18}
N 3560 29960 3540 29960 {}
C {lab_pin.sym} 3540 29960 0 0 {name=l24093 lab=WL150}
N 3640 30040 3660 30040 {}
C {lab_pin.sym} 3660 30040 0 0 {name=l24094 lab=VDD}
N 3640 29960 3660 29960 {}
C {lab_pin.sym} 3660 29960 0 0 {name=l24095 lab=VSS}
C {bitcell_6t.sym} 3800 30000 0 0 {name=Xr150c19}
N 3760 30040 3740 30040 {}
C {lab_pin.sym} 3740 30040 0 0 {name=l24096 lab=BL19}
N 3760 30000 3740 30000 {}
C {lab_pin.sym} 3740 30000 0 0 {name=l24097 lab=BLB19}
N 3760 29960 3740 29960 {}
C {lab_pin.sym} 3740 29960 0 0 {name=l24098 lab=WL150}
N 3840 30040 3860 30040 {}
C {lab_pin.sym} 3860 30040 0 0 {name=l24099 lab=VDD}
N 3840 29960 3860 29960 {}
C {lab_pin.sym} 3860 29960 0 0 {name=l24100 lab=VSS}
C {bitcell_6t.sym} 4000 30000 0 0 {name=Xr150c20}
N 3960 30040 3940 30040 {}
C {lab_pin.sym} 3940 30040 0 0 {name=l24101 lab=BL20}
N 3960 30000 3940 30000 {}
C {lab_pin.sym} 3940 30000 0 0 {name=l24102 lab=BLB20}
N 3960 29960 3940 29960 {}
C {lab_pin.sym} 3940 29960 0 0 {name=l24103 lab=WL150}
N 4040 30040 4060 30040 {}
C {lab_pin.sym} 4060 30040 0 0 {name=l24104 lab=VDD}
N 4040 29960 4060 29960 {}
C {lab_pin.sym} 4060 29960 0 0 {name=l24105 lab=VSS}
C {bitcell_6t.sym} 4200 30000 0 0 {name=Xr150c21}
N 4160 30040 4140 30040 {}
C {lab_pin.sym} 4140 30040 0 0 {name=l24106 lab=BL21}
N 4160 30000 4140 30000 {}
C {lab_pin.sym} 4140 30000 0 0 {name=l24107 lab=BLB21}
N 4160 29960 4140 29960 {}
C {lab_pin.sym} 4140 29960 0 0 {name=l24108 lab=WL150}
N 4240 30040 4260 30040 {}
C {lab_pin.sym} 4260 30040 0 0 {name=l24109 lab=VDD}
N 4240 29960 4260 29960 {}
C {lab_pin.sym} 4260 29960 0 0 {name=l24110 lab=VSS}
C {bitcell_6t.sym} 4400 30000 0 0 {name=Xr150c22}
N 4360 30040 4340 30040 {}
C {lab_pin.sym} 4340 30040 0 0 {name=l24111 lab=BL22}
N 4360 30000 4340 30000 {}
C {lab_pin.sym} 4340 30000 0 0 {name=l24112 lab=BLB22}
N 4360 29960 4340 29960 {}
C {lab_pin.sym} 4340 29960 0 0 {name=l24113 lab=WL150}
N 4440 30040 4460 30040 {}
C {lab_pin.sym} 4460 30040 0 0 {name=l24114 lab=VDD}
N 4440 29960 4460 29960 {}
C {lab_pin.sym} 4460 29960 0 0 {name=l24115 lab=VSS}
C {bitcell_6t.sym} 4600 30000 0 0 {name=Xr150c23}
N 4560 30040 4540 30040 {}
C {lab_pin.sym} 4540 30040 0 0 {name=l24116 lab=BL23}
N 4560 30000 4540 30000 {}
C {lab_pin.sym} 4540 30000 0 0 {name=l24117 lab=BLB23}
N 4560 29960 4540 29960 {}
C {lab_pin.sym} 4540 29960 0 0 {name=l24118 lab=WL150}
N 4640 30040 4660 30040 {}
C {lab_pin.sym} 4660 30040 0 0 {name=l24119 lab=VDD}
N 4640 29960 4660 29960 {}
C {lab_pin.sym} 4660 29960 0 0 {name=l24120 lab=VSS}
C {bitcell_6t.sym} 4800 30000 0 0 {name=Xr150c24}
N 4760 30040 4740 30040 {}
C {lab_pin.sym} 4740 30040 0 0 {name=l24121 lab=BL24}
N 4760 30000 4740 30000 {}
C {lab_pin.sym} 4740 30000 0 0 {name=l24122 lab=BLB24}
N 4760 29960 4740 29960 {}
C {lab_pin.sym} 4740 29960 0 0 {name=l24123 lab=WL150}
N 4840 30040 4860 30040 {}
C {lab_pin.sym} 4860 30040 0 0 {name=l24124 lab=VDD}
N 4840 29960 4860 29960 {}
C {lab_pin.sym} 4860 29960 0 0 {name=l24125 lab=VSS}
C {bitcell_6t.sym} 5000 30000 0 0 {name=Xr150c25}
N 4960 30040 4940 30040 {}
C {lab_pin.sym} 4940 30040 0 0 {name=l24126 lab=BL25}
N 4960 30000 4940 30000 {}
C {lab_pin.sym} 4940 30000 0 0 {name=l24127 lab=BLB25}
N 4960 29960 4940 29960 {}
C {lab_pin.sym} 4940 29960 0 0 {name=l24128 lab=WL150}
N 5040 30040 5060 30040 {}
C {lab_pin.sym} 5060 30040 0 0 {name=l24129 lab=VDD}
N 5040 29960 5060 29960 {}
C {lab_pin.sym} 5060 29960 0 0 {name=l24130 lab=VSS}
C {bitcell_6t.sym} 5200 30000 0 0 {name=Xr150c26}
N 5160 30040 5140 30040 {}
C {lab_pin.sym} 5140 30040 0 0 {name=l24131 lab=BL26}
N 5160 30000 5140 30000 {}
C {lab_pin.sym} 5140 30000 0 0 {name=l24132 lab=BLB26}
N 5160 29960 5140 29960 {}
C {lab_pin.sym} 5140 29960 0 0 {name=l24133 lab=WL150}
N 5240 30040 5260 30040 {}
C {lab_pin.sym} 5260 30040 0 0 {name=l24134 lab=VDD}
N 5240 29960 5260 29960 {}
C {lab_pin.sym} 5260 29960 0 0 {name=l24135 lab=VSS}
C {bitcell_6t.sym} 5400 30000 0 0 {name=Xr150c27}
N 5360 30040 5340 30040 {}
C {lab_pin.sym} 5340 30040 0 0 {name=l24136 lab=BL27}
N 5360 30000 5340 30000 {}
C {lab_pin.sym} 5340 30000 0 0 {name=l24137 lab=BLB27}
N 5360 29960 5340 29960 {}
C {lab_pin.sym} 5340 29960 0 0 {name=l24138 lab=WL150}
N 5440 30040 5460 30040 {}
C {lab_pin.sym} 5460 30040 0 0 {name=l24139 lab=VDD}
N 5440 29960 5460 29960 {}
C {lab_pin.sym} 5460 29960 0 0 {name=l24140 lab=VSS}
C {bitcell_6t.sym} 5600 30000 0 0 {name=Xr150c28}
N 5560 30040 5540 30040 {}
C {lab_pin.sym} 5540 30040 0 0 {name=l24141 lab=BL28}
N 5560 30000 5540 30000 {}
C {lab_pin.sym} 5540 30000 0 0 {name=l24142 lab=BLB28}
N 5560 29960 5540 29960 {}
C {lab_pin.sym} 5540 29960 0 0 {name=l24143 lab=WL150}
N 5640 30040 5660 30040 {}
C {lab_pin.sym} 5660 30040 0 0 {name=l24144 lab=VDD}
N 5640 29960 5660 29960 {}
C {lab_pin.sym} 5660 29960 0 0 {name=l24145 lab=VSS}
C {bitcell_6t.sym} 5800 30000 0 0 {name=Xr150c29}
N 5760 30040 5740 30040 {}
C {lab_pin.sym} 5740 30040 0 0 {name=l24146 lab=BL29}
N 5760 30000 5740 30000 {}
C {lab_pin.sym} 5740 30000 0 0 {name=l24147 lab=BLB29}
N 5760 29960 5740 29960 {}
C {lab_pin.sym} 5740 29960 0 0 {name=l24148 lab=WL150}
N 5840 30040 5860 30040 {}
C {lab_pin.sym} 5860 30040 0 0 {name=l24149 lab=VDD}
N 5840 29960 5860 29960 {}
C {lab_pin.sym} 5860 29960 0 0 {name=l24150 lab=VSS}
C {bitcell_6t.sym} 6000 30000 0 0 {name=Xr150c30}
N 5960 30040 5940 30040 {}
C {lab_pin.sym} 5940 30040 0 0 {name=l24151 lab=BL30}
N 5960 30000 5940 30000 {}
C {lab_pin.sym} 5940 30000 0 0 {name=l24152 lab=BLB30}
N 5960 29960 5940 29960 {}
C {lab_pin.sym} 5940 29960 0 0 {name=l24153 lab=WL150}
N 6040 30040 6060 30040 {}
C {lab_pin.sym} 6060 30040 0 0 {name=l24154 lab=VDD}
N 6040 29960 6060 29960 {}
C {lab_pin.sym} 6060 29960 0 0 {name=l24155 lab=VSS}
C {bitcell_6t.sym} 6200 30000 0 0 {name=Xr150c31}
N 6160 30040 6140 30040 {}
C {lab_pin.sym} 6140 30040 0 0 {name=l24156 lab=BL31}
N 6160 30000 6140 30000 {}
C {lab_pin.sym} 6140 30000 0 0 {name=l24157 lab=BLB31}
N 6160 29960 6140 29960 {}
C {lab_pin.sym} 6140 29960 0 0 {name=l24158 lab=WL150}
N 6240 30040 6260 30040 {}
C {lab_pin.sym} 6260 30040 0 0 {name=l24159 lab=VDD}
N 6240 29960 6260 29960 {}
C {lab_pin.sym} 6260 29960 0 0 {name=l24160 lab=VSS}
C {bitcell_6t.sym} 0 30200 0 0 {name=Xr151c0}
N -40 30240 -60 30240 {}
C {lab_pin.sym} -60 30240 0 0 {name=l24161 lab=BL0}
N -40 30200 -60 30200 {}
C {lab_pin.sym} -60 30200 0 0 {name=l24162 lab=BLB0}
N -40 30160 -60 30160 {}
C {lab_pin.sym} -60 30160 0 0 {name=l24163 lab=WL151}
N 40 30240 60 30240 {}
C {lab_pin.sym} 60 30240 0 0 {name=l24164 lab=VDD}
N 40 30160 60 30160 {}
C {lab_pin.sym} 60 30160 0 0 {name=l24165 lab=VSS}
C {bitcell_6t.sym} 200 30200 0 0 {name=Xr151c1}
N 160 30240 140 30240 {}
C {lab_pin.sym} 140 30240 0 0 {name=l24166 lab=BL1}
N 160 30200 140 30200 {}
C {lab_pin.sym} 140 30200 0 0 {name=l24167 lab=BLB1}
N 160 30160 140 30160 {}
C {lab_pin.sym} 140 30160 0 0 {name=l24168 lab=WL151}
N 240 30240 260 30240 {}
C {lab_pin.sym} 260 30240 0 0 {name=l24169 lab=VDD}
N 240 30160 260 30160 {}
C {lab_pin.sym} 260 30160 0 0 {name=l24170 lab=VSS}
C {bitcell_6t.sym} 400 30200 0 0 {name=Xr151c2}
N 360 30240 340 30240 {}
C {lab_pin.sym} 340 30240 0 0 {name=l24171 lab=BL2}
N 360 30200 340 30200 {}
C {lab_pin.sym} 340 30200 0 0 {name=l24172 lab=BLB2}
N 360 30160 340 30160 {}
C {lab_pin.sym} 340 30160 0 0 {name=l24173 lab=WL151}
N 440 30240 460 30240 {}
C {lab_pin.sym} 460 30240 0 0 {name=l24174 lab=VDD}
N 440 30160 460 30160 {}
C {lab_pin.sym} 460 30160 0 0 {name=l24175 lab=VSS}
C {bitcell_6t.sym} 600 30200 0 0 {name=Xr151c3}
N 560 30240 540 30240 {}
C {lab_pin.sym} 540 30240 0 0 {name=l24176 lab=BL3}
N 560 30200 540 30200 {}
C {lab_pin.sym} 540 30200 0 0 {name=l24177 lab=BLB3}
N 560 30160 540 30160 {}
C {lab_pin.sym} 540 30160 0 0 {name=l24178 lab=WL151}
N 640 30240 660 30240 {}
C {lab_pin.sym} 660 30240 0 0 {name=l24179 lab=VDD}
N 640 30160 660 30160 {}
C {lab_pin.sym} 660 30160 0 0 {name=l24180 lab=VSS}
C {bitcell_6t.sym} 800 30200 0 0 {name=Xr151c4}
N 760 30240 740 30240 {}
C {lab_pin.sym} 740 30240 0 0 {name=l24181 lab=BL4}
N 760 30200 740 30200 {}
C {lab_pin.sym} 740 30200 0 0 {name=l24182 lab=BLB4}
N 760 30160 740 30160 {}
C {lab_pin.sym} 740 30160 0 0 {name=l24183 lab=WL151}
N 840 30240 860 30240 {}
C {lab_pin.sym} 860 30240 0 0 {name=l24184 lab=VDD}
N 840 30160 860 30160 {}
C {lab_pin.sym} 860 30160 0 0 {name=l24185 lab=VSS}
C {bitcell_6t.sym} 1000 30200 0 0 {name=Xr151c5}
N 960 30240 940 30240 {}
C {lab_pin.sym} 940 30240 0 0 {name=l24186 lab=BL5}
N 960 30200 940 30200 {}
C {lab_pin.sym} 940 30200 0 0 {name=l24187 lab=BLB5}
N 960 30160 940 30160 {}
C {lab_pin.sym} 940 30160 0 0 {name=l24188 lab=WL151}
N 1040 30240 1060 30240 {}
C {lab_pin.sym} 1060 30240 0 0 {name=l24189 lab=VDD}
N 1040 30160 1060 30160 {}
C {lab_pin.sym} 1060 30160 0 0 {name=l24190 lab=VSS}
C {bitcell_6t.sym} 1200 30200 0 0 {name=Xr151c6}
N 1160 30240 1140 30240 {}
C {lab_pin.sym} 1140 30240 0 0 {name=l24191 lab=BL6}
N 1160 30200 1140 30200 {}
C {lab_pin.sym} 1140 30200 0 0 {name=l24192 lab=BLB6}
N 1160 30160 1140 30160 {}
C {lab_pin.sym} 1140 30160 0 0 {name=l24193 lab=WL151}
N 1240 30240 1260 30240 {}
C {lab_pin.sym} 1260 30240 0 0 {name=l24194 lab=VDD}
N 1240 30160 1260 30160 {}
C {lab_pin.sym} 1260 30160 0 0 {name=l24195 lab=VSS}
C {bitcell_6t.sym} 1400 30200 0 0 {name=Xr151c7}
N 1360 30240 1340 30240 {}
C {lab_pin.sym} 1340 30240 0 0 {name=l24196 lab=BL7}
N 1360 30200 1340 30200 {}
C {lab_pin.sym} 1340 30200 0 0 {name=l24197 lab=BLB7}
N 1360 30160 1340 30160 {}
C {lab_pin.sym} 1340 30160 0 0 {name=l24198 lab=WL151}
N 1440 30240 1460 30240 {}
C {lab_pin.sym} 1460 30240 0 0 {name=l24199 lab=VDD}
N 1440 30160 1460 30160 {}
C {lab_pin.sym} 1460 30160 0 0 {name=l24200 lab=VSS}
C {bitcell_6t.sym} 1600 30200 0 0 {name=Xr151c8}
N 1560 30240 1540 30240 {}
C {lab_pin.sym} 1540 30240 0 0 {name=l24201 lab=BL8}
N 1560 30200 1540 30200 {}
C {lab_pin.sym} 1540 30200 0 0 {name=l24202 lab=BLB8}
N 1560 30160 1540 30160 {}
C {lab_pin.sym} 1540 30160 0 0 {name=l24203 lab=WL151}
N 1640 30240 1660 30240 {}
C {lab_pin.sym} 1660 30240 0 0 {name=l24204 lab=VDD}
N 1640 30160 1660 30160 {}
C {lab_pin.sym} 1660 30160 0 0 {name=l24205 lab=VSS}
C {bitcell_6t.sym} 1800 30200 0 0 {name=Xr151c9}
N 1760 30240 1740 30240 {}
C {lab_pin.sym} 1740 30240 0 0 {name=l24206 lab=BL9}
N 1760 30200 1740 30200 {}
C {lab_pin.sym} 1740 30200 0 0 {name=l24207 lab=BLB9}
N 1760 30160 1740 30160 {}
C {lab_pin.sym} 1740 30160 0 0 {name=l24208 lab=WL151}
N 1840 30240 1860 30240 {}
C {lab_pin.sym} 1860 30240 0 0 {name=l24209 lab=VDD}
N 1840 30160 1860 30160 {}
C {lab_pin.sym} 1860 30160 0 0 {name=l24210 lab=VSS}
C {bitcell_6t.sym} 2000 30200 0 0 {name=Xr151c10}
N 1960 30240 1940 30240 {}
C {lab_pin.sym} 1940 30240 0 0 {name=l24211 lab=BL10}
N 1960 30200 1940 30200 {}
C {lab_pin.sym} 1940 30200 0 0 {name=l24212 lab=BLB10}
N 1960 30160 1940 30160 {}
C {lab_pin.sym} 1940 30160 0 0 {name=l24213 lab=WL151}
N 2040 30240 2060 30240 {}
C {lab_pin.sym} 2060 30240 0 0 {name=l24214 lab=VDD}
N 2040 30160 2060 30160 {}
C {lab_pin.sym} 2060 30160 0 0 {name=l24215 lab=VSS}
C {bitcell_6t.sym} 2200 30200 0 0 {name=Xr151c11}
N 2160 30240 2140 30240 {}
C {lab_pin.sym} 2140 30240 0 0 {name=l24216 lab=BL11}
N 2160 30200 2140 30200 {}
C {lab_pin.sym} 2140 30200 0 0 {name=l24217 lab=BLB11}
N 2160 30160 2140 30160 {}
C {lab_pin.sym} 2140 30160 0 0 {name=l24218 lab=WL151}
N 2240 30240 2260 30240 {}
C {lab_pin.sym} 2260 30240 0 0 {name=l24219 lab=VDD}
N 2240 30160 2260 30160 {}
C {lab_pin.sym} 2260 30160 0 0 {name=l24220 lab=VSS}
C {bitcell_6t.sym} 2400 30200 0 0 {name=Xr151c12}
N 2360 30240 2340 30240 {}
C {lab_pin.sym} 2340 30240 0 0 {name=l24221 lab=BL12}
N 2360 30200 2340 30200 {}
C {lab_pin.sym} 2340 30200 0 0 {name=l24222 lab=BLB12}
N 2360 30160 2340 30160 {}
C {lab_pin.sym} 2340 30160 0 0 {name=l24223 lab=WL151}
N 2440 30240 2460 30240 {}
C {lab_pin.sym} 2460 30240 0 0 {name=l24224 lab=VDD}
N 2440 30160 2460 30160 {}
C {lab_pin.sym} 2460 30160 0 0 {name=l24225 lab=VSS}
C {bitcell_6t.sym} 2600 30200 0 0 {name=Xr151c13}
N 2560 30240 2540 30240 {}
C {lab_pin.sym} 2540 30240 0 0 {name=l24226 lab=BL13}
N 2560 30200 2540 30200 {}
C {lab_pin.sym} 2540 30200 0 0 {name=l24227 lab=BLB13}
N 2560 30160 2540 30160 {}
C {lab_pin.sym} 2540 30160 0 0 {name=l24228 lab=WL151}
N 2640 30240 2660 30240 {}
C {lab_pin.sym} 2660 30240 0 0 {name=l24229 lab=VDD}
N 2640 30160 2660 30160 {}
C {lab_pin.sym} 2660 30160 0 0 {name=l24230 lab=VSS}
C {bitcell_6t.sym} 2800 30200 0 0 {name=Xr151c14}
N 2760 30240 2740 30240 {}
C {lab_pin.sym} 2740 30240 0 0 {name=l24231 lab=BL14}
N 2760 30200 2740 30200 {}
C {lab_pin.sym} 2740 30200 0 0 {name=l24232 lab=BLB14}
N 2760 30160 2740 30160 {}
C {lab_pin.sym} 2740 30160 0 0 {name=l24233 lab=WL151}
N 2840 30240 2860 30240 {}
C {lab_pin.sym} 2860 30240 0 0 {name=l24234 lab=VDD}
N 2840 30160 2860 30160 {}
C {lab_pin.sym} 2860 30160 0 0 {name=l24235 lab=VSS}
C {bitcell_6t.sym} 3000 30200 0 0 {name=Xr151c15}
N 2960 30240 2940 30240 {}
C {lab_pin.sym} 2940 30240 0 0 {name=l24236 lab=BL15}
N 2960 30200 2940 30200 {}
C {lab_pin.sym} 2940 30200 0 0 {name=l24237 lab=BLB15}
N 2960 30160 2940 30160 {}
C {lab_pin.sym} 2940 30160 0 0 {name=l24238 lab=WL151}
N 3040 30240 3060 30240 {}
C {lab_pin.sym} 3060 30240 0 0 {name=l24239 lab=VDD}
N 3040 30160 3060 30160 {}
C {lab_pin.sym} 3060 30160 0 0 {name=l24240 lab=VSS}
C {bitcell_6t.sym} 3200 30200 0 0 {name=Xr151c16}
N 3160 30240 3140 30240 {}
C {lab_pin.sym} 3140 30240 0 0 {name=l24241 lab=BL16}
N 3160 30200 3140 30200 {}
C {lab_pin.sym} 3140 30200 0 0 {name=l24242 lab=BLB16}
N 3160 30160 3140 30160 {}
C {lab_pin.sym} 3140 30160 0 0 {name=l24243 lab=WL151}
N 3240 30240 3260 30240 {}
C {lab_pin.sym} 3260 30240 0 0 {name=l24244 lab=VDD}
N 3240 30160 3260 30160 {}
C {lab_pin.sym} 3260 30160 0 0 {name=l24245 lab=VSS}
C {bitcell_6t.sym} 3400 30200 0 0 {name=Xr151c17}
N 3360 30240 3340 30240 {}
C {lab_pin.sym} 3340 30240 0 0 {name=l24246 lab=BL17}
N 3360 30200 3340 30200 {}
C {lab_pin.sym} 3340 30200 0 0 {name=l24247 lab=BLB17}
N 3360 30160 3340 30160 {}
C {lab_pin.sym} 3340 30160 0 0 {name=l24248 lab=WL151}
N 3440 30240 3460 30240 {}
C {lab_pin.sym} 3460 30240 0 0 {name=l24249 lab=VDD}
N 3440 30160 3460 30160 {}
C {lab_pin.sym} 3460 30160 0 0 {name=l24250 lab=VSS}
C {bitcell_6t.sym} 3600 30200 0 0 {name=Xr151c18}
N 3560 30240 3540 30240 {}
C {lab_pin.sym} 3540 30240 0 0 {name=l24251 lab=BL18}
N 3560 30200 3540 30200 {}
C {lab_pin.sym} 3540 30200 0 0 {name=l24252 lab=BLB18}
N 3560 30160 3540 30160 {}
C {lab_pin.sym} 3540 30160 0 0 {name=l24253 lab=WL151}
N 3640 30240 3660 30240 {}
C {lab_pin.sym} 3660 30240 0 0 {name=l24254 lab=VDD}
N 3640 30160 3660 30160 {}
C {lab_pin.sym} 3660 30160 0 0 {name=l24255 lab=VSS}
C {bitcell_6t.sym} 3800 30200 0 0 {name=Xr151c19}
N 3760 30240 3740 30240 {}
C {lab_pin.sym} 3740 30240 0 0 {name=l24256 lab=BL19}
N 3760 30200 3740 30200 {}
C {lab_pin.sym} 3740 30200 0 0 {name=l24257 lab=BLB19}
N 3760 30160 3740 30160 {}
C {lab_pin.sym} 3740 30160 0 0 {name=l24258 lab=WL151}
N 3840 30240 3860 30240 {}
C {lab_pin.sym} 3860 30240 0 0 {name=l24259 lab=VDD}
N 3840 30160 3860 30160 {}
C {lab_pin.sym} 3860 30160 0 0 {name=l24260 lab=VSS}
C {bitcell_6t.sym} 4000 30200 0 0 {name=Xr151c20}
N 3960 30240 3940 30240 {}
C {lab_pin.sym} 3940 30240 0 0 {name=l24261 lab=BL20}
N 3960 30200 3940 30200 {}
C {lab_pin.sym} 3940 30200 0 0 {name=l24262 lab=BLB20}
N 3960 30160 3940 30160 {}
C {lab_pin.sym} 3940 30160 0 0 {name=l24263 lab=WL151}
N 4040 30240 4060 30240 {}
C {lab_pin.sym} 4060 30240 0 0 {name=l24264 lab=VDD}
N 4040 30160 4060 30160 {}
C {lab_pin.sym} 4060 30160 0 0 {name=l24265 lab=VSS}
C {bitcell_6t.sym} 4200 30200 0 0 {name=Xr151c21}
N 4160 30240 4140 30240 {}
C {lab_pin.sym} 4140 30240 0 0 {name=l24266 lab=BL21}
N 4160 30200 4140 30200 {}
C {lab_pin.sym} 4140 30200 0 0 {name=l24267 lab=BLB21}
N 4160 30160 4140 30160 {}
C {lab_pin.sym} 4140 30160 0 0 {name=l24268 lab=WL151}
N 4240 30240 4260 30240 {}
C {lab_pin.sym} 4260 30240 0 0 {name=l24269 lab=VDD}
N 4240 30160 4260 30160 {}
C {lab_pin.sym} 4260 30160 0 0 {name=l24270 lab=VSS}
C {bitcell_6t.sym} 4400 30200 0 0 {name=Xr151c22}
N 4360 30240 4340 30240 {}
C {lab_pin.sym} 4340 30240 0 0 {name=l24271 lab=BL22}
N 4360 30200 4340 30200 {}
C {lab_pin.sym} 4340 30200 0 0 {name=l24272 lab=BLB22}
N 4360 30160 4340 30160 {}
C {lab_pin.sym} 4340 30160 0 0 {name=l24273 lab=WL151}
N 4440 30240 4460 30240 {}
C {lab_pin.sym} 4460 30240 0 0 {name=l24274 lab=VDD}
N 4440 30160 4460 30160 {}
C {lab_pin.sym} 4460 30160 0 0 {name=l24275 lab=VSS}
C {bitcell_6t.sym} 4600 30200 0 0 {name=Xr151c23}
N 4560 30240 4540 30240 {}
C {lab_pin.sym} 4540 30240 0 0 {name=l24276 lab=BL23}
N 4560 30200 4540 30200 {}
C {lab_pin.sym} 4540 30200 0 0 {name=l24277 lab=BLB23}
N 4560 30160 4540 30160 {}
C {lab_pin.sym} 4540 30160 0 0 {name=l24278 lab=WL151}
N 4640 30240 4660 30240 {}
C {lab_pin.sym} 4660 30240 0 0 {name=l24279 lab=VDD}
N 4640 30160 4660 30160 {}
C {lab_pin.sym} 4660 30160 0 0 {name=l24280 lab=VSS}
C {bitcell_6t.sym} 4800 30200 0 0 {name=Xr151c24}
N 4760 30240 4740 30240 {}
C {lab_pin.sym} 4740 30240 0 0 {name=l24281 lab=BL24}
N 4760 30200 4740 30200 {}
C {lab_pin.sym} 4740 30200 0 0 {name=l24282 lab=BLB24}
N 4760 30160 4740 30160 {}
C {lab_pin.sym} 4740 30160 0 0 {name=l24283 lab=WL151}
N 4840 30240 4860 30240 {}
C {lab_pin.sym} 4860 30240 0 0 {name=l24284 lab=VDD}
N 4840 30160 4860 30160 {}
C {lab_pin.sym} 4860 30160 0 0 {name=l24285 lab=VSS}
C {bitcell_6t.sym} 5000 30200 0 0 {name=Xr151c25}
N 4960 30240 4940 30240 {}
C {lab_pin.sym} 4940 30240 0 0 {name=l24286 lab=BL25}
N 4960 30200 4940 30200 {}
C {lab_pin.sym} 4940 30200 0 0 {name=l24287 lab=BLB25}
N 4960 30160 4940 30160 {}
C {lab_pin.sym} 4940 30160 0 0 {name=l24288 lab=WL151}
N 5040 30240 5060 30240 {}
C {lab_pin.sym} 5060 30240 0 0 {name=l24289 lab=VDD}
N 5040 30160 5060 30160 {}
C {lab_pin.sym} 5060 30160 0 0 {name=l24290 lab=VSS}
C {bitcell_6t.sym} 5200 30200 0 0 {name=Xr151c26}
N 5160 30240 5140 30240 {}
C {lab_pin.sym} 5140 30240 0 0 {name=l24291 lab=BL26}
N 5160 30200 5140 30200 {}
C {lab_pin.sym} 5140 30200 0 0 {name=l24292 lab=BLB26}
N 5160 30160 5140 30160 {}
C {lab_pin.sym} 5140 30160 0 0 {name=l24293 lab=WL151}
N 5240 30240 5260 30240 {}
C {lab_pin.sym} 5260 30240 0 0 {name=l24294 lab=VDD}
N 5240 30160 5260 30160 {}
C {lab_pin.sym} 5260 30160 0 0 {name=l24295 lab=VSS}
C {bitcell_6t.sym} 5400 30200 0 0 {name=Xr151c27}
N 5360 30240 5340 30240 {}
C {lab_pin.sym} 5340 30240 0 0 {name=l24296 lab=BL27}
N 5360 30200 5340 30200 {}
C {lab_pin.sym} 5340 30200 0 0 {name=l24297 lab=BLB27}
N 5360 30160 5340 30160 {}
C {lab_pin.sym} 5340 30160 0 0 {name=l24298 lab=WL151}
N 5440 30240 5460 30240 {}
C {lab_pin.sym} 5460 30240 0 0 {name=l24299 lab=VDD}
N 5440 30160 5460 30160 {}
C {lab_pin.sym} 5460 30160 0 0 {name=l24300 lab=VSS}
C {bitcell_6t.sym} 5600 30200 0 0 {name=Xr151c28}
N 5560 30240 5540 30240 {}
C {lab_pin.sym} 5540 30240 0 0 {name=l24301 lab=BL28}
N 5560 30200 5540 30200 {}
C {lab_pin.sym} 5540 30200 0 0 {name=l24302 lab=BLB28}
N 5560 30160 5540 30160 {}
C {lab_pin.sym} 5540 30160 0 0 {name=l24303 lab=WL151}
N 5640 30240 5660 30240 {}
C {lab_pin.sym} 5660 30240 0 0 {name=l24304 lab=VDD}
N 5640 30160 5660 30160 {}
C {lab_pin.sym} 5660 30160 0 0 {name=l24305 lab=VSS}
C {bitcell_6t.sym} 5800 30200 0 0 {name=Xr151c29}
N 5760 30240 5740 30240 {}
C {lab_pin.sym} 5740 30240 0 0 {name=l24306 lab=BL29}
N 5760 30200 5740 30200 {}
C {lab_pin.sym} 5740 30200 0 0 {name=l24307 lab=BLB29}
N 5760 30160 5740 30160 {}
C {lab_pin.sym} 5740 30160 0 0 {name=l24308 lab=WL151}
N 5840 30240 5860 30240 {}
C {lab_pin.sym} 5860 30240 0 0 {name=l24309 lab=VDD}
N 5840 30160 5860 30160 {}
C {lab_pin.sym} 5860 30160 0 0 {name=l24310 lab=VSS}
C {bitcell_6t.sym} 6000 30200 0 0 {name=Xr151c30}
N 5960 30240 5940 30240 {}
C {lab_pin.sym} 5940 30240 0 0 {name=l24311 lab=BL30}
N 5960 30200 5940 30200 {}
C {lab_pin.sym} 5940 30200 0 0 {name=l24312 lab=BLB30}
N 5960 30160 5940 30160 {}
C {lab_pin.sym} 5940 30160 0 0 {name=l24313 lab=WL151}
N 6040 30240 6060 30240 {}
C {lab_pin.sym} 6060 30240 0 0 {name=l24314 lab=VDD}
N 6040 30160 6060 30160 {}
C {lab_pin.sym} 6060 30160 0 0 {name=l24315 lab=VSS}
C {bitcell_6t.sym} 6200 30200 0 0 {name=Xr151c31}
N 6160 30240 6140 30240 {}
C {lab_pin.sym} 6140 30240 0 0 {name=l24316 lab=BL31}
N 6160 30200 6140 30200 {}
C {lab_pin.sym} 6140 30200 0 0 {name=l24317 lab=BLB31}
N 6160 30160 6140 30160 {}
C {lab_pin.sym} 6140 30160 0 0 {name=l24318 lab=WL151}
N 6240 30240 6260 30240 {}
C {lab_pin.sym} 6260 30240 0 0 {name=l24319 lab=VDD}
N 6240 30160 6260 30160 {}
C {lab_pin.sym} 6260 30160 0 0 {name=l24320 lab=VSS}
C {bitcell_6t.sym} 0 30400 0 0 {name=Xr152c0}
N -40 30440 -60 30440 {}
C {lab_pin.sym} -60 30440 0 0 {name=l24321 lab=BL0}
N -40 30400 -60 30400 {}
C {lab_pin.sym} -60 30400 0 0 {name=l24322 lab=BLB0}
N -40 30360 -60 30360 {}
C {lab_pin.sym} -60 30360 0 0 {name=l24323 lab=WL152}
N 40 30440 60 30440 {}
C {lab_pin.sym} 60 30440 0 0 {name=l24324 lab=VDD}
N 40 30360 60 30360 {}
C {lab_pin.sym} 60 30360 0 0 {name=l24325 lab=VSS}
C {bitcell_6t.sym} 200 30400 0 0 {name=Xr152c1}
N 160 30440 140 30440 {}
C {lab_pin.sym} 140 30440 0 0 {name=l24326 lab=BL1}
N 160 30400 140 30400 {}
C {lab_pin.sym} 140 30400 0 0 {name=l24327 lab=BLB1}
N 160 30360 140 30360 {}
C {lab_pin.sym} 140 30360 0 0 {name=l24328 lab=WL152}
N 240 30440 260 30440 {}
C {lab_pin.sym} 260 30440 0 0 {name=l24329 lab=VDD}
N 240 30360 260 30360 {}
C {lab_pin.sym} 260 30360 0 0 {name=l24330 lab=VSS}
C {bitcell_6t.sym} 400 30400 0 0 {name=Xr152c2}
N 360 30440 340 30440 {}
C {lab_pin.sym} 340 30440 0 0 {name=l24331 lab=BL2}
N 360 30400 340 30400 {}
C {lab_pin.sym} 340 30400 0 0 {name=l24332 lab=BLB2}
N 360 30360 340 30360 {}
C {lab_pin.sym} 340 30360 0 0 {name=l24333 lab=WL152}
N 440 30440 460 30440 {}
C {lab_pin.sym} 460 30440 0 0 {name=l24334 lab=VDD}
N 440 30360 460 30360 {}
C {lab_pin.sym} 460 30360 0 0 {name=l24335 lab=VSS}
C {bitcell_6t.sym} 600 30400 0 0 {name=Xr152c3}
N 560 30440 540 30440 {}
C {lab_pin.sym} 540 30440 0 0 {name=l24336 lab=BL3}
N 560 30400 540 30400 {}
C {lab_pin.sym} 540 30400 0 0 {name=l24337 lab=BLB3}
N 560 30360 540 30360 {}
C {lab_pin.sym} 540 30360 0 0 {name=l24338 lab=WL152}
N 640 30440 660 30440 {}
C {lab_pin.sym} 660 30440 0 0 {name=l24339 lab=VDD}
N 640 30360 660 30360 {}
C {lab_pin.sym} 660 30360 0 0 {name=l24340 lab=VSS}
C {bitcell_6t.sym} 800 30400 0 0 {name=Xr152c4}
N 760 30440 740 30440 {}
C {lab_pin.sym} 740 30440 0 0 {name=l24341 lab=BL4}
N 760 30400 740 30400 {}
C {lab_pin.sym} 740 30400 0 0 {name=l24342 lab=BLB4}
N 760 30360 740 30360 {}
C {lab_pin.sym} 740 30360 0 0 {name=l24343 lab=WL152}
N 840 30440 860 30440 {}
C {lab_pin.sym} 860 30440 0 0 {name=l24344 lab=VDD}
N 840 30360 860 30360 {}
C {lab_pin.sym} 860 30360 0 0 {name=l24345 lab=VSS}
C {bitcell_6t.sym} 1000 30400 0 0 {name=Xr152c5}
N 960 30440 940 30440 {}
C {lab_pin.sym} 940 30440 0 0 {name=l24346 lab=BL5}
N 960 30400 940 30400 {}
C {lab_pin.sym} 940 30400 0 0 {name=l24347 lab=BLB5}
N 960 30360 940 30360 {}
C {lab_pin.sym} 940 30360 0 0 {name=l24348 lab=WL152}
N 1040 30440 1060 30440 {}
C {lab_pin.sym} 1060 30440 0 0 {name=l24349 lab=VDD}
N 1040 30360 1060 30360 {}
C {lab_pin.sym} 1060 30360 0 0 {name=l24350 lab=VSS}
C {bitcell_6t.sym} 1200 30400 0 0 {name=Xr152c6}
N 1160 30440 1140 30440 {}
C {lab_pin.sym} 1140 30440 0 0 {name=l24351 lab=BL6}
N 1160 30400 1140 30400 {}
C {lab_pin.sym} 1140 30400 0 0 {name=l24352 lab=BLB6}
N 1160 30360 1140 30360 {}
C {lab_pin.sym} 1140 30360 0 0 {name=l24353 lab=WL152}
N 1240 30440 1260 30440 {}
C {lab_pin.sym} 1260 30440 0 0 {name=l24354 lab=VDD}
N 1240 30360 1260 30360 {}
C {lab_pin.sym} 1260 30360 0 0 {name=l24355 lab=VSS}
C {bitcell_6t.sym} 1400 30400 0 0 {name=Xr152c7}
N 1360 30440 1340 30440 {}
C {lab_pin.sym} 1340 30440 0 0 {name=l24356 lab=BL7}
N 1360 30400 1340 30400 {}
C {lab_pin.sym} 1340 30400 0 0 {name=l24357 lab=BLB7}
N 1360 30360 1340 30360 {}
C {lab_pin.sym} 1340 30360 0 0 {name=l24358 lab=WL152}
N 1440 30440 1460 30440 {}
C {lab_pin.sym} 1460 30440 0 0 {name=l24359 lab=VDD}
N 1440 30360 1460 30360 {}
C {lab_pin.sym} 1460 30360 0 0 {name=l24360 lab=VSS}
C {bitcell_6t.sym} 1600 30400 0 0 {name=Xr152c8}
N 1560 30440 1540 30440 {}
C {lab_pin.sym} 1540 30440 0 0 {name=l24361 lab=BL8}
N 1560 30400 1540 30400 {}
C {lab_pin.sym} 1540 30400 0 0 {name=l24362 lab=BLB8}
N 1560 30360 1540 30360 {}
C {lab_pin.sym} 1540 30360 0 0 {name=l24363 lab=WL152}
N 1640 30440 1660 30440 {}
C {lab_pin.sym} 1660 30440 0 0 {name=l24364 lab=VDD}
N 1640 30360 1660 30360 {}
C {lab_pin.sym} 1660 30360 0 0 {name=l24365 lab=VSS}
C {bitcell_6t.sym} 1800 30400 0 0 {name=Xr152c9}
N 1760 30440 1740 30440 {}
C {lab_pin.sym} 1740 30440 0 0 {name=l24366 lab=BL9}
N 1760 30400 1740 30400 {}
C {lab_pin.sym} 1740 30400 0 0 {name=l24367 lab=BLB9}
N 1760 30360 1740 30360 {}
C {lab_pin.sym} 1740 30360 0 0 {name=l24368 lab=WL152}
N 1840 30440 1860 30440 {}
C {lab_pin.sym} 1860 30440 0 0 {name=l24369 lab=VDD}
N 1840 30360 1860 30360 {}
C {lab_pin.sym} 1860 30360 0 0 {name=l24370 lab=VSS}
C {bitcell_6t.sym} 2000 30400 0 0 {name=Xr152c10}
N 1960 30440 1940 30440 {}
C {lab_pin.sym} 1940 30440 0 0 {name=l24371 lab=BL10}
N 1960 30400 1940 30400 {}
C {lab_pin.sym} 1940 30400 0 0 {name=l24372 lab=BLB10}
N 1960 30360 1940 30360 {}
C {lab_pin.sym} 1940 30360 0 0 {name=l24373 lab=WL152}
N 2040 30440 2060 30440 {}
C {lab_pin.sym} 2060 30440 0 0 {name=l24374 lab=VDD}
N 2040 30360 2060 30360 {}
C {lab_pin.sym} 2060 30360 0 0 {name=l24375 lab=VSS}
C {bitcell_6t.sym} 2200 30400 0 0 {name=Xr152c11}
N 2160 30440 2140 30440 {}
C {lab_pin.sym} 2140 30440 0 0 {name=l24376 lab=BL11}
N 2160 30400 2140 30400 {}
C {lab_pin.sym} 2140 30400 0 0 {name=l24377 lab=BLB11}
N 2160 30360 2140 30360 {}
C {lab_pin.sym} 2140 30360 0 0 {name=l24378 lab=WL152}
N 2240 30440 2260 30440 {}
C {lab_pin.sym} 2260 30440 0 0 {name=l24379 lab=VDD}
N 2240 30360 2260 30360 {}
C {lab_pin.sym} 2260 30360 0 0 {name=l24380 lab=VSS}
C {bitcell_6t.sym} 2400 30400 0 0 {name=Xr152c12}
N 2360 30440 2340 30440 {}
C {lab_pin.sym} 2340 30440 0 0 {name=l24381 lab=BL12}
N 2360 30400 2340 30400 {}
C {lab_pin.sym} 2340 30400 0 0 {name=l24382 lab=BLB12}
N 2360 30360 2340 30360 {}
C {lab_pin.sym} 2340 30360 0 0 {name=l24383 lab=WL152}
N 2440 30440 2460 30440 {}
C {lab_pin.sym} 2460 30440 0 0 {name=l24384 lab=VDD}
N 2440 30360 2460 30360 {}
C {lab_pin.sym} 2460 30360 0 0 {name=l24385 lab=VSS}
C {bitcell_6t.sym} 2600 30400 0 0 {name=Xr152c13}
N 2560 30440 2540 30440 {}
C {lab_pin.sym} 2540 30440 0 0 {name=l24386 lab=BL13}
N 2560 30400 2540 30400 {}
C {lab_pin.sym} 2540 30400 0 0 {name=l24387 lab=BLB13}
N 2560 30360 2540 30360 {}
C {lab_pin.sym} 2540 30360 0 0 {name=l24388 lab=WL152}
N 2640 30440 2660 30440 {}
C {lab_pin.sym} 2660 30440 0 0 {name=l24389 lab=VDD}
N 2640 30360 2660 30360 {}
C {lab_pin.sym} 2660 30360 0 0 {name=l24390 lab=VSS}
C {bitcell_6t.sym} 2800 30400 0 0 {name=Xr152c14}
N 2760 30440 2740 30440 {}
C {lab_pin.sym} 2740 30440 0 0 {name=l24391 lab=BL14}
N 2760 30400 2740 30400 {}
C {lab_pin.sym} 2740 30400 0 0 {name=l24392 lab=BLB14}
N 2760 30360 2740 30360 {}
C {lab_pin.sym} 2740 30360 0 0 {name=l24393 lab=WL152}
N 2840 30440 2860 30440 {}
C {lab_pin.sym} 2860 30440 0 0 {name=l24394 lab=VDD}
N 2840 30360 2860 30360 {}
C {lab_pin.sym} 2860 30360 0 0 {name=l24395 lab=VSS}
C {bitcell_6t.sym} 3000 30400 0 0 {name=Xr152c15}
N 2960 30440 2940 30440 {}
C {lab_pin.sym} 2940 30440 0 0 {name=l24396 lab=BL15}
N 2960 30400 2940 30400 {}
C {lab_pin.sym} 2940 30400 0 0 {name=l24397 lab=BLB15}
N 2960 30360 2940 30360 {}
C {lab_pin.sym} 2940 30360 0 0 {name=l24398 lab=WL152}
N 3040 30440 3060 30440 {}
C {lab_pin.sym} 3060 30440 0 0 {name=l24399 lab=VDD}
N 3040 30360 3060 30360 {}
C {lab_pin.sym} 3060 30360 0 0 {name=l24400 lab=VSS}
C {bitcell_6t.sym} 3200 30400 0 0 {name=Xr152c16}
N 3160 30440 3140 30440 {}
C {lab_pin.sym} 3140 30440 0 0 {name=l24401 lab=BL16}
N 3160 30400 3140 30400 {}
C {lab_pin.sym} 3140 30400 0 0 {name=l24402 lab=BLB16}
N 3160 30360 3140 30360 {}
C {lab_pin.sym} 3140 30360 0 0 {name=l24403 lab=WL152}
N 3240 30440 3260 30440 {}
C {lab_pin.sym} 3260 30440 0 0 {name=l24404 lab=VDD}
N 3240 30360 3260 30360 {}
C {lab_pin.sym} 3260 30360 0 0 {name=l24405 lab=VSS}
C {bitcell_6t.sym} 3400 30400 0 0 {name=Xr152c17}
N 3360 30440 3340 30440 {}
C {lab_pin.sym} 3340 30440 0 0 {name=l24406 lab=BL17}
N 3360 30400 3340 30400 {}
C {lab_pin.sym} 3340 30400 0 0 {name=l24407 lab=BLB17}
N 3360 30360 3340 30360 {}
C {lab_pin.sym} 3340 30360 0 0 {name=l24408 lab=WL152}
N 3440 30440 3460 30440 {}
C {lab_pin.sym} 3460 30440 0 0 {name=l24409 lab=VDD}
N 3440 30360 3460 30360 {}
C {lab_pin.sym} 3460 30360 0 0 {name=l24410 lab=VSS}
C {bitcell_6t.sym} 3600 30400 0 0 {name=Xr152c18}
N 3560 30440 3540 30440 {}
C {lab_pin.sym} 3540 30440 0 0 {name=l24411 lab=BL18}
N 3560 30400 3540 30400 {}
C {lab_pin.sym} 3540 30400 0 0 {name=l24412 lab=BLB18}
N 3560 30360 3540 30360 {}
C {lab_pin.sym} 3540 30360 0 0 {name=l24413 lab=WL152}
N 3640 30440 3660 30440 {}
C {lab_pin.sym} 3660 30440 0 0 {name=l24414 lab=VDD}
N 3640 30360 3660 30360 {}
C {lab_pin.sym} 3660 30360 0 0 {name=l24415 lab=VSS}
C {bitcell_6t.sym} 3800 30400 0 0 {name=Xr152c19}
N 3760 30440 3740 30440 {}
C {lab_pin.sym} 3740 30440 0 0 {name=l24416 lab=BL19}
N 3760 30400 3740 30400 {}
C {lab_pin.sym} 3740 30400 0 0 {name=l24417 lab=BLB19}
N 3760 30360 3740 30360 {}
C {lab_pin.sym} 3740 30360 0 0 {name=l24418 lab=WL152}
N 3840 30440 3860 30440 {}
C {lab_pin.sym} 3860 30440 0 0 {name=l24419 lab=VDD}
N 3840 30360 3860 30360 {}
C {lab_pin.sym} 3860 30360 0 0 {name=l24420 lab=VSS}
C {bitcell_6t.sym} 4000 30400 0 0 {name=Xr152c20}
N 3960 30440 3940 30440 {}
C {lab_pin.sym} 3940 30440 0 0 {name=l24421 lab=BL20}
N 3960 30400 3940 30400 {}
C {lab_pin.sym} 3940 30400 0 0 {name=l24422 lab=BLB20}
N 3960 30360 3940 30360 {}
C {lab_pin.sym} 3940 30360 0 0 {name=l24423 lab=WL152}
N 4040 30440 4060 30440 {}
C {lab_pin.sym} 4060 30440 0 0 {name=l24424 lab=VDD}
N 4040 30360 4060 30360 {}
C {lab_pin.sym} 4060 30360 0 0 {name=l24425 lab=VSS}
C {bitcell_6t.sym} 4200 30400 0 0 {name=Xr152c21}
N 4160 30440 4140 30440 {}
C {lab_pin.sym} 4140 30440 0 0 {name=l24426 lab=BL21}
N 4160 30400 4140 30400 {}
C {lab_pin.sym} 4140 30400 0 0 {name=l24427 lab=BLB21}
N 4160 30360 4140 30360 {}
C {lab_pin.sym} 4140 30360 0 0 {name=l24428 lab=WL152}
N 4240 30440 4260 30440 {}
C {lab_pin.sym} 4260 30440 0 0 {name=l24429 lab=VDD}
N 4240 30360 4260 30360 {}
C {lab_pin.sym} 4260 30360 0 0 {name=l24430 lab=VSS}
C {bitcell_6t.sym} 4400 30400 0 0 {name=Xr152c22}
N 4360 30440 4340 30440 {}
C {lab_pin.sym} 4340 30440 0 0 {name=l24431 lab=BL22}
N 4360 30400 4340 30400 {}
C {lab_pin.sym} 4340 30400 0 0 {name=l24432 lab=BLB22}
N 4360 30360 4340 30360 {}
C {lab_pin.sym} 4340 30360 0 0 {name=l24433 lab=WL152}
N 4440 30440 4460 30440 {}
C {lab_pin.sym} 4460 30440 0 0 {name=l24434 lab=VDD}
N 4440 30360 4460 30360 {}
C {lab_pin.sym} 4460 30360 0 0 {name=l24435 lab=VSS}
C {bitcell_6t.sym} 4600 30400 0 0 {name=Xr152c23}
N 4560 30440 4540 30440 {}
C {lab_pin.sym} 4540 30440 0 0 {name=l24436 lab=BL23}
N 4560 30400 4540 30400 {}
C {lab_pin.sym} 4540 30400 0 0 {name=l24437 lab=BLB23}
N 4560 30360 4540 30360 {}
C {lab_pin.sym} 4540 30360 0 0 {name=l24438 lab=WL152}
N 4640 30440 4660 30440 {}
C {lab_pin.sym} 4660 30440 0 0 {name=l24439 lab=VDD}
N 4640 30360 4660 30360 {}
C {lab_pin.sym} 4660 30360 0 0 {name=l24440 lab=VSS}
C {bitcell_6t.sym} 4800 30400 0 0 {name=Xr152c24}
N 4760 30440 4740 30440 {}
C {lab_pin.sym} 4740 30440 0 0 {name=l24441 lab=BL24}
N 4760 30400 4740 30400 {}
C {lab_pin.sym} 4740 30400 0 0 {name=l24442 lab=BLB24}
N 4760 30360 4740 30360 {}
C {lab_pin.sym} 4740 30360 0 0 {name=l24443 lab=WL152}
N 4840 30440 4860 30440 {}
C {lab_pin.sym} 4860 30440 0 0 {name=l24444 lab=VDD}
N 4840 30360 4860 30360 {}
C {lab_pin.sym} 4860 30360 0 0 {name=l24445 lab=VSS}
C {bitcell_6t.sym} 5000 30400 0 0 {name=Xr152c25}
N 4960 30440 4940 30440 {}
C {lab_pin.sym} 4940 30440 0 0 {name=l24446 lab=BL25}
N 4960 30400 4940 30400 {}
C {lab_pin.sym} 4940 30400 0 0 {name=l24447 lab=BLB25}
N 4960 30360 4940 30360 {}
C {lab_pin.sym} 4940 30360 0 0 {name=l24448 lab=WL152}
N 5040 30440 5060 30440 {}
C {lab_pin.sym} 5060 30440 0 0 {name=l24449 lab=VDD}
N 5040 30360 5060 30360 {}
C {lab_pin.sym} 5060 30360 0 0 {name=l24450 lab=VSS}
C {bitcell_6t.sym} 5200 30400 0 0 {name=Xr152c26}
N 5160 30440 5140 30440 {}
C {lab_pin.sym} 5140 30440 0 0 {name=l24451 lab=BL26}
N 5160 30400 5140 30400 {}
C {lab_pin.sym} 5140 30400 0 0 {name=l24452 lab=BLB26}
N 5160 30360 5140 30360 {}
C {lab_pin.sym} 5140 30360 0 0 {name=l24453 lab=WL152}
N 5240 30440 5260 30440 {}
C {lab_pin.sym} 5260 30440 0 0 {name=l24454 lab=VDD}
N 5240 30360 5260 30360 {}
C {lab_pin.sym} 5260 30360 0 0 {name=l24455 lab=VSS}
C {bitcell_6t.sym} 5400 30400 0 0 {name=Xr152c27}
N 5360 30440 5340 30440 {}
C {lab_pin.sym} 5340 30440 0 0 {name=l24456 lab=BL27}
N 5360 30400 5340 30400 {}
C {lab_pin.sym} 5340 30400 0 0 {name=l24457 lab=BLB27}
N 5360 30360 5340 30360 {}
C {lab_pin.sym} 5340 30360 0 0 {name=l24458 lab=WL152}
N 5440 30440 5460 30440 {}
C {lab_pin.sym} 5460 30440 0 0 {name=l24459 lab=VDD}
N 5440 30360 5460 30360 {}
C {lab_pin.sym} 5460 30360 0 0 {name=l24460 lab=VSS}
C {bitcell_6t.sym} 5600 30400 0 0 {name=Xr152c28}
N 5560 30440 5540 30440 {}
C {lab_pin.sym} 5540 30440 0 0 {name=l24461 lab=BL28}
N 5560 30400 5540 30400 {}
C {lab_pin.sym} 5540 30400 0 0 {name=l24462 lab=BLB28}
N 5560 30360 5540 30360 {}
C {lab_pin.sym} 5540 30360 0 0 {name=l24463 lab=WL152}
N 5640 30440 5660 30440 {}
C {lab_pin.sym} 5660 30440 0 0 {name=l24464 lab=VDD}
N 5640 30360 5660 30360 {}
C {lab_pin.sym} 5660 30360 0 0 {name=l24465 lab=VSS}
C {bitcell_6t.sym} 5800 30400 0 0 {name=Xr152c29}
N 5760 30440 5740 30440 {}
C {lab_pin.sym} 5740 30440 0 0 {name=l24466 lab=BL29}
N 5760 30400 5740 30400 {}
C {lab_pin.sym} 5740 30400 0 0 {name=l24467 lab=BLB29}
N 5760 30360 5740 30360 {}
C {lab_pin.sym} 5740 30360 0 0 {name=l24468 lab=WL152}
N 5840 30440 5860 30440 {}
C {lab_pin.sym} 5860 30440 0 0 {name=l24469 lab=VDD}
N 5840 30360 5860 30360 {}
C {lab_pin.sym} 5860 30360 0 0 {name=l24470 lab=VSS}
C {bitcell_6t.sym} 6000 30400 0 0 {name=Xr152c30}
N 5960 30440 5940 30440 {}
C {lab_pin.sym} 5940 30440 0 0 {name=l24471 lab=BL30}
N 5960 30400 5940 30400 {}
C {lab_pin.sym} 5940 30400 0 0 {name=l24472 lab=BLB30}
N 5960 30360 5940 30360 {}
C {lab_pin.sym} 5940 30360 0 0 {name=l24473 lab=WL152}
N 6040 30440 6060 30440 {}
C {lab_pin.sym} 6060 30440 0 0 {name=l24474 lab=VDD}
N 6040 30360 6060 30360 {}
C {lab_pin.sym} 6060 30360 0 0 {name=l24475 lab=VSS}
C {bitcell_6t.sym} 6200 30400 0 0 {name=Xr152c31}
N 6160 30440 6140 30440 {}
C {lab_pin.sym} 6140 30440 0 0 {name=l24476 lab=BL31}
N 6160 30400 6140 30400 {}
C {lab_pin.sym} 6140 30400 0 0 {name=l24477 lab=BLB31}
N 6160 30360 6140 30360 {}
C {lab_pin.sym} 6140 30360 0 0 {name=l24478 lab=WL152}
N 6240 30440 6260 30440 {}
C {lab_pin.sym} 6260 30440 0 0 {name=l24479 lab=VDD}
N 6240 30360 6260 30360 {}
C {lab_pin.sym} 6260 30360 0 0 {name=l24480 lab=VSS}
C {bitcell_6t.sym} 0 30600 0 0 {name=Xr153c0}
N -40 30640 -60 30640 {}
C {lab_pin.sym} -60 30640 0 0 {name=l24481 lab=BL0}
N -40 30600 -60 30600 {}
C {lab_pin.sym} -60 30600 0 0 {name=l24482 lab=BLB0}
N -40 30560 -60 30560 {}
C {lab_pin.sym} -60 30560 0 0 {name=l24483 lab=WL153}
N 40 30640 60 30640 {}
C {lab_pin.sym} 60 30640 0 0 {name=l24484 lab=VDD}
N 40 30560 60 30560 {}
C {lab_pin.sym} 60 30560 0 0 {name=l24485 lab=VSS}
C {bitcell_6t.sym} 200 30600 0 0 {name=Xr153c1}
N 160 30640 140 30640 {}
C {lab_pin.sym} 140 30640 0 0 {name=l24486 lab=BL1}
N 160 30600 140 30600 {}
C {lab_pin.sym} 140 30600 0 0 {name=l24487 lab=BLB1}
N 160 30560 140 30560 {}
C {lab_pin.sym} 140 30560 0 0 {name=l24488 lab=WL153}
N 240 30640 260 30640 {}
C {lab_pin.sym} 260 30640 0 0 {name=l24489 lab=VDD}
N 240 30560 260 30560 {}
C {lab_pin.sym} 260 30560 0 0 {name=l24490 lab=VSS}
C {bitcell_6t.sym} 400 30600 0 0 {name=Xr153c2}
N 360 30640 340 30640 {}
C {lab_pin.sym} 340 30640 0 0 {name=l24491 lab=BL2}
N 360 30600 340 30600 {}
C {lab_pin.sym} 340 30600 0 0 {name=l24492 lab=BLB2}
N 360 30560 340 30560 {}
C {lab_pin.sym} 340 30560 0 0 {name=l24493 lab=WL153}
N 440 30640 460 30640 {}
C {lab_pin.sym} 460 30640 0 0 {name=l24494 lab=VDD}
N 440 30560 460 30560 {}
C {lab_pin.sym} 460 30560 0 0 {name=l24495 lab=VSS}
C {bitcell_6t.sym} 600 30600 0 0 {name=Xr153c3}
N 560 30640 540 30640 {}
C {lab_pin.sym} 540 30640 0 0 {name=l24496 lab=BL3}
N 560 30600 540 30600 {}
C {lab_pin.sym} 540 30600 0 0 {name=l24497 lab=BLB3}
N 560 30560 540 30560 {}
C {lab_pin.sym} 540 30560 0 0 {name=l24498 lab=WL153}
N 640 30640 660 30640 {}
C {lab_pin.sym} 660 30640 0 0 {name=l24499 lab=VDD}
N 640 30560 660 30560 {}
C {lab_pin.sym} 660 30560 0 0 {name=l24500 lab=VSS}
C {bitcell_6t.sym} 800 30600 0 0 {name=Xr153c4}
N 760 30640 740 30640 {}
C {lab_pin.sym} 740 30640 0 0 {name=l24501 lab=BL4}
N 760 30600 740 30600 {}
C {lab_pin.sym} 740 30600 0 0 {name=l24502 lab=BLB4}
N 760 30560 740 30560 {}
C {lab_pin.sym} 740 30560 0 0 {name=l24503 lab=WL153}
N 840 30640 860 30640 {}
C {lab_pin.sym} 860 30640 0 0 {name=l24504 lab=VDD}
N 840 30560 860 30560 {}
C {lab_pin.sym} 860 30560 0 0 {name=l24505 lab=VSS}
C {bitcell_6t.sym} 1000 30600 0 0 {name=Xr153c5}
N 960 30640 940 30640 {}
C {lab_pin.sym} 940 30640 0 0 {name=l24506 lab=BL5}
N 960 30600 940 30600 {}
C {lab_pin.sym} 940 30600 0 0 {name=l24507 lab=BLB5}
N 960 30560 940 30560 {}
C {lab_pin.sym} 940 30560 0 0 {name=l24508 lab=WL153}
N 1040 30640 1060 30640 {}
C {lab_pin.sym} 1060 30640 0 0 {name=l24509 lab=VDD}
N 1040 30560 1060 30560 {}
C {lab_pin.sym} 1060 30560 0 0 {name=l24510 lab=VSS}
C {bitcell_6t.sym} 1200 30600 0 0 {name=Xr153c6}
N 1160 30640 1140 30640 {}
C {lab_pin.sym} 1140 30640 0 0 {name=l24511 lab=BL6}
N 1160 30600 1140 30600 {}
C {lab_pin.sym} 1140 30600 0 0 {name=l24512 lab=BLB6}
N 1160 30560 1140 30560 {}
C {lab_pin.sym} 1140 30560 0 0 {name=l24513 lab=WL153}
N 1240 30640 1260 30640 {}
C {lab_pin.sym} 1260 30640 0 0 {name=l24514 lab=VDD}
N 1240 30560 1260 30560 {}
C {lab_pin.sym} 1260 30560 0 0 {name=l24515 lab=VSS}
C {bitcell_6t.sym} 1400 30600 0 0 {name=Xr153c7}
N 1360 30640 1340 30640 {}
C {lab_pin.sym} 1340 30640 0 0 {name=l24516 lab=BL7}
N 1360 30600 1340 30600 {}
C {lab_pin.sym} 1340 30600 0 0 {name=l24517 lab=BLB7}
N 1360 30560 1340 30560 {}
C {lab_pin.sym} 1340 30560 0 0 {name=l24518 lab=WL153}
N 1440 30640 1460 30640 {}
C {lab_pin.sym} 1460 30640 0 0 {name=l24519 lab=VDD}
N 1440 30560 1460 30560 {}
C {lab_pin.sym} 1460 30560 0 0 {name=l24520 lab=VSS}
C {bitcell_6t.sym} 1600 30600 0 0 {name=Xr153c8}
N 1560 30640 1540 30640 {}
C {lab_pin.sym} 1540 30640 0 0 {name=l24521 lab=BL8}
N 1560 30600 1540 30600 {}
C {lab_pin.sym} 1540 30600 0 0 {name=l24522 lab=BLB8}
N 1560 30560 1540 30560 {}
C {lab_pin.sym} 1540 30560 0 0 {name=l24523 lab=WL153}
N 1640 30640 1660 30640 {}
C {lab_pin.sym} 1660 30640 0 0 {name=l24524 lab=VDD}
N 1640 30560 1660 30560 {}
C {lab_pin.sym} 1660 30560 0 0 {name=l24525 lab=VSS}
C {bitcell_6t.sym} 1800 30600 0 0 {name=Xr153c9}
N 1760 30640 1740 30640 {}
C {lab_pin.sym} 1740 30640 0 0 {name=l24526 lab=BL9}
N 1760 30600 1740 30600 {}
C {lab_pin.sym} 1740 30600 0 0 {name=l24527 lab=BLB9}
N 1760 30560 1740 30560 {}
C {lab_pin.sym} 1740 30560 0 0 {name=l24528 lab=WL153}
N 1840 30640 1860 30640 {}
C {lab_pin.sym} 1860 30640 0 0 {name=l24529 lab=VDD}
N 1840 30560 1860 30560 {}
C {lab_pin.sym} 1860 30560 0 0 {name=l24530 lab=VSS}
C {bitcell_6t.sym} 2000 30600 0 0 {name=Xr153c10}
N 1960 30640 1940 30640 {}
C {lab_pin.sym} 1940 30640 0 0 {name=l24531 lab=BL10}
N 1960 30600 1940 30600 {}
C {lab_pin.sym} 1940 30600 0 0 {name=l24532 lab=BLB10}
N 1960 30560 1940 30560 {}
C {lab_pin.sym} 1940 30560 0 0 {name=l24533 lab=WL153}
N 2040 30640 2060 30640 {}
C {lab_pin.sym} 2060 30640 0 0 {name=l24534 lab=VDD}
N 2040 30560 2060 30560 {}
C {lab_pin.sym} 2060 30560 0 0 {name=l24535 lab=VSS}
C {bitcell_6t.sym} 2200 30600 0 0 {name=Xr153c11}
N 2160 30640 2140 30640 {}
C {lab_pin.sym} 2140 30640 0 0 {name=l24536 lab=BL11}
N 2160 30600 2140 30600 {}
C {lab_pin.sym} 2140 30600 0 0 {name=l24537 lab=BLB11}
N 2160 30560 2140 30560 {}
C {lab_pin.sym} 2140 30560 0 0 {name=l24538 lab=WL153}
N 2240 30640 2260 30640 {}
C {lab_pin.sym} 2260 30640 0 0 {name=l24539 lab=VDD}
N 2240 30560 2260 30560 {}
C {lab_pin.sym} 2260 30560 0 0 {name=l24540 lab=VSS}
C {bitcell_6t.sym} 2400 30600 0 0 {name=Xr153c12}
N 2360 30640 2340 30640 {}
C {lab_pin.sym} 2340 30640 0 0 {name=l24541 lab=BL12}
N 2360 30600 2340 30600 {}
C {lab_pin.sym} 2340 30600 0 0 {name=l24542 lab=BLB12}
N 2360 30560 2340 30560 {}
C {lab_pin.sym} 2340 30560 0 0 {name=l24543 lab=WL153}
N 2440 30640 2460 30640 {}
C {lab_pin.sym} 2460 30640 0 0 {name=l24544 lab=VDD}
N 2440 30560 2460 30560 {}
C {lab_pin.sym} 2460 30560 0 0 {name=l24545 lab=VSS}
C {bitcell_6t.sym} 2600 30600 0 0 {name=Xr153c13}
N 2560 30640 2540 30640 {}
C {lab_pin.sym} 2540 30640 0 0 {name=l24546 lab=BL13}
N 2560 30600 2540 30600 {}
C {lab_pin.sym} 2540 30600 0 0 {name=l24547 lab=BLB13}
N 2560 30560 2540 30560 {}
C {lab_pin.sym} 2540 30560 0 0 {name=l24548 lab=WL153}
N 2640 30640 2660 30640 {}
C {lab_pin.sym} 2660 30640 0 0 {name=l24549 lab=VDD}
N 2640 30560 2660 30560 {}
C {lab_pin.sym} 2660 30560 0 0 {name=l24550 lab=VSS}
C {bitcell_6t.sym} 2800 30600 0 0 {name=Xr153c14}
N 2760 30640 2740 30640 {}
C {lab_pin.sym} 2740 30640 0 0 {name=l24551 lab=BL14}
N 2760 30600 2740 30600 {}
C {lab_pin.sym} 2740 30600 0 0 {name=l24552 lab=BLB14}
N 2760 30560 2740 30560 {}
C {lab_pin.sym} 2740 30560 0 0 {name=l24553 lab=WL153}
N 2840 30640 2860 30640 {}
C {lab_pin.sym} 2860 30640 0 0 {name=l24554 lab=VDD}
N 2840 30560 2860 30560 {}
C {lab_pin.sym} 2860 30560 0 0 {name=l24555 lab=VSS}
C {bitcell_6t.sym} 3000 30600 0 0 {name=Xr153c15}
N 2960 30640 2940 30640 {}
C {lab_pin.sym} 2940 30640 0 0 {name=l24556 lab=BL15}
N 2960 30600 2940 30600 {}
C {lab_pin.sym} 2940 30600 0 0 {name=l24557 lab=BLB15}
N 2960 30560 2940 30560 {}
C {lab_pin.sym} 2940 30560 0 0 {name=l24558 lab=WL153}
N 3040 30640 3060 30640 {}
C {lab_pin.sym} 3060 30640 0 0 {name=l24559 lab=VDD}
N 3040 30560 3060 30560 {}
C {lab_pin.sym} 3060 30560 0 0 {name=l24560 lab=VSS}
C {bitcell_6t.sym} 3200 30600 0 0 {name=Xr153c16}
N 3160 30640 3140 30640 {}
C {lab_pin.sym} 3140 30640 0 0 {name=l24561 lab=BL16}
N 3160 30600 3140 30600 {}
C {lab_pin.sym} 3140 30600 0 0 {name=l24562 lab=BLB16}
N 3160 30560 3140 30560 {}
C {lab_pin.sym} 3140 30560 0 0 {name=l24563 lab=WL153}
N 3240 30640 3260 30640 {}
C {lab_pin.sym} 3260 30640 0 0 {name=l24564 lab=VDD}
N 3240 30560 3260 30560 {}
C {lab_pin.sym} 3260 30560 0 0 {name=l24565 lab=VSS}
C {bitcell_6t.sym} 3400 30600 0 0 {name=Xr153c17}
N 3360 30640 3340 30640 {}
C {lab_pin.sym} 3340 30640 0 0 {name=l24566 lab=BL17}
N 3360 30600 3340 30600 {}
C {lab_pin.sym} 3340 30600 0 0 {name=l24567 lab=BLB17}
N 3360 30560 3340 30560 {}
C {lab_pin.sym} 3340 30560 0 0 {name=l24568 lab=WL153}
N 3440 30640 3460 30640 {}
C {lab_pin.sym} 3460 30640 0 0 {name=l24569 lab=VDD}
N 3440 30560 3460 30560 {}
C {lab_pin.sym} 3460 30560 0 0 {name=l24570 lab=VSS}
C {bitcell_6t.sym} 3600 30600 0 0 {name=Xr153c18}
N 3560 30640 3540 30640 {}
C {lab_pin.sym} 3540 30640 0 0 {name=l24571 lab=BL18}
N 3560 30600 3540 30600 {}
C {lab_pin.sym} 3540 30600 0 0 {name=l24572 lab=BLB18}
N 3560 30560 3540 30560 {}
C {lab_pin.sym} 3540 30560 0 0 {name=l24573 lab=WL153}
N 3640 30640 3660 30640 {}
C {lab_pin.sym} 3660 30640 0 0 {name=l24574 lab=VDD}
N 3640 30560 3660 30560 {}
C {lab_pin.sym} 3660 30560 0 0 {name=l24575 lab=VSS}
C {bitcell_6t.sym} 3800 30600 0 0 {name=Xr153c19}
N 3760 30640 3740 30640 {}
C {lab_pin.sym} 3740 30640 0 0 {name=l24576 lab=BL19}
N 3760 30600 3740 30600 {}
C {lab_pin.sym} 3740 30600 0 0 {name=l24577 lab=BLB19}
N 3760 30560 3740 30560 {}
C {lab_pin.sym} 3740 30560 0 0 {name=l24578 lab=WL153}
N 3840 30640 3860 30640 {}
C {lab_pin.sym} 3860 30640 0 0 {name=l24579 lab=VDD}
N 3840 30560 3860 30560 {}
C {lab_pin.sym} 3860 30560 0 0 {name=l24580 lab=VSS}
C {bitcell_6t.sym} 4000 30600 0 0 {name=Xr153c20}
N 3960 30640 3940 30640 {}
C {lab_pin.sym} 3940 30640 0 0 {name=l24581 lab=BL20}
N 3960 30600 3940 30600 {}
C {lab_pin.sym} 3940 30600 0 0 {name=l24582 lab=BLB20}
N 3960 30560 3940 30560 {}
C {lab_pin.sym} 3940 30560 0 0 {name=l24583 lab=WL153}
N 4040 30640 4060 30640 {}
C {lab_pin.sym} 4060 30640 0 0 {name=l24584 lab=VDD}
N 4040 30560 4060 30560 {}
C {lab_pin.sym} 4060 30560 0 0 {name=l24585 lab=VSS}
C {bitcell_6t.sym} 4200 30600 0 0 {name=Xr153c21}
N 4160 30640 4140 30640 {}
C {lab_pin.sym} 4140 30640 0 0 {name=l24586 lab=BL21}
N 4160 30600 4140 30600 {}
C {lab_pin.sym} 4140 30600 0 0 {name=l24587 lab=BLB21}
N 4160 30560 4140 30560 {}
C {lab_pin.sym} 4140 30560 0 0 {name=l24588 lab=WL153}
N 4240 30640 4260 30640 {}
C {lab_pin.sym} 4260 30640 0 0 {name=l24589 lab=VDD}
N 4240 30560 4260 30560 {}
C {lab_pin.sym} 4260 30560 0 0 {name=l24590 lab=VSS}
C {bitcell_6t.sym} 4400 30600 0 0 {name=Xr153c22}
N 4360 30640 4340 30640 {}
C {lab_pin.sym} 4340 30640 0 0 {name=l24591 lab=BL22}
N 4360 30600 4340 30600 {}
C {lab_pin.sym} 4340 30600 0 0 {name=l24592 lab=BLB22}
N 4360 30560 4340 30560 {}
C {lab_pin.sym} 4340 30560 0 0 {name=l24593 lab=WL153}
N 4440 30640 4460 30640 {}
C {lab_pin.sym} 4460 30640 0 0 {name=l24594 lab=VDD}
N 4440 30560 4460 30560 {}
C {lab_pin.sym} 4460 30560 0 0 {name=l24595 lab=VSS}
C {bitcell_6t.sym} 4600 30600 0 0 {name=Xr153c23}
N 4560 30640 4540 30640 {}
C {lab_pin.sym} 4540 30640 0 0 {name=l24596 lab=BL23}
N 4560 30600 4540 30600 {}
C {lab_pin.sym} 4540 30600 0 0 {name=l24597 lab=BLB23}
N 4560 30560 4540 30560 {}
C {lab_pin.sym} 4540 30560 0 0 {name=l24598 lab=WL153}
N 4640 30640 4660 30640 {}
C {lab_pin.sym} 4660 30640 0 0 {name=l24599 lab=VDD}
N 4640 30560 4660 30560 {}
C {lab_pin.sym} 4660 30560 0 0 {name=l24600 lab=VSS}
C {bitcell_6t.sym} 4800 30600 0 0 {name=Xr153c24}
N 4760 30640 4740 30640 {}
C {lab_pin.sym} 4740 30640 0 0 {name=l24601 lab=BL24}
N 4760 30600 4740 30600 {}
C {lab_pin.sym} 4740 30600 0 0 {name=l24602 lab=BLB24}
N 4760 30560 4740 30560 {}
C {lab_pin.sym} 4740 30560 0 0 {name=l24603 lab=WL153}
N 4840 30640 4860 30640 {}
C {lab_pin.sym} 4860 30640 0 0 {name=l24604 lab=VDD}
N 4840 30560 4860 30560 {}
C {lab_pin.sym} 4860 30560 0 0 {name=l24605 lab=VSS}
C {bitcell_6t.sym} 5000 30600 0 0 {name=Xr153c25}
N 4960 30640 4940 30640 {}
C {lab_pin.sym} 4940 30640 0 0 {name=l24606 lab=BL25}
N 4960 30600 4940 30600 {}
C {lab_pin.sym} 4940 30600 0 0 {name=l24607 lab=BLB25}
N 4960 30560 4940 30560 {}
C {lab_pin.sym} 4940 30560 0 0 {name=l24608 lab=WL153}
N 5040 30640 5060 30640 {}
C {lab_pin.sym} 5060 30640 0 0 {name=l24609 lab=VDD}
N 5040 30560 5060 30560 {}
C {lab_pin.sym} 5060 30560 0 0 {name=l24610 lab=VSS}
C {bitcell_6t.sym} 5200 30600 0 0 {name=Xr153c26}
N 5160 30640 5140 30640 {}
C {lab_pin.sym} 5140 30640 0 0 {name=l24611 lab=BL26}
N 5160 30600 5140 30600 {}
C {lab_pin.sym} 5140 30600 0 0 {name=l24612 lab=BLB26}
N 5160 30560 5140 30560 {}
C {lab_pin.sym} 5140 30560 0 0 {name=l24613 lab=WL153}
N 5240 30640 5260 30640 {}
C {lab_pin.sym} 5260 30640 0 0 {name=l24614 lab=VDD}
N 5240 30560 5260 30560 {}
C {lab_pin.sym} 5260 30560 0 0 {name=l24615 lab=VSS}
C {bitcell_6t.sym} 5400 30600 0 0 {name=Xr153c27}
N 5360 30640 5340 30640 {}
C {lab_pin.sym} 5340 30640 0 0 {name=l24616 lab=BL27}
N 5360 30600 5340 30600 {}
C {lab_pin.sym} 5340 30600 0 0 {name=l24617 lab=BLB27}
N 5360 30560 5340 30560 {}
C {lab_pin.sym} 5340 30560 0 0 {name=l24618 lab=WL153}
N 5440 30640 5460 30640 {}
C {lab_pin.sym} 5460 30640 0 0 {name=l24619 lab=VDD}
N 5440 30560 5460 30560 {}
C {lab_pin.sym} 5460 30560 0 0 {name=l24620 lab=VSS}
C {bitcell_6t.sym} 5600 30600 0 0 {name=Xr153c28}
N 5560 30640 5540 30640 {}
C {lab_pin.sym} 5540 30640 0 0 {name=l24621 lab=BL28}
N 5560 30600 5540 30600 {}
C {lab_pin.sym} 5540 30600 0 0 {name=l24622 lab=BLB28}
N 5560 30560 5540 30560 {}
C {lab_pin.sym} 5540 30560 0 0 {name=l24623 lab=WL153}
N 5640 30640 5660 30640 {}
C {lab_pin.sym} 5660 30640 0 0 {name=l24624 lab=VDD}
N 5640 30560 5660 30560 {}
C {lab_pin.sym} 5660 30560 0 0 {name=l24625 lab=VSS}
C {bitcell_6t.sym} 5800 30600 0 0 {name=Xr153c29}
N 5760 30640 5740 30640 {}
C {lab_pin.sym} 5740 30640 0 0 {name=l24626 lab=BL29}
N 5760 30600 5740 30600 {}
C {lab_pin.sym} 5740 30600 0 0 {name=l24627 lab=BLB29}
N 5760 30560 5740 30560 {}
C {lab_pin.sym} 5740 30560 0 0 {name=l24628 lab=WL153}
N 5840 30640 5860 30640 {}
C {lab_pin.sym} 5860 30640 0 0 {name=l24629 lab=VDD}
N 5840 30560 5860 30560 {}
C {lab_pin.sym} 5860 30560 0 0 {name=l24630 lab=VSS}
C {bitcell_6t.sym} 6000 30600 0 0 {name=Xr153c30}
N 5960 30640 5940 30640 {}
C {lab_pin.sym} 5940 30640 0 0 {name=l24631 lab=BL30}
N 5960 30600 5940 30600 {}
C {lab_pin.sym} 5940 30600 0 0 {name=l24632 lab=BLB30}
N 5960 30560 5940 30560 {}
C {lab_pin.sym} 5940 30560 0 0 {name=l24633 lab=WL153}
N 6040 30640 6060 30640 {}
C {lab_pin.sym} 6060 30640 0 0 {name=l24634 lab=VDD}
N 6040 30560 6060 30560 {}
C {lab_pin.sym} 6060 30560 0 0 {name=l24635 lab=VSS}
C {bitcell_6t.sym} 6200 30600 0 0 {name=Xr153c31}
N 6160 30640 6140 30640 {}
C {lab_pin.sym} 6140 30640 0 0 {name=l24636 lab=BL31}
N 6160 30600 6140 30600 {}
C {lab_pin.sym} 6140 30600 0 0 {name=l24637 lab=BLB31}
N 6160 30560 6140 30560 {}
C {lab_pin.sym} 6140 30560 0 0 {name=l24638 lab=WL153}
N 6240 30640 6260 30640 {}
C {lab_pin.sym} 6260 30640 0 0 {name=l24639 lab=VDD}
N 6240 30560 6260 30560 {}
C {lab_pin.sym} 6260 30560 0 0 {name=l24640 lab=VSS}
C {bitcell_6t.sym} 0 30800 0 0 {name=Xr154c0}
N -40 30840 -60 30840 {}
C {lab_pin.sym} -60 30840 0 0 {name=l24641 lab=BL0}
N -40 30800 -60 30800 {}
C {lab_pin.sym} -60 30800 0 0 {name=l24642 lab=BLB0}
N -40 30760 -60 30760 {}
C {lab_pin.sym} -60 30760 0 0 {name=l24643 lab=WL154}
N 40 30840 60 30840 {}
C {lab_pin.sym} 60 30840 0 0 {name=l24644 lab=VDD}
N 40 30760 60 30760 {}
C {lab_pin.sym} 60 30760 0 0 {name=l24645 lab=VSS}
C {bitcell_6t.sym} 200 30800 0 0 {name=Xr154c1}
N 160 30840 140 30840 {}
C {lab_pin.sym} 140 30840 0 0 {name=l24646 lab=BL1}
N 160 30800 140 30800 {}
C {lab_pin.sym} 140 30800 0 0 {name=l24647 lab=BLB1}
N 160 30760 140 30760 {}
C {lab_pin.sym} 140 30760 0 0 {name=l24648 lab=WL154}
N 240 30840 260 30840 {}
C {lab_pin.sym} 260 30840 0 0 {name=l24649 lab=VDD}
N 240 30760 260 30760 {}
C {lab_pin.sym} 260 30760 0 0 {name=l24650 lab=VSS}
C {bitcell_6t.sym} 400 30800 0 0 {name=Xr154c2}
N 360 30840 340 30840 {}
C {lab_pin.sym} 340 30840 0 0 {name=l24651 lab=BL2}
N 360 30800 340 30800 {}
C {lab_pin.sym} 340 30800 0 0 {name=l24652 lab=BLB2}
N 360 30760 340 30760 {}
C {lab_pin.sym} 340 30760 0 0 {name=l24653 lab=WL154}
N 440 30840 460 30840 {}
C {lab_pin.sym} 460 30840 0 0 {name=l24654 lab=VDD}
N 440 30760 460 30760 {}
C {lab_pin.sym} 460 30760 0 0 {name=l24655 lab=VSS}
C {bitcell_6t.sym} 600 30800 0 0 {name=Xr154c3}
N 560 30840 540 30840 {}
C {lab_pin.sym} 540 30840 0 0 {name=l24656 lab=BL3}
N 560 30800 540 30800 {}
C {lab_pin.sym} 540 30800 0 0 {name=l24657 lab=BLB3}
N 560 30760 540 30760 {}
C {lab_pin.sym} 540 30760 0 0 {name=l24658 lab=WL154}
N 640 30840 660 30840 {}
C {lab_pin.sym} 660 30840 0 0 {name=l24659 lab=VDD}
N 640 30760 660 30760 {}
C {lab_pin.sym} 660 30760 0 0 {name=l24660 lab=VSS}
C {bitcell_6t.sym} 800 30800 0 0 {name=Xr154c4}
N 760 30840 740 30840 {}
C {lab_pin.sym} 740 30840 0 0 {name=l24661 lab=BL4}
N 760 30800 740 30800 {}
C {lab_pin.sym} 740 30800 0 0 {name=l24662 lab=BLB4}
N 760 30760 740 30760 {}
C {lab_pin.sym} 740 30760 0 0 {name=l24663 lab=WL154}
N 840 30840 860 30840 {}
C {lab_pin.sym} 860 30840 0 0 {name=l24664 lab=VDD}
N 840 30760 860 30760 {}
C {lab_pin.sym} 860 30760 0 0 {name=l24665 lab=VSS}
C {bitcell_6t.sym} 1000 30800 0 0 {name=Xr154c5}
N 960 30840 940 30840 {}
C {lab_pin.sym} 940 30840 0 0 {name=l24666 lab=BL5}
N 960 30800 940 30800 {}
C {lab_pin.sym} 940 30800 0 0 {name=l24667 lab=BLB5}
N 960 30760 940 30760 {}
C {lab_pin.sym} 940 30760 0 0 {name=l24668 lab=WL154}
N 1040 30840 1060 30840 {}
C {lab_pin.sym} 1060 30840 0 0 {name=l24669 lab=VDD}
N 1040 30760 1060 30760 {}
C {lab_pin.sym} 1060 30760 0 0 {name=l24670 lab=VSS}
C {bitcell_6t.sym} 1200 30800 0 0 {name=Xr154c6}
N 1160 30840 1140 30840 {}
C {lab_pin.sym} 1140 30840 0 0 {name=l24671 lab=BL6}
N 1160 30800 1140 30800 {}
C {lab_pin.sym} 1140 30800 0 0 {name=l24672 lab=BLB6}
N 1160 30760 1140 30760 {}
C {lab_pin.sym} 1140 30760 0 0 {name=l24673 lab=WL154}
N 1240 30840 1260 30840 {}
C {lab_pin.sym} 1260 30840 0 0 {name=l24674 lab=VDD}
N 1240 30760 1260 30760 {}
C {lab_pin.sym} 1260 30760 0 0 {name=l24675 lab=VSS}
C {bitcell_6t.sym} 1400 30800 0 0 {name=Xr154c7}
N 1360 30840 1340 30840 {}
C {lab_pin.sym} 1340 30840 0 0 {name=l24676 lab=BL7}
N 1360 30800 1340 30800 {}
C {lab_pin.sym} 1340 30800 0 0 {name=l24677 lab=BLB7}
N 1360 30760 1340 30760 {}
C {lab_pin.sym} 1340 30760 0 0 {name=l24678 lab=WL154}
N 1440 30840 1460 30840 {}
C {lab_pin.sym} 1460 30840 0 0 {name=l24679 lab=VDD}
N 1440 30760 1460 30760 {}
C {lab_pin.sym} 1460 30760 0 0 {name=l24680 lab=VSS}
C {bitcell_6t.sym} 1600 30800 0 0 {name=Xr154c8}
N 1560 30840 1540 30840 {}
C {lab_pin.sym} 1540 30840 0 0 {name=l24681 lab=BL8}
N 1560 30800 1540 30800 {}
C {lab_pin.sym} 1540 30800 0 0 {name=l24682 lab=BLB8}
N 1560 30760 1540 30760 {}
C {lab_pin.sym} 1540 30760 0 0 {name=l24683 lab=WL154}
N 1640 30840 1660 30840 {}
C {lab_pin.sym} 1660 30840 0 0 {name=l24684 lab=VDD}
N 1640 30760 1660 30760 {}
C {lab_pin.sym} 1660 30760 0 0 {name=l24685 lab=VSS}
C {bitcell_6t.sym} 1800 30800 0 0 {name=Xr154c9}
N 1760 30840 1740 30840 {}
C {lab_pin.sym} 1740 30840 0 0 {name=l24686 lab=BL9}
N 1760 30800 1740 30800 {}
C {lab_pin.sym} 1740 30800 0 0 {name=l24687 lab=BLB9}
N 1760 30760 1740 30760 {}
C {lab_pin.sym} 1740 30760 0 0 {name=l24688 lab=WL154}
N 1840 30840 1860 30840 {}
C {lab_pin.sym} 1860 30840 0 0 {name=l24689 lab=VDD}
N 1840 30760 1860 30760 {}
C {lab_pin.sym} 1860 30760 0 0 {name=l24690 lab=VSS}
C {bitcell_6t.sym} 2000 30800 0 0 {name=Xr154c10}
N 1960 30840 1940 30840 {}
C {lab_pin.sym} 1940 30840 0 0 {name=l24691 lab=BL10}
N 1960 30800 1940 30800 {}
C {lab_pin.sym} 1940 30800 0 0 {name=l24692 lab=BLB10}
N 1960 30760 1940 30760 {}
C {lab_pin.sym} 1940 30760 0 0 {name=l24693 lab=WL154}
N 2040 30840 2060 30840 {}
C {lab_pin.sym} 2060 30840 0 0 {name=l24694 lab=VDD}
N 2040 30760 2060 30760 {}
C {lab_pin.sym} 2060 30760 0 0 {name=l24695 lab=VSS}
C {bitcell_6t.sym} 2200 30800 0 0 {name=Xr154c11}
N 2160 30840 2140 30840 {}
C {lab_pin.sym} 2140 30840 0 0 {name=l24696 lab=BL11}
N 2160 30800 2140 30800 {}
C {lab_pin.sym} 2140 30800 0 0 {name=l24697 lab=BLB11}
N 2160 30760 2140 30760 {}
C {lab_pin.sym} 2140 30760 0 0 {name=l24698 lab=WL154}
N 2240 30840 2260 30840 {}
C {lab_pin.sym} 2260 30840 0 0 {name=l24699 lab=VDD}
N 2240 30760 2260 30760 {}
C {lab_pin.sym} 2260 30760 0 0 {name=l24700 lab=VSS}
C {bitcell_6t.sym} 2400 30800 0 0 {name=Xr154c12}
N 2360 30840 2340 30840 {}
C {lab_pin.sym} 2340 30840 0 0 {name=l24701 lab=BL12}
N 2360 30800 2340 30800 {}
C {lab_pin.sym} 2340 30800 0 0 {name=l24702 lab=BLB12}
N 2360 30760 2340 30760 {}
C {lab_pin.sym} 2340 30760 0 0 {name=l24703 lab=WL154}
N 2440 30840 2460 30840 {}
C {lab_pin.sym} 2460 30840 0 0 {name=l24704 lab=VDD}
N 2440 30760 2460 30760 {}
C {lab_pin.sym} 2460 30760 0 0 {name=l24705 lab=VSS}
C {bitcell_6t.sym} 2600 30800 0 0 {name=Xr154c13}
N 2560 30840 2540 30840 {}
C {lab_pin.sym} 2540 30840 0 0 {name=l24706 lab=BL13}
N 2560 30800 2540 30800 {}
C {lab_pin.sym} 2540 30800 0 0 {name=l24707 lab=BLB13}
N 2560 30760 2540 30760 {}
C {lab_pin.sym} 2540 30760 0 0 {name=l24708 lab=WL154}
N 2640 30840 2660 30840 {}
C {lab_pin.sym} 2660 30840 0 0 {name=l24709 lab=VDD}
N 2640 30760 2660 30760 {}
C {lab_pin.sym} 2660 30760 0 0 {name=l24710 lab=VSS}
C {bitcell_6t.sym} 2800 30800 0 0 {name=Xr154c14}
N 2760 30840 2740 30840 {}
C {lab_pin.sym} 2740 30840 0 0 {name=l24711 lab=BL14}
N 2760 30800 2740 30800 {}
C {lab_pin.sym} 2740 30800 0 0 {name=l24712 lab=BLB14}
N 2760 30760 2740 30760 {}
C {lab_pin.sym} 2740 30760 0 0 {name=l24713 lab=WL154}
N 2840 30840 2860 30840 {}
C {lab_pin.sym} 2860 30840 0 0 {name=l24714 lab=VDD}
N 2840 30760 2860 30760 {}
C {lab_pin.sym} 2860 30760 0 0 {name=l24715 lab=VSS}
C {bitcell_6t.sym} 3000 30800 0 0 {name=Xr154c15}
N 2960 30840 2940 30840 {}
C {lab_pin.sym} 2940 30840 0 0 {name=l24716 lab=BL15}
N 2960 30800 2940 30800 {}
C {lab_pin.sym} 2940 30800 0 0 {name=l24717 lab=BLB15}
N 2960 30760 2940 30760 {}
C {lab_pin.sym} 2940 30760 0 0 {name=l24718 lab=WL154}
N 3040 30840 3060 30840 {}
C {lab_pin.sym} 3060 30840 0 0 {name=l24719 lab=VDD}
N 3040 30760 3060 30760 {}
C {lab_pin.sym} 3060 30760 0 0 {name=l24720 lab=VSS}
C {bitcell_6t.sym} 3200 30800 0 0 {name=Xr154c16}
N 3160 30840 3140 30840 {}
C {lab_pin.sym} 3140 30840 0 0 {name=l24721 lab=BL16}
N 3160 30800 3140 30800 {}
C {lab_pin.sym} 3140 30800 0 0 {name=l24722 lab=BLB16}
N 3160 30760 3140 30760 {}
C {lab_pin.sym} 3140 30760 0 0 {name=l24723 lab=WL154}
N 3240 30840 3260 30840 {}
C {lab_pin.sym} 3260 30840 0 0 {name=l24724 lab=VDD}
N 3240 30760 3260 30760 {}
C {lab_pin.sym} 3260 30760 0 0 {name=l24725 lab=VSS}
C {bitcell_6t.sym} 3400 30800 0 0 {name=Xr154c17}
N 3360 30840 3340 30840 {}
C {lab_pin.sym} 3340 30840 0 0 {name=l24726 lab=BL17}
N 3360 30800 3340 30800 {}
C {lab_pin.sym} 3340 30800 0 0 {name=l24727 lab=BLB17}
N 3360 30760 3340 30760 {}
C {lab_pin.sym} 3340 30760 0 0 {name=l24728 lab=WL154}
N 3440 30840 3460 30840 {}
C {lab_pin.sym} 3460 30840 0 0 {name=l24729 lab=VDD}
N 3440 30760 3460 30760 {}
C {lab_pin.sym} 3460 30760 0 0 {name=l24730 lab=VSS}
C {bitcell_6t.sym} 3600 30800 0 0 {name=Xr154c18}
N 3560 30840 3540 30840 {}
C {lab_pin.sym} 3540 30840 0 0 {name=l24731 lab=BL18}
N 3560 30800 3540 30800 {}
C {lab_pin.sym} 3540 30800 0 0 {name=l24732 lab=BLB18}
N 3560 30760 3540 30760 {}
C {lab_pin.sym} 3540 30760 0 0 {name=l24733 lab=WL154}
N 3640 30840 3660 30840 {}
C {lab_pin.sym} 3660 30840 0 0 {name=l24734 lab=VDD}
N 3640 30760 3660 30760 {}
C {lab_pin.sym} 3660 30760 0 0 {name=l24735 lab=VSS}
C {bitcell_6t.sym} 3800 30800 0 0 {name=Xr154c19}
N 3760 30840 3740 30840 {}
C {lab_pin.sym} 3740 30840 0 0 {name=l24736 lab=BL19}
N 3760 30800 3740 30800 {}
C {lab_pin.sym} 3740 30800 0 0 {name=l24737 lab=BLB19}
N 3760 30760 3740 30760 {}
C {lab_pin.sym} 3740 30760 0 0 {name=l24738 lab=WL154}
N 3840 30840 3860 30840 {}
C {lab_pin.sym} 3860 30840 0 0 {name=l24739 lab=VDD}
N 3840 30760 3860 30760 {}
C {lab_pin.sym} 3860 30760 0 0 {name=l24740 lab=VSS}
C {bitcell_6t.sym} 4000 30800 0 0 {name=Xr154c20}
N 3960 30840 3940 30840 {}
C {lab_pin.sym} 3940 30840 0 0 {name=l24741 lab=BL20}
N 3960 30800 3940 30800 {}
C {lab_pin.sym} 3940 30800 0 0 {name=l24742 lab=BLB20}
N 3960 30760 3940 30760 {}
C {lab_pin.sym} 3940 30760 0 0 {name=l24743 lab=WL154}
N 4040 30840 4060 30840 {}
C {lab_pin.sym} 4060 30840 0 0 {name=l24744 lab=VDD}
N 4040 30760 4060 30760 {}
C {lab_pin.sym} 4060 30760 0 0 {name=l24745 lab=VSS}
C {bitcell_6t.sym} 4200 30800 0 0 {name=Xr154c21}
N 4160 30840 4140 30840 {}
C {lab_pin.sym} 4140 30840 0 0 {name=l24746 lab=BL21}
N 4160 30800 4140 30800 {}
C {lab_pin.sym} 4140 30800 0 0 {name=l24747 lab=BLB21}
N 4160 30760 4140 30760 {}
C {lab_pin.sym} 4140 30760 0 0 {name=l24748 lab=WL154}
N 4240 30840 4260 30840 {}
C {lab_pin.sym} 4260 30840 0 0 {name=l24749 lab=VDD}
N 4240 30760 4260 30760 {}
C {lab_pin.sym} 4260 30760 0 0 {name=l24750 lab=VSS}
C {bitcell_6t.sym} 4400 30800 0 0 {name=Xr154c22}
N 4360 30840 4340 30840 {}
C {lab_pin.sym} 4340 30840 0 0 {name=l24751 lab=BL22}
N 4360 30800 4340 30800 {}
C {lab_pin.sym} 4340 30800 0 0 {name=l24752 lab=BLB22}
N 4360 30760 4340 30760 {}
C {lab_pin.sym} 4340 30760 0 0 {name=l24753 lab=WL154}
N 4440 30840 4460 30840 {}
C {lab_pin.sym} 4460 30840 0 0 {name=l24754 lab=VDD}
N 4440 30760 4460 30760 {}
C {lab_pin.sym} 4460 30760 0 0 {name=l24755 lab=VSS}
C {bitcell_6t.sym} 4600 30800 0 0 {name=Xr154c23}
N 4560 30840 4540 30840 {}
C {lab_pin.sym} 4540 30840 0 0 {name=l24756 lab=BL23}
N 4560 30800 4540 30800 {}
C {lab_pin.sym} 4540 30800 0 0 {name=l24757 lab=BLB23}
N 4560 30760 4540 30760 {}
C {lab_pin.sym} 4540 30760 0 0 {name=l24758 lab=WL154}
N 4640 30840 4660 30840 {}
C {lab_pin.sym} 4660 30840 0 0 {name=l24759 lab=VDD}
N 4640 30760 4660 30760 {}
C {lab_pin.sym} 4660 30760 0 0 {name=l24760 lab=VSS}
C {bitcell_6t.sym} 4800 30800 0 0 {name=Xr154c24}
N 4760 30840 4740 30840 {}
C {lab_pin.sym} 4740 30840 0 0 {name=l24761 lab=BL24}
N 4760 30800 4740 30800 {}
C {lab_pin.sym} 4740 30800 0 0 {name=l24762 lab=BLB24}
N 4760 30760 4740 30760 {}
C {lab_pin.sym} 4740 30760 0 0 {name=l24763 lab=WL154}
N 4840 30840 4860 30840 {}
C {lab_pin.sym} 4860 30840 0 0 {name=l24764 lab=VDD}
N 4840 30760 4860 30760 {}
C {lab_pin.sym} 4860 30760 0 0 {name=l24765 lab=VSS}
C {bitcell_6t.sym} 5000 30800 0 0 {name=Xr154c25}
N 4960 30840 4940 30840 {}
C {lab_pin.sym} 4940 30840 0 0 {name=l24766 lab=BL25}
N 4960 30800 4940 30800 {}
C {lab_pin.sym} 4940 30800 0 0 {name=l24767 lab=BLB25}
N 4960 30760 4940 30760 {}
C {lab_pin.sym} 4940 30760 0 0 {name=l24768 lab=WL154}
N 5040 30840 5060 30840 {}
C {lab_pin.sym} 5060 30840 0 0 {name=l24769 lab=VDD}
N 5040 30760 5060 30760 {}
C {lab_pin.sym} 5060 30760 0 0 {name=l24770 lab=VSS}
C {bitcell_6t.sym} 5200 30800 0 0 {name=Xr154c26}
N 5160 30840 5140 30840 {}
C {lab_pin.sym} 5140 30840 0 0 {name=l24771 lab=BL26}
N 5160 30800 5140 30800 {}
C {lab_pin.sym} 5140 30800 0 0 {name=l24772 lab=BLB26}
N 5160 30760 5140 30760 {}
C {lab_pin.sym} 5140 30760 0 0 {name=l24773 lab=WL154}
N 5240 30840 5260 30840 {}
C {lab_pin.sym} 5260 30840 0 0 {name=l24774 lab=VDD}
N 5240 30760 5260 30760 {}
C {lab_pin.sym} 5260 30760 0 0 {name=l24775 lab=VSS}
C {bitcell_6t.sym} 5400 30800 0 0 {name=Xr154c27}
N 5360 30840 5340 30840 {}
C {lab_pin.sym} 5340 30840 0 0 {name=l24776 lab=BL27}
N 5360 30800 5340 30800 {}
C {lab_pin.sym} 5340 30800 0 0 {name=l24777 lab=BLB27}
N 5360 30760 5340 30760 {}
C {lab_pin.sym} 5340 30760 0 0 {name=l24778 lab=WL154}
N 5440 30840 5460 30840 {}
C {lab_pin.sym} 5460 30840 0 0 {name=l24779 lab=VDD}
N 5440 30760 5460 30760 {}
C {lab_pin.sym} 5460 30760 0 0 {name=l24780 lab=VSS}
C {bitcell_6t.sym} 5600 30800 0 0 {name=Xr154c28}
N 5560 30840 5540 30840 {}
C {lab_pin.sym} 5540 30840 0 0 {name=l24781 lab=BL28}
N 5560 30800 5540 30800 {}
C {lab_pin.sym} 5540 30800 0 0 {name=l24782 lab=BLB28}
N 5560 30760 5540 30760 {}
C {lab_pin.sym} 5540 30760 0 0 {name=l24783 lab=WL154}
N 5640 30840 5660 30840 {}
C {lab_pin.sym} 5660 30840 0 0 {name=l24784 lab=VDD}
N 5640 30760 5660 30760 {}
C {lab_pin.sym} 5660 30760 0 0 {name=l24785 lab=VSS}
C {bitcell_6t.sym} 5800 30800 0 0 {name=Xr154c29}
N 5760 30840 5740 30840 {}
C {lab_pin.sym} 5740 30840 0 0 {name=l24786 lab=BL29}
N 5760 30800 5740 30800 {}
C {lab_pin.sym} 5740 30800 0 0 {name=l24787 lab=BLB29}
N 5760 30760 5740 30760 {}
C {lab_pin.sym} 5740 30760 0 0 {name=l24788 lab=WL154}
N 5840 30840 5860 30840 {}
C {lab_pin.sym} 5860 30840 0 0 {name=l24789 lab=VDD}
N 5840 30760 5860 30760 {}
C {lab_pin.sym} 5860 30760 0 0 {name=l24790 lab=VSS}
C {bitcell_6t.sym} 6000 30800 0 0 {name=Xr154c30}
N 5960 30840 5940 30840 {}
C {lab_pin.sym} 5940 30840 0 0 {name=l24791 lab=BL30}
N 5960 30800 5940 30800 {}
C {lab_pin.sym} 5940 30800 0 0 {name=l24792 lab=BLB30}
N 5960 30760 5940 30760 {}
C {lab_pin.sym} 5940 30760 0 0 {name=l24793 lab=WL154}
N 6040 30840 6060 30840 {}
C {lab_pin.sym} 6060 30840 0 0 {name=l24794 lab=VDD}
N 6040 30760 6060 30760 {}
C {lab_pin.sym} 6060 30760 0 0 {name=l24795 lab=VSS}
C {bitcell_6t.sym} 6200 30800 0 0 {name=Xr154c31}
N 6160 30840 6140 30840 {}
C {lab_pin.sym} 6140 30840 0 0 {name=l24796 lab=BL31}
N 6160 30800 6140 30800 {}
C {lab_pin.sym} 6140 30800 0 0 {name=l24797 lab=BLB31}
N 6160 30760 6140 30760 {}
C {lab_pin.sym} 6140 30760 0 0 {name=l24798 lab=WL154}
N 6240 30840 6260 30840 {}
C {lab_pin.sym} 6260 30840 0 0 {name=l24799 lab=VDD}
N 6240 30760 6260 30760 {}
C {lab_pin.sym} 6260 30760 0 0 {name=l24800 lab=VSS}
C {bitcell_6t.sym} 0 31000 0 0 {name=Xr155c0}
N -40 31040 -60 31040 {}
C {lab_pin.sym} -60 31040 0 0 {name=l24801 lab=BL0}
N -40 31000 -60 31000 {}
C {lab_pin.sym} -60 31000 0 0 {name=l24802 lab=BLB0}
N -40 30960 -60 30960 {}
C {lab_pin.sym} -60 30960 0 0 {name=l24803 lab=WL155}
N 40 31040 60 31040 {}
C {lab_pin.sym} 60 31040 0 0 {name=l24804 lab=VDD}
N 40 30960 60 30960 {}
C {lab_pin.sym} 60 30960 0 0 {name=l24805 lab=VSS}
C {bitcell_6t.sym} 200 31000 0 0 {name=Xr155c1}
N 160 31040 140 31040 {}
C {lab_pin.sym} 140 31040 0 0 {name=l24806 lab=BL1}
N 160 31000 140 31000 {}
C {lab_pin.sym} 140 31000 0 0 {name=l24807 lab=BLB1}
N 160 30960 140 30960 {}
C {lab_pin.sym} 140 30960 0 0 {name=l24808 lab=WL155}
N 240 31040 260 31040 {}
C {lab_pin.sym} 260 31040 0 0 {name=l24809 lab=VDD}
N 240 30960 260 30960 {}
C {lab_pin.sym} 260 30960 0 0 {name=l24810 lab=VSS}
C {bitcell_6t.sym} 400 31000 0 0 {name=Xr155c2}
N 360 31040 340 31040 {}
C {lab_pin.sym} 340 31040 0 0 {name=l24811 lab=BL2}
N 360 31000 340 31000 {}
C {lab_pin.sym} 340 31000 0 0 {name=l24812 lab=BLB2}
N 360 30960 340 30960 {}
C {lab_pin.sym} 340 30960 0 0 {name=l24813 lab=WL155}
N 440 31040 460 31040 {}
C {lab_pin.sym} 460 31040 0 0 {name=l24814 lab=VDD}
N 440 30960 460 30960 {}
C {lab_pin.sym} 460 30960 0 0 {name=l24815 lab=VSS}
C {bitcell_6t.sym} 600 31000 0 0 {name=Xr155c3}
N 560 31040 540 31040 {}
C {lab_pin.sym} 540 31040 0 0 {name=l24816 lab=BL3}
N 560 31000 540 31000 {}
C {lab_pin.sym} 540 31000 0 0 {name=l24817 lab=BLB3}
N 560 30960 540 30960 {}
C {lab_pin.sym} 540 30960 0 0 {name=l24818 lab=WL155}
N 640 31040 660 31040 {}
C {lab_pin.sym} 660 31040 0 0 {name=l24819 lab=VDD}
N 640 30960 660 30960 {}
C {lab_pin.sym} 660 30960 0 0 {name=l24820 lab=VSS}
C {bitcell_6t.sym} 800 31000 0 0 {name=Xr155c4}
N 760 31040 740 31040 {}
C {lab_pin.sym} 740 31040 0 0 {name=l24821 lab=BL4}
N 760 31000 740 31000 {}
C {lab_pin.sym} 740 31000 0 0 {name=l24822 lab=BLB4}
N 760 30960 740 30960 {}
C {lab_pin.sym} 740 30960 0 0 {name=l24823 lab=WL155}
N 840 31040 860 31040 {}
C {lab_pin.sym} 860 31040 0 0 {name=l24824 lab=VDD}
N 840 30960 860 30960 {}
C {lab_pin.sym} 860 30960 0 0 {name=l24825 lab=VSS}
C {bitcell_6t.sym} 1000 31000 0 0 {name=Xr155c5}
N 960 31040 940 31040 {}
C {lab_pin.sym} 940 31040 0 0 {name=l24826 lab=BL5}
N 960 31000 940 31000 {}
C {lab_pin.sym} 940 31000 0 0 {name=l24827 lab=BLB5}
N 960 30960 940 30960 {}
C {lab_pin.sym} 940 30960 0 0 {name=l24828 lab=WL155}
N 1040 31040 1060 31040 {}
C {lab_pin.sym} 1060 31040 0 0 {name=l24829 lab=VDD}
N 1040 30960 1060 30960 {}
C {lab_pin.sym} 1060 30960 0 0 {name=l24830 lab=VSS}
C {bitcell_6t.sym} 1200 31000 0 0 {name=Xr155c6}
N 1160 31040 1140 31040 {}
C {lab_pin.sym} 1140 31040 0 0 {name=l24831 lab=BL6}
N 1160 31000 1140 31000 {}
C {lab_pin.sym} 1140 31000 0 0 {name=l24832 lab=BLB6}
N 1160 30960 1140 30960 {}
C {lab_pin.sym} 1140 30960 0 0 {name=l24833 lab=WL155}
N 1240 31040 1260 31040 {}
C {lab_pin.sym} 1260 31040 0 0 {name=l24834 lab=VDD}
N 1240 30960 1260 30960 {}
C {lab_pin.sym} 1260 30960 0 0 {name=l24835 lab=VSS}
C {bitcell_6t.sym} 1400 31000 0 0 {name=Xr155c7}
N 1360 31040 1340 31040 {}
C {lab_pin.sym} 1340 31040 0 0 {name=l24836 lab=BL7}
N 1360 31000 1340 31000 {}
C {lab_pin.sym} 1340 31000 0 0 {name=l24837 lab=BLB7}
N 1360 30960 1340 30960 {}
C {lab_pin.sym} 1340 30960 0 0 {name=l24838 lab=WL155}
N 1440 31040 1460 31040 {}
C {lab_pin.sym} 1460 31040 0 0 {name=l24839 lab=VDD}
N 1440 30960 1460 30960 {}
C {lab_pin.sym} 1460 30960 0 0 {name=l24840 lab=VSS}
C {bitcell_6t.sym} 1600 31000 0 0 {name=Xr155c8}
N 1560 31040 1540 31040 {}
C {lab_pin.sym} 1540 31040 0 0 {name=l24841 lab=BL8}
N 1560 31000 1540 31000 {}
C {lab_pin.sym} 1540 31000 0 0 {name=l24842 lab=BLB8}
N 1560 30960 1540 30960 {}
C {lab_pin.sym} 1540 30960 0 0 {name=l24843 lab=WL155}
N 1640 31040 1660 31040 {}
C {lab_pin.sym} 1660 31040 0 0 {name=l24844 lab=VDD}
N 1640 30960 1660 30960 {}
C {lab_pin.sym} 1660 30960 0 0 {name=l24845 lab=VSS}
C {bitcell_6t.sym} 1800 31000 0 0 {name=Xr155c9}
N 1760 31040 1740 31040 {}
C {lab_pin.sym} 1740 31040 0 0 {name=l24846 lab=BL9}
N 1760 31000 1740 31000 {}
C {lab_pin.sym} 1740 31000 0 0 {name=l24847 lab=BLB9}
N 1760 30960 1740 30960 {}
C {lab_pin.sym} 1740 30960 0 0 {name=l24848 lab=WL155}
N 1840 31040 1860 31040 {}
C {lab_pin.sym} 1860 31040 0 0 {name=l24849 lab=VDD}
N 1840 30960 1860 30960 {}
C {lab_pin.sym} 1860 30960 0 0 {name=l24850 lab=VSS}
C {bitcell_6t.sym} 2000 31000 0 0 {name=Xr155c10}
N 1960 31040 1940 31040 {}
C {lab_pin.sym} 1940 31040 0 0 {name=l24851 lab=BL10}
N 1960 31000 1940 31000 {}
C {lab_pin.sym} 1940 31000 0 0 {name=l24852 lab=BLB10}
N 1960 30960 1940 30960 {}
C {lab_pin.sym} 1940 30960 0 0 {name=l24853 lab=WL155}
N 2040 31040 2060 31040 {}
C {lab_pin.sym} 2060 31040 0 0 {name=l24854 lab=VDD}
N 2040 30960 2060 30960 {}
C {lab_pin.sym} 2060 30960 0 0 {name=l24855 lab=VSS}
C {bitcell_6t.sym} 2200 31000 0 0 {name=Xr155c11}
N 2160 31040 2140 31040 {}
C {lab_pin.sym} 2140 31040 0 0 {name=l24856 lab=BL11}
N 2160 31000 2140 31000 {}
C {lab_pin.sym} 2140 31000 0 0 {name=l24857 lab=BLB11}
N 2160 30960 2140 30960 {}
C {lab_pin.sym} 2140 30960 0 0 {name=l24858 lab=WL155}
N 2240 31040 2260 31040 {}
C {lab_pin.sym} 2260 31040 0 0 {name=l24859 lab=VDD}
N 2240 30960 2260 30960 {}
C {lab_pin.sym} 2260 30960 0 0 {name=l24860 lab=VSS}
C {bitcell_6t.sym} 2400 31000 0 0 {name=Xr155c12}
N 2360 31040 2340 31040 {}
C {lab_pin.sym} 2340 31040 0 0 {name=l24861 lab=BL12}
N 2360 31000 2340 31000 {}
C {lab_pin.sym} 2340 31000 0 0 {name=l24862 lab=BLB12}
N 2360 30960 2340 30960 {}
C {lab_pin.sym} 2340 30960 0 0 {name=l24863 lab=WL155}
N 2440 31040 2460 31040 {}
C {lab_pin.sym} 2460 31040 0 0 {name=l24864 lab=VDD}
N 2440 30960 2460 30960 {}
C {lab_pin.sym} 2460 30960 0 0 {name=l24865 lab=VSS}
C {bitcell_6t.sym} 2600 31000 0 0 {name=Xr155c13}
N 2560 31040 2540 31040 {}
C {lab_pin.sym} 2540 31040 0 0 {name=l24866 lab=BL13}
N 2560 31000 2540 31000 {}
C {lab_pin.sym} 2540 31000 0 0 {name=l24867 lab=BLB13}
N 2560 30960 2540 30960 {}
C {lab_pin.sym} 2540 30960 0 0 {name=l24868 lab=WL155}
N 2640 31040 2660 31040 {}
C {lab_pin.sym} 2660 31040 0 0 {name=l24869 lab=VDD}
N 2640 30960 2660 30960 {}
C {lab_pin.sym} 2660 30960 0 0 {name=l24870 lab=VSS}
C {bitcell_6t.sym} 2800 31000 0 0 {name=Xr155c14}
N 2760 31040 2740 31040 {}
C {lab_pin.sym} 2740 31040 0 0 {name=l24871 lab=BL14}
N 2760 31000 2740 31000 {}
C {lab_pin.sym} 2740 31000 0 0 {name=l24872 lab=BLB14}
N 2760 30960 2740 30960 {}
C {lab_pin.sym} 2740 30960 0 0 {name=l24873 lab=WL155}
N 2840 31040 2860 31040 {}
C {lab_pin.sym} 2860 31040 0 0 {name=l24874 lab=VDD}
N 2840 30960 2860 30960 {}
C {lab_pin.sym} 2860 30960 0 0 {name=l24875 lab=VSS}
C {bitcell_6t.sym} 3000 31000 0 0 {name=Xr155c15}
N 2960 31040 2940 31040 {}
C {lab_pin.sym} 2940 31040 0 0 {name=l24876 lab=BL15}
N 2960 31000 2940 31000 {}
C {lab_pin.sym} 2940 31000 0 0 {name=l24877 lab=BLB15}
N 2960 30960 2940 30960 {}
C {lab_pin.sym} 2940 30960 0 0 {name=l24878 lab=WL155}
N 3040 31040 3060 31040 {}
C {lab_pin.sym} 3060 31040 0 0 {name=l24879 lab=VDD}
N 3040 30960 3060 30960 {}
C {lab_pin.sym} 3060 30960 0 0 {name=l24880 lab=VSS}
C {bitcell_6t.sym} 3200 31000 0 0 {name=Xr155c16}
N 3160 31040 3140 31040 {}
C {lab_pin.sym} 3140 31040 0 0 {name=l24881 lab=BL16}
N 3160 31000 3140 31000 {}
C {lab_pin.sym} 3140 31000 0 0 {name=l24882 lab=BLB16}
N 3160 30960 3140 30960 {}
C {lab_pin.sym} 3140 30960 0 0 {name=l24883 lab=WL155}
N 3240 31040 3260 31040 {}
C {lab_pin.sym} 3260 31040 0 0 {name=l24884 lab=VDD}
N 3240 30960 3260 30960 {}
C {lab_pin.sym} 3260 30960 0 0 {name=l24885 lab=VSS}
C {bitcell_6t.sym} 3400 31000 0 0 {name=Xr155c17}
N 3360 31040 3340 31040 {}
C {lab_pin.sym} 3340 31040 0 0 {name=l24886 lab=BL17}
N 3360 31000 3340 31000 {}
C {lab_pin.sym} 3340 31000 0 0 {name=l24887 lab=BLB17}
N 3360 30960 3340 30960 {}
C {lab_pin.sym} 3340 30960 0 0 {name=l24888 lab=WL155}
N 3440 31040 3460 31040 {}
C {lab_pin.sym} 3460 31040 0 0 {name=l24889 lab=VDD}
N 3440 30960 3460 30960 {}
C {lab_pin.sym} 3460 30960 0 0 {name=l24890 lab=VSS}
C {bitcell_6t.sym} 3600 31000 0 0 {name=Xr155c18}
N 3560 31040 3540 31040 {}
C {lab_pin.sym} 3540 31040 0 0 {name=l24891 lab=BL18}
N 3560 31000 3540 31000 {}
C {lab_pin.sym} 3540 31000 0 0 {name=l24892 lab=BLB18}
N 3560 30960 3540 30960 {}
C {lab_pin.sym} 3540 30960 0 0 {name=l24893 lab=WL155}
N 3640 31040 3660 31040 {}
C {lab_pin.sym} 3660 31040 0 0 {name=l24894 lab=VDD}
N 3640 30960 3660 30960 {}
C {lab_pin.sym} 3660 30960 0 0 {name=l24895 lab=VSS}
C {bitcell_6t.sym} 3800 31000 0 0 {name=Xr155c19}
N 3760 31040 3740 31040 {}
C {lab_pin.sym} 3740 31040 0 0 {name=l24896 lab=BL19}
N 3760 31000 3740 31000 {}
C {lab_pin.sym} 3740 31000 0 0 {name=l24897 lab=BLB19}
N 3760 30960 3740 30960 {}
C {lab_pin.sym} 3740 30960 0 0 {name=l24898 lab=WL155}
N 3840 31040 3860 31040 {}
C {lab_pin.sym} 3860 31040 0 0 {name=l24899 lab=VDD}
N 3840 30960 3860 30960 {}
C {lab_pin.sym} 3860 30960 0 0 {name=l24900 lab=VSS}
C {bitcell_6t.sym} 4000 31000 0 0 {name=Xr155c20}
N 3960 31040 3940 31040 {}
C {lab_pin.sym} 3940 31040 0 0 {name=l24901 lab=BL20}
N 3960 31000 3940 31000 {}
C {lab_pin.sym} 3940 31000 0 0 {name=l24902 lab=BLB20}
N 3960 30960 3940 30960 {}
C {lab_pin.sym} 3940 30960 0 0 {name=l24903 lab=WL155}
N 4040 31040 4060 31040 {}
C {lab_pin.sym} 4060 31040 0 0 {name=l24904 lab=VDD}
N 4040 30960 4060 30960 {}
C {lab_pin.sym} 4060 30960 0 0 {name=l24905 lab=VSS}
C {bitcell_6t.sym} 4200 31000 0 0 {name=Xr155c21}
N 4160 31040 4140 31040 {}
C {lab_pin.sym} 4140 31040 0 0 {name=l24906 lab=BL21}
N 4160 31000 4140 31000 {}
C {lab_pin.sym} 4140 31000 0 0 {name=l24907 lab=BLB21}
N 4160 30960 4140 30960 {}
C {lab_pin.sym} 4140 30960 0 0 {name=l24908 lab=WL155}
N 4240 31040 4260 31040 {}
C {lab_pin.sym} 4260 31040 0 0 {name=l24909 lab=VDD}
N 4240 30960 4260 30960 {}
C {lab_pin.sym} 4260 30960 0 0 {name=l24910 lab=VSS}
C {bitcell_6t.sym} 4400 31000 0 0 {name=Xr155c22}
N 4360 31040 4340 31040 {}
C {lab_pin.sym} 4340 31040 0 0 {name=l24911 lab=BL22}
N 4360 31000 4340 31000 {}
C {lab_pin.sym} 4340 31000 0 0 {name=l24912 lab=BLB22}
N 4360 30960 4340 30960 {}
C {lab_pin.sym} 4340 30960 0 0 {name=l24913 lab=WL155}
N 4440 31040 4460 31040 {}
C {lab_pin.sym} 4460 31040 0 0 {name=l24914 lab=VDD}
N 4440 30960 4460 30960 {}
C {lab_pin.sym} 4460 30960 0 0 {name=l24915 lab=VSS}
C {bitcell_6t.sym} 4600 31000 0 0 {name=Xr155c23}
N 4560 31040 4540 31040 {}
C {lab_pin.sym} 4540 31040 0 0 {name=l24916 lab=BL23}
N 4560 31000 4540 31000 {}
C {lab_pin.sym} 4540 31000 0 0 {name=l24917 lab=BLB23}
N 4560 30960 4540 30960 {}
C {lab_pin.sym} 4540 30960 0 0 {name=l24918 lab=WL155}
N 4640 31040 4660 31040 {}
C {lab_pin.sym} 4660 31040 0 0 {name=l24919 lab=VDD}
N 4640 30960 4660 30960 {}
C {lab_pin.sym} 4660 30960 0 0 {name=l24920 lab=VSS}
C {bitcell_6t.sym} 4800 31000 0 0 {name=Xr155c24}
N 4760 31040 4740 31040 {}
C {lab_pin.sym} 4740 31040 0 0 {name=l24921 lab=BL24}
N 4760 31000 4740 31000 {}
C {lab_pin.sym} 4740 31000 0 0 {name=l24922 lab=BLB24}
N 4760 30960 4740 30960 {}
C {lab_pin.sym} 4740 30960 0 0 {name=l24923 lab=WL155}
N 4840 31040 4860 31040 {}
C {lab_pin.sym} 4860 31040 0 0 {name=l24924 lab=VDD}
N 4840 30960 4860 30960 {}
C {lab_pin.sym} 4860 30960 0 0 {name=l24925 lab=VSS}
C {bitcell_6t.sym} 5000 31000 0 0 {name=Xr155c25}
N 4960 31040 4940 31040 {}
C {lab_pin.sym} 4940 31040 0 0 {name=l24926 lab=BL25}
N 4960 31000 4940 31000 {}
C {lab_pin.sym} 4940 31000 0 0 {name=l24927 lab=BLB25}
N 4960 30960 4940 30960 {}
C {lab_pin.sym} 4940 30960 0 0 {name=l24928 lab=WL155}
N 5040 31040 5060 31040 {}
C {lab_pin.sym} 5060 31040 0 0 {name=l24929 lab=VDD}
N 5040 30960 5060 30960 {}
C {lab_pin.sym} 5060 30960 0 0 {name=l24930 lab=VSS}
C {bitcell_6t.sym} 5200 31000 0 0 {name=Xr155c26}
N 5160 31040 5140 31040 {}
C {lab_pin.sym} 5140 31040 0 0 {name=l24931 lab=BL26}
N 5160 31000 5140 31000 {}
C {lab_pin.sym} 5140 31000 0 0 {name=l24932 lab=BLB26}
N 5160 30960 5140 30960 {}
C {lab_pin.sym} 5140 30960 0 0 {name=l24933 lab=WL155}
N 5240 31040 5260 31040 {}
C {lab_pin.sym} 5260 31040 0 0 {name=l24934 lab=VDD}
N 5240 30960 5260 30960 {}
C {lab_pin.sym} 5260 30960 0 0 {name=l24935 lab=VSS}
C {bitcell_6t.sym} 5400 31000 0 0 {name=Xr155c27}
N 5360 31040 5340 31040 {}
C {lab_pin.sym} 5340 31040 0 0 {name=l24936 lab=BL27}
N 5360 31000 5340 31000 {}
C {lab_pin.sym} 5340 31000 0 0 {name=l24937 lab=BLB27}
N 5360 30960 5340 30960 {}
C {lab_pin.sym} 5340 30960 0 0 {name=l24938 lab=WL155}
N 5440 31040 5460 31040 {}
C {lab_pin.sym} 5460 31040 0 0 {name=l24939 lab=VDD}
N 5440 30960 5460 30960 {}
C {lab_pin.sym} 5460 30960 0 0 {name=l24940 lab=VSS}
C {bitcell_6t.sym} 5600 31000 0 0 {name=Xr155c28}
N 5560 31040 5540 31040 {}
C {lab_pin.sym} 5540 31040 0 0 {name=l24941 lab=BL28}
N 5560 31000 5540 31000 {}
C {lab_pin.sym} 5540 31000 0 0 {name=l24942 lab=BLB28}
N 5560 30960 5540 30960 {}
C {lab_pin.sym} 5540 30960 0 0 {name=l24943 lab=WL155}
N 5640 31040 5660 31040 {}
C {lab_pin.sym} 5660 31040 0 0 {name=l24944 lab=VDD}
N 5640 30960 5660 30960 {}
C {lab_pin.sym} 5660 30960 0 0 {name=l24945 lab=VSS}
C {bitcell_6t.sym} 5800 31000 0 0 {name=Xr155c29}
N 5760 31040 5740 31040 {}
C {lab_pin.sym} 5740 31040 0 0 {name=l24946 lab=BL29}
N 5760 31000 5740 31000 {}
C {lab_pin.sym} 5740 31000 0 0 {name=l24947 lab=BLB29}
N 5760 30960 5740 30960 {}
C {lab_pin.sym} 5740 30960 0 0 {name=l24948 lab=WL155}
N 5840 31040 5860 31040 {}
C {lab_pin.sym} 5860 31040 0 0 {name=l24949 lab=VDD}
N 5840 30960 5860 30960 {}
C {lab_pin.sym} 5860 30960 0 0 {name=l24950 lab=VSS}
C {bitcell_6t.sym} 6000 31000 0 0 {name=Xr155c30}
N 5960 31040 5940 31040 {}
C {lab_pin.sym} 5940 31040 0 0 {name=l24951 lab=BL30}
N 5960 31000 5940 31000 {}
C {lab_pin.sym} 5940 31000 0 0 {name=l24952 lab=BLB30}
N 5960 30960 5940 30960 {}
C {lab_pin.sym} 5940 30960 0 0 {name=l24953 lab=WL155}
N 6040 31040 6060 31040 {}
C {lab_pin.sym} 6060 31040 0 0 {name=l24954 lab=VDD}
N 6040 30960 6060 30960 {}
C {lab_pin.sym} 6060 30960 0 0 {name=l24955 lab=VSS}
C {bitcell_6t.sym} 6200 31000 0 0 {name=Xr155c31}
N 6160 31040 6140 31040 {}
C {lab_pin.sym} 6140 31040 0 0 {name=l24956 lab=BL31}
N 6160 31000 6140 31000 {}
C {lab_pin.sym} 6140 31000 0 0 {name=l24957 lab=BLB31}
N 6160 30960 6140 30960 {}
C {lab_pin.sym} 6140 30960 0 0 {name=l24958 lab=WL155}
N 6240 31040 6260 31040 {}
C {lab_pin.sym} 6260 31040 0 0 {name=l24959 lab=VDD}
N 6240 30960 6260 30960 {}
C {lab_pin.sym} 6260 30960 0 0 {name=l24960 lab=VSS}
C {bitcell_6t.sym} 0 31200 0 0 {name=Xr156c0}
N -40 31240 -60 31240 {}
C {lab_pin.sym} -60 31240 0 0 {name=l24961 lab=BL0}
N -40 31200 -60 31200 {}
C {lab_pin.sym} -60 31200 0 0 {name=l24962 lab=BLB0}
N -40 31160 -60 31160 {}
C {lab_pin.sym} -60 31160 0 0 {name=l24963 lab=WL156}
N 40 31240 60 31240 {}
C {lab_pin.sym} 60 31240 0 0 {name=l24964 lab=VDD}
N 40 31160 60 31160 {}
C {lab_pin.sym} 60 31160 0 0 {name=l24965 lab=VSS}
C {bitcell_6t.sym} 200 31200 0 0 {name=Xr156c1}
N 160 31240 140 31240 {}
C {lab_pin.sym} 140 31240 0 0 {name=l24966 lab=BL1}
N 160 31200 140 31200 {}
C {lab_pin.sym} 140 31200 0 0 {name=l24967 lab=BLB1}
N 160 31160 140 31160 {}
C {lab_pin.sym} 140 31160 0 0 {name=l24968 lab=WL156}
N 240 31240 260 31240 {}
C {lab_pin.sym} 260 31240 0 0 {name=l24969 lab=VDD}
N 240 31160 260 31160 {}
C {lab_pin.sym} 260 31160 0 0 {name=l24970 lab=VSS}
C {bitcell_6t.sym} 400 31200 0 0 {name=Xr156c2}
N 360 31240 340 31240 {}
C {lab_pin.sym} 340 31240 0 0 {name=l24971 lab=BL2}
N 360 31200 340 31200 {}
C {lab_pin.sym} 340 31200 0 0 {name=l24972 lab=BLB2}
N 360 31160 340 31160 {}
C {lab_pin.sym} 340 31160 0 0 {name=l24973 lab=WL156}
N 440 31240 460 31240 {}
C {lab_pin.sym} 460 31240 0 0 {name=l24974 lab=VDD}
N 440 31160 460 31160 {}
C {lab_pin.sym} 460 31160 0 0 {name=l24975 lab=VSS}
C {bitcell_6t.sym} 600 31200 0 0 {name=Xr156c3}
N 560 31240 540 31240 {}
C {lab_pin.sym} 540 31240 0 0 {name=l24976 lab=BL3}
N 560 31200 540 31200 {}
C {lab_pin.sym} 540 31200 0 0 {name=l24977 lab=BLB3}
N 560 31160 540 31160 {}
C {lab_pin.sym} 540 31160 0 0 {name=l24978 lab=WL156}
N 640 31240 660 31240 {}
C {lab_pin.sym} 660 31240 0 0 {name=l24979 lab=VDD}
N 640 31160 660 31160 {}
C {lab_pin.sym} 660 31160 0 0 {name=l24980 lab=VSS}
C {bitcell_6t.sym} 800 31200 0 0 {name=Xr156c4}
N 760 31240 740 31240 {}
C {lab_pin.sym} 740 31240 0 0 {name=l24981 lab=BL4}
N 760 31200 740 31200 {}
C {lab_pin.sym} 740 31200 0 0 {name=l24982 lab=BLB4}
N 760 31160 740 31160 {}
C {lab_pin.sym} 740 31160 0 0 {name=l24983 lab=WL156}
N 840 31240 860 31240 {}
C {lab_pin.sym} 860 31240 0 0 {name=l24984 lab=VDD}
N 840 31160 860 31160 {}
C {lab_pin.sym} 860 31160 0 0 {name=l24985 lab=VSS}
C {bitcell_6t.sym} 1000 31200 0 0 {name=Xr156c5}
N 960 31240 940 31240 {}
C {lab_pin.sym} 940 31240 0 0 {name=l24986 lab=BL5}
N 960 31200 940 31200 {}
C {lab_pin.sym} 940 31200 0 0 {name=l24987 lab=BLB5}
N 960 31160 940 31160 {}
C {lab_pin.sym} 940 31160 0 0 {name=l24988 lab=WL156}
N 1040 31240 1060 31240 {}
C {lab_pin.sym} 1060 31240 0 0 {name=l24989 lab=VDD}
N 1040 31160 1060 31160 {}
C {lab_pin.sym} 1060 31160 0 0 {name=l24990 lab=VSS}
C {bitcell_6t.sym} 1200 31200 0 0 {name=Xr156c6}
N 1160 31240 1140 31240 {}
C {lab_pin.sym} 1140 31240 0 0 {name=l24991 lab=BL6}
N 1160 31200 1140 31200 {}
C {lab_pin.sym} 1140 31200 0 0 {name=l24992 lab=BLB6}
N 1160 31160 1140 31160 {}
C {lab_pin.sym} 1140 31160 0 0 {name=l24993 lab=WL156}
N 1240 31240 1260 31240 {}
C {lab_pin.sym} 1260 31240 0 0 {name=l24994 lab=VDD}
N 1240 31160 1260 31160 {}
C {lab_pin.sym} 1260 31160 0 0 {name=l24995 lab=VSS}
C {bitcell_6t.sym} 1400 31200 0 0 {name=Xr156c7}
N 1360 31240 1340 31240 {}
C {lab_pin.sym} 1340 31240 0 0 {name=l24996 lab=BL7}
N 1360 31200 1340 31200 {}
C {lab_pin.sym} 1340 31200 0 0 {name=l24997 lab=BLB7}
N 1360 31160 1340 31160 {}
C {lab_pin.sym} 1340 31160 0 0 {name=l24998 lab=WL156}
N 1440 31240 1460 31240 {}
C {lab_pin.sym} 1460 31240 0 0 {name=l24999 lab=VDD}
N 1440 31160 1460 31160 {}
C {lab_pin.sym} 1460 31160 0 0 {name=l25000 lab=VSS}
C {bitcell_6t.sym} 1600 31200 0 0 {name=Xr156c8}
N 1560 31240 1540 31240 {}
C {lab_pin.sym} 1540 31240 0 0 {name=l25001 lab=BL8}
N 1560 31200 1540 31200 {}
C {lab_pin.sym} 1540 31200 0 0 {name=l25002 lab=BLB8}
N 1560 31160 1540 31160 {}
C {lab_pin.sym} 1540 31160 0 0 {name=l25003 lab=WL156}
N 1640 31240 1660 31240 {}
C {lab_pin.sym} 1660 31240 0 0 {name=l25004 lab=VDD}
N 1640 31160 1660 31160 {}
C {lab_pin.sym} 1660 31160 0 0 {name=l25005 lab=VSS}
C {bitcell_6t.sym} 1800 31200 0 0 {name=Xr156c9}
N 1760 31240 1740 31240 {}
C {lab_pin.sym} 1740 31240 0 0 {name=l25006 lab=BL9}
N 1760 31200 1740 31200 {}
C {lab_pin.sym} 1740 31200 0 0 {name=l25007 lab=BLB9}
N 1760 31160 1740 31160 {}
C {lab_pin.sym} 1740 31160 0 0 {name=l25008 lab=WL156}
N 1840 31240 1860 31240 {}
C {lab_pin.sym} 1860 31240 0 0 {name=l25009 lab=VDD}
N 1840 31160 1860 31160 {}
C {lab_pin.sym} 1860 31160 0 0 {name=l25010 lab=VSS}
C {bitcell_6t.sym} 2000 31200 0 0 {name=Xr156c10}
N 1960 31240 1940 31240 {}
C {lab_pin.sym} 1940 31240 0 0 {name=l25011 lab=BL10}
N 1960 31200 1940 31200 {}
C {lab_pin.sym} 1940 31200 0 0 {name=l25012 lab=BLB10}
N 1960 31160 1940 31160 {}
C {lab_pin.sym} 1940 31160 0 0 {name=l25013 lab=WL156}
N 2040 31240 2060 31240 {}
C {lab_pin.sym} 2060 31240 0 0 {name=l25014 lab=VDD}
N 2040 31160 2060 31160 {}
C {lab_pin.sym} 2060 31160 0 0 {name=l25015 lab=VSS}
C {bitcell_6t.sym} 2200 31200 0 0 {name=Xr156c11}
N 2160 31240 2140 31240 {}
C {lab_pin.sym} 2140 31240 0 0 {name=l25016 lab=BL11}
N 2160 31200 2140 31200 {}
C {lab_pin.sym} 2140 31200 0 0 {name=l25017 lab=BLB11}
N 2160 31160 2140 31160 {}
C {lab_pin.sym} 2140 31160 0 0 {name=l25018 lab=WL156}
N 2240 31240 2260 31240 {}
C {lab_pin.sym} 2260 31240 0 0 {name=l25019 lab=VDD}
N 2240 31160 2260 31160 {}
C {lab_pin.sym} 2260 31160 0 0 {name=l25020 lab=VSS}
C {bitcell_6t.sym} 2400 31200 0 0 {name=Xr156c12}
N 2360 31240 2340 31240 {}
C {lab_pin.sym} 2340 31240 0 0 {name=l25021 lab=BL12}
N 2360 31200 2340 31200 {}
C {lab_pin.sym} 2340 31200 0 0 {name=l25022 lab=BLB12}
N 2360 31160 2340 31160 {}
C {lab_pin.sym} 2340 31160 0 0 {name=l25023 lab=WL156}
N 2440 31240 2460 31240 {}
C {lab_pin.sym} 2460 31240 0 0 {name=l25024 lab=VDD}
N 2440 31160 2460 31160 {}
C {lab_pin.sym} 2460 31160 0 0 {name=l25025 lab=VSS}
C {bitcell_6t.sym} 2600 31200 0 0 {name=Xr156c13}
N 2560 31240 2540 31240 {}
C {lab_pin.sym} 2540 31240 0 0 {name=l25026 lab=BL13}
N 2560 31200 2540 31200 {}
C {lab_pin.sym} 2540 31200 0 0 {name=l25027 lab=BLB13}
N 2560 31160 2540 31160 {}
C {lab_pin.sym} 2540 31160 0 0 {name=l25028 lab=WL156}
N 2640 31240 2660 31240 {}
C {lab_pin.sym} 2660 31240 0 0 {name=l25029 lab=VDD}
N 2640 31160 2660 31160 {}
C {lab_pin.sym} 2660 31160 0 0 {name=l25030 lab=VSS}
C {bitcell_6t.sym} 2800 31200 0 0 {name=Xr156c14}
N 2760 31240 2740 31240 {}
C {lab_pin.sym} 2740 31240 0 0 {name=l25031 lab=BL14}
N 2760 31200 2740 31200 {}
C {lab_pin.sym} 2740 31200 0 0 {name=l25032 lab=BLB14}
N 2760 31160 2740 31160 {}
C {lab_pin.sym} 2740 31160 0 0 {name=l25033 lab=WL156}
N 2840 31240 2860 31240 {}
C {lab_pin.sym} 2860 31240 0 0 {name=l25034 lab=VDD}
N 2840 31160 2860 31160 {}
C {lab_pin.sym} 2860 31160 0 0 {name=l25035 lab=VSS}
C {bitcell_6t.sym} 3000 31200 0 0 {name=Xr156c15}
N 2960 31240 2940 31240 {}
C {lab_pin.sym} 2940 31240 0 0 {name=l25036 lab=BL15}
N 2960 31200 2940 31200 {}
C {lab_pin.sym} 2940 31200 0 0 {name=l25037 lab=BLB15}
N 2960 31160 2940 31160 {}
C {lab_pin.sym} 2940 31160 0 0 {name=l25038 lab=WL156}
N 3040 31240 3060 31240 {}
C {lab_pin.sym} 3060 31240 0 0 {name=l25039 lab=VDD}
N 3040 31160 3060 31160 {}
C {lab_pin.sym} 3060 31160 0 0 {name=l25040 lab=VSS}
C {bitcell_6t.sym} 3200 31200 0 0 {name=Xr156c16}
N 3160 31240 3140 31240 {}
C {lab_pin.sym} 3140 31240 0 0 {name=l25041 lab=BL16}
N 3160 31200 3140 31200 {}
C {lab_pin.sym} 3140 31200 0 0 {name=l25042 lab=BLB16}
N 3160 31160 3140 31160 {}
C {lab_pin.sym} 3140 31160 0 0 {name=l25043 lab=WL156}
N 3240 31240 3260 31240 {}
C {lab_pin.sym} 3260 31240 0 0 {name=l25044 lab=VDD}
N 3240 31160 3260 31160 {}
C {lab_pin.sym} 3260 31160 0 0 {name=l25045 lab=VSS}
C {bitcell_6t.sym} 3400 31200 0 0 {name=Xr156c17}
N 3360 31240 3340 31240 {}
C {lab_pin.sym} 3340 31240 0 0 {name=l25046 lab=BL17}
N 3360 31200 3340 31200 {}
C {lab_pin.sym} 3340 31200 0 0 {name=l25047 lab=BLB17}
N 3360 31160 3340 31160 {}
C {lab_pin.sym} 3340 31160 0 0 {name=l25048 lab=WL156}
N 3440 31240 3460 31240 {}
C {lab_pin.sym} 3460 31240 0 0 {name=l25049 lab=VDD}
N 3440 31160 3460 31160 {}
C {lab_pin.sym} 3460 31160 0 0 {name=l25050 lab=VSS}
C {bitcell_6t.sym} 3600 31200 0 0 {name=Xr156c18}
N 3560 31240 3540 31240 {}
C {lab_pin.sym} 3540 31240 0 0 {name=l25051 lab=BL18}
N 3560 31200 3540 31200 {}
C {lab_pin.sym} 3540 31200 0 0 {name=l25052 lab=BLB18}
N 3560 31160 3540 31160 {}
C {lab_pin.sym} 3540 31160 0 0 {name=l25053 lab=WL156}
N 3640 31240 3660 31240 {}
C {lab_pin.sym} 3660 31240 0 0 {name=l25054 lab=VDD}
N 3640 31160 3660 31160 {}
C {lab_pin.sym} 3660 31160 0 0 {name=l25055 lab=VSS}
C {bitcell_6t.sym} 3800 31200 0 0 {name=Xr156c19}
N 3760 31240 3740 31240 {}
C {lab_pin.sym} 3740 31240 0 0 {name=l25056 lab=BL19}
N 3760 31200 3740 31200 {}
C {lab_pin.sym} 3740 31200 0 0 {name=l25057 lab=BLB19}
N 3760 31160 3740 31160 {}
C {lab_pin.sym} 3740 31160 0 0 {name=l25058 lab=WL156}
N 3840 31240 3860 31240 {}
C {lab_pin.sym} 3860 31240 0 0 {name=l25059 lab=VDD}
N 3840 31160 3860 31160 {}
C {lab_pin.sym} 3860 31160 0 0 {name=l25060 lab=VSS}
C {bitcell_6t.sym} 4000 31200 0 0 {name=Xr156c20}
N 3960 31240 3940 31240 {}
C {lab_pin.sym} 3940 31240 0 0 {name=l25061 lab=BL20}
N 3960 31200 3940 31200 {}
C {lab_pin.sym} 3940 31200 0 0 {name=l25062 lab=BLB20}
N 3960 31160 3940 31160 {}
C {lab_pin.sym} 3940 31160 0 0 {name=l25063 lab=WL156}
N 4040 31240 4060 31240 {}
C {lab_pin.sym} 4060 31240 0 0 {name=l25064 lab=VDD}
N 4040 31160 4060 31160 {}
C {lab_pin.sym} 4060 31160 0 0 {name=l25065 lab=VSS}
C {bitcell_6t.sym} 4200 31200 0 0 {name=Xr156c21}
N 4160 31240 4140 31240 {}
C {lab_pin.sym} 4140 31240 0 0 {name=l25066 lab=BL21}
N 4160 31200 4140 31200 {}
C {lab_pin.sym} 4140 31200 0 0 {name=l25067 lab=BLB21}
N 4160 31160 4140 31160 {}
C {lab_pin.sym} 4140 31160 0 0 {name=l25068 lab=WL156}
N 4240 31240 4260 31240 {}
C {lab_pin.sym} 4260 31240 0 0 {name=l25069 lab=VDD}
N 4240 31160 4260 31160 {}
C {lab_pin.sym} 4260 31160 0 0 {name=l25070 lab=VSS}
C {bitcell_6t.sym} 4400 31200 0 0 {name=Xr156c22}
N 4360 31240 4340 31240 {}
C {lab_pin.sym} 4340 31240 0 0 {name=l25071 lab=BL22}
N 4360 31200 4340 31200 {}
C {lab_pin.sym} 4340 31200 0 0 {name=l25072 lab=BLB22}
N 4360 31160 4340 31160 {}
C {lab_pin.sym} 4340 31160 0 0 {name=l25073 lab=WL156}
N 4440 31240 4460 31240 {}
C {lab_pin.sym} 4460 31240 0 0 {name=l25074 lab=VDD}
N 4440 31160 4460 31160 {}
C {lab_pin.sym} 4460 31160 0 0 {name=l25075 lab=VSS}
C {bitcell_6t.sym} 4600 31200 0 0 {name=Xr156c23}
N 4560 31240 4540 31240 {}
C {lab_pin.sym} 4540 31240 0 0 {name=l25076 lab=BL23}
N 4560 31200 4540 31200 {}
C {lab_pin.sym} 4540 31200 0 0 {name=l25077 lab=BLB23}
N 4560 31160 4540 31160 {}
C {lab_pin.sym} 4540 31160 0 0 {name=l25078 lab=WL156}
N 4640 31240 4660 31240 {}
C {lab_pin.sym} 4660 31240 0 0 {name=l25079 lab=VDD}
N 4640 31160 4660 31160 {}
C {lab_pin.sym} 4660 31160 0 0 {name=l25080 lab=VSS}
C {bitcell_6t.sym} 4800 31200 0 0 {name=Xr156c24}
N 4760 31240 4740 31240 {}
C {lab_pin.sym} 4740 31240 0 0 {name=l25081 lab=BL24}
N 4760 31200 4740 31200 {}
C {lab_pin.sym} 4740 31200 0 0 {name=l25082 lab=BLB24}
N 4760 31160 4740 31160 {}
C {lab_pin.sym} 4740 31160 0 0 {name=l25083 lab=WL156}
N 4840 31240 4860 31240 {}
C {lab_pin.sym} 4860 31240 0 0 {name=l25084 lab=VDD}
N 4840 31160 4860 31160 {}
C {lab_pin.sym} 4860 31160 0 0 {name=l25085 lab=VSS}
C {bitcell_6t.sym} 5000 31200 0 0 {name=Xr156c25}
N 4960 31240 4940 31240 {}
C {lab_pin.sym} 4940 31240 0 0 {name=l25086 lab=BL25}
N 4960 31200 4940 31200 {}
C {lab_pin.sym} 4940 31200 0 0 {name=l25087 lab=BLB25}
N 4960 31160 4940 31160 {}
C {lab_pin.sym} 4940 31160 0 0 {name=l25088 lab=WL156}
N 5040 31240 5060 31240 {}
C {lab_pin.sym} 5060 31240 0 0 {name=l25089 lab=VDD}
N 5040 31160 5060 31160 {}
C {lab_pin.sym} 5060 31160 0 0 {name=l25090 lab=VSS}
C {bitcell_6t.sym} 5200 31200 0 0 {name=Xr156c26}
N 5160 31240 5140 31240 {}
C {lab_pin.sym} 5140 31240 0 0 {name=l25091 lab=BL26}
N 5160 31200 5140 31200 {}
C {lab_pin.sym} 5140 31200 0 0 {name=l25092 lab=BLB26}
N 5160 31160 5140 31160 {}
C {lab_pin.sym} 5140 31160 0 0 {name=l25093 lab=WL156}
N 5240 31240 5260 31240 {}
C {lab_pin.sym} 5260 31240 0 0 {name=l25094 lab=VDD}
N 5240 31160 5260 31160 {}
C {lab_pin.sym} 5260 31160 0 0 {name=l25095 lab=VSS}
C {bitcell_6t.sym} 5400 31200 0 0 {name=Xr156c27}
N 5360 31240 5340 31240 {}
C {lab_pin.sym} 5340 31240 0 0 {name=l25096 lab=BL27}
N 5360 31200 5340 31200 {}
C {lab_pin.sym} 5340 31200 0 0 {name=l25097 lab=BLB27}
N 5360 31160 5340 31160 {}
C {lab_pin.sym} 5340 31160 0 0 {name=l25098 lab=WL156}
N 5440 31240 5460 31240 {}
C {lab_pin.sym} 5460 31240 0 0 {name=l25099 lab=VDD}
N 5440 31160 5460 31160 {}
C {lab_pin.sym} 5460 31160 0 0 {name=l25100 lab=VSS}
C {bitcell_6t.sym} 5600 31200 0 0 {name=Xr156c28}
N 5560 31240 5540 31240 {}
C {lab_pin.sym} 5540 31240 0 0 {name=l25101 lab=BL28}
N 5560 31200 5540 31200 {}
C {lab_pin.sym} 5540 31200 0 0 {name=l25102 lab=BLB28}
N 5560 31160 5540 31160 {}
C {lab_pin.sym} 5540 31160 0 0 {name=l25103 lab=WL156}
N 5640 31240 5660 31240 {}
C {lab_pin.sym} 5660 31240 0 0 {name=l25104 lab=VDD}
N 5640 31160 5660 31160 {}
C {lab_pin.sym} 5660 31160 0 0 {name=l25105 lab=VSS}
C {bitcell_6t.sym} 5800 31200 0 0 {name=Xr156c29}
N 5760 31240 5740 31240 {}
C {lab_pin.sym} 5740 31240 0 0 {name=l25106 lab=BL29}
N 5760 31200 5740 31200 {}
C {lab_pin.sym} 5740 31200 0 0 {name=l25107 lab=BLB29}
N 5760 31160 5740 31160 {}
C {lab_pin.sym} 5740 31160 0 0 {name=l25108 lab=WL156}
N 5840 31240 5860 31240 {}
C {lab_pin.sym} 5860 31240 0 0 {name=l25109 lab=VDD}
N 5840 31160 5860 31160 {}
C {lab_pin.sym} 5860 31160 0 0 {name=l25110 lab=VSS}
C {bitcell_6t.sym} 6000 31200 0 0 {name=Xr156c30}
N 5960 31240 5940 31240 {}
C {lab_pin.sym} 5940 31240 0 0 {name=l25111 lab=BL30}
N 5960 31200 5940 31200 {}
C {lab_pin.sym} 5940 31200 0 0 {name=l25112 lab=BLB30}
N 5960 31160 5940 31160 {}
C {lab_pin.sym} 5940 31160 0 0 {name=l25113 lab=WL156}
N 6040 31240 6060 31240 {}
C {lab_pin.sym} 6060 31240 0 0 {name=l25114 lab=VDD}
N 6040 31160 6060 31160 {}
C {lab_pin.sym} 6060 31160 0 0 {name=l25115 lab=VSS}
C {bitcell_6t.sym} 6200 31200 0 0 {name=Xr156c31}
N 6160 31240 6140 31240 {}
C {lab_pin.sym} 6140 31240 0 0 {name=l25116 lab=BL31}
N 6160 31200 6140 31200 {}
C {lab_pin.sym} 6140 31200 0 0 {name=l25117 lab=BLB31}
N 6160 31160 6140 31160 {}
C {lab_pin.sym} 6140 31160 0 0 {name=l25118 lab=WL156}
N 6240 31240 6260 31240 {}
C {lab_pin.sym} 6260 31240 0 0 {name=l25119 lab=VDD}
N 6240 31160 6260 31160 {}
C {lab_pin.sym} 6260 31160 0 0 {name=l25120 lab=VSS}
C {bitcell_6t.sym} 0 31400 0 0 {name=Xr157c0}
N -40 31440 -60 31440 {}
C {lab_pin.sym} -60 31440 0 0 {name=l25121 lab=BL0}
N -40 31400 -60 31400 {}
C {lab_pin.sym} -60 31400 0 0 {name=l25122 lab=BLB0}
N -40 31360 -60 31360 {}
C {lab_pin.sym} -60 31360 0 0 {name=l25123 lab=WL157}
N 40 31440 60 31440 {}
C {lab_pin.sym} 60 31440 0 0 {name=l25124 lab=VDD}
N 40 31360 60 31360 {}
C {lab_pin.sym} 60 31360 0 0 {name=l25125 lab=VSS}
C {bitcell_6t.sym} 200 31400 0 0 {name=Xr157c1}
N 160 31440 140 31440 {}
C {lab_pin.sym} 140 31440 0 0 {name=l25126 lab=BL1}
N 160 31400 140 31400 {}
C {lab_pin.sym} 140 31400 0 0 {name=l25127 lab=BLB1}
N 160 31360 140 31360 {}
C {lab_pin.sym} 140 31360 0 0 {name=l25128 lab=WL157}
N 240 31440 260 31440 {}
C {lab_pin.sym} 260 31440 0 0 {name=l25129 lab=VDD}
N 240 31360 260 31360 {}
C {lab_pin.sym} 260 31360 0 0 {name=l25130 lab=VSS}
C {bitcell_6t.sym} 400 31400 0 0 {name=Xr157c2}
N 360 31440 340 31440 {}
C {lab_pin.sym} 340 31440 0 0 {name=l25131 lab=BL2}
N 360 31400 340 31400 {}
C {lab_pin.sym} 340 31400 0 0 {name=l25132 lab=BLB2}
N 360 31360 340 31360 {}
C {lab_pin.sym} 340 31360 0 0 {name=l25133 lab=WL157}
N 440 31440 460 31440 {}
C {lab_pin.sym} 460 31440 0 0 {name=l25134 lab=VDD}
N 440 31360 460 31360 {}
C {lab_pin.sym} 460 31360 0 0 {name=l25135 lab=VSS}
C {bitcell_6t.sym} 600 31400 0 0 {name=Xr157c3}
N 560 31440 540 31440 {}
C {lab_pin.sym} 540 31440 0 0 {name=l25136 lab=BL3}
N 560 31400 540 31400 {}
C {lab_pin.sym} 540 31400 0 0 {name=l25137 lab=BLB3}
N 560 31360 540 31360 {}
C {lab_pin.sym} 540 31360 0 0 {name=l25138 lab=WL157}
N 640 31440 660 31440 {}
C {lab_pin.sym} 660 31440 0 0 {name=l25139 lab=VDD}
N 640 31360 660 31360 {}
C {lab_pin.sym} 660 31360 0 0 {name=l25140 lab=VSS}
C {bitcell_6t.sym} 800 31400 0 0 {name=Xr157c4}
N 760 31440 740 31440 {}
C {lab_pin.sym} 740 31440 0 0 {name=l25141 lab=BL4}
N 760 31400 740 31400 {}
C {lab_pin.sym} 740 31400 0 0 {name=l25142 lab=BLB4}
N 760 31360 740 31360 {}
C {lab_pin.sym} 740 31360 0 0 {name=l25143 lab=WL157}
N 840 31440 860 31440 {}
C {lab_pin.sym} 860 31440 0 0 {name=l25144 lab=VDD}
N 840 31360 860 31360 {}
C {lab_pin.sym} 860 31360 0 0 {name=l25145 lab=VSS}
C {bitcell_6t.sym} 1000 31400 0 0 {name=Xr157c5}
N 960 31440 940 31440 {}
C {lab_pin.sym} 940 31440 0 0 {name=l25146 lab=BL5}
N 960 31400 940 31400 {}
C {lab_pin.sym} 940 31400 0 0 {name=l25147 lab=BLB5}
N 960 31360 940 31360 {}
C {lab_pin.sym} 940 31360 0 0 {name=l25148 lab=WL157}
N 1040 31440 1060 31440 {}
C {lab_pin.sym} 1060 31440 0 0 {name=l25149 lab=VDD}
N 1040 31360 1060 31360 {}
C {lab_pin.sym} 1060 31360 0 0 {name=l25150 lab=VSS}
C {bitcell_6t.sym} 1200 31400 0 0 {name=Xr157c6}
N 1160 31440 1140 31440 {}
C {lab_pin.sym} 1140 31440 0 0 {name=l25151 lab=BL6}
N 1160 31400 1140 31400 {}
C {lab_pin.sym} 1140 31400 0 0 {name=l25152 lab=BLB6}
N 1160 31360 1140 31360 {}
C {lab_pin.sym} 1140 31360 0 0 {name=l25153 lab=WL157}
N 1240 31440 1260 31440 {}
C {lab_pin.sym} 1260 31440 0 0 {name=l25154 lab=VDD}
N 1240 31360 1260 31360 {}
C {lab_pin.sym} 1260 31360 0 0 {name=l25155 lab=VSS}
C {bitcell_6t.sym} 1400 31400 0 0 {name=Xr157c7}
N 1360 31440 1340 31440 {}
C {lab_pin.sym} 1340 31440 0 0 {name=l25156 lab=BL7}
N 1360 31400 1340 31400 {}
C {lab_pin.sym} 1340 31400 0 0 {name=l25157 lab=BLB7}
N 1360 31360 1340 31360 {}
C {lab_pin.sym} 1340 31360 0 0 {name=l25158 lab=WL157}
N 1440 31440 1460 31440 {}
C {lab_pin.sym} 1460 31440 0 0 {name=l25159 lab=VDD}
N 1440 31360 1460 31360 {}
C {lab_pin.sym} 1460 31360 0 0 {name=l25160 lab=VSS}
C {bitcell_6t.sym} 1600 31400 0 0 {name=Xr157c8}
N 1560 31440 1540 31440 {}
C {lab_pin.sym} 1540 31440 0 0 {name=l25161 lab=BL8}
N 1560 31400 1540 31400 {}
C {lab_pin.sym} 1540 31400 0 0 {name=l25162 lab=BLB8}
N 1560 31360 1540 31360 {}
C {lab_pin.sym} 1540 31360 0 0 {name=l25163 lab=WL157}
N 1640 31440 1660 31440 {}
C {lab_pin.sym} 1660 31440 0 0 {name=l25164 lab=VDD}
N 1640 31360 1660 31360 {}
C {lab_pin.sym} 1660 31360 0 0 {name=l25165 lab=VSS}
C {bitcell_6t.sym} 1800 31400 0 0 {name=Xr157c9}
N 1760 31440 1740 31440 {}
C {lab_pin.sym} 1740 31440 0 0 {name=l25166 lab=BL9}
N 1760 31400 1740 31400 {}
C {lab_pin.sym} 1740 31400 0 0 {name=l25167 lab=BLB9}
N 1760 31360 1740 31360 {}
C {lab_pin.sym} 1740 31360 0 0 {name=l25168 lab=WL157}
N 1840 31440 1860 31440 {}
C {lab_pin.sym} 1860 31440 0 0 {name=l25169 lab=VDD}
N 1840 31360 1860 31360 {}
C {lab_pin.sym} 1860 31360 0 0 {name=l25170 lab=VSS}
C {bitcell_6t.sym} 2000 31400 0 0 {name=Xr157c10}
N 1960 31440 1940 31440 {}
C {lab_pin.sym} 1940 31440 0 0 {name=l25171 lab=BL10}
N 1960 31400 1940 31400 {}
C {lab_pin.sym} 1940 31400 0 0 {name=l25172 lab=BLB10}
N 1960 31360 1940 31360 {}
C {lab_pin.sym} 1940 31360 0 0 {name=l25173 lab=WL157}
N 2040 31440 2060 31440 {}
C {lab_pin.sym} 2060 31440 0 0 {name=l25174 lab=VDD}
N 2040 31360 2060 31360 {}
C {lab_pin.sym} 2060 31360 0 0 {name=l25175 lab=VSS}
C {bitcell_6t.sym} 2200 31400 0 0 {name=Xr157c11}
N 2160 31440 2140 31440 {}
C {lab_pin.sym} 2140 31440 0 0 {name=l25176 lab=BL11}
N 2160 31400 2140 31400 {}
C {lab_pin.sym} 2140 31400 0 0 {name=l25177 lab=BLB11}
N 2160 31360 2140 31360 {}
C {lab_pin.sym} 2140 31360 0 0 {name=l25178 lab=WL157}
N 2240 31440 2260 31440 {}
C {lab_pin.sym} 2260 31440 0 0 {name=l25179 lab=VDD}
N 2240 31360 2260 31360 {}
C {lab_pin.sym} 2260 31360 0 0 {name=l25180 lab=VSS}
C {bitcell_6t.sym} 2400 31400 0 0 {name=Xr157c12}
N 2360 31440 2340 31440 {}
C {lab_pin.sym} 2340 31440 0 0 {name=l25181 lab=BL12}
N 2360 31400 2340 31400 {}
C {lab_pin.sym} 2340 31400 0 0 {name=l25182 lab=BLB12}
N 2360 31360 2340 31360 {}
C {lab_pin.sym} 2340 31360 0 0 {name=l25183 lab=WL157}
N 2440 31440 2460 31440 {}
C {lab_pin.sym} 2460 31440 0 0 {name=l25184 lab=VDD}
N 2440 31360 2460 31360 {}
C {lab_pin.sym} 2460 31360 0 0 {name=l25185 lab=VSS}
C {bitcell_6t.sym} 2600 31400 0 0 {name=Xr157c13}
N 2560 31440 2540 31440 {}
C {lab_pin.sym} 2540 31440 0 0 {name=l25186 lab=BL13}
N 2560 31400 2540 31400 {}
C {lab_pin.sym} 2540 31400 0 0 {name=l25187 lab=BLB13}
N 2560 31360 2540 31360 {}
C {lab_pin.sym} 2540 31360 0 0 {name=l25188 lab=WL157}
N 2640 31440 2660 31440 {}
C {lab_pin.sym} 2660 31440 0 0 {name=l25189 lab=VDD}
N 2640 31360 2660 31360 {}
C {lab_pin.sym} 2660 31360 0 0 {name=l25190 lab=VSS}
C {bitcell_6t.sym} 2800 31400 0 0 {name=Xr157c14}
N 2760 31440 2740 31440 {}
C {lab_pin.sym} 2740 31440 0 0 {name=l25191 lab=BL14}
N 2760 31400 2740 31400 {}
C {lab_pin.sym} 2740 31400 0 0 {name=l25192 lab=BLB14}
N 2760 31360 2740 31360 {}
C {lab_pin.sym} 2740 31360 0 0 {name=l25193 lab=WL157}
N 2840 31440 2860 31440 {}
C {lab_pin.sym} 2860 31440 0 0 {name=l25194 lab=VDD}
N 2840 31360 2860 31360 {}
C {lab_pin.sym} 2860 31360 0 0 {name=l25195 lab=VSS}
C {bitcell_6t.sym} 3000 31400 0 0 {name=Xr157c15}
N 2960 31440 2940 31440 {}
C {lab_pin.sym} 2940 31440 0 0 {name=l25196 lab=BL15}
N 2960 31400 2940 31400 {}
C {lab_pin.sym} 2940 31400 0 0 {name=l25197 lab=BLB15}
N 2960 31360 2940 31360 {}
C {lab_pin.sym} 2940 31360 0 0 {name=l25198 lab=WL157}
N 3040 31440 3060 31440 {}
C {lab_pin.sym} 3060 31440 0 0 {name=l25199 lab=VDD}
N 3040 31360 3060 31360 {}
C {lab_pin.sym} 3060 31360 0 0 {name=l25200 lab=VSS}
C {bitcell_6t.sym} 3200 31400 0 0 {name=Xr157c16}
N 3160 31440 3140 31440 {}
C {lab_pin.sym} 3140 31440 0 0 {name=l25201 lab=BL16}
N 3160 31400 3140 31400 {}
C {lab_pin.sym} 3140 31400 0 0 {name=l25202 lab=BLB16}
N 3160 31360 3140 31360 {}
C {lab_pin.sym} 3140 31360 0 0 {name=l25203 lab=WL157}
N 3240 31440 3260 31440 {}
C {lab_pin.sym} 3260 31440 0 0 {name=l25204 lab=VDD}
N 3240 31360 3260 31360 {}
C {lab_pin.sym} 3260 31360 0 0 {name=l25205 lab=VSS}
C {bitcell_6t.sym} 3400 31400 0 0 {name=Xr157c17}
N 3360 31440 3340 31440 {}
C {lab_pin.sym} 3340 31440 0 0 {name=l25206 lab=BL17}
N 3360 31400 3340 31400 {}
C {lab_pin.sym} 3340 31400 0 0 {name=l25207 lab=BLB17}
N 3360 31360 3340 31360 {}
C {lab_pin.sym} 3340 31360 0 0 {name=l25208 lab=WL157}
N 3440 31440 3460 31440 {}
C {lab_pin.sym} 3460 31440 0 0 {name=l25209 lab=VDD}
N 3440 31360 3460 31360 {}
C {lab_pin.sym} 3460 31360 0 0 {name=l25210 lab=VSS}
C {bitcell_6t.sym} 3600 31400 0 0 {name=Xr157c18}
N 3560 31440 3540 31440 {}
C {lab_pin.sym} 3540 31440 0 0 {name=l25211 lab=BL18}
N 3560 31400 3540 31400 {}
C {lab_pin.sym} 3540 31400 0 0 {name=l25212 lab=BLB18}
N 3560 31360 3540 31360 {}
C {lab_pin.sym} 3540 31360 0 0 {name=l25213 lab=WL157}
N 3640 31440 3660 31440 {}
C {lab_pin.sym} 3660 31440 0 0 {name=l25214 lab=VDD}
N 3640 31360 3660 31360 {}
C {lab_pin.sym} 3660 31360 0 0 {name=l25215 lab=VSS}
C {bitcell_6t.sym} 3800 31400 0 0 {name=Xr157c19}
N 3760 31440 3740 31440 {}
C {lab_pin.sym} 3740 31440 0 0 {name=l25216 lab=BL19}
N 3760 31400 3740 31400 {}
C {lab_pin.sym} 3740 31400 0 0 {name=l25217 lab=BLB19}
N 3760 31360 3740 31360 {}
C {lab_pin.sym} 3740 31360 0 0 {name=l25218 lab=WL157}
N 3840 31440 3860 31440 {}
C {lab_pin.sym} 3860 31440 0 0 {name=l25219 lab=VDD}
N 3840 31360 3860 31360 {}
C {lab_pin.sym} 3860 31360 0 0 {name=l25220 lab=VSS}
C {bitcell_6t.sym} 4000 31400 0 0 {name=Xr157c20}
N 3960 31440 3940 31440 {}
C {lab_pin.sym} 3940 31440 0 0 {name=l25221 lab=BL20}
N 3960 31400 3940 31400 {}
C {lab_pin.sym} 3940 31400 0 0 {name=l25222 lab=BLB20}
N 3960 31360 3940 31360 {}
C {lab_pin.sym} 3940 31360 0 0 {name=l25223 lab=WL157}
N 4040 31440 4060 31440 {}
C {lab_pin.sym} 4060 31440 0 0 {name=l25224 lab=VDD}
N 4040 31360 4060 31360 {}
C {lab_pin.sym} 4060 31360 0 0 {name=l25225 lab=VSS}
C {bitcell_6t.sym} 4200 31400 0 0 {name=Xr157c21}
N 4160 31440 4140 31440 {}
C {lab_pin.sym} 4140 31440 0 0 {name=l25226 lab=BL21}
N 4160 31400 4140 31400 {}
C {lab_pin.sym} 4140 31400 0 0 {name=l25227 lab=BLB21}
N 4160 31360 4140 31360 {}
C {lab_pin.sym} 4140 31360 0 0 {name=l25228 lab=WL157}
N 4240 31440 4260 31440 {}
C {lab_pin.sym} 4260 31440 0 0 {name=l25229 lab=VDD}
N 4240 31360 4260 31360 {}
C {lab_pin.sym} 4260 31360 0 0 {name=l25230 lab=VSS}
C {bitcell_6t.sym} 4400 31400 0 0 {name=Xr157c22}
N 4360 31440 4340 31440 {}
C {lab_pin.sym} 4340 31440 0 0 {name=l25231 lab=BL22}
N 4360 31400 4340 31400 {}
C {lab_pin.sym} 4340 31400 0 0 {name=l25232 lab=BLB22}
N 4360 31360 4340 31360 {}
C {lab_pin.sym} 4340 31360 0 0 {name=l25233 lab=WL157}
N 4440 31440 4460 31440 {}
C {lab_pin.sym} 4460 31440 0 0 {name=l25234 lab=VDD}
N 4440 31360 4460 31360 {}
C {lab_pin.sym} 4460 31360 0 0 {name=l25235 lab=VSS}
C {bitcell_6t.sym} 4600 31400 0 0 {name=Xr157c23}
N 4560 31440 4540 31440 {}
C {lab_pin.sym} 4540 31440 0 0 {name=l25236 lab=BL23}
N 4560 31400 4540 31400 {}
C {lab_pin.sym} 4540 31400 0 0 {name=l25237 lab=BLB23}
N 4560 31360 4540 31360 {}
C {lab_pin.sym} 4540 31360 0 0 {name=l25238 lab=WL157}
N 4640 31440 4660 31440 {}
C {lab_pin.sym} 4660 31440 0 0 {name=l25239 lab=VDD}
N 4640 31360 4660 31360 {}
C {lab_pin.sym} 4660 31360 0 0 {name=l25240 lab=VSS}
C {bitcell_6t.sym} 4800 31400 0 0 {name=Xr157c24}
N 4760 31440 4740 31440 {}
C {lab_pin.sym} 4740 31440 0 0 {name=l25241 lab=BL24}
N 4760 31400 4740 31400 {}
C {lab_pin.sym} 4740 31400 0 0 {name=l25242 lab=BLB24}
N 4760 31360 4740 31360 {}
C {lab_pin.sym} 4740 31360 0 0 {name=l25243 lab=WL157}
N 4840 31440 4860 31440 {}
C {lab_pin.sym} 4860 31440 0 0 {name=l25244 lab=VDD}
N 4840 31360 4860 31360 {}
C {lab_pin.sym} 4860 31360 0 0 {name=l25245 lab=VSS}
C {bitcell_6t.sym} 5000 31400 0 0 {name=Xr157c25}
N 4960 31440 4940 31440 {}
C {lab_pin.sym} 4940 31440 0 0 {name=l25246 lab=BL25}
N 4960 31400 4940 31400 {}
C {lab_pin.sym} 4940 31400 0 0 {name=l25247 lab=BLB25}
N 4960 31360 4940 31360 {}
C {lab_pin.sym} 4940 31360 0 0 {name=l25248 lab=WL157}
N 5040 31440 5060 31440 {}
C {lab_pin.sym} 5060 31440 0 0 {name=l25249 lab=VDD}
N 5040 31360 5060 31360 {}
C {lab_pin.sym} 5060 31360 0 0 {name=l25250 lab=VSS}
C {bitcell_6t.sym} 5200 31400 0 0 {name=Xr157c26}
N 5160 31440 5140 31440 {}
C {lab_pin.sym} 5140 31440 0 0 {name=l25251 lab=BL26}
N 5160 31400 5140 31400 {}
C {lab_pin.sym} 5140 31400 0 0 {name=l25252 lab=BLB26}
N 5160 31360 5140 31360 {}
C {lab_pin.sym} 5140 31360 0 0 {name=l25253 lab=WL157}
N 5240 31440 5260 31440 {}
C {lab_pin.sym} 5260 31440 0 0 {name=l25254 lab=VDD}
N 5240 31360 5260 31360 {}
C {lab_pin.sym} 5260 31360 0 0 {name=l25255 lab=VSS}
C {bitcell_6t.sym} 5400 31400 0 0 {name=Xr157c27}
N 5360 31440 5340 31440 {}
C {lab_pin.sym} 5340 31440 0 0 {name=l25256 lab=BL27}
N 5360 31400 5340 31400 {}
C {lab_pin.sym} 5340 31400 0 0 {name=l25257 lab=BLB27}
N 5360 31360 5340 31360 {}
C {lab_pin.sym} 5340 31360 0 0 {name=l25258 lab=WL157}
N 5440 31440 5460 31440 {}
C {lab_pin.sym} 5460 31440 0 0 {name=l25259 lab=VDD}
N 5440 31360 5460 31360 {}
C {lab_pin.sym} 5460 31360 0 0 {name=l25260 lab=VSS}
C {bitcell_6t.sym} 5600 31400 0 0 {name=Xr157c28}
N 5560 31440 5540 31440 {}
C {lab_pin.sym} 5540 31440 0 0 {name=l25261 lab=BL28}
N 5560 31400 5540 31400 {}
C {lab_pin.sym} 5540 31400 0 0 {name=l25262 lab=BLB28}
N 5560 31360 5540 31360 {}
C {lab_pin.sym} 5540 31360 0 0 {name=l25263 lab=WL157}
N 5640 31440 5660 31440 {}
C {lab_pin.sym} 5660 31440 0 0 {name=l25264 lab=VDD}
N 5640 31360 5660 31360 {}
C {lab_pin.sym} 5660 31360 0 0 {name=l25265 lab=VSS}
C {bitcell_6t.sym} 5800 31400 0 0 {name=Xr157c29}
N 5760 31440 5740 31440 {}
C {lab_pin.sym} 5740 31440 0 0 {name=l25266 lab=BL29}
N 5760 31400 5740 31400 {}
C {lab_pin.sym} 5740 31400 0 0 {name=l25267 lab=BLB29}
N 5760 31360 5740 31360 {}
C {lab_pin.sym} 5740 31360 0 0 {name=l25268 lab=WL157}
N 5840 31440 5860 31440 {}
C {lab_pin.sym} 5860 31440 0 0 {name=l25269 lab=VDD}
N 5840 31360 5860 31360 {}
C {lab_pin.sym} 5860 31360 0 0 {name=l25270 lab=VSS}
C {bitcell_6t.sym} 6000 31400 0 0 {name=Xr157c30}
N 5960 31440 5940 31440 {}
C {lab_pin.sym} 5940 31440 0 0 {name=l25271 lab=BL30}
N 5960 31400 5940 31400 {}
C {lab_pin.sym} 5940 31400 0 0 {name=l25272 lab=BLB30}
N 5960 31360 5940 31360 {}
C {lab_pin.sym} 5940 31360 0 0 {name=l25273 lab=WL157}
N 6040 31440 6060 31440 {}
C {lab_pin.sym} 6060 31440 0 0 {name=l25274 lab=VDD}
N 6040 31360 6060 31360 {}
C {lab_pin.sym} 6060 31360 0 0 {name=l25275 lab=VSS}
C {bitcell_6t.sym} 6200 31400 0 0 {name=Xr157c31}
N 6160 31440 6140 31440 {}
C {lab_pin.sym} 6140 31440 0 0 {name=l25276 lab=BL31}
N 6160 31400 6140 31400 {}
C {lab_pin.sym} 6140 31400 0 0 {name=l25277 lab=BLB31}
N 6160 31360 6140 31360 {}
C {lab_pin.sym} 6140 31360 0 0 {name=l25278 lab=WL157}
N 6240 31440 6260 31440 {}
C {lab_pin.sym} 6260 31440 0 0 {name=l25279 lab=VDD}
N 6240 31360 6260 31360 {}
C {lab_pin.sym} 6260 31360 0 0 {name=l25280 lab=VSS}
C {bitcell_6t.sym} 0 31600 0 0 {name=Xr158c0}
N -40 31640 -60 31640 {}
C {lab_pin.sym} -60 31640 0 0 {name=l25281 lab=BL0}
N -40 31600 -60 31600 {}
C {lab_pin.sym} -60 31600 0 0 {name=l25282 lab=BLB0}
N -40 31560 -60 31560 {}
C {lab_pin.sym} -60 31560 0 0 {name=l25283 lab=WL158}
N 40 31640 60 31640 {}
C {lab_pin.sym} 60 31640 0 0 {name=l25284 lab=VDD}
N 40 31560 60 31560 {}
C {lab_pin.sym} 60 31560 0 0 {name=l25285 lab=VSS}
C {bitcell_6t.sym} 200 31600 0 0 {name=Xr158c1}
N 160 31640 140 31640 {}
C {lab_pin.sym} 140 31640 0 0 {name=l25286 lab=BL1}
N 160 31600 140 31600 {}
C {lab_pin.sym} 140 31600 0 0 {name=l25287 lab=BLB1}
N 160 31560 140 31560 {}
C {lab_pin.sym} 140 31560 0 0 {name=l25288 lab=WL158}
N 240 31640 260 31640 {}
C {lab_pin.sym} 260 31640 0 0 {name=l25289 lab=VDD}
N 240 31560 260 31560 {}
C {lab_pin.sym} 260 31560 0 0 {name=l25290 lab=VSS}
C {bitcell_6t.sym} 400 31600 0 0 {name=Xr158c2}
N 360 31640 340 31640 {}
C {lab_pin.sym} 340 31640 0 0 {name=l25291 lab=BL2}
N 360 31600 340 31600 {}
C {lab_pin.sym} 340 31600 0 0 {name=l25292 lab=BLB2}
N 360 31560 340 31560 {}
C {lab_pin.sym} 340 31560 0 0 {name=l25293 lab=WL158}
N 440 31640 460 31640 {}
C {lab_pin.sym} 460 31640 0 0 {name=l25294 lab=VDD}
N 440 31560 460 31560 {}
C {lab_pin.sym} 460 31560 0 0 {name=l25295 lab=VSS}
C {bitcell_6t.sym} 600 31600 0 0 {name=Xr158c3}
N 560 31640 540 31640 {}
C {lab_pin.sym} 540 31640 0 0 {name=l25296 lab=BL3}
N 560 31600 540 31600 {}
C {lab_pin.sym} 540 31600 0 0 {name=l25297 lab=BLB3}
N 560 31560 540 31560 {}
C {lab_pin.sym} 540 31560 0 0 {name=l25298 lab=WL158}
N 640 31640 660 31640 {}
C {lab_pin.sym} 660 31640 0 0 {name=l25299 lab=VDD}
N 640 31560 660 31560 {}
C {lab_pin.sym} 660 31560 0 0 {name=l25300 lab=VSS}
C {bitcell_6t.sym} 800 31600 0 0 {name=Xr158c4}
N 760 31640 740 31640 {}
C {lab_pin.sym} 740 31640 0 0 {name=l25301 lab=BL4}
N 760 31600 740 31600 {}
C {lab_pin.sym} 740 31600 0 0 {name=l25302 lab=BLB4}
N 760 31560 740 31560 {}
C {lab_pin.sym} 740 31560 0 0 {name=l25303 lab=WL158}
N 840 31640 860 31640 {}
C {lab_pin.sym} 860 31640 0 0 {name=l25304 lab=VDD}
N 840 31560 860 31560 {}
C {lab_pin.sym} 860 31560 0 0 {name=l25305 lab=VSS}
C {bitcell_6t.sym} 1000 31600 0 0 {name=Xr158c5}
N 960 31640 940 31640 {}
C {lab_pin.sym} 940 31640 0 0 {name=l25306 lab=BL5}
N 960 31600 940 31600 {}
C {lab_pin.sym} 940 31600 0 0 {name=l25307 lab=BLB5}
N 960 31560 940 31560 {}
C {lab_pin.sym} 940 31560 0 0 {name=l25308 lab=WL158}
N 1040 31640 1060 31640 {}
C {lab_pin.sym} 1060 31640 0 0 {name=l25309 lab=VDD}
N 1040 31560 1060 31560 {}
C {lab_pin.sym} 1060 31560 0 0 {name=l25310 lab=VSS}
C {bitcell_6t.sym} 1200 31600 0 0 {name=Xr158c6}
N 1160 31640 1140 31640 {}
C {lab_pin.sym} 1140 31640 0 0 {name=l25311 lab=BL6}
N 1160 31600 1140 31600 {}
C {lab_pin.sym} 1140 31600 0 0 {name=l25312 lab=BLB6}
N 1160 31560 1140 31560 {}
C {lab_pin.sym} 1140 31560 0 0 {name=l25313 lab=WL158}
N 1240 31640 1260 31640 {}
C {lab_pin.sym} 1260 31640 0 0 {name=l25314 lab=VDD}
N 1240 31560 1260 31560 {}
C {lab_pin.sym} 1260 31560 0 0 {name=l25315 lab=VSS}
C {bitcell_6t.sym} 1400 31600 0 0 {name=Xr158c7}
N 1360 31640 1340 31640 {}
C {lab_pin.sym} 1340 31640 0 0 {name=l25316 lab=BL7}
N 1360 31600 1340 31600 {}
C {lab_pin.sym} 1340 31600 0 0 {name=l25317 lab=BLB7}
N 1360 31560 1340 31560 {}
C {lab_pin.sym} 1340 31560 0 0 {name=l25318 lab=WL158}
N 1440 31640 1460 31640 {}
C {lab_pin.sym} 1460 31640 0 0 {name=l25319 lab=VDD}
N 1440 31560 1460 31560 {}
C {lab_pin.sym} 1460 31560 0 0 {name=l25320 lab=VSS}
C {bitcell_6t.sym} 1600 31600 0 0 {name=Xr158c8}
N 1560 31640 1540 31640 {}
C {lab_pin.sym} 1540 31640 0 0 {name=l25321 lab=BL8}
N 1560 31600 1540 31600 {}
C {lab_pin.sym} 1540 31600 0 0 {name=l25322 lab=BLB8}
N 1560 31560 1540 31560 {}
C {lab_pin.sym} 1540 31560 0 0 {name=l25323 lab=WL158}
N 1640 31640 1660 31640 {}
C {lab_pin.sym} 1660 31640 0 0 {name=l25324 lab=VDD}
N 1640 31560 1660 31560 {}
C {lab_pin.sym} 1660 31560 0 0 {name=l25325 lab=VSS}
C {bitcell_6t.sym} 1800 31600 0 0 {name=Xr158c9}
N 1760 31640 1740 31640 {}
C {lab_pin.sym} 1740 31640 0 0 {name=l25326 lab=BL9}
N 1760 31600 1740 31600 {}
C {lab_pin.sym} 1740 31600 0 0 {name=l25327 lab=BLB9}
N 1760 31560 1740 31560 {}
C {lab_pin.sym} 1740 31560 0 0 {name=l25328 lab=WL158}
N 1840 31640 1860 31640 {}
C {lab_pin.sym} 1860 31640 0 0 {name=l25329 lab=VDD}
N 1840 31560 1860 31560 {}
C {lab_pin.sym} 1860 31560 0 0 {name=l25330 lab=VSS}
C {bitcell_6t.sym} 2000 31600 0 0 {name=Xr158c10}
N 1960 31640 1940 31640 {}
C {lab_pin.sym} 1940 31640 0 0 {name=l25331 lab=BL10}
N 1960 31600 1940 31600 {}
C {lab_pin.sym} 1940 31600 0 0 {name=l25332 lab=BLB10}
N 1960 31560 1940 31560 {}
C {lab_pin.sym} 1940 31560 0 0 {name=l25333 lab=WL158}
N 2040 31640 2060 31640 {}
C {lab_pin.sym} 2060 31640 0 0 {name=l25334 lab=VDD}
N 2040 31560 2060 31560 {}
C {lab_pin.sym} 2060 31560 0 0 {name=l25335 lab=VSS}
C {bitcell_6t.sym} 2200 31600 0 0 {name=Xr158c11}
N 2160 31640 2140 31640 {}
C {lab_pin.sym} 2140 31640 0 0 {name=l25336 lab=BL11}
N 2160 31600 2140 31600 {}
C {lab_pin.sym} 2140 31600 0 0 {name=l25337 lab=BLB11}
N 2160 31560 2140 31560 {}
C {lab_pin.sym} 2140 31560 0 0 {name=l25338 lab=WL158}
N 2240 31640 2260 31640 {}
C {lab_pin.sym} 2260 31640 0 0 {name=l25339 lab=VDD}
N 2240 31560 2260 31560 {}
C {lab_pin.sym} 2260 31560 0 0 {name=l25340 lab=VSS}
C {bitcell_6t.sym} 2400 31600 0 0 {name=Xr158c12}
N 2360 31640 2340 31640 {}
C {lab_pin.sym} 2340 31640 0 0 {name=l25341 lab=BL12}
N 2360 31600 2340 31600 {}
C {lab_pin.sym} 2340 31600 0 0 {name=l25342 lab=BLB12}
N 2360 31560 2340 31560 {}
C {lab_pin.sym} 2340 31560 0 0 {name=l25343 lab=WL158}
N 2440 31640 2460 31640 {}
C {lab_pin.sym} 2460 31640 0 0 {name=l25344 lab=VDD}
N 2440 31560 2460 31560 {}
C {lab_pin.sym} 2460 31560 0 0 {name=l25345 lab=VSS}
C {bitcell_6t.sym} 2600 31600 0 0 {name=Xr158c13}
N 2560 31640 2540 31640 {}
C {lab_pin.sym} 2540 31640 0 0 {name=l25346 lab=BL13}
N 2560 31600 2540 31600 {}
C {lab_pin.sym} 2540 31600 0 0 {name=l25347 lab=BLB13}
N 2560 31560 2540 31560 {}
C {lab_pin.sym} 2540 31560 0 0 {name=l25348 lab=WL158}
N 2640 31640 2660 31640 {}
C {lab_pin.sym} 2660 31640 0 0 {name=l25349 lab=VDD}
N 2640 31560 2660 31560 {}
C {lab_pin.sym} 2660 31560 0 0 {name=l25350 lab=VSS}
C {bitcell_6t.sym} 2800 31600 0 0 {name=Xr158c14}
N 2760 31640 2740 31640 {}
C {lab_pin.sym} 2740 31640 0 0 {name=l25351 lab=BL14}
N 2760 31600 2740 31600 {}
C {lab_pin.sym} 2740 31600 0 0 {name=l25352 lab=BLB14}
N 2760 31560 2740 31560 {}
C {lab_pin.sym} 2740 31560 0 0 {name=l25353 lab=WL158}
N 2840 31640 2860 31640 {}
C {lab_pin.sym} 2860 31640 0 0 {name=l25354 lab=VDD}
N 2840 31560 2860 31560 {}
C {lab_pin.sym} 2860 31560 0 0 {name=l25355 lab=VSS}
C {bitcell_6t.sym} 3000 31600 0 0 {name=Xr158c15}
N 2960 31640 2940 31640 {}
C {lab_pin.sym} 2940 31640 0 0 {name=l25356 lab=BL15}
N 2960 31600 2940 31600 {}
C {lab_pin.sym} 2940 31600 0 0 {name=l25357 lab=BLB15}
N 2960 31560 2940 31560 {}
C {lab_pin.sym} 2940 31560 0 0 {name=l25358 lab=WL158}
N 3040 31640 3060 31640 {}
C {lab_pin.sym} 3060 31640 0 0 {name=l25359 lab=VDD}
N 3040 31560 3060 31560 {}
C {lab_pin.sym} 3060 31560 0 0 {name=l25360 lab=VSS}
C {bitcell_6t.sym} 3200 31600 0 0 {name=Xr158c16}
N 3160 31640 3140 31640 {}
C {lab_pin.sym} 3140 31640 0 0 {name=l25361 lab=BL16}
N 3160 31600 3140 31600 {}
C {lab_pin.sym} 3140 31600 0 0 {name=l25362 lab=BLB16}
N 3160 31560 3140 31560 {}
C {lab_pin.sym} 3140 31560 0 0 {name=l25363 lab=WL158}
N 3240 31640 3260 31640 {}
C {lab_pin.sym} 3260 31640 0 0 {name=l25364 lab=VDD}
N 3240 31560 3260 31560 {}
C {lab_pin.sym} 3260 31560 0 0 {name=l25365 lab=VSS}
C {bitcell_6t.sym} 3400 31600 0 0 {name=Xr158c17}
N 3360 31640 3340 31640 {}
C {lab_pin.sym} 3340 31640 0 0 {name=l25366 lab=BL17}
N 3360 31600 3340 31600 {}
C {lab_pin.sym} 3340 31600 0 0 {name=l25367 lab=BLB17}
N 3360 31560 3340 31560 {}
C {lab_pin.sym} 3340 31560 0 0 {name=l25368 lab=WL158}
N 3440 31640 3460 31640 {}
C {lab_pin.sym} 3460 31640 0 0 {name=l25369 lab=VDD}
N 3440 31560 3460 31560 {}
C {lab_pin.sym} 3460 31560 0 0 {name=l25370 lab=VSS}
C {bitcell_6t.sym} 3600 31600 0 0 {name=Xr158c18}
N 3560 31640 3540 31640 {}
C {lab_pin.sym} 3540 31640 0 0 {name=l25371 lab=BL18}
N 3560 31600 3540 31600 {}
C {lab_pin.sym} 3540 31600 0 0 {name=l25372 lab=BLB18}
N 3560 31560 3540 31560 {}
C {lab_pin.sym} 3540 31560 0 0 {name=l25373 lab=WL158}
N 3640 31640 3660 31640 {}
C {lab_pin.sym} 3660 31640 0 0 {name=l25374 lab=VDD}
N 3640 31560 3660 31560 {}
C {lab_pin.sym} 3660 31560 0 0 {name=l25375 lab=VSS}
C {bitcell_6t.sym} 3800 31600 0 0 {name=Xr158c19}
N 3760 31640 3740 31640 {}
C {lab_pin.sym} 3740 31640 0 0 {name=l25376 lab=BL19}
N 3760 31600 3740 31600 {}
C {lab_pin.sym} 3740 31600 0 0 {name=l25377 lab=BLB19}
N 3760 31560 3740 31560 {}
C {lab_pin.sym} 3740 31560 0 0 {name=l25378 lab=WL158}
N 3840 31640 3860 31640 {}
C {lab_pin.sym} 3860 31640 0 0 {name=l25379 lab=VDD}
N 3840 31560 3860 31560 {}
C {lab_pin.sym} 3860 31560 0 0 {name=l25380 lab=VSS}
C {bitcell_6t.sym} 4000 31600 0 0 {name=Xr158c20}
N 3960 31640 3940 31640 {}
C {lab_pin.sym} 3940 31640 0 0 {name=l25381 lab=BL20}
N 3960 31600 3940 31600 {}
C {lab_pin.sym} 3940 31600 0 0 {name=l25382 lab=BLB20}
N 3960 31560 3940 31560 {}
C {lab_pin.sym} 3940 31560 0 0 {name=l25383 lab=WL158}
N 4040 31640 4060 31640 {}
C {lab_pin.sym} 4060 31640 0 0 {name=l25384 lab=VDD}
N 4040 31560 4060 31560 {}
C {lab_pin.sym} 4060 31560 0 0 {name=l25385 lab=VSS}
C {bitcell_6t.sym} 4200 31600 0 0 {name=Xr158c21}
N 4160 31640 4140 31640 {}
C {lab_pin.sym} 4140 31640 0 0 {name=l25386 lab=BL21}
N 4160 31600 4140 31600 {}
C {lab_pin.sym} 4140 31600 0 0 {name=l25387 lab=BLB21}
N 4160 31560 4140 31560 {}
C {lab_pin.sym} 4140 31560 0 0 {name=l25388 lab=WL158}
N 4240 31640 4260 31640 {}
C {lab_pin.sym} 4260 31640 0 0 {name=l25389 lab=VDD}
N 4240 31560 4260 31560 {}
C {lab_pin.sym} 4260 31560 0 0 {name=l25390 lab=VSS}
C {bitcell_6t.sym} 4400 31600 0 0 {name=Xr158c22}
N 4360 31640 4340 31640 {}
C {lab_pin.sym} 4340 31640 0 0 {name=l25391 lab=BL22}
N 4360 31600 4340 31600 {}
C {lab_pin.sym} 4340 31600 0 0 {name=l25392 lab=BLB22}
N 4360 31560 4340 31560 {}
C {lab_pin.sym} 4340 31560 0 0 {name=l25393 lab=WL158}
N 4440 31640 4460 31640 {}
C {lab_pin.sym} 4460 31640 0 0 {name=l25394 lab=VDD}
N 4440 31560 4460 31560 {}
C {lab_pin.sym} 4460 31560 0 0 {name=l25395 lab=VSS}
C {bitcell_6t.sym} 4600 31600 0 0 {name=Xr158c23}
N 4560 31640 4540 31640 {}
C {lab_pin.sym} 4540 31640 0 0 {name=l25396 lab=BL23}
N 4560 31600 4540 31600 {}
C {lab_pin.sym} 4540 31600 0 0 {name=l25397 lab=BLB23}
N 4560 31560 4540 31560 {}
C {lab_pin.sym} 4540 31560 0 0 {name=l25398 lab=WL158}
N 4640 31640 4660 31640 {}
C {lab_pin.sym} 4660 31640 0 0 {name=l25399 lab=VDD}
N 4640 31560 4660 31560 {}
C {lab_pin.sym} 4660 31560 0 0 {name=l25400 lab=VSS}
C {bitcell_6t.sym} 4800 31600 0 0 {name=Xr158c24}
N 4760 31640 4740 31640 {}
C {lab_pin.sym} 4740 31640 0 0 {name=l25401 lab=BL24}
N 4760 31600 4740 31600 {}
C {lab_pin.sym} 4740 31600 0 0 {name=l25402 lab=BLB24}
N 4760 31560 4740 31560 {}
C {lab_pin.sym} 4740 31560 0 0 {name=l25403 lab=WL158}
N 4840 31640 4860 31640 {}
C {lab_pin.sym} 4860 31640 0 0 {name=l25404 lab=VDD}
N 4840 31560 4860 31560 {}
C {lab_pin.sym} 4860 31560 0 0 {name=l25405 lab=VSS}
C {bitcell_6t.sym} 5000 31600 0 0 {name=Xr158c25}
N 4960 31640 4940 31640 {}
C {lab_pin.sym} 4940 31640 0 0 {name=l25406 lab=BL25}
N 4960 31600 4940 31600 {}
C {lab_pin.sym} 4940 31600 0 0 {name=l25407 lab=BLB25}
N 4960 31560 4940 31560 {}
C {lab_pin.sym} 4940 31560 0 0 {name=l25408 lab=WL158}
N 5040 31640 5060 31640 {}
C {lab_pin.sym} 5060 31640 0 0 {name=l25409 lab=VDD}
N 5040 31560 5060 31560 {}
C {lab_pin.sym} 5060 31560 0 0 {name=l25410 lab=VSS}
C {bitcell_6t.sym} 5200 31600 0 0 {name=Xr158c26}
N 5160 31640 5140 31640 {}
C {lab_pin.sym} 5140 31640 0 0 {name=l25411 lab=BL26}
N 5160 31600 5140 31600 {}
C {lab_pin.sym} 5140 31600 0 0 {name=l25412 lab=BLB26}
N 5160 31560 5140 31560 {}
C {lab_pin.sym} 5140 31560 0 0 {name=l25413 lab=WL158}
N 5240 31640 5260 31640 {}
C {lab_pin.sym} 5260 31640 0 0 {name=l25414 lab=VDD}
N 5240 31560 5260 31560 {}
C {lab_pin.sym} 5260 31560 0 0 {name=l25415 lab=VSS}
C {bitcell_6t.sym} 5400 31600 0 0 {name=Xr158c27}
N 5360 31640 5340 31640 {}
C {lab_pin.sym} 5340 31640 0 0 {name=l25416 lab=BL27}
N 5360 31600 5340 31600 {}
C {lab_pin.sym} 5340 31600 0 0 {name=l25417 lab=BLB27}
N 5360 31560 5340 31560 {}
C {lab_pin.sym} 5340 31560 0 0 {name=l25418 lab=WL158}
N 5440 31640 5460 31640 {}
C {lab_pin.sym} 5460 31640 0 0 {name=l25419 lab=VDD}
N 5440 31560 5460 31560 {}
C {lab_pin.sym} 5460 31560 0 0 {name=l25420 lab=VSS}
C {bitcell_6t.sym} 5600 31600 0 0 {name=Xr158c28}
N 5560 31640 5540 31640 {}
C {lab_pin.sym} 5540 31640 0 0 {name=l25421 lab=BL28}
N 5560 31600 5540 31600 {}
C {lab_pin.sym} 5540 31600 0 0 {name=l25422 lab=BLB28}
N 5560 31560 5540 31560 {}
C {lab_pin.sym} 5540 31560 0 0 {name=l25423 lab=WL158}
N 5640 31640 5660 31640 {}
C {lab_pin.sym} 5660 31640 0 0 {name=l25424 lab=VDD}
N 5640 31560 5660 31560 {}
C {lab_pin.sym} 5660 31560 0 0 {name=l25425 lab=VSS}
C {bitcell_6t.sym} 5800 31600 0 0 {name=Xr158c29}
N 5760 31640 5740 31640 {}
C {lab_pin.sym} 5740 31640 0 0 {name=l25426 lab=BL29}
N 5760 31600 5740 31600 {}
C {lab_pin.sym} 5740 31600 0 0 {name=l25427 lab=BLB29}
N 5760 31560 5740 31560 {}
C {lab_pin.sym} 5740 31560 0 0 {name=l25428 lab=WL158}
N 5840 31640 5860 31640 {}
C {lab_pin.sym} 5860 31640 0 0 {name=l25429 lab=VDD}
N 5840 31560 5860 31560 {}
C {lab_pin.sym} 5860 31560 0 0 {name=l25430 lab=VSS}
C {bitcell_6t.sym} 6000 31600 0 0 {name=Xr158c30}
N 5960 31640 5940 31640 {}
C {lab_pin.sym} 5940 31640 0 0 {name=l25431 lab=BL30}
N 5960 31600 5940 31600 {}
C {lab_pin.sym} 5940 31600 0 0 {name=l25432 lab=BLB30}
N 5960 31560 5940 31560 {}
C {lab_pin.sym} 5940 31560 0 0 {name=l25433 lab=WL158}
N 6040 31640 6060 31640 {}
C {lab_pin.sym} 6060 31640 0 0 {name=l25434 lab=VDD}
N 6040 31560 6060 31560 {}
C {lab_pin.sym} 6060 31560 0 0 {name=l25435 lab=VSS}
C {bitcell_6t.sym} 6200 31600 0 0 {name=Xr158c31}
N 6160 31640 6140 31640 {}
C {lab_pin.sym} 6140 31640 0 0 {name=l25436 lab=BL31}
N 6160 31600 6140 31600 {}
C {lab_pin.sym} 6140 31600 0 0 {name=l25437 lab=BLB31}
N 6160 31560 6140 31560 {}
C {lab_pin.sym} 6140 31560 0 0 {name=l25438 lab=WL158}
N 6240 31640 6260 31640 {}
C {lab_pin.sym} 6260 31640 0 0 {name=l25439 lab=VDD}
N 6240 31560 6260 31560 {}
C {lab_pin.sym} 6260 31560 0 0 {name=l25440 lab=VSS}
C {bitcell_6t.sym} 0 31800 0 0 {name=Xr159c0}
N -40 31840 -60 31840 {}
C {lab_pin.sym} -60 31840 0 0 {name=l25441 lab=BL0}
N -40 31800 -60 31800 {}
C {lab_pin.sym} -60 31800 0 0 {name=l25442 lab=BLB0}
N -40 31760 -60 31760 {}
C {lab_pin.sym} -60 31760 0 0 {name=l25443 lab=WL159}
N 40 31840 60 31840 {}
C {lab_pin.sym} 60 31840 0 0 {name=l25444 lab=VDD}
N 40 31760 60 31760 {}
C {lab_pin.sym} 60 31760 0 0 {name=l25445 lab=VSS}
C {bitcell_6t.sym} 200 31800 0 0 {name=Xr159c1}
N 160 31840 140 31840 {}
C {lab_pin.sym} 140 31840 0 0 {name=l25446 lab=BL1}
N 160 31800 140 31800 {}
C {lab_pin.sym} 140 31800 0 0 {name=l25447 lab=BLB1}
N 160 31760 140 31760 {}
C {lab_pin.sym} 140 31760 0 0 {name=l25448 lab=WL159}
N 240 31840 260 31840 {}
C {lab_pin.sym} 260 31840 0 0 {name=l25449 lab=VDD}
N 240 31760 260 31760 {}
C {lab_pin.sym} 260 31760 0 0 {name=l25450 lab=VSS}
C {bitcell_6t.sym} 400 31800 0 0 {name=Xr159c2}
N 360 31840 340 31840 {}
C {lab_pin.sym} 340 31840 0 0 {name=l25451 lab=BL2}
N 360 31800 340 31800 {}
C {lab_pin.sym} 340 31800 0 0 {name=l25452 lab=BLB2}
N 360 31760 340 31760 {}
C {lab_pin.sym} 340 31760 0 0 {name=l25453 lab=WL159}
N 440 31840 460 31840 {}
C {lab_pin.sym} 460 31840 0 0 {name=l25454 lab=VDD}
N 440 31760 460 31760 {}
C {lab_pin.sym} 460 31760 0 0 {name=l25455 lab=VSS}
C {bitcell_6t.sym} 600 31800 0 0 {name=Xr159c3}
N 560 31840 540 31840 {}
C {lab_pin.sym} 540 31840 0 0 {name=l25456 lab=BL3}
N 560 31800 540 31800 {}
C {lab_pin.sym} 540 31800 0 0 {name=l25457 lab=BLB3}
N 560 31760 540 31760 {}
C {lab_pin.sym} 540 31760 0 0 {name=l25458 lab=WL159}
N 640 31840 660 31840 {}
C {lab_pin.sym} 660 31840 0 0 {name=l25459 lab=VDD}
N 640 31760 660 31760 {}
C {lab_pin.sym} 660 31760 0 0 {name=l25460 lab=VSS}
C {bitcell_6t.sym} 800 31800 0 0 {name=Xr159c4}
N 760 31840 740 31840 {}
C {lab_pin.sym} 740 31840 0 0 {name=l25461 lab=BL4}
N 760 31800 740 31800 {}
C {lab_pin.sym} 740 31800 0 0 {name=l25462 lab=BLB4}
N 760 31760 740 31760 {}
C {lab_pin.sym} 740 31760 0 0 {name=l25463 lab=WL159}
N 840 31840 860 31840 {}
C {lab_pin.sym} 860 31840 0 0 {name=l25464 lab=VDD}
N 840 31760 860 31760 {}
C {lab_pin.sym} 860 31760 0 0 {name=l25465 lab=VSS}
C {bitcell_6t.sym} 1000 31800 0 0 {name=Xr159c5}
N 960 31840 940 31840 {}
C {lab_pin.sym} 940 31840 0 0 {name=l25466 lab=BL5}
N 960 31800 940 31800 {}
C {lab_pin.sym} 940 31800 0 0 {name=l25467 lab=BLB5}
N 960 31760 940 31760 {}
C {lab_pin.sym} 940 31760 0 0 {name=l25468 lab=WL159}
N 1040 31840 1060 31840 {}
C {lab_pin.sym} 1060 31840 0 0 {name=l25469 lab=VDD}
N 1040 31760 1060 31760 {}
C {lab_pin.sym} 1060 31760 0 0 {name=l25470 lab=VSS}
C {bitcell_6t.sym} 1200 31800 0 0 {name=Xr159c6}
N 1160 31840 1140 31840 {}
C {lab_pin.sym} 1140 31840 0 0 {name=l25471 lab=BL6}
N 1160 31800 1140 31800 {}
C {lab_pin.sym} 1140 31800 0 0 {name=l25472 lab=BLB6}
N 1160 31760 1140 31760 {}
C {lab_pin.sym} 1140 31760 0 0 {name=l25473 lab=WL159}
N 1240 31840 1260 31840 {}
C {lab_pin.sym} 1260 31840 0 0 {name=l25474 lab=VDD}
N 1240 31760 1260 31760 {}
C {lab_pin.sym} 1260 31760 0 0 {name=l25475 lab=VSS}
C {bitcell_6t.sym} 1400 31800 0 0 {name=Xr159c7}
N 1360 31840 1340 31840 {}
C {lab_pin.sym} 1340 31840 0 0 {name=l25476 lab=BL7}
N 1360 31800 1340 31800 {}
C {lab_pin.sym} 1340 31800 0 0 {name=l25477 lab=BLB7}
N 1360 31760 1340 31760 {}
C {lab_pin.sym} 1340 31760 0 0 {name=l25478 lab=WL159}
N 1440 31840 1460 31840 {}
C {lab_pin.sym} 1460 31840 0 0 {name=l25479 lab=VDD}
N 1440 31760 1460 31760 {}
C {lab_pin.sym} 1460 31760 0 0 {name=l25480 lab=VSS}
C {bitcell_6t.sym} 1600 31800 0 0 {name=Xr159c8}
N 1560 31840 1540 31840 {}
C {lab_pin.sym} 1540 31840 0 0 {name=l25481 lab=BL8}
N 1560 31800 1540 31800 {}
C {lab_pin.sym} 1540 31800 0 0 {name=l25482 lab=BLB8}
N 1560 31760 1540 31760 {}
C {lab_pin.sym} 1540 31760 0 0 {name=l25483 lab=WL159}
N 1640 31840 1660 31840 {}
C {lab_pin.sym} 1660 31840 0 0 {name=l25484 lab=VDD}
N 1640 31760 1660 31760 {}
C {lab_pin.sym} 1660 31760 0 0 {name=l25485 lab=VSS}
C {bitcell_6t.sym} 1800 31800 0 0 {name=Xr159c9}
N 1760 31840 1740 31840 {}
C {lab_pin.sym} 1740 31840 0 0 {name=l25486 lab=BL9}
N 1760 31800 1740 31800 {}
C {lab_pin.sym} 1740 31800 0 0 {name=l25487 lab=BLB9}
N 1760 31760 1740 31760 {}
C {lab_pin.sym} 1740 31760 0 0 {name=l25488 lab=WL159}
N 1840 31840 1860 31840 {}
C {lab_pin.sym} 1860 31840 0 0 {name=l25489 lab=VDD}
N 1840 31760 1860 31760 {}
C {lab_pin.sym} 1860 31760 0 0 {name=l25490 lab=VSS}
C {bitcell_6t.sym} 2000 31800 0 0 {name=Xr159c10}
N 1960 31840 1940 31840 {}
C {lab_pin.sym} 1940 31840 0 0 {name=l25491 lab=BL10}
N 1960 31800 1940 31800 {}
C {lab_pin.sym} 1940 31800 0 0 {name=l25492 lab=BLB10}
N 1960 31760 1940 31760 {}
C {lab_pin.sym} 1940 31760 0 0 {name=l25493 lab=WL159}
N 2040 31840 2060 31840 {}
C {lab_pin.sym} 2060 31840 0 0 {name=l25494 lab=VDD}
N 2040 31760 2060 31760 {}
C {lab_pin.sym} 2060 31760 0 0 {name=l25495 lab=VSS}
C {bitcell_6t.sym} 2200 31800 0 0 {name=Xr159c11}
N 2160 31840 2140 31840 {}
C {lab_pin.sym} 2140 31840 0 0 {name=l25496 lab=BL11}
N 2160 31800 2140 31800 {}
C {lab_pin.sym} 2140 31800 0 0 {name=l25497 lab=BLB11}
N 2160 31760 2140 31760 {}
C {lab_pin.sym} 2140 31760 0 0 {name=l25498 lab=WL159}
N 2240 31840 2260 31840 {}
C {lab_pin.sym} 2260 31840 0 0 {name=l25499 lab=VDD}
N 2240 31760 2260 31760 {}
C {lab_pin.sym} 2260 31760 0 0 {name=l25500 lab=VSS}
C {bitcell_6t.sym} 2400 31800 0 0 {name=Xr159c12}
N 2360 31840 2340 31840 {}
C {lab_pin.sym} 2340 31840 0 0 {name=l25501 lab=BL12}
N 2360 31800 2340 31800 {}
C {lab_pin.sym} 2340 31800 0 0 {name=l25502 lab=BLB12}
N 2360 31760 2340 31760 {}
C {lab_pin.sym} 2340 31760 0 0 {name=l25503 lab=WL159}
N 2440 31840 2460 31840 {}
C {lab_pin.sym} 2460 31840 0 0 {name=l25504 lab=VDD}
N 2440 31760 2460 31760 {}
C {lab_pin.sym} 2460 31760 0 0 {name=l25505 lab=VSS}
C {bitcell_6t.sym} 2600 31800 0 0 {name=Xr159c13}
N 2560 31840 2540 31840 {}
C {lab_pin.sym} 2540 31840 0 0 {name=l25506 lab=BL13}
N 2560 31800 2540 31800 {}
C {lab_pin.sym} 2540 31800 0 0 {name=l25507 lab=BLB13}
N 2560 31760 2540 31760 {}
C {lab_pin.sym} 2540 31760 0 0 {name=l25508 lab=WL159}
N 2640 31840 2660 31840 {}
C {lab_pin.sym} 2660 31840 0 0 {name=l25509 lab=VDD}
N 2640 31760 2660 31760 {}
C {lab_pin.sym} 2660 31760 0 0 {name=l25510 lab=VSS}
C {bitcell_6t.sym} 2800 31800 0 0 {name=Xr159c14}
N 2760 31840 2740 31840 {}
C {lab_pin.sym} 2740 31840 0 0 {name=l25511 lab=BL14}
N 2760 31800 2740 31800 {}
C {lab_pin.sym} 2740 31800 0 0 {name=l25512 lab=BLB14}
N 2760 31760 2740 31760 {}
C {lab_pin.sym} 2740 31760 0 0 {name=l25513 lab=WL159}
N 2840 31840 2860 31840 {}
C {lab_pin.sym} 2860 31840 0 0 {name=l25514 lab=VDD}
N 2840 31760 2860 31760 {}
C {lab_pin.sym} 2860 31760 0 0 {name=l25515 lab=VSS}
C {bitcell_6t.sym} 3000 31800 0 0 {name=Xr159c15}
N 2960 31840 2940 31840 {}
C {lab_pin.sym} 2940 31840 0 0 {name=l25516 lab=BL15}
N 2960 31800 2940 31800 {}
C {lab_pin.sym} 2940 31800 0 0 {name=l25517 lab=BLB15}
N 2960 31760 2940 31760 {}
C {lab_pin.sym} 2940 31760 0 0 {name=l25518 lab=WL159}
N 3040 31840 3060 31840 {}
C {lab_pin.sym} 3060 31840 0 0 {name=l25519 lab=VDD}
N 3040 31760 3060 31760 {}
C {lab_pin.sym} 3060 31760 0 0 {name=l25520 lab=VSS}
C {bitcell_6t.sym} 3200 31800 0 0 {name=Xr159c16}
N 3160 31840 3140 31840 {}
C {lab_pin.sym} 3140 31840 0 0 {name=l25521 lab=BL16}
N 3160 31800 3140 31800 {}
C {lab_pin.sym} 3140 31800 0 0 {name=l25522 lab=BLB16}
N 3160 31760 3140 31760 {}
C {lab_pin.sym} 3140 31760 0 0 {name=l25523 lab=WL159}
N 3240 31840 3260 31840 {}
C {lab_pin.sym} 3260 31840 0 0 {name=l25524 lab=VDD}
N 3240 31760 3260 31760 {}
C {lab_pin.sym} 3260 31760 0 0 {name=l25525 lab=VSS}
C {bitcell_6t.sym} 3400 31800 0 0 {name=Xr159c17}
N 3360 31840 3340 31840 {}
C {lab_pin.sym} 3340 31840 0 0 {name=l25526 lab=BL17}
N 3360 31800 3340 31800 {}
C {lab_pin.sym} 3340 31800 0 0 {name=l25527 lab=BLB17}
N 3360 31760 3340 31760 {}
C {lab_pin.sym} 3340 31760 0 0 {name=l25528 lab=WL159}
N 3440 31840 3460 31840 {}
C {lab_pin.sym} 3460 31840 0 0 {name=l25529 lab=VDD}
N 3440 31760 3460 31760 {}
C {lab_pin.sym} 3460 31760 0 0 {name=l25530 lab=VSS}
C {bitcell_6t.sym} 3600 31800 0 0 {name=Xr159c18}
N 3560 31840 3540 31840 {}
C {lab_pin.sym} 3540 31840 0 0 {name=l25531 lab=BL18}
N 3560 31800 3540 31800 {}
C {lab_pin.sym} 3540 31800 0 0 {name=l25532 lab=BLB18}
N 3560 31760 3540 31760 {}
C {lab_pin.sym} 3540 31760 0 0 {name=l25533 lab=WL159}
N 3640 31840 3660 31840 {}
C {lab_pin.sym} 3660 31840 0 0 {name=l25534 lab=VDD}
N 3640 31760 3660 31760 {}
C {lab_pin.sym} 3660 31760 0 0 {name=l25535 lab=VSS}
C {bitcell_6t.sym} 3800 31800 0 0 {name=Xr159c19}
N 3760 31840 3740 31840 {}
C {lab_pin.sym} 3740 31840 0 0 {name=l25536 lab=BL19}
N 3760 31800 3740 31800 {}
C {lab_pin.sym} 3740 31800 0 0 {name=l25537 lab=BLB19}
N 3760 31760 3740 31760 {}
C {lab_pin.sym} 3740 31760 0 0 {name=l25538 lab=WL159}
N 3840 31840 3860 31840 {}
C {lab_pin.sym} 3860 31840 0 0 {name=l25539 lab=VDD}
N 3840 31760 3860 31760 {}
C {lab_pin.sym} 3860 31760 0 0 {name=l25540 lab=VSS}
C {bitcell_6t.sym} 4000 31800 0 0 {name=Xr159c20}
N 3960 31840 3940 31840 {}
C {lab_pin.sym} 3940 31840 0 0 {name=l25541 lab=BL20}
N 3960 31800 3940 31800 {}
C {lab_pin.sym} 3940 31800 0 0 {name=l25542 lab=BLB20}
N 3960 31760 3940 31760 {}
C {lab_pin.sym} 3940 31760 0 0 {name=l25543 lab=WL159}
N 4040 31840 4060 31840 {}
C {lab_pin.sym} 4060 31840 0 0 {name=l25544 lab=VDD}
N 4040 31760 4060 31760 {}
C {lab_pin.sym} 4060 31760 0 0 {name=l25545 lab=VSS}
C {bitcell_6t.sym} 4200 31800 0 0 {name=Xr159c21}
N 4160 31840 4140 31840 {}
C {lab_pin.sym} 4140 31840 0 0 {name=l25546 lab=BL21}
N 4160 31800 4140 31800 {}
C {lab_pin.sym} 4140 31800 0 0 {name=l25547 lab=BLB21}
N 4160 31760 4140 31760 {}
C {lab_pin.sym} 4140 31760 0 0 {name=l25548 lab=WL159}
N 4240 31840 4260 31840 {}
C {lab_pin.sym} 4260 31840 0 0 {name=l25549 lab=VDD}
N 4240 31760 4260 31760 {}
C {lab_pin.sym} 4260 31760 0 0 {name=l25550 lab=VSS}
C {bitcell_6t.sym} 4400 31800 0 0 {name=Xr159c22}
N 4360 31840 4340 31840 {}
C {lab_pin.sym} 4340 31840 0 0 {name=l25551 lab=BL22}
N 4360 31800 4340 31800 {}
C {lab_pin.sym} 4340 31800 0 0 {name=l25552 lab=BLB22}
N 4360 31760 4340 31760 {}
C {lab_pin.sym} 4340 31760 0 0 {name=l25553 lab=WL159}
N 4440 31840 4460 31840 {}
C {lab_pin.sym} 4460 31840 0 0 {name=l25554 lab=VDD}
N 4440 31760 4460 31760 {}
C {lab_pin.sym} 4460 31760 0 0 {name=l25555 lab=VSS}
C {bitcell_6t.sym} 4600 31800 0 0 {name=Xr159c23}
N 4560 31840 4540 31840 {}
C {lab_pin.sym} 4540 31840 0 0 {name=l25556 lab=BL23}
N 4560 31800 4540 31800 {}
C {lab_pin.sym} 4540 31800 0 0 {name=l25557 lab=BLB23}
N 4560 31760 4540 31760 {}
C {lab_pin.sym} 4540 31760 0 0 {name=l25558 lab=WL159}
N 4640 31840 4660 31840 {}
C {lab_pin.sym} 4660 31840 0 0 {name=l25559 lab=VDD}
N 4640 31760 4660 31760 {}
C {lab_pin.sym} 4660 31760 0 0 {name=l25560 lab=VSS}
C {bitcell_6t.sym} 4800 31800 0 0 {name=Xr159c24}
N 4760 31840 4740 31840 {}
C {lab_pin.sym} 4740 31840 0 0 {name=l25561 lab=BL24}
N 4760 31800 4740 31800 {}
C {lab_pin.sym} 4740 31800 0 0 {name=l25562 lab=BLB24}
N 4760 31760 4740 31760 {}
C {lab_pin.sym} 4740 31760 0 0 {name=l25563 lab=WL159}
N 4840 31840 4860 31840 {}
C {lab_pin.sym} 4860 31840 0 0 {name=l25564 lab=VDD}
N 4840 31760 4860 31760 {}
C {lab_pin.sym} 4860 31760 0 0 {name=l25565 lab=VSS}
C {bitcell_6t.sym} 5000 31800 0 0 {name=Xr159c25}
N 4960 31840 4940 31840 {}
C {lab_pin.sym} 4940 31840 0 0 {name=l25566 lab=BL25}
N 4960 31800 4940 31800 {}
C {lab_pin.sym} 4940 31800 0 0 {name=l25567 lab=BLB25}
N 4960 31760 4940 31760 {}
C {lab_pin.sym} 4940 31760 0 0 {name=l25568 lab=WL159}
N 5040 31840 5060 31840 {}
C {lab_pin.sym} 5060 31840 0 0 {name=l25569 lab=VDD}
N 5040 31760 5060 31760 {}
C {lab_pin.sym} 5060 31760 0 0 {name=l25570 lab=VSS}
C {bitcell_6t.sym} 5200 31800 0 0 {name=Xr159c26}
N 5160 31840 5140 31840 {}
C {lab_pin.sym} 5140 31840 0 0 {name=l25571 lab=BL26}
N 5160 31800 5140 31800 {}
C {lab_pin.sym} 5140 31800 0 0 {name=l25572 lab=BLB26}
N 5160 31760 5140 31760 {}
C {lab_pin.sym} 5140 31760 0 0 {name=l25573 lab=WL159}
N 5240 31840 5260 31840 {}
C {lab_pin.sym} 5260 31840 0 0 {name=l25574 lab=VDD}
N 5240 31760 5260 31760 {}
C {lab_pin.sym} 5260 31760 0 0 {name=l25575 lab=VSS}
C {bitcell_6t.sym} 5400 31800 0 0 {name=Xr159c27}
N 5360 31840 5340 31840 {}
C {lab_pin.sym} 5340 31840 0 0 {name=l25576 lab=BL27}
N 5360 31800 5340 31800 {}
C {lab_pin.sym} 5340 31800 0 0 {name=l25577 lab=BLB27}
N 5360 31760 5340 31760 {}
C {lab_pin.sym} 5340 31760 0 0 {name=l25578 lab=WL159}
N 5440 31840 5460 31840 {}
C {lab_pin.sym} 5460 31840 0 0 {name=l25579 lab=VDD}
N 5440 31760 5460 31760 {}
C {lab_pin.sym} 5460 31760 0 0 {name=l25580 lab=VSS}
C {bitcell_6t.sym} 5600 31800 0 0 {name=Xr159c28}
N 5560 31840 5540 31840 {}
C {lab_pin.sym} 5540 31840 0 0 {name=l25581 lab=BL28}
N 5560 31800 5540 31800 {}
C {lab_pin.sym} 5540 31800 0 0 {name=l25582 lab=BLB28}
N 5560 31760 5540 31760 {}
C {lab_pin.sym} 5540 31760 0 0 {name=l25583 lab=WL159}
N 5640 31840 5660 31840 {}
C {lab_pin.sym} 5660 31840 0 0 {name=l25584 lab=VDD}
N 5640 31760 5660 31760 {}
C {lab_pin.sym} 5660 31760 0 0 {name=l25585 lab=VSS}
C {bitcell_6t.sym} 5800 31800 0 0 {name=Xr159c29}
N 5760 31840 5740 31840 {}
C {lab_pin.sym} 5740 31840 0 0 {name=l25586 lab=BL29}
N 5760 31800 5740 31800 {}
C {lab_pin.sym} 5740 31800 0 0 {name=l25587 lab=BLB29}
N 5760 31760 5740 31760 {}
C {lab_pin.sym} 5740 31760 0 0 {name=l25588 lab=WL159}
N 5840 31840 5860 31840 {}
C {lab_pin.sym} 5860 31840 0 0 {name=l25589 lab=VDD}
N 5840 31760 5860 31760 {}
C {lab_pin.sym} 5860 31760 0 0 {name=l25590 lab=VSS}
C {bitcell_6t.sym} 6000 31800 0 0 {name=Xr159c30}
N 5960 31840 5940 31840 {}
C {lab_pin.sym} 5940 31840 0 0 {name=l25591 lab=BL30}
N 5960 31800 5940 31800 {}
C {lab_pin.sym} 5940 31800 0 0 {name=l25592 lab=BLB30}
N 5960 31760 5940 31760 {}
C {lab_pin.sym} 5940 31760 0 0 {name=l25593 lab=WL159}
N 6040 31840 6060 31840 {}
C {lab_pin.sym} 6060 31840 0 0 {name=l25594 lab=VDD}
N 6040 31760 6060 31760 {}
C {lab_pin.sym} 6060 31760 0 0 {name=l25595 lab=VSS}
C {bitcell_6t.sym} 6200 31800 0 0 {name=Xr159c31}
N 6160 31840 6140 31840 {}
C {lab_pin.sym} 6140 31840 0 0 {name=l25596 lab=BL31}
N 6160 31800 6140 31800 {}
C {lab_pin.sym} 6140 31800 0 0 {name=l25597 lab=BLB31}
N 6160 31760 6140 31760 {}
C {lab_pin.sym} 6140 31760 0 0 {name=l25598 lab=WL159}
N 6240 31840 6260 31840 {}
C {lab_pin.sym} 6260 31840 0 0 {name=l25599 lab=VDD}
N 6240 31760 6260 31760 {}
C {lab_pin.sym} 6260 31760 0 0 {name=l25600 lab=VSS}
C {bitcell_6t.sym} 0 32000 0 0 {name=Xr160c0}
N -40 32040 -60 32040 {}
C {lab_pin.sym} -60 32040 0 0 {name=l25601 lab=BL0}
N -40 32000 -60 32000 {}
C {lab_pin.sym} -60 32000 0 0 {name=l25602 lab=BLB0}
N -40 31960 -60 31960 {}
C {lab_pin.sym} -60 31960 0 0 {name=l25603 lab=WL160}
N 40 32040 60 32040 {}
C {lab_pin.sym} 60 32040 0 0 {name=l25604 lab=VDD}
N 40 31960 60 31960 {}
C {lab_pin.sym} 60 31960 0 0 {name=l25605 lab=VSS}
C {bitcell_6t.sym} 200 32000 0 0 {name=Xr160c1}
N 160 32040 140 32040 {}
C {lab_pin.sym} 140 32040 0 0 {name=l25606 lab=BL1}
N 160 32000 140 32000 {}
C {lab_pin.sym} 140 32000 0 0 {name=l25607 lab=BLB1}
N 160 31960 140 31960 {}
C {lab_pin.sym} 140 31960 0 0 {name=l25608 lab=WL160}
N 240 32040 260 32040 {}
C {lab_pin.sym} 260 32040 0 0 {name=l25609 lab=VDD}
N 240 31960 260 31960 {}
C {lab_pin.sym} 260 31960 0 0 {name=l25610 lab=VSS}
C {bitcell_6t.sym} 400 32000 0 0 {name=Xr160c2}
N 360 32040 340 32040 {}
C {lab_pin.sym} 340 32040 0 0 {name=l25611 lab=BL2}
N 360 32000 340 32000 {}
C {lab_pin.sym} 340 32000 0 0 {name=l25612 lab=BLB2}
N 360 31960 340 31960 {}
C {lab_pin.sym} 340 31960 0 0 {name=l25613 lab=WL160}
N 440 32040 460 32040 {}
C {lab_pin.sym} 460 32040 0 0 {name=l25614 lab=VDD}
N 440 31960 460 31960 {}
C {lab_pin.sym} 460 31960 0 0 {name=l25615 lab=VSS}
C {bitcell_6t.sym} 600 32000 0 0 {name=Xr160c3}
N 560 32040 540 32040 {}
C {lab_pin.sym} 540 32040 0 0 {name=l25616 lab=BL3}
N 560 32000 540 32000 {}
C {lab_pin.sym} 540 32000 0 0 {name=l25617 lab=BLB3}
N 560 31960 540 31960 {}
C {lab_pin.sym} 540 31960 0 0 {name=l25618 lab=WL160}
N 640 32040 660 32040 {}
C {lab_pin.sym} 660 32040 0 0 {name=l25619 lab=VDD}
N 640 31960 660 31960 {}
C {lab_pin.sym} 660 31960 0 0 {name=l25620 lab=VSS}
C {bitcell_6t.sym} 800 32000 0 0 {name=Xr160c4}
N 760 32040 740 32040 {}
C {lab_pin.sym} 740 32040 0 0 {name=l25621 lab=BL4}
N 760 32000 740 32000 {}
C {lab_pin.sym} 740 32000 0 0 {name=l25622 lab=BLB4}
N 760 31960 740 31960 {}
C {lab_pin.sym} 740 31960 0 0 {name=l25623 lab=WL160}
N 840 32040 860 32040 {}
C {lab_pin.sym} 860 32040 0 0 {name=l25624 lab=VDD}
N 840 31960 860 31960 {}
C {lab_pin.sym} 860 31960 0 0 {name=l25625 lab=VSS}
C {bitcell_6t.sym} 1000 32000 0 0 {name=Xr160c5}
N 960 32040 940 32040 {}
C {lab_pin.sym} 940 32040 0 0 {name=l25626 lab=BL5}
N 960 32000 940 32000 {}
C {lab_pin.sym} 940 32000 0 0 {name=l25627 lab=BLB5}
N 960 31960 940 31960 {}
C {lab_pin.sym} 940 31960 0 0 {name=l25628 lab=WL160}
N 1040 32040 1060 32040 {}
C {lab_pin.sym} 1060 32040 0 0 {name=l25629 lab=VDD}
N 1040 31960 1060 31960 {}
C {lab_pin.sym} 1060 31960 0 0 {name=l25630 lab=VSS}
C {bitcell_6t.sym} 1200 32000 0 0 {name=Xr160c6}
N 1160 32040 1140 32040 {}
C {lab_pin.sym} 1140 32040 0 0 {name=l25631 lab=BL6}
N 1160 32000 1140 32000 {}
C {lab_pin.sym} 1140 32000 0 0 {name=l25632 lab=BLB6}
N 1160 31960 1140 31960 {}
C {lab_pin.sym} 1140 31960 0 0 {name=l25633 lab=WL160}
N 1240 32040 1260 32040 {}
C {lab_pin.sym} 1260 32040 0 0 {name=l25634 lab=VDD}
N 1240 31960 1260 31960 {}
C {lab_pin.sym} 1260 31960 0 0 {name=l25635 lab=VSS}
C {bitcell_6t.sym} 1400 32000 0 0 {name=Xr160c7}
N 1360 32040 1340 32040 {}
C {lab_pin.sym} 1340 32040 0 0 {name=l25636 lab=BL7}
N 1360 32000 1340 32000 {}
C {lab_pin.sym} 1340 32000 0 0 {name=l25637 lab=BLB7}
N 1360 31960 1340 31960 {}
C {lab_pin.sym} 1340 31960 0 0 {name=l25638 lab=WL160}
N 1440 32040 1460 32040 {}
C {lab_pin.sym} 1460 32040 0 0 {name=l25639 lab=VDD}
N 1440 31960 1460 31960 {}
C {lab_pin.sym} 1460 31960 0 0 {name=l25640 lab=VSS}
C {bitcell_6t.sym} 1600 32000 0 0 {name=Xr160c8}
N 1560 32040 1540 32040 {}
C {lab_pin.sym} 1540 32040 0 0 {name=l25641 lab=BL8}
N 1560 32000 1540 32000 {}
C {lab_pin.sym} 1540 32000 0 0 {name=l25642 lab=BLB8}
N 1560 31960 1540 31960 {}
C {lab_pin.sym} 1540 31960 0 0 {name=l25643 lab=WL160}
N 1640 32040 1660 32040 {}
C {lab_pin.sym} 1660 32040 0 0 {name=l25644 lab=VDD}
N 1640 31960 1660 31960 {}
C {lab_pin.sym} 1660 31960 0 0 {name=l25645 lab=VSS}
C {bitcell_6t.sym} 1800 32000 0 0 {name=Xr160c9}
N 1760 32040 1740 32040 {}
C {lab_pin.sym} 1740 32040 0 0 {name=l25646 lab=BL9}
N 1760 32000 1740 32000 {}
C {lab_pin.sym} 1740 32000 0 0 {name=l25647 lab=BLB9}
N 1760 31960 1740 31960 {}
C {lab_pin.sym} 1740 31960 0 0 {name=l25648 lab=WL160}
N 1840 32040 1860 32040 {}
C {lab_pin.sym} 1860 32040 0 0 {name=l25649 lab=VDD}
N 1840 31960 1860 31960 {}
C {lab_pin.sym} 1860 31960 0 0 {name=l25650 lab=VSS}
C {bitcell_6t.sym} 2000 32000 0 0 {name=Xr160c10}
N 1960 32040 1940 32040 {}
C {lab_pin.sym} 1940 32040 0 0 {name=l25651 lab=BL10}
N 1960 32000 1940 32000 {}
C {lab_pin.sym} 1940 32000 0 0 {name=l25652 lab=BLB10}
N 1960 31960 1940 31960 {}
C {lab_pin.sym} 1940 31960 0 0 {name=l25653 lab=WL160}
N 2040 32040 2060 32040 {}
C {lab_pin.sym} 2060 32040 0 0 {name=l25654 lab=VDD}
N 2040 31960 2060 31960 {}
C {lab_pin.sym} 2060 31960 0 0 {name=l25655 lab=VSS}
C {bitcell_6t.sym} 2200 32000 0 0 {name=Xr160c11}
N 2160 32040 2140 32040 {}
C {lab_pin.sym} 2140 32040 0 0 {name=l25656 lab=BL11}
N 2160 32000 2140 32000 {}
C {lab_pin.sym} 2140 32000 0 0 {name=l25657 lab=BLB11}
N 2160 31960 2140 31960 {}
C {lab_pin.sym} 2140 31960 0 0 {name=l25658 lab=WL160}
N 2240 32040 2260 32040 {}
C {lab_pin.sym} 2260 32040 0 0 {name=l25659 lab=VDD}
N 2240 31960 2260 31960 {}
C {lab_pin.sym} 2260 31960 0 0 {name=l25660 lab=VSS}
C {bitcell_6t.sym} 2400 32000 0 0 {name=Xr160c12}
N 2360 32040 2340 32040 {}
C {lab_pin.sym} 2340 32040 0 0 {name=l25661 lab=BL12}
N 2360 32000 2340 32000 {}
C {lab_pin.sym} 2340 32000 0 0 {name=l25662 lab=BLB12}
N 2360 31960 2340 31960 {}
C {lab_pin.sym} 2340 31960 0 0 {name=l25663 lab=WL160}
N 2440 32040 2460 32040 {}
C {lab_pin.sym} 2460 32040 0 0 {name=l25664 lab=VDD}
N 2440 31960 2460 31960 {}
C {lab_pin.sym} 2460 31960 0 0 {name=l25665 lab=VSS}
C {bitcell_6t.sym} 2600 32000 0 0 {name=Xr160c13}
N 2560 32040 2540 32040 {}
C {lab_pin.sym} 2540 32040 0 0 {name=l25666 lab=BL13}
N 2560 32000 2540 32000 {}
C {lab_pin.sym} 2540 32000 0 0 {name=l25667 lab=BLB13}
N 2560 31960 2540 31960 {}
C {lab_pin.sym} 2540 31960 0 0 {name=l25668 lab=WL160}
N 2640 32040 2660 32040 {}
C {lab_pin.sym} 2660 32040 0 0 {name=l25669 lab=VDD}
N 2640 31960 2660 31960 {}
C {lab_pin.sym} 2660 31960 0 0 {name=l25670 lab=VSS}
C {bitcell_6t.sym} 2800 32000 0 0 {name=Xr160c14}
N 2760 32040 2740 32040 {}
C {lab_pin.sym} 2740 32040 0 0 {name=l25671 lab=BL14}
N 2760 32000 2740 32000 {}
C {lab_pin.sym} 2740 32000 0 0 {name=l25672 lab=BLB14}
N 2760 31960 2740 31960 {}
C {lab_pin.sym} 2740 31960 0 0 {name=l25673 lab=WL160}
N 2840 32040 2860 32040 {}
C {lab_pin.sym} 2860 32040 0 0 {name=l25674 lab=VDD}
N 2840 31960 2860 31960 {}
C {lab_pin.sym} 2860 31960 0 0 {name=l25675 lab=VSS}
C {bitcell_6t.sym} 3000 32000 0 0 {name=Xr160c15}
N 2960 32040 2940 32040 {}
C {lab_pin.sym} 2940 32040 0 0 {name=l25676 lab=BL15}
N 2960 32000 2940 32000 {}
C {lab_pin.sym} 2940 32000 0 0 {name=l25677 lab=BLB15}
N 2960 31960 2940 31960 {}
C {lab_pin.sym} 2940 31960 0 0 {name=l25678 lab=WL160}
N 3040 32040 3060 32040 {}
C {lab_pin.sym} 3060 32040 0 0 {name=l25679 lab=VDD}
N 3040 31960 3060 31960 {}
C {lab_pin.sym} 3060 31960 0 0 {name=l25680 lab=VSS}
C {bitcell_6t.sym} 3200 32000 0 0 {name=Xr160c16}
N 3160 32040 3140 32040 {}
C {lab_pin.sym} 3140 32040 0 0 {name=l25681 lab=BL16}
N 3160 32000 3140 32000 {}
C {lab_pin.sym} 3140 32000 0 0 {name=l25682 lab=BLB16}
N 3160 31960 3140 31960 {}
C {lab_pin.sym} 3140 31960 0 0 {name=l25683 lab=WL160}
N 3240 32040 3260 32040 {}
C {lab_pin.sym} 3260 32040 0 0 {name=l25684 lab=VDD}
N 3240 31960 3260 31960 {}
C {lab_pin.sym} 3260 31960 0 0 {name=l25685 lab=VSS}
C {bitcell_6t.sym} 3400 32000 0 0 {name=Xr160c17}
N 3360 32040 3340 32040 {}
C {lab_pin.sym} 3340 32040 0 0 {name=l25686 lab=BL17}
N 3360 32000 3340 32000 {}
C {lab_pin.sym} 3340 32000 0 0 {name=l25687 lab=BLB17}
N 3360 31960 3340 31960 {}
C {lab_pin.sym} 3340 31960 0 0 {name=l25688 lab=WL160}
N 3440 32040 3460 32040 {}
C {lab_pin.sym} 3460 32040 0 0 {name=l25689 lab=VDD}
N 3440 31960 3460 31960 {}
C {lab_pin.sym} 3460 31960 0 0 {name=l25690 lab=VSS}
C {bitcell_6t.sym} 3600 32000 0 0 {name=Xr160c18}
N 3560 32040 3540 32040 {}
C {lab_pin.sym} 3540 32040 0 0 {name=l25691 lab=BL18}
N 3560 32000 3540 32000 {}
C {lab_pin.sym} 3540 32000 0 0 {name=l25692 lab=BLB18}
N 3560 31960 3540 31960 {}
C {lab_pin.sym} 3540 31960 0 0 {name=l25693 lab=WL160}
N 3640 32040 3660 32040 {}
C {lab_pin.sym} 3660 32040 0 0 {name=l25694 lab=VDD}
N 3640 31960 3660 31960 {}
C {lab_pin.sym} 3660 31960 0 0 {name=l25695 lab=VSS}
C {bitcell_6t.sym} 3800 32000 0 0 {name=Xr160c19}
N 3760 32040 3740 32040 {}
C {lab_pin.sym} 3740 32040 0 0 {name=l25696 lab=BL19}
N 3760 32000 3740 32000 {}
C {lab_pin.sym} 3740 32000 0 0 {name=l25697 lab=BLB19}
N 3760 31960 3740 31960 {}
C {lab_pin.sym} 3740 31960 0 0 {name=l25698 lab=WL160}
N 3840 32040 3860 32040 {}
C {lab_pin.sym} 3860 32040 0 0 {name=l25699 lab=VDD}
N 3840 31960 3860 31960 {}
C {lab_pin.sym} 3860 31960 0 0 {name=l25700 lab=VSS}
C {bitcell_6t.sym} 4000 32000 0 0 {name=Xr160c20}
N 3960 32040 3940 32040 {}
C {lab_pin.sym} 3940 32040 0 0 {name=l25701 lab=BL20}
N 3960 32000 3940 32000 {}
C {lab_pin.sym} 3940 32000 0 0 {name=l25702 lab=BLB20}
N 3960 31960 3940 31960 {}
C {lab_pin.sym} 3940 31960 0 0 {name=l25703 lab=WL160}
N 4040 32040 4060 32040 {}
C {lab_pin.sym} 4060 32040 0 0 {name=l25704 lab=VDD}
N 4040 31960 4060 31960 {}
C {lab_pin.sym} 4060 31960 0 0 {name=l25705 lab=VSS}
C {bitcell_6t.sym} 4200 32000 0 0 {name=Xr160c21}
N 4160 32040 4140 32040 {}
C {lab_pin.sym} 4140 32040 0 0 {name=l25706 lab=BL21}
N 4160 32000 4140 32000 {}
C {lab_pin.sym} 4140 32000 0 0 {name=l25707 lab=BLB21}
N 4160 31960 4140 31960 {}
C {lab_pin.sym} 4140 31960 0 0 {name=l25708 lab=WL160}
N 4240 32040 4260 32040 {}
C {lab_pin.sym} 4260 32040 0 0 {name=l25709 lab=VDD}
N 4240 31960 4260 31960 {}
C {lab_pin.sym} 4260 31960 0 0 {name=l25710 lab=VSS}
C {bitcell_6t.sym} 4400 32000 0 0 {name=Xr160c22}
N 4360 32040 4340 32040 {}
C {lab_pin.sym} 4340 32040 0 0 {name=l25711 lab=BL22}
N 4360 32000 4340 32000 {}
C {lab_pin.sym} 4340 32000 0 0 {name=l25712 lab=BLB22}
N 4360 31960 4340 31960 {}
C {lab_pin.sym} 4340 31960 0 0 {name=l25713 lab=WL160}
N 4440 32040 4460 32040 {}
C {lab_pin.sym} 4460 32040 0 0 {name=l25714 lab=VDD}
N 4440 31960 4460 31960 {}
C {lab_pin.sym} 4460 31960 0 0 {name=l25715 lab=VSS}
C {bitcell_6t.sym} 4600 32000 0 0 {name=Xr160c23}
N 4560 32040 4540 32040 {}
C {lab_pin.sym} 4540 32040 0 0 {name=l25716 lab=BL23}
N 4560 32000 4540 32000 {}
C {lab_pin.sym} 4540 32000 0 0 {name=l25717 lab=BLB23}
N 4560 31960 4540 31960 {}
C {lab_pin.sym} 4540 31960 0 0 {name=l25718 lab=WL160}
N 4640 32040 4660 32040 {}
C {lab_pin.sym} 4660 32040 0 0 {name=l25719 lab=VDD}
N 4640 31960 4660 31960 {}
C {lab_pin.sym} 4660 31960 0 0 {name=l25720 lab=VSS}
C {bitcell_6t.sym} 4800 32000 0 0 {name=Xr160c24}
N 4760 32040 4740 32040 {}
C {lab_pin.sym} 4740 32040 0 0 {name=l25721 lab=BL24}
N 4760 32000 4740 32000 {}
C {lab_pin.sym} 4740 32000 0 0 {name=l25722 lab=BLB24}
N 4760 31960 4740 31960 {}
C {lab_pin.sym} 4740 31960 0 0 {name=l25723 lab=WL160}
N 4840 32040 4860 32040 {}
C {lab_pin.sym} 4860 32040 0 0 {name=l25724 lab=VDD}
N 4840 31960 4860 31960 {}
C {lab_pin.sym} 4860 31960 0 0 {name=l25725 lab=VSS}
C {bitcell_6t.sym} 5000 32000 0 0 {name=Xr160c25}
N 4960 32040 4940 32040 {}
C {lab_pin.sym} 4940 32040 0 0 {name=l25726 lab=BL25}
N 4960 32000 4940 32000 {}
C {lab_pin.sym} 4940 32000 0 0 {name=l25727 lab=BLB25}
N 4960 31960 4940 31960 {}
C {lab_pin.sym} 4940 31960 0 0 {name=l25728 lab=WL160}
N 5040 32040 5060 32040 {}
C {lab_pin.sym} 5060 32040 0 0 {name=l25729 lab=VDD}
N 5040 31960 5060 31960 {}
C {lab_pin.sym} 5060 31960 0 0 {name=l25730 lab=VSS}
C {bitcell_6t.sym} 5200 32000 0 0 {name=Xr160c26}
N 5160 32040 5140 32040 {}
C {lab_pin.sym} 5140 32040 0 0 {name=l25731 lab=BL26}
N 5160 32000 5140 32000 {}
C {lab_pin.sym} 5140 32000 0 0 {name=l25732 lab=BLB26}
N 5160 31960 5140 31960 {}
C {lab_pin.sym} 5140 31960 0 0 {name=l25733 lab=WL160}
N 5240 32040 5260 32040 {}
C {lab_pin.sym} 5260 32040 0 0 {name=l25734 lab=VDD}
N 5240 31960 5260 31960 {}
C {lab_pin.sym} 5260 31960 0 0 {name=l25735 lab=VSS}
C {bitcell_6t.sym} 5400 32000 0 0 {name=Xr160c27}
N 5360 32040 5340 32040 {}
C {lab_pin.sym} 5340 32040 0 0 {name=l25736 lab=BL27}
N 5360 32000 5340 32000 {}
C {lab_pin.sym} 5340 32000 0 0 {name=l25737 lab=BLB27}
N 5360 31960 5340 31960 {}
C {lab_pin.sym} 5340 31960 0 0 {name=l25738 lab=WL160}
N 5440 32040 5460 32040 {}
C {lab_pin.sym} 5460 32040 0 0 {name=l25739 lab=VDD}
N 5440 31960 5460 31960 {}
C {lab_pin.sym} 5460 31960 0 0 {name=l25740 lab=VSS}
C {bitcell_6t.sym} 5600 32000 0 0 {name=Xr160c28}
N 5560 32040 5540 32040 {}
C {lab_pin.sym} 5540 32040 0 0 {name=l25741 lab=BL28}
N 5560 32000 5540 32000 {}
C {lab_pin.sym} 5540 32000 0 0 {name=l25742 lab=BLB28}
N 5560 31960 5540 31960 {}
C {lab_pin.sym} 5540 31960 0 0 {name=l25743 lab=WL160}
N 5640 32040 5660 32040 {}
C {lab_pin.sym} 5660 32040 0 0 {name=l25744 lab=VDD}
N 5640 31960 5660 31960 {}
C {lab_pin.sym} 5660 31960 0 0 {name=l25745 lab=VSS}
C {bitcell_6t.sym} 5800 32000 0 0 {name=Xr160c29}
N 5760 32040 5740 32040 {}
C {lab_pin.sym} 5740 32040 0 0 {name=l25746 lab=BL29}
N 5760 32000 5740 32000 {}
C {lab_pin.sym} 5740 32000 0 0 {name=l25747 lab=BLB29}
N 5760 31960 5740 31960 {}
C {lab_pin.sym} 5740 31960 0 0 {name=l25748 lab=WL160}
N 5840 32040 5860 32040 {}
C {lab_pin.sym} 5860 32040 0 0 {name=l25749 lab=VDD}
N 5840 31960 5860 31960 {}
C {lab_pin.sym} 5860 31960 0 0 {name=l25750 lab=VSS}
C {bitcell_6t.sym} 6000 32000 0 0 {name=Xr160c30}
N 5960 32040 5940 32040 {}
C {lab_pin.sym} 5940 32040 0 0 {name=l25751 lab=BL30}
N 5960 32000 5940 32000 {}
C {lab_pin.sym} 5940 32000 0 0 {name=l25752 lab=BLB30}
N 5960 31960 5940 31960 {}
C {lab_pin.sym} 5940 31960 0 0 {name=l25753 lab=WL160}
N 6040 32040 6060 32040 {}
C {lab_pin.sym} 6060 32040 0 0 {name=l25754 lab=VDD}
N 6040 31960 6060 31960 {}
C {lab_pin.sym} 6060 31960 0 0 {name=l25755 lab=VSS}
C {bitcell_6t.sym} 6200 32000 0 0 {name=Xr160c31}
N 6160 32040 6140 32040 {}
C {lab_pin.sym} 6140 32040 0 0 {name=l25756 lab=BL31}
N 6160 32000 6140 32000 {}
C {lab_pin.sym} 6140 32000 0 0 {name=l25757 lab=BLB31}
N 6160 31960 6140 31960 {}
C {lab_pin.sym} 6140 31960 0 0 {name=l25758 lab=WL160}
N 6240 32040 6260 32040 {}
C {lab_pin.sym} 6260 32040 0 0 {name=l25759 lab=VDD}
N 6240 31960 6260 31960 {}
C {lab_pin.sym} 6260 31960 0 0 {name=l25760 lab=VSS}
C {bitcell_6t.sym} 0 32200 0 0 {name=Xr161c0}
N -40 32240 -60 32240 {}
C {lab_pin.sym} -60 32240 0 0 {name=l25761 lab=BL0}
N -40 32200 -60 32200 {}
C {lab_pin.sym} -60 32200 0 0 {name=l25762 lab=BLB0}
N -40 32160 -60 32160 {}
C {lab_pin.sym} -60 32160 0 0 {name=l25763 lab=WL161}
N 40 32240 60 32240 {}
C {lab_pin.sym} 60 32240 0 0 {name=l25764 lab=VDD}
N 40 32160 60 32160 {}
C {lab_pin.sym} 60 32160 0 0 {name=l25765 lab=VSS}
C {bitcell_6t.sym} 200 32200 0 0 {name=Xr161c1}
N 160 32240 140 32240 {}
C {lab_pin.sym} 140 32240 0 0 {name=l25766 lab=BL1}
N 160 32200 140 32200 {}
C {lab_pin.sym} 140 32200 0 0 {name=l25767 lab=BLB1}
N 160 32160 140 32160 {}
C {lab_pin.sym} 140 32160 0 0 {name=l25768 lab=WL161}
N 240 32240 260 32240 {}
C {lab_pin.sym} 260 32240 0 0 {name=l25769 lab=VDD}
N 240 32160 260 32160 {}
C {lab_pin.sym} 260 32160 0 0 {name=l25770 lab=VSS}
C {bitcell_6t.sym} 400 32200 0 0 {name=Xr161c2}
N 360 32240 340 32240 {}
C {lab_pin.sym} 340 32240 0 0 {name=l25771 lab=BL2}
N 360 32200 340 32200 {}
C {lab_pin.sym} 340 32200 0 0 {name=l25772 lab=BLB2}
N 360 32160 340 32160 {}
C {lab_pin.sym} 340 32160 0 0 {name=l25773 lab=WL161}
N 440 32240 460 32240 {}
C {lab_pin.sym} 460 32240 0 0 {name=l25774 lab=VDD}
N 440 32160 460 32160 {}
C {lab_pin.sym} 460 32160 0 0 {name=l25775 lab=VSS}
C {bitcell_6t.sym} 600 32200 0 0 {name=Xr161c3}
N 560 32240 540 32240 {}
C {lab_pin.sym} 540 32240 0 0 {name=l25776 lab=BL3}
N 560 32200 540 32200 {}
C {lab_pin.sym} 540 32200 0 0 {name=l25777 lab=BLB3}
N 560 32160 540 32160 {}
C {lab_pin.sym} 540 32160 0 0 {name=l25778 lab=WL161}
N 640 32240 660 32240 {}
C {lab_pin.sym} 660 32240 0 0 {name=l25779 lab=VDD}
N 640 32160 660 32160 {}
C {lab_pin.sym} 660 32160 0 0 {name=l25780 lab=VSS}
C {bitcell_6t.sym} 800 32200 0 0 {name=Xr161c4}
N 760 32240 740 32240 {}
C {lab_pin.sym} 740 32240 0 0 {name=l25781 lab=BL4}
N 760 32200 740 32200 {}
C {lab_pin.sym} 740 32200 0 0 {name=l25782 lab=BLB4}
N 760 32160 740 32160 {}
C {lab_pin.sym} 740 32160 0 0 {name=l25783 lab=WL161}
N 840 32240 860 32240 {}
C {lab_pin.sym} 860 32240 0 0 {name=l25784 lab=VDD}
N 840 32160 860 32160 {}
C {lab_pin.sym} 860 32160 0 0 {name=l25785 lab=VSS}
C {bitcell_6t.sym} 1000 32200 0 0 {name=Xr161c5}
N 960 32240 940 32240 {}
C {lab_pin.sym} 940 32240 0 0 {name=l25786 lab=BL5}
N 960 32200 940 32200 {}
C {lab_pin.sym} 940 32200 0 0 {name=l25787 lab=BLB5}
N 960 32160 940 32160 {}
C {lab_pin.sym} 940 32160 0 0 {name=l25788 lab=WL161}
N 1040 32240 1060 32240 {}
C {lab_pin.sym} 1060 32240 0 0 {name=l25789 lab=VDD}
N 1040 32160 1060 32160 {}
C {lab_pin.sym} 1060 32160 0 0 {name=l25790 lab=VSS}
C {bitcell_6t.sym} 1200 32200 0 0 {name=Xr161c6}
N 1160 32240 1140 32240 {}
C {lab_pin.sym} 1140 32240 0 0 {name=l25791 lab=BL6}
N 1160 32200 1140 32200 {}
C {lab_pin.sym} 1140 32200 0 0 {name=l25792 lab=BLB6}
N 1160 32160 1140 32160 {}
C {lab_pin.sym} 1140 32160 0 0 {name=l25793 lab=WL161}
N 1240 32240 1260 32240 {}
C {lab_pin.sym} 1260 32240 0 0 {name=l25794 lab=VDD}
N 1240 32160 1260 32160 {}
C {lab_pin.sym} 1260 32160 0 0 {name=l25795 lab=VSS}
C {bitcell_6t.sym} 1400 32200 0 0 {name=Xr161c7}
N 1360 32240 1340 32240 {}
C {lab_pin.sym} 1340 32240 0 0 {name=l25796 lab=BL7}
N 1360 32200 1340 32200 {}
C {lab_pin.sym} 1340 32200 0 0 {name=l25797 lab=BLB7}
N 1360 32160 1340 32160 {}
C {lab_pin.sym} 1340 32160 0 0 {name=l25798 lab=WL161}
N 1440 32240 1460 32240 {}
C {lab_pin.sym} 1460 32240 0 0 {name=l25799 lab=VDD}
N 1440 32160 1460 32160 {}
C {lab_pin.sym} 1460 32160 0 0 {name=l25800 lab=VSS}
C {bitcell_6t.sym} 1600 32200 0 0 {name=Xr161c8}
N 1560 32240 1540 32240 {}
C {lab_pin.sym} 1540 32240 0 0 {name=l25801 lab=BL8}
N 1560 32200 1540 32200 {}
C {lab_pin.sym} 1540 32200 0 0 {name=l25802 lab=BLB8}
N 1560 32160 1540 32160 {}
C {lab_pin.sym} 1540 32160 0 0 {name=l25803 lab=WL161}
N 1640 32240 1660 32240 {}
C {lab_pin.sym} 1660 32240 0 0 {name=l25804 lab=VDD}
N 1640 32160 1660 32160 {}
C {lab_pin.sym} 1660 32160 0 0 {name=l25805 lab=VSS}
C {bitcell_6t.sym} 1800 32200 0 0 {name=Xr161c9}
N 1760 32240 1740 32240 {}
C {lab_pin.sym} 1740 32240 0 0 {name=l25806 lab=BL9}
N 1760 32200 1740 32200 {}
C {lab_pin.sym} 1740 32200 0 0 {name=l25807 lab=BLB9}
N 1760 32160 1740 32160 {}
C {lab_pin.sym} 1740 32160 0 0 {name=l25808 lab=WL161}
N 1840 32240 1860 32240 {}
C {lab_pin.sym} 1860 32240 0 0 {name=l25809 lab=VDD}
N 1840 32160 1860 32160 {}
C {lab_pin.sym} 1860 32160 0 0 {name=l25810 lab=VSS}
C {bitcell_6t.sym} 2000 32200 0 0 {name=Xr161c10}
N 1960 32240 1940 32240 {}
C {lab_pin.sym} 1940 32240 0 0 {name=l25811 lab=BL10}
N 1960 32200 1940 32200 {}
C {lab_pin.sym} 1940 32200 0 0 {name=l25812 lab=BLB10}
N 1960 32160 1940 32160 {}
C {lab_pin.sym} 1940 32160 0 0 {name=l25813 lab=WL161}
N 2040 32240 2060 32240 {}
C {lab_pin.sym} 2060 32240 0 0 {name=l25814 lab=VDD}
N 2040 32160 2060 32160 {}
C {lab_pin.sym} 2060 32160 0 0 {name=l25815 lab=VSS}
C {bitcell_6t.sym} 2200 32200 0 0 {name=Xr161c11}
N 2160 32240 2140 32240 {}
C {lab_pin.sym} 2140 32240 0 0 {name=l25816 lab=BL11}
N 2160 32200 2140 32200 {}
C {lab_pin.sym} 2140 32200 0 0 {name=l25817 lab=BLB11}
N 2160 32160 2140 32160 {}
C {lab_pin.sym} 2140 32160 0 0 {name=l25818 lab=WL161}
N 2240 32240 2260 32240 {}
C {lab_pin.sym} 2260 32240 0 0 {name=l25819 lab=VDD}
N 2240 32160 2260 32160 {}
C {lab_pin.sym} 2260 32160 0 0 {name=l25820 lab=VSS}
C {bitcell_6t.sym} 2400 32200 0 0 {name=Xr161c12}
N 2360 32240 2340 32240 {}
C {lab_pin.sym} 2340 32240 0 0 {name=l25821 lab=BL12}
N 2360 32200 2340 32200 {}
C {lab_pin.sym} 2340 32200 0 0 {name=l25822 lab=BLB12}
N 2360 32160 2340 32160 {}
C {lab_pin.sym} 2340 32160 0 0 {name=l25823 lab=WL161}
N 2440 32240 2460 32240 {}
C {lab_pin.sym} 2460 32240 0 0 {name=l25824 lab=VDD}
N 2440 32160 2460 32160 {}
C {lab_pin.sym} 2460 32160 0 0 {name=l25825 lab=VSS}
C {bitcell_6t.sym} 2600 32200 0 0 {name=Xr161c13}
N 2560 32240 2540 32240 {}
C {lab_pin.sym} 2540 32240 0 0 {name=l25826 lab=BL13}
N 2560 32200 2540 32200 {}
C {lab_pin.sym} 2540 32200 0 0 {name=l25827 lab=BLB13}
N 2560 32160 2540 32160 {}
C {lab_pin.sym} 2540 32160 0 0 {name=l25828 lab=WL161}
N 2640 32240 2660 32240 {}
C {lab_pin.sym} 2660 32240 0 0 {name=l25829 lab=VDD}
N 2640 32160 2660 32160 {}
C {lab_pin.sym} 2660 32160 0 0 {name=l25830 lab=VSS}
C {bitcell_6t.sym} 2800 32200 0 0 {name=Xr161c14}
N 2760 32240 2740 32240 {}
C {lab_pin.sym} 2740 32240 0 0 {name=l25831 lab=BL14}
N 2760 32200 2740 32200 {}
C {lab_pin.sym} 2740 32200 0 0 {name=l25832 lab=BLB14}
N 2760 32160 2740 32160 {}
C {lab_pin.sym} 2740 32160 0 0 {name=l25833 lab=WL161}
N 2840 32240 2860 32240 {}
C {lab_pin.sym} 2860 32240 0 0 {name=l25834 lab=VDD}
N 2840 32160 2860 32160 {}
C {lab_pin.sym} 2860 32160 0 0 {name=l25835 lab=VSS}
C {bitcell_6t.sym} 3000 32200 0 0 {name=Xr161c15}
N 2960 32240 2940 32240 {}
C {lab_pin.sym} 2940 32240 0 0 {name=l25836 lab=BL15}
N 2960 32200 2940 32200 {}
C {lab_pin.sym} 2940 32200 0 0 {name=l25837 lab=BLB15}
N 2960 32160 2940 32160 {}
C {lab_pin.sym} 2940 32160 0 0 {name=l25838 lab=WL161}
N 3040 32240 3060 32240 {}
C {lab_pin.sym} 3060 32240 0 0 {name=l25839 lab=VDD}
N 3040 32160 3060 32160 {}
C {lab_pin.sym} 3060 32160 0 0 {name=l25840 lab=VSS}
C {bitcell_6t.sym} 3200 32200 0 0 {name=Xr161c16}
N 3160 32240 3140 32240 {}
C {lab_pin.sym} 3140 32240 0 0 {name=l25841 lab=BL16}
N 3160 32200 3140 32200 {}
C {lab_pin.sym} 3140 32200 0 0 {name=l25842 lab=BLB16}
N 3160 32160 3140 32160 {}
C {lab_pin.sym} 3140 32160 0 0 {name=l25843 lab=WL161}
N 3240 32240 3260 32240 {}
C {lab_pin.sym} 3260 32240 0 0 {name=l25844 lab=VDD}
N 3240 32160 3260 32160 {}
C {lab_pin.sym} 3260 32160 0 0 {name=l25845 lab=VSS}
C {bitcell_6t.sym} 3400 32200 0 0 {name=Xr161c17}
N 3360 32240 3340 32240 {}
C {lab_pin.sym} 3340 32240 0 0 {name=l25846 lab=BL17}
N 3360 32200 3340 32200 {}
C {lab_pin.sym} 3340 32200 0 0 {name=l25847 lab=BLB17}
N 3360 32160 3340 32160 {}
C {lab_pin.sym} 3340 32160 0 0 {name=l25848 lab=WL161}
N 3440 32240 3460 32240 {}
C {lab_pin.sym} 3460 32240 0 0 {name=l25849 lab=VDD}
N 3440 32160 3460 32160 {}
C {lab_pin.sym} 3460 32160 0 0 {name=l25850 lab=VSS}
C {bitcell_6t.sym} 3600 32200 0 0 {name=Xr161c18}
N 3560 32240 3540 32240 {}
C {lab_pin.sym} 3540 32240 0 0 {name=l25851 lab=BL18}
N 3560 32200 3540 32200 {}
C {lab_pin.sym} 3540 32200 0 0 {name=l25852 lab=BLB18}
N 3560 32160 3540 32160 {}
C {lab_pin.sym} 3540 32160 0 0 {name=l25853 lab=WL161}
N 3640 32240 3660 32240 {}
C {lab_pin.sym} 3660 32240 0 0 {name=l25854 lab=VDD}
N 3640 32160 3660 32160 {}
C {lab_pin.sym} 3660 32160 0 0 {name=l25855 lab=VSS}
C {bitcell_6t.sym} 3800 32200 0 0 {name=Xr161c19}
N 3760 32240 3740 32240 {}
C {lab_pin.sym} 3740 32240 0 0 {name=l25856 lab=BL19}
N 3760 32200 3740 32200 {}
C {lab_pin.sym} 3740 32200 0 0 {name=l25857 lab=BLB19}
N 3760 32160 3740 32160 {}
C {lab_pin.sym} 3740 32160 0 0 {name=l25858 lab=WL161}
N 3840 32240 3860 32240 {}
C {lab_pin.sym} 3860 32240 0 0 {name=l25859 lab=VDD}
N 3840 32160 3860 32160 {}
C {lab_pin.sym} 3860 32160 0 0 {name=l25860 lab=VSS}
C {bitcell_6t.sym} 4000 32200 0 0 {name=Xr161c20}
N 3960 32240 3940 32240 {}
C {lab_pin.sym} 3940 32240 0 0 {name=l25861 lab=BL20}
N 3960 32200 3940 32200 {}
C {lab_pin.sym} 3940 32200 0 0 {name=l25862 lab=BLB20}
N 3960 32160 3940 32160 {}
C {lab_pin.sym} 3940 32160 0 0 {name=l25863 lab=WL161}
N 4040 32240 4060 32240 {}
C {lab_pin.sym} 4060 32240 0 0 {name=l25864 lab=VDD}
N 4040 32160 4060 32160 {}
C {lab_pin.sym} 4060 32160 0 0 {name=l25865 lab=VSS}
C {bitcell_6t.sym} 4200 32200 0 0 {name=Xr161c21}
N 4160 32240 4140 32240 {}
C {lab_pin.sym} 4140 32240 0 0 {name=l25866 lab=BL21}
N 4160 32200 4140 32200 {}
C {lab_pin.sym} 4140 32200 0 0 {name=l25867 lab=BLB21}
N 4160 32160 4140 32160 {}
C {lab_pin.sym} 4140 32160 0 0 {name=l25868 lab=WL161}
N 4240 32240 4260 32240 {}
C {lab_pin.sym} 4260 32240 0 0 {name=l25869 lab=VDD}
N 4240 32160 4260 32160 {}
C {lab_pin.sym} 4260 32160 0 0 {name=l25870 lab=VSS}
C {bitcell_6t.sym} 4400 32200 0 0 {name=Xr161c22}
N 4360 32240 4340 32240 {}
C {lab_pin.sym} 4340 32240 0 0 {name=l25871 lab=BL22}
N 4360 32200 4340 32200 {}
C {lab_pin.sym} 4340 32200 0 0 {name=l25872 lab=BLB22}
N 4360 32160 4340 32160 {}
C {lab_pin.sym} 4340 32160 0 0 {name=l25873 lab=WL161}
N 4440 32240 4460 32240 {}
C {lab_pin.sym} 4460 32240 0 0 {name=l25874 lab=VDD}
N 4440 32160 4460 32160 {}
C {lab_pin.sym} 4460 32160 0 0 {name=l25875 lab=VSS}
C {bitcell_6t.sym} 4600 32200 0 0 {name=Xr161c23}
N 4560 32240 4540 32240 {}
C {lab_pin.sym} 4540 32240 0 0 {name=l25876 lab=BL23}
N 4560 32200 4540 32200 {}
C {lab_pin.sym} 4540 32200 0 0 {name=l25877 lab=BLB23}
N 4560 32160 4540 32160 {}
C {lab_pin.sym} 4540 32160 0 0 {name=l25878 lab=WL161}
N 4640 32240 4660 32240 {}
C {lab_pin.sym} 4660 32240 0 0 {name=l25879 lab=VDD}
N 4640 32160 4660 32160 {}
C {lab_pin.sym} 4660 32160 0 0 {name=l25880 lab=VSS}
C {bitcell_6t.sym} 4800 32200 0 0 {name=Xr161c24}
N 4760 32240 4740 32240 {}
C {lab_pin.sym} 4740 32240 0 0 {name=l25881 lab=BL24}
N 4760 32200 4740 32200 {}
C {lab_pin.sym} 4740 32200 0 0 {name=l25882 lab=BLB24}
N 4760 32160 4740 32160 {}
C {lab_pin.sym} 4740 32160 0 0 {name=l25883 lab=WL161}
N 4840 32240 4860 32240 {}
C {lab_pin.sym} 4860 32240 0 0 {name=l25884 lab=VDD}
N 4840 32160 4860 32160 {}
C {lab_pin.sym} 4860 32160 0 0 {name=l25885 lab=VSS}
C {bitcell_6t.sym} 5000 32200 0 0 {name=Xr161c25}
N 4960 32240 4940 32240 {}
C {lab_pin.sym} 4940 32240 0 0 {name=l25886 lab=BL25}
N 4960 32200 4940 32200 {}
C {lab_pin.sym} 4940 32200 0 0 {name=l25887 lab=BLB25}
N 4960 32160 4940 32160 {}
C {lab_pin.sym} 4940 32160 0 0 {name=l25888 lab=WL161}
N 5040 32240 5060 32240 {}
C {lab_pin.sym} 5060 32240 0 0 {name=l25889 lab=VDD}
N 5040 32160 5060 32160 {}
C {lab_pin.sym} 5060 32160 0 0 {name=l25890 lab=VSS}
C {bitcell_6t.sym} 5200 32200 0 0 {name=Xr161c26}
N 5160 32240 5140 32240 {}
C {lab_pin.sym} 5140 32240 0 0 {name=l25891 lab=BL26}
N 5160 32200 5140 32200 {}
C {lab_pin.sym} 5140 32200 0 0 {name=l25892 lab=BLB26}
N 5160 32160 5140 32160 {}
C {lab_pin.sym} 5140 32160 0 0 {name=l25893 lab=WL161}
N 5240 32240 5260 32240 {}
C {lab_pin.sym} 5260 32240 0 0 {name=l25894 lab=VDD}
N 5240 32160 5260 32160 {}
C {lab_pin.sym} 5260 32160 0 0 {name=l25895 lab=VSS}
C {bitcell_6t.sym} 5400 32200 0 0 {name=Xr161c27}
N 5360 32240 5340 32240 {}
C {lab_pin.sym} 5340 32240 0 0 {name=l25896 lab=BL27}
N 5360 32200 5340 32200 {}
C {lab_pin.sym} 5340 32200 0 0 {name=l25897 lab=BLB27}
N 5360 32160 5340 32160 {}
C {lab_pin.sym} 5340 32160 0 0 {name=l25898 lab=WL161}
N 5440 32240 5460 32240 {}
C {lab_pin.sym} 5460 32240 0 0 {name=l25899 lab=VDD}
N 5440 32160 5460 32160 {}
C {lab_pin.sym} 5460 32160 0 0 {name=l25900 lab=VSS}
C {bitcell_6t.sym} 5600 32200 0 0 {name=Xr161c28}
N 5560 32240 5540 32240 {}
C {lab_pin.sym} 5540 32240 0 0 {name=l25901 lab=BL28}
N 5560 32200 5540 32200 {}
C {lab_pin.sym} 5540 32200 0 0 {name=l25902 lab=BLB28}
N 5560 32160 5540 32160 {}
C {lab_pin.sym} 5540 32160 0 0 {name=l25903 lab=WL161}
N 5640 32240 5660 32240 {}
C {lab_pin.sym} 5660 32240 0 0 {name=l25904 lab=VDD}
N 5640 32160 5660 32160 {}
C {lab_pin.sym} 5660 32160 0 0 {name=l25905 lab=VSS}
C {bitcell_6t.sym} 5800 32200 0 0 {name=Xr161c29}
N 5760 32240 5740 32240 {}
C {lab_pin.sym} 5740 32240 0 0 {name=l25906 lab=BL29}
N 5760 32200 5740 32200 {}
C {lab_pin.sym} 5740 32200 0 0 {name=l25907 lab=BLB29}
N 5760 32160 5740 32160 {}
C {lab_pin.sym} 5740 32160 0 0 {name=l25908 lab=WL161}
N 5840 32240 5860 32240 {}
C {lab_pin.sym} 5860 32240 0 0 {name=l25909 lab=VDD}
N 5840 32160 5860 32160 {}
C {lab_pin.sym} 5860 32160 0 0 {name=l25910 lab=VSS}
C {bitcell_6t.sym} 6000 32200 0 0 {name=Xr161c30}
N 5960 32240 5940 32240 {}
C {lab_pin.sym} 5940 32240 0 0 {name=l25911 lab=BL30}
N 5960 32200 5940 32200 {}
C {lab_pin.sym} 5940 32200 0 0 {name=l25912 lab=BLB30}
N 5960 32160 5940 32160 {}
C {lab_pin.sym} 5940 32160 0 0 {name=l25913 lab=WL161}
N 6040 32240 6060 32240 {}
C {lab_pin.sym} 6060 32240 0 0 {name=l25914 lab=VDD}
N 6040 32160 6060 32160 {}
C {lab_pin.sym} 6060 32160 0 0 {name=l25915 lab=VSS}
C {bitcell_6t.sym} 6200 32200 0 0 {name=Xr161c31}
N 6160 32240 6140 32240 {}
C {lab_pin.sym} 6140 32240 0 0 {name=l25916 lab=BL31}
N 6160 32200 6140 32200 {}
C {lab_pin.sym} 6140 32200 0 0 {name=l25917 lab=BLB31}
N 6160 32160 6140 32160 {}
C {lab_pin.sym} 6140 32160 0 0 {name=l25918 lab=WL161}
N 6240 32240 6260 32240 {}
C {lab_pin.sym} 6260 32240 0 0 {name=l25919 lab=VDD}
N 6240 32160 6260 32160 {}
C {lab_pin.sym} 6260 32160 0 0 {name=l25920 lab=VSS}
C {bitcell_6t.sym} 0 32400 0 0 {name=Xr162c0}
N -40 32440 -60 32440 {}
C {lab_pin.sym} -60 32440 0 0 {name=l25921 lab=BL0}
N -40 32400 -60 32400 {}
C {lab_pin.sym} -60 32400 0 0 {name=l25922 lab=BLB0}
N -40 32360 -60 32360 {}
C {lab_pin.sym} -60 32360 0 0 {name=l25923 lab=WL162}
N 40 32440 60 32440 {}
C {lab_pin.sym} 60 32440 0 0 {name=l25924 lab=VDD}
N 40 32360 60 32360 {}
C {lab_pin.sym} 60 32360 0 0 {name=l25925 lab=VSS}
C {bitcell_6t.sym} 200 32400 0 0 {name=Xr162c1}
N 160 32440 140 32440 {}
C {lab_pin.sym} 140 32440 0 0 {name=l25926 lab=BL1}
N 160 32400 140 32400 {}
C {lab_pin.sym} 140 32400 0 0 {name=l25927 lab=BLB1}
N 160 32360 140 32360 {}
C {lab_pin.sym} 140 32360 0 0 {name=l25928 lab=WL162}
N 240 32440 260 32440 {}
C {lab_pin.sym} 260 32440 0 0 {name=l25929 lab=VDD}
N 240 32360 260 32360 {}
C {lab_pin.sym} 260 32360 0 0 {name=l25930 lab=VSS}
C {bitcell_6t.sym} 400 32400 0 0 {name=Xr162c2}
N 360 32440 340 32440 {}
C {lab_pin.sym} 340 32440 0 0 {name=l25931 lab=BL2}
N 360 32400 340 32400 {}
C {lab_pin.sym} 340 32400 0 0 {name=l25932 lab=BLB2}
N 360 32360 340 32360 {}
C {lab_pin.sym} 340 32360 0 0 {name=l25933 lab=WL162}
N 440 32440 460 32440 {}
C {lab_pin.sym} 460 32440 0 0 {name=l25934 lab=VDD}
N 440 32360 460 32360 {}
C {lab_pin.sym} 460 32360 0 0 {name=l25935 lab=VSS}
C {bitcell_6t.sym} 600 32400 0 0 {name=Xr162c3}
N 560 32440 540 32440 {}
C {lab_pin.sym} 540 32440 0 0 {name=l25936 lab=BL3}
N 560 32400 540 32400 {}
C {lab_pin.sym} 540 32400 0 0 {name=l25937 lab=BLB3}
N 560 32360 540 32360 {}
C {lab_pin.sym} 540 32360 0 0 {name=l25938 lab=WL162}
N 640 32440 660 32440 {}
C {lab_pin.sym} 660 32440 0 0 {name=l25939 lab=VDD}
N 640 32360 660 32360 {}
C {lab_pin.sym} 660 32360 0 0 {name=l25940 lab=VSS}
C {bitcell_6t.sym} 800 32400 0 0 {name=Xr162c4}
N 760 32440 740 32440 {}
C {lab_pin.sym} 740 32440 0 0 {name=l25941 lab=BL4}
N 760 32400 740 32400 {}
C {lab_pin.sym} 740 32400 0 0 {name=l25942 lab=BLB4}
N 760 32360 740 32360 {}
C {lab_pin.sym} 740 32360 0 0 {name=l25943 lab=WL162}
N 840 32440 860 32440 {}
C {lab_pin.sym} 860 32440 0 0 {name=l25944 lab=VDD}
N 840 32360 860 32360 {}
C {lab_pin.sym} 860 32360 0 0 {name=l25945 lab=VSS}
C {bitcell_6t.sym} 1000 32400 0 0 {name=Xr162c5}
N 960 32440 940 32440 {}
C {lab_pin.sym} 940 32440 0 0 {name=l25946 lab=BL5}
N 960 32400 940 32400 {}
C {lab_pin.sym} 940 32400 0 0 {name=l25947 lab=BLB5}
N 960 32360 940 32360 {}
C {lab_pin.sym} 940 32360 0 0 {name=l25948 lab=WL162}
N 1040 32440 1060 32440 {}
C {lab_pin.sym} 1060 32440 0 0 {name=l25949 lab=VDD}
N 1040 32360 1060 32360 {}
C {lab_pin.sym} 1060 32360 0 0 {name=l25950 lab=VSS}
C {bitcell_6t.sym} 1200 32400 0 0 {name=Xr162c6}
N 1160 32440 1140 32440 {}
C {lab_pin.sym} 1140 32440 0 0 {name=l25951 lab=BL6}
N 1160 32400 1140 32400 {}
C {lab_pin.sym} 1140 32400 0 0 {name=l25952 lab=BLB6}
N 1160 32360 1140 32360 {}
C {lab_pin.sym} 1140 32360 0 0 {name=l25953 lab=WL162}
N 1240 32440 1260 32440 {}
C {lab_pin.sym} 1260 32440 0 0 {name=l25954 lab=VDD}
N 1240 32360 1260 32360 {}
C {lab_pin.sym} 1260 32360 0 0 {name=l25955 lab=VSS}
C {bitcell_6t.sym} 1400 32400 0 0 {name=Xr162c7}
N 1360 32440 1340 32440 {}
C {lab_pin.sym} 1340 32440 0 0 {name=l25956 lab=BL7}
N 1360 32400 1340 32400 {}
C {lab_pin.sym} 1340 32400 0 0 {name=l25957 lab=BLB7}
N 1360 32360 1340 32360 {}
C {lab_pin.sym} 1340 32360 0 0 {name=l25958 lab=WL162}
N 1440 32440 1460 32440 {}
C {lab_pin.sym} 1460 32440 0 0 {name=l25959 lab=VDD}
N 1440 32360 1460 32360 {}
C {lab_pin.sym} 1460 32360 0 0 {name=l25960 lab=VSS}
C {bitcell_6t.sym} 1600 32400 0 0 {name=Xr162c8}
N 1560 32440 1540 32440 {}
C {lab_pin.sym} 1540 32440 0 0 {name=l25961 lab=BL8}
N 1560 32400 1540 32400 {}
C {lab_pin.sym} 1540 32400 0 0 {name=l25962 lab=BLB8}
N 1560 32360 1540 32360 {}
C {lab_pin.sym} 1540 32360 0 0 {name=l25963 lab=WL162}
N 1640 32440 1660 32440 {}
C {lab_pin.sym} 1660 32440 0 0 {name=l25964 lab=VDD}
N 1640 32360 1660 32360 {}
C {lab_pin.sym} 1660 32360 0 0 {name=l25965 lab=VSS}
C {bitcell_6t.sym} 1800 32400 0 0 {name=Xr162c9}
N 1760 32440 1740 32440 {}
C {lab_pin.sym} 1740 32440 0 0 {name=l25966 lab=BL9}
N 1760 32400 1740 32400 {}
C {lab_pin.sym} 1740 32400 0 0 {name=l25967 lab=BLB9}
N 1760 32360 1740 32360 {}
C {lab_pin.sym} 1740 32360 0 0 {name=l25968 lab=WL162}
N 1840 32440 1860 32440 {}
C {lab_pin.sym} 1860 32440 0 0 {name=l25969 lab=VDD}
N 1840 32360 1860 32360 {}
C {lab_pin.sym} 1860 32360 0 0 {name=l25970 lab=VSS}
C {bitcell_6t.sym} 2000 32400 0 0 {name=Xr162c10}
N 1960 32440 1940 32440 {}
C {lab_pin.sym} 1940 32440 0 0 {name=l25971 lab=BL10}
N 1960 32400 1940 32400 {}
C {lab_pin.sym} 1940 32400 0 0 {name=l25972 lab=BLB10}
N 1960 32360 1940 32360 {}
C {lab_pin.sym} 1940 32360 0 0 {name=l25973 lab=WL162}
N 2040 32440 2060 32440 {}
C {lab_pin.sym} 2060 32440 0 0 {name=l25974 lab=VDD}
N 2040 32360 2060 32360 {}
C {lab_pin.sym} 2060 32360 0 0 {name=l25975 lab=VSS}
C {bitcell_6t.sym} 2200 32400 0 0 {name=Xr162c11}
N 2160 32440 2140 32440 {}
C {lab_pin.sym} 2140 32440 0 0 {name=l25976 lab=BL11}
N 2160 32400 2140 32400 {}
C {lab_pin.sym} 2140 32400 0 0 {name=l25977 lab=BLB11}
N 2160 32360 2140 32360 {}
C {lab_pin.sym} 2140 32360 0 0 {name=l25978 lab=WL162}
N 2240 32440 2260 32440 {}
C {lab_pin.sym} 2260 32440 0 0 {name=l25979 lab=VDD}
N 2240 32360 2260 32360 {}
C {lab_pin.sym} 2260 32360 0 0 {name=l25980 lab=VSS}
C {bitcell_6t.sym} 2400 32400 0 0 {name=Xr162c12}
N 2360 32440 2340 32440 {}
C {lab_pin.sym} 2340 32440 0 0 {name=l25981 lab=BL12}
N 2360 32400 2340 32400 {}
C {lab_pin.sym} 2340 32400 0 0 {name=l25982 lab=BLB12}
N 2360 32360 2340 32360 {}
C {lab_pin.sym} 2340 32360 0 0 {name=l25983 lab=WL162}
N 2440 32440 2460 32440 {}
C {lab_pin.sym} 2460 32440 0 0 {name=l25984 lab=VDD}
N 2440 32360 2460 32360 {}
C {lab_pin.sym} 2460 32360 0 0 {name=l25985 lab=VSS}
C {bitcell_6t.sym} 2600 32400 0 0 {name=Xr162c13}
N 2560 32440 2540 32440 {}
C {lab_pin.sym} 2540 32440 0 0 {name=l25986 lab=BL13}
N 2560 32400 2540 32400 {}
C {lab_pin.sym} 2540 32400 0 0 {name=l25987 lab=BLB13}
N 2560 32360 2540 32360 {}
C {lab_pin.sym} 2540 32360 0 0 {name=l25988 lab=WL162}
N 2640 32440 2660 32440 {}
C {lab_pin.sym} 2660 32440 0 0 {name=l25989 lab=VDD}
N 2640 32360 2660 32360 {}
C {lab_pin.sym} 2660 32360 0 0 {name=l25990 lab=VSS}
C {bitcell_6t.sym} 2800 32400 0 0 {name=Xr162c14}
N 2760 32440 2740 32440 {}
C {lab_pin.sym} 2740 32440 0 0 {name=l25991 lab=BL14}
N 2760 32400 2740 32400 {}
C {lab_pin.sym} 2740 32400 0 0 {name=l25992 lab=BLB14}
N 2760 32360 2740 32360 {}
C {lab_pin.sym} 2740 32360 0 0 {name=l25993 lab=WL162}
N 2840 32440 2860 32440 {}
C {lab_pin.sym} 2860 32440 0 0 {name=l25994 lab=VDD}
N 2840 32360 2860 32360 {}
C {lab_pin.sym} 2860 32360 0 0 {name=l25995 lab=VSS}
C {bitcell_6t.sym} 3000 32400 0 0 {name=Xr162c15}
N 2960 32440 2940 32440 {}
C {lab_pin.sym} 2940 32440 0 0 {name=l25996 lab=BL15}
N 2960 32400 2940 32400 {}
C {lab_pin.sym} 2940 32400 0 0 {name=l25997 lab=BLB15}
N 2960 32360 2940 32360 {}
C {lab_pin.sym} 2940 32360 0 0 {name=l25998 lab=WL162}
N 3040 32440 3060 32440 {}
C {lab_pin.sym} 3060 32440 0 0 {name=l25999 lab=VDD}
N 3040 32360 3060 32360 {}
C {lab_pin.sym} 3060 32360 0 0 {name=l26000 lab=VSS}
C {bitcell_6t.sym} 3200 32400 0 0 {name=Xr162c16}
N 3160 32440 3140 32440 {}
C {lab_pin.sym} 3140 32440 0 0 {name=l26001 lab=BL16}
N 3160 32400 3140 32400 {}
C {lab_pin.sym} 3140 32400 0 0 {name=l26002 lab=BLB16}
N 3160 32360 3140 32360 {}
C {lab_pin.sym} 3140 32360 0 0 {name=l26003 lab=WL162}
N 3240 32440 3260 32440 {}
C {lab_pin.sym} 3260 32440 0 0 {name=l26004 lab=VDD}
N 3240 32360 3260 32360 {}
C {lab_pin.sym} 3260 32360 0 0 {name=l26005 lab=VSS}
C {bitcell_6t.sym} 3400 32400 0 0 {name=Xr162c17}
N 3360 32440 3340 32440 {}
C {lab_pin.sym} 3340 32440 0 0 {name=l26006 lab=BL17}
N 3360 32400 3340 32400 {}
C {lab_pin.sym} 3340 32400 0 0 {name=l26007 lab=BLB17}
N 3360 32360 3340 32360 {}
C {lab_pin.sym} 3340 32360 0 0 {name=l26008 lab=WL162}
N 3440 32440 3460 32440 {}
C {lab_pin.sym} 3460 32440 0 0 {name=l26009 lab=VDD}
N 3440 32360 3460 32360 {}
C {lab_pin.sym} 3460 32360 0 0 {name=l26010 lab=VSS}
C {bitcell_6t.sym} 3600 32400 0 0 {name=Xr162c18}
N 3560 32440 3540 32440 {}
C {lab_pin.sym} 3540 32440 0 0 {name=l26011 lab=BL18}
N 3560 32400 3540 32400 {}
C {lab_pin.sym} 3540 32400 0 0 {name=l26012 lab=BLB18}
N 3560 32360 3540 32360 {}
C {lab_pin.sym} 3540 32360 0 0 {name=l26013 lab=WL162}
N 3640 32440 3660 32440 {}
C {lab_pin.sym} 3660 32440 0 0 {name=l26014 lab=VDD}
N 3640 32360 3660 32360 {}
C {lab_pin.sym} 3660 32360 0 0 {name=l26015 lab=VSS}
C {bitcell_6t.sym} 3800 32400 0 0 {name=Xr162c19}
N 3760 32440 3740 32440 {}
C {lab_pin.sym} 3740 32440 0 0 {name=l26016 lab=BL19}
N 3760 32400 3740 32400 {}
C {lab_pin.sym} 3740 32400 0 0 {name=l26017 lab=BLB19}
N 3760 32360 3740 32360 {}
C {lab_pin.sym} 3740 32360 0 0 {name=l26018 lab=WL162}
N 3840 32440 3860 32440 {}
C {lab_pin.sym} 3860 32440 0 0 {name=l26019 lab=VDD}
N 3840 32360 3860 32360 {}
C {lab_pin.sym} 3860 32360 0 0 {name=l26020 lab=VSS}
C {bitcell_6t.sym} 4000 32400 0 0 {name=Xr162c20}
N 3960 32440 3940 32440 {}
C {lab_pin.sym} 3940 32440 0 0 {name=l26021 lab=BL20}
N 3960 32400 3940 32400 {}
C {lab_pin.sym} 3940 32400 0 0 {name=l26022 lab=BLB20}
N 3960 32360 3940 32360 {}
C {lab_pin.sym} 3940 32360 0 0 {name=l26023 lab=WL162}
N 4040 32440 4060 32440 {}
C {lab_pin.sym} 4060 32440 0 0 {name=l26024 lab=VDD}
N 4040 32360 4060 32360 {}
C {lab_pin.sym} 4060 32360 0 0 {name=l26025 lab=VSS}
C {bitcell_6t.sym} 4200 32400 0 0 {name=Xr162c21}
N 4160 32440 4140 32440 {}
C {lab_pin.sym} 4140 32440 0 0 {name=l26026 lab=BL21}
N 4160 32400 4140 32400 {}
C {lab_pin.sym} 4140 32400 0 0 {name=l26027 lab=BLB21}
N 4160 32360 4140 32360 {}
C {lab_pin.sym} 4140 32360 0 0 {name=l26028 lab=WL162}
N 4240 32440 4260 32440 {}
C {lab_pin.sym} 4260 32440 0 0 {name=l26029 lab=VDD}
N 4240 32360 4260 32360 {}
C {lab_pin.sym} 4260 32360 0 0 {name=l26030 lab=VSS}
C {bitcell_6t.sym} 4400 32400 0 0 {name=Xr162c22}
N 4360 32440 4340 32440 {}
C {lab_pin.sym} 4340 32440 0 0 {name=l26031 lab=BL22}
N 4360 32400 4340 32400 {}
C {lab_pin.sym} 4340 32400 0 0 {name=l26032 lab=BLB22}
N 4360 32360 4340 32360 {}
C {lab_pin.sym} 4340 32360 0 0 {name=l26033 lab=WL162}
N 4440 32440 4460 32440 {}
C {lab_pin.sym} 4460 32440 0 0 {name=l26034 lab=VDD}
N 4440 32360 4460 32360 {}
C {lab_pin.sym} 4460 32360 0 0 {name=l26035 lab=VSS}
C {bitcell_6t.sym} 4600 32400 0 0 {name=Xr162c23}
N 4560 32440 4540 32440 {}
C {lab_pin.sym} 4540 32440 0 0 {name=l26036 lab=BL23}
N 4560 32400 4540 32400 {}
C {lab_pin.sym} 4540 32400 0 0 {name=l26037 lab=BLB23}
N 4560 32360 4540 32360 {}
C {lab_pin.sym} 4540 32360 0 0 {name=l26038 lab=WL162}
N 4640 32440 4660 32440 {}
C {lab_pin.sym} 4660 32440 0 0 {name=l26039 lab=VDD}
N 4640 32360 4660 32360 {}
C {lab_pin.sym} 4660 32360 0 0 {name=l26040 lab=VSS}
C {bitcell_6t.sym} 4800 32400 0 0 {name=Xr162c24}
N 4760 32440 4740 32440 {}
C {lab_pin.sym} 4740 32440 0 0 {name=l26041 lab=BL24}
N 4760 32400 4740 32400 {}
C {lab_pin.sym} 4740 32400 0 0 {name=l26042 lab=BLB24}
N 4760 32360 4740 32360 {}
C {lab_pin.sym} 4740 32360 0 0 {name=l26043 lab=WL162}
N 4840 32440 4860 32440 {}
C {lab_pin.sym} 4860 32440 0 0 {name=l26044 lab=VDD}
N 4840 32360 4860 32360 {}
C {lab_pin.sym} 4860 32360 0 0 {name=l26045 lab=VSS}
C {bitcell_6t.sym} 5000 32400 0 0 {name=Xr162c25}
N 4960 32440 4940 32440 {}
C {lab_pin.sym} 4940 32440 0 0 {name=l26046 lab=BL25}
N 4960 32400 4940 32400 {}
C {lab_pin.sym} 4940 32400 0 0 {name=l26047 lab=BLB25}
N 4960 32360 4940 32360 {}
C {lab_pin.sym} 4940 32360 0 0 {name=l26048 lab=WL162}
N 5040 32440 5060 32440 {}
C {lab_pin.sym} 5060 32440 0 0 {name=l26049 lab=VDD}
N 5040 32360 5060 32360 {}
C {lab_pin.sym} 5060 32360 0 0 {name=l26050 lab=VSS}
C {bitcell_6t.sym} 5200 32400 0 0 {name=Xr162c26}
N 5160 32440 5140 32440 {}
C {lab_pin.sym} 5140 32440 0 0 {name=l26051 lab=BL26}
N 5160 32400 5140 32400 {}
C {lab_pin.sym} 5140 32400 0 0 {name=l26052 lab=BLB26}
N 5160 32360 5140 32360 {}
C {lab_pin.sym} 5140 32360 0 0 {name=l26053 lab=WL162}
N 5240 32440 5260 32440 {}
C {lab_pin.sym} 5260 32440 0 0 {name=l26054 lab=VDD}
N 5240 32360 5260 32360 {}
C {lab_pin.sym} 5260 32360 0 0 {name=l26055 lab=VSS}
C {bitcell_6t.sym} 5400 32400 0 0 {name=Xr162c27}
N 5360 32440 5340 32440 {}
C {lab_pin.sym} 5340 32440 0 0 {name=l26056 lab=BL27}
N 5360 32400 5340 32400 {}
C {lab_pin.sym} 5340 32400 0 0 {name=l26057 lab=BLB27}
N 5360 32360 5340 32360 {}
C {lab_pin.sym} 5340 32360 0 0 {name=l26058 lab=WL162}
N 5440 32440 5460 32440 {}
C {lab_pin.sym} 5460 32440 0 0 {name=l26059 lab=VDD}
N 5440 32360 5460 32360 {}
C {lab_pin.sym} 5460 32360 0 0 {name=l26060 lab=VSS}
C {bitcell_6t.sym} 5600 32400 0 0 {name=Xr162c28}
N 5560 32440 5540 32440 {}
C {lab_pin.sym} 5540 32440 0 0 {name=l26061 lab=BL28}
N 5560 32400 5540 32400 {}
C {lab_pin.sym} 5540 32400 0 0 {name=l26062 lab=BLB28}
N 5560 32360 5540 32360 {}
C {lab_pin.sym} 5540 32360 0 0 {name=l26063 lab=WL162}
N 5640 32440 5660 32440 {}
C {lab_pin.sym} 5660 32440 0 0 {name=l26064 lab=VDD}
N 5640 32360 5660 32360 {}
C {lab_pin.sym} 5660 32360 0 0 {name=l26065 lab=VSS}
C {bitcell_6t.sym} 5800 32400 0 0 {name=Xr162c29}
N 5760 32440 5740 32440 {}
C {lab_pin.sym} 5740 32440 0 0 {name=l26066 lab=BL29}
N 5760 32400 5740 32400 {}
C {lab_pin.sym} 5740 32400 0 0 {name=l26067 lab=BLB29}
N 5760 32360 5740 32360 {}
C {lab_pin.sym} 5740 32360 0 0 {name=l26068 lab=WL162}
N 5840 32440 5860 32440 {}
C {lab_pin.sym} 5860 32440 0 0 {name=l26069 lab=VDD}
N 5840 32360 5860 32360 {}
C {lab_pin.sym} 5860 32360 0 0 {name=l26070 lab=VSS}
C {bitcell_6t.sym} 6000 32400 0 0 {name=Xr162c30}
N 5960 32440 5940 32440 {}
C {lab_pin.sym} 5940 32440 0 0 {name=l26071 lab=BL30}
N 5960 32400 5940 32400 {}
C {lab_pin.sym} 5940 32400 0 0 {name=l26072 lab=BLB30}
N 5960 32360 5940 32360 {}
C {lab_pin.sym} 5940 32360 0 0 {name=l26073 lab=WL162}
N 6040 32440 6060 32440 {}
C {lab_pin.sym} 6060 32440 0 0 {name=l26074 lab=VDD}
N 6040 32360 6060 32360 {}
C {lab_pin.sym} 6060 32360 0 0 {name=l26075 lab=VSS}
C {bitcell_6t.sym} 6200 32400 0 0 {name=Xr162c31}
N 6160 32440 6140 32440 {}
C {lab_pin.sym} 6140 32440 0 0 {name=l26076 lab=BL31}
N 6160 32400 6140 32400 {}
C {lab_pin.sym} 6140 32400 0 0 {name=l26077 lab=BLB31}
N 6160 32360 6140 32360 {}
C {lab_pin.sym} 6140 32360 0 0 {name=l26078 lab=WL162}
N 6240 32440 6260 32440 {}
C {lab_pin.sym} 6260 32440 0 0 {name=l26079 lab=VDD}
N 6240 32360 6260 32360 {}
C {lab_pin.sym} 6260 32360 0 0 {name=l26080 lab=VSS}
C {bitcell_6t.sym} 0 32600 0 0 {name=Xr163c0}
N -40 32640 -60 32640 {}
C {lab_pin.sym} -60 32640 0 0 {name=l26081 lab=BL0}
N -40 32600 -60 32600 {}
C {lab_pin.sym} -60 32600 0 0 {name=l26082 lab=BLB0}
N -40 32560 -60 32560 {}
C {lab_pin.sym} -60 32560 0 0 {name=l26083 lab=WL163}
N 40 32640 60 32640 {}
C {lab_pin.sym} 60 32640 0 0 {name=l26084 lab=VDD}
N 40 32560 60 32560 {}
C {lab_pin.sym} 60 32560 0 0 {name=l26085 lab=VSS}
C {bitcell_6t.sym} 200 32600 0 0 {name=Xr163c1}
N 160 32640 140 32640 {}
C {lab_pin.sym} 140 32640 0 0 {name=l26086 lab=BL1}
N 160 32600 140 32600 {}
C {lab_pin.sym} 140 32600 0 0 {name=l26087 lab=BLB1}
N 160 32560 140 32560 {}
C {lab_pin.sym} 140 32560 0 0 {name=l26088 lab=WL163}
N 240 32640 260 32640 {}
C {lab_pin.sym} 260 32640 0 0 {name=l26089 lab=VDD}
N 240 32560 260 32560 {}
C {lab_pin.sym} 260 32560 0 0 {name=l26090 lab=VSS}
C {bitcell_6t.sym} 400 32600 0 0 {name=Xr163c2}
N 360 32640 340 32640 {}
C {lab_pin.sym} 340 32640 0 0 {name=l26091 lab=BL2}
N 360 32600 340 32600 {}
C {lab_pin.sym} 340 32600 0 0 {name=l26092 lab=BLB2}
N 360 32560 340 32560 {}
C {lab_pin.sym} 340 32560 0 0 {name=l26093 lab=WL163}
N 440 32640 460 32640 {}
C {lab_pin.sym} 460 32640 0 0 {name=l26094 lab=VDD}
N 440 32560 460 32560 {}
C {lab_pin.sym} 460 32560 0 0 {name=l26095 lab=VSS}
C {bitcell_6t.sym} 600 32600 0 0 {name=Xr163c3}
N 560 32640 540 32640 {}
C {lab_pin.sym} 540 32640 0 0 {name=l26096 lab=BL3}
N 560 32600 540 32600 {}
C {lab_pin.sym} 540 32600 0 0 {name=l26097 lab=BLB3}
N 560 32560 540 32560 {}
C {lab_pin.sym} 540 32560 0 0 {name=l26098 lab=WL163}
N 640 32640 660 32640 {}
C {lab_pin.sym} 660 32640 0 0 {name=l26099 lab=VDD}
N 640 32560 660 32560 {}
C {lab_pin.sym} 660 32560 0 0 {name=l26100 lab=VSS}
C {bitcell_6t.sym} 800 32600 0 0 {name=Xr163c4}
N 760 32640 740 32640 {}
C {lab_pin.sym} 740 32640 0 0 {name=l26101 lab=BL4}
N 760 32600 740 32600 {}
C {lab_pin.sym} 740 32600 0 0 {name=l26102 lab=BLB4}
N 760 32560 740 32560 {}
C {lab_pin.sym} 740 32560 0 0 {name=l26103 lab=WL163}
N 840 32640 860 32640 {}
C {lab_pin.sym} 860 32640 0 0 {name=l26104 lab=VDD}
N 840 32560 860 32560 {}
C {lab_pin.sym} 860 32560 0 0 {name=l26105 lab=VSS}
C {bitcell_6t.sym} 1000 32600 0 0 {name=Xr163c5}
N 960 32640 940 32640 {}
C {lab_pin.sym} 940 32640 0 0 {name=l26106 lab=BL5}
N 960 32600 940 32600 {}
C {lab_pin.sym} 940 32600 0 0 {name=l26107 lab=BLB5}
N 960 32560 940 32560 {}
C {lab_pin.sym} 940 32560 0 0 {name=l26108 lab=WL163}
N 1040 32640 1060 32640 {}
C {lab_pin.sym} 1060 32640 0 0 {name=l26109 lab=VDD}
N 1040 32560 1060 32560 {}
C {lab_pin.sym} 1060 32560 0 0 {name=l26110 lab=VSS}
C {bitcell_6t.sym} 1200 32600 0 0 {name=Xr163c6}
N 1160 32640 1140 32640 {}
C {lab_pin.sym} 1140 32640 0 0 {name=l26111 lab=BL6}
N 1160 32600 1140 32600 {}
C {lab_pin.sym} 1140 32600 0 0 {name=l26112 lab=BLB6}
N 1160 32560 1140 32560 {}
C {lab_pin.sym} 1140 32560 0 0 {name=l26113 lab=WL163}
N 1240 32640 1260 32640 {}
C {lab_pin.sym} 1260 32640 0 0 {name=l26114 lab=VDD}
N 1240 32560 1260 32560 {}
C {lab_pin.sym} 1260 32560 0 0 {name=l26115 lab=VSS}
C {bitcell_6t.sym} 1400 32600 0 0 {name=Xr163c7}
N 1360 32640 1340 32640 {}
C {lab_pin.sym} 1340 32640 0 0 {name=l26116 lab=BL7}
N 1360 32600 1340 32600 {}
C {lab_pin.sym} 1340 32600 0 0 {name=l26117 lab=BLB7}
N 1360 32560 1340 32560 {}
C {lab_pin.sym} 1340 32560 0 0 {name=l26118 lab=WL163}
N 1440 32640 1460 32640 {}
C {lab_pin.sym} 1460 32640 0 0 {name=l26119 lab=VDD}
N 1440 32560 1460 32560 {}
C {lab_pin.sym} 1460 32560 0 0 {name=l26120 lab=VSS}
C {bitcell_6t.sym} 1600 32600 0 0 {name=Xr163c8}
N 1560 32640 1540 32640 {}
C {lab_pin.sym} 1540 32640 0 0 {name=l26121 lab=BL8}
N 1560 32600 1540 32600 {}
C {lab_pin.sym} 1540 32600 0 0 {name=l26122 lab=BLB8}
N 1560 32560 1540 32560 {}
C {lab_pin.sym} 1540 32560 0 0 {name=l26123 lab=WL163}
N 1640 32640 1660 32640 {}
C {lab_pin.sym} 1660 32640 0 0 {name=l26124 lab=VDD}
N 1640 32560 1660 32560 {}
C {lab_pin.sym} 1660 32560 0 0 {name=l26125 lab=VSS}
C {bitcell_6t.sym} 1800 32600 0 0 {name=Xr163c9}
N 1760 32640 1740 32640 {}
C {lab_pin.sym} 1740 32640 0 0 {name=l26126 lab=BL9}
N 1760 32600 1740 32600 {}
C {lab_pin.sym} 1740 32600 0 0 {name=l26127 lab=BLB9}
N 1760 32560 1740 32560 {}
C {lab_pin.sym} 1740 32560 0 0 {name=l26128 lab=WL163}
N 1840 32640 1860 32640 {}
C {lab_pin.sym} 1860 32640 0 0 {name=l26129 lab=VDD}
N 1840 32560 1860 32560 {}
C {lab_pin.sym} 1860 32560 0 0 {name=l26130 lab=VSS}
C {bitcell_6t.sym} 2000 32600 0 0 {name=Xr163c10}
N 1960 32640 1940 32640 {}
C {lab_pin.sym} 1940 32640 0 0 {name=l26131 lab=BL10}
N 1960 32600 1940 32600 {}
C {lab_pin.sym} 1940 32600 0 0 {name=l26132 lab=BLB10}
N 1960 32560 1940 32560 {}
C {lab_pin.sym} 1940 32560 0 0 {name=l26133 lab=WL163}
N 2040 32640 2060 32640 {}
C {lab_pin.sym} 2060 32640 0 0 {name=l26134 lab=VDD}
N 2040 32560 2060 32560 {}
C {lab_pin.sym} 2060 32560 0 0 {name=l26135 lab=VSS}
C {bitcell_6t.sym} 2200 32600 0 0 {name=Xr163c11}
N 2160 32640 2140 32640 {}
C {lab_pin.sym} 2140 32640 0 0 {name=l26136 lab=BL11}
N 2160 32600 2140 32600 {}
C {lab_pin.sym} 2140 32600 0 0 {name=l26137 lab=BLB11}
N 2160 32560 2140 32560 {}
C {lab_pin.sym} 2140 32560 0 0 {name=l26138 lab=WL163}
N 2240 32640 2260 32640 {}
C {lab_pin.sym} 2260 32640 0 0 {name=l26139 lab=VDD}
N 2240 32560 2260 32560 {}
C {lab_pin.sym} 2260 32560 0 0 {name=l26140 lab=VSS}
C {bitcell_6t.sym} 2400 32600 0 0 {name=Xr163c12}
N 2360 32640 2340 32640 {}
C {lab_pin.sym} 2340 32640 0 0 {name=l26141 lab=BL12}
N 2360 32600 2340 32600 {}
C {lab_pin.sym} 2340 32600 0 0 {name=l26142 lab=BLB12}
N 2360 32560 2340 32560 {}
C {lab_pin.sym} 2340 32560 0 0 {name=l26143 lab=WL163}
N 2440 32640 2460 32640 {}
C {lab_pin.sym} 2460 32640 0 0 {name=l26144 lab=VDD}
N 2440 32560 2460 32560 {}
C {lab_pin.sym} 2460 32560 0 0 {name=l26145 lab=VSS}
C {bitcell_6t.sym} 2600 32600 0 0 {name=Xr163c13}
N 2560 32640 2540 32640 {}
C {lab_pin.sym} 2540 32640 0 0 {name=l26146 lab=BL13}
N 2560 32600 2540 32600 {}
C {lab_pin.sym} 2540 32600 0 0 {name=l26147 lab=BLB13}
N 2560 32560 2540 32560 {}
C {lab_pin.sym} 2540 32560 0 0 {name=l26148 lab=WL163}
N 2640 32640 2660 32640 {}
C {lab_pin.sym} 2660 32640 0 0 {name=l26149 lab=VDD}
N 2640 32560 2660 32560 {}
C {lab_pin.sym} 2660 32560 0 0 {name=l26150 lab=VSS}
C {bitcell_6t.sym} 2800 32600 0 0 {name=Xr163c14}
N 2760 32640 2740 32640 {}
C {lab_pin.sym} 2740 32640 0 0 {name=l26151 lab=BL14}
N 2760 32600 2740 32600 {}
C {lab_pin.sym} 2740 32600 0 0 {name=l26152 lab=BLB14}
N 2760 32560 2740 32560 {}
C {lab_pin.sym} 2740 32560 0 0 {name=l26153 lab=WL163}
N 2840 32640 2860 32640 {}
C {lab_pin.sym} 2860 32640 0 0 {name=l26154 lab=VDD}
N 2840 32560 2860 32560 {}
C {lab_pin.sym} 2860 32560 0 0 {name=l26155 lab=VSS}
C {bitcell_6t.sym} 3000 32600 0 0 {name=Xr163c15}
N 2960 32640 2940 32640 {}
C {lab_pin.sym} 2940 32640 0 0 {name=l26156 lab=BL15}
N 2960 32600 2940 32600 {}
C {lab_pin.sym} 2940 32600 0 0 {name=l26157 lab=BLB15}
N 2960 32560 2940 32560 {}
C {lab_pin.sym} 2940 32560 0 0 {name=l26158 lab=WL163}
N 3040 32640 3060 32640 {}
C {lab_pin.sym} 3060 32640 0 0 {name=l26159 lab=VDD}
N 3040 32560 3060 32560 {}
C {lab_pin.sym} 3060 32560 0 0 {name=l26160 lab=VSS}
C {bitcell_6t.sym} 3200 32600 0 0 {name=Xr163c16}
N 3160 32640 3140 32640 {}
C {lab_pin.sym} 3140 32640 0 0 {name=l26161 lab=BL16}
N 3160 32600 3140 32600 {}
C {lab_pin.sym} 3140 32600 0 0 {name=l26162 lab=BLB16}
N 3160 32560 3140 32560 {}
C {lab_pin.sym} 3140 32560 0 0 {name=l26163 lab=WL163}
N 3240 32640 3260 32640 {}
C {lab_pin.sym} 3260 32640 0 0 {name=l26164 lab=VDD}
N 3240 32560 3260 32560 {}
C {lab_pin.sym} 3260 32560 0 0 {name=l26165 lab=VSS}
C {bitcell_6t.sym} 3400 32600 0 0 {name=Xr163c17}
N 3360 32640 3340 32640 {}
C {lab_pin.sym} 3340 32640 0 0 {name=l26166 lab=BL17}
N 3360 32600 3340 32600 {}
C {lab_pin.sym} 3340 32600 0 0 {name=l26167 lab=BLB17}
N 3360 32560 3340 32560 {}
C {lab_pin.sym} 3340 32560 0 0 {name=l26168 lab=WL163}
N 3440 32640 3460 32640 {}
C {lab_pin.sym} 3460 32640 0 0 {name=l26169 lab=VDD}
N 3440 32560 3460 32560 {}
C {lab_pin.sym} 3460 32560 0 0 {name=l26170 lab=VSS}
C {bitcell_6t.sym} 3600 32600 0 0 {name=Xr163c18}
N 3560 32640 3540 32640 {}
C {lab_pin.sym} 3540 32640 0 0 {name=l26171 lab=BL18}
N 3560 32600 3540 32600 {}
C {lab_pin.sym} 3540 32600 0 0 {name=l26172 lab=BLB18}
N 3560 32560 3540 32560 {}
C {lab_pin.sym} 3540 32560 0 0 {name=l26173 lab=WL163}
N 3640 32640 3660 32640 {}
C {lab_pin.sym} 3660 32640 0 0 {name=l26174 lab=VDD}
N 3640 32560 3660 32560 {}
C {lab_pin.sym} 3660 32560 0 0 {name=l26175 lab=VSS}
C {bitcell_6t.sym} 3800 32600 0 0 {name=Xr163c19}
N 3760 32640 3740 32640 {}
C {lab_pin.sym} 3740 32640 0 0 {name=l26176 lab=BL19}
N 3760 32600 3740 32600 {}
C {lab_pin.sym} 3740 32600 0 0 {name=l26177 lab=BLB19}
N 3760 32560 3740 32560 {}
C {lab_pin.sym} 3740 32560 0 0 {name=l26178 lab=WL163}
N 3840 32640 3860 32640 {}
C {lab_pin.sym} 3860 32640 0 0 {name=l26179 lab=VDD}
N 3840 32560 3860 32560 {}
C {lab_pin.sym} 3860 32560 0 0 {name=l26180 lab=VSS}
C {bitcell_6t.sym} 4000 32600 0 0 {name=Xr163c20}
N 3960 32640 3940 32640 {}
C {lab_pin.sym} 3940 32640 0 0 {name=l26181 lab=BL20}
N 3960 32600 3940 32600 {}
C {lab_pin.sym} 3940 32600 0 0 {name=l26182 lab=BLB20}
N 3960 32560 3940 32560 {}
C {lab_pin.sym} 3940 32560 0 0 {name=l26183 lab=WL163}
N 4040 32640 4060 32640 {}
C {lab_pin.sym} 4060 32640 0 0 {name=l26184 lab=VDD}
N 4040 32560 4060 32560 {}
C {lab_pin.sym} 4060 32560 0 0 {name=l26185 lab=VSS}
C {bitcell_6t.sym} 4200 32600 0 0 {name=Xr163c21}
N 4160 32640 4140 32640 {}
C {lab_pin.sym} 4140 32640 0 0 {name=l26186 lab=BL21}
N 4160 32600 4140 32600 {}
C {lab_pin.sym} 4140 32600 0 0 {name=l26187 lab=BLB21}
N 4160 32560 4140 32560 {}
C {lab_pin.sym} 4140 32560 0 0 {name=l26188 lab=WL163}
N 4240 32640 4260 32640 {}
C {lab_pin.sym} 4260 32640 0 0 {name=l26189 lab=VDD}
N 4240 32560 4260 32560 {}
C {lab_pin.sym} 4260 32560 0 0 {name=l26190 lab=VSS}
C {bitcell_6t.sym} 4400 32600 0 0 {name=Xr163c22}
N 4360 32640 4340 32640 {}
C {lab_pin.sym} 4340 32640 0 0 {name=l26191 lab=BL22}
N 4360 32600 4340 32600 {}
C {lab_pin.sym} 4340 32600 0 0 {name=l26192 lab=BLB22}
N 4360 32560 4340 32560 {}
C {lab_pin.sym} 4340 32560 0 0 {name=l26193 lab=WL163}
N 4440 32640 4460 32640 {}
C {lab_pin.sym} 4460 32640 0 0 {name=l26194 lab=VDD}
N 4440 32560 4460 32560 {}
C {lab_pin.sym} 4460 32560 0 0 {name=l26195 lab=VSS}
C {bitcell_6t.sym} 4600 32600 0 0 {name=Xr163c23}
N 4560 32640 4540 32640 {}
C {lab_pin.sym} 4540 32640 0 0 {name=l26196 lab=BL23}
N 4560 32600 4540 32600 {}
C {lab_pin.sym} 4540 32600 0 0 {name=l26197 lab=BLB23}
N 4560 32560 4540 32560 {}
C {lab_pin.sym} 4540 32560 0 0 {name=l26198 lab=WL163}
N 4640 32640 4660 32640 {}
C {lab_pin.sym} 4660 32640 0 0 {name=l26199 lab=VDD}
N 4640 32560 4660 32560 {}
C {lab_pin.sym} 4660 32560 0 0 {name=l26200 lab=VSS}
C {bitcell_6t.sym} 4800 32600 0 0 {name=Xr163c24}
N 4760 32640 4740 32640 {}
C {lab_pin.sym} 4740 32640 0 0 {name=l26201 lab=BL24}
N 4760 32600 4740 32600 {}
C {lab_pin.sym} 4740 32600 0 0 {name=l26202 lab=BLB24}
N 4760 32560 4740 32560 {}
C {lab_pin.sym} 4740 32560 0 0 {name=l26203 lab=WL163}
N 4840 32640 4860 32640 {}
C {lab_pin.sym} 4860 32640 0 0 {name=l26204 lab=VDD}
N 4840 32560 4860 32560 {}
C {lab_pin.sym} 4860 32560 0 0 {name=l26205 lab=VSS}
C {bitcell_6t.sym} 5000 32600 0 0 {name=Xr163c25}
N 4960 32640 4940 32640 {}
C {lab_pin.sym} 4940 32640 0 0 {name=l26206 lab=BL25}
N 4960 32600 4940 32600 {}
C {lab_pin.sym} 4940 32600 0 0 {name=l26207 lab=BLB25}
N 4960 32560 4940 32560 {}
C {lab_pin.sym} 4940 32560 0 0 {name=l26208 lab=WL163}
N 5040 32640 5060 32640 {}
C {lab_pin.sym} 5060 32640 0 0 {name=l26209 lab=VDD}
N 5040 32560 5060 32560 {}
C {lab_pin.sym} 5060 32560 0 0 {name=l26210 lab=VSS}
C {bitcell_6t.sym} 5200 32600 0 0 {name=Xr163c26}
N 5160 32640 5140 32640 {}
C {lab_pin.sym} 5140 32640 0 0 {name=l26211 lab=BL26}
N 5160 32600 5140 32600 {}
C {lab_pin.sym} 5140 32600 0 0 {name=l26212 lab=BLB26}
N 5160 32560 5140 32560 {}
C {lab_pin.sym} 5140 32560 0 0 {name=l26213 lab=WL163}
N 5240 32640 5260 32640 {}
C {lab_pin.sym} 5260 32640 0 0 {name=l26214 lab=VDD}
N 5240 32560 5260 32560 {}
C {lab_pin.sym} 5260 32560 0 0 {name=l26215 lab=VSS}
C {bitcell_6t.sym} 5400 32600 0 0 {name=Xr163c27}
N 5360 32640 5340 32640 {}
C {lab_pin.sym} 5340 32640 0 0 {name=l26216 lab=BL27}
N 5360 32600 5340 32600 {}
C {lab_pin.sym} 5340 32600 0 0 {name=l26217 lab=BLB27}
N 5360 32560 5340 32560 {}
C {lab_pin.sym} 5340 32560 0 0 {name=l26218 lab=WL163}
N 5440 32640 5460 32640 {}
C {lab_pin.sym} 5460 32640 0 0 {name=l26219 lab=VDD}
N 5440 32560 5460 32560 {}
C {lab_pin.sym} 5460 32560 0 0 {name=l26220 lab=VSS}
C {bitcell_6t.sym} 5600 32600 0 0 {name=Xr163c28}
N 5560 32640 5540 32640 {}
C {lab_pin.sym} 5540 32640 0 0 {name=l26221 lab=BL28}
N 5560 32600 5540 32600 {}
C {lab_pin.sym} 5540 32600 0 0 {name=l26222 lab=BLB28}
N 5560 32560 5540 32560 {}
C {lab_pin.sym} 5540 32560 0 0 {name=l26223 lab=WL163}
N 5640 32640 5660 32640 {}
C {lab_pin.sym} 5660 32640 0 0 {name=l26224 lab=VDD}
N 5640 32560 5660 32560 {}
C {lab_pin.sym} 5660 32560 0 0 {name=l26225 lab=VSS}
C {bitcell_6t.sym} 5800 32600 0 0 {name=Xr163c29}
N 5760 32640 5740 32640 {}
C {lab_pin.sym} 5740 32640 0 0 {name=l26226 lab=BL29}
N 5760 32600 5740 32600 {}
C {lab_pin.sym} 5740 32600 0 0 {name=l26227 lab=BLB29}
N 5760 32560 5740 32560 {}
C {lab_pin.sym} 5740 32560 0 0 {name=l26228 lab=WL163}
N 5840 32640 5860 32640 {}
C {lab_pin.sym} 5860 32640 0 0 {name=l26229 lab=VDD}
N 5840 32560 5860 32560 {}
C {lab_pin.sym} 5860 32560 0 0 {name=l26230 lab=VSS}
C {bitcell_6t.sym} 6000 32600 0 0 {name=Xr163c30}
N 5960 32640 5940 32640 {}
C {lab_pin.sym} 5940 32640 0 0 {name=l26231 lab=BL30}
N 5960 32600 5940 32600 {}
C {lab_pin.sym} 5940 32600 0 0 {name=l26232 lab=BLB30}
N 5960 32560 5940 32560 {}
C {lab_pin.sym} 5940 32560 0 0 {name=l26233 lab=WL163}
N 6040 32640 6060 32640 {}
C {lab_pin.sym} 6060 32640 0 0 {name=l26234 lab=VDD}
N 6040 32560 6060 32560 {}
C {lab_pin.sym} 6060 32560 0 0 {name=l26235 lab=VSS}
C {bitcell_6t.sym} 6200 32600 0 0 {name=Xr163c31}
N 6160 32640 6140 32640 {}
C {lab_pin.sym} 6140 32640 0 0 {name=l26236 lab=BL31}
N 6160 32600 6140 32600 {}
C {lab_pin.sym} 6140 32600 0 0 {name=l26237 lab=BLB31}
N 6160 32560 6140 32560 {}
C {lab_pin.sym} 6140 32560 0 0 {name=l26238 lab=WL163}
N 6240 32640 6260 32640 {}
C {lab_pin.sym} 6260 32640 0 0 {name=l26239 lab=VDD}
N 6240 32560 6260 32560 {}
C {lab_pin.sym} 6260 32560 0 0 {name=l26240 lab=VSS}
C {bitcell_6t.sym} 0 32800 0 0 {name=Xr164c0}
N -40 32840 -60 32840 {}
C {lab_pin.sym} -60 32840 0 0 {name=l26241 lab=BL0}
N -40 32800 -60 32800 {}
C {lab_pin.sym} -60 32800 0 0 {name=l26242 lab=BLB0}
N -40 32760 -60 32760 {}
C {lab_pin.sym} -60 32760 0 0 {name=l26243 lab=WL164}
N 40 32840 60 32840 {}
C {lab_pin.sym} 60 32840 0 0 {name=l26244 lab=VDD}
N 40 32760 60 32760 {}
C {lab_pin.sym} 60 32760 0 0 {name=l26245 lab=VSS}
C {bitcell_6t.sym} 200 32800 0 0 {name=Xr164c1}
N 160 32840 140 32840 {}
C {lab_pin.sym} 140 32840 0 0 {name=l26246 lab=BL1}
N 160 32800 140 32800 {}
C {lab_pin.sym} 140 32800 0 0 {name=l26247 lab=BLB1}
N 160 32760 140 32760 {}
C {lab_pin.sym} 140 32760 0 0 {name=l26248 lab=WL164}
N 240 32840 260 32840 {}
C {lab_pin.sym} 260 32840 0 0 {name=l26249 lab=VDD}
N 240 32760 260 32760 {}
C {lab_pin.sym} 260 32760 0 0 {name=l26250 lab=VSS}
C {bitcell_6t.sym} 400 32800 0 0 {name=Xr164c2}
N 360 32840 340 32840 {}
C {lab_pin.sym} 340 32840 0 0 {name=l26251 lab=BL2}
N 360 32800 340 32800 {}
C {lab_pin.sym} 340 32800 0 0 {name=l26252 lab=BLB2}
N 360 32760 340 32760 {}
C {lab_pin.sym} 340 32760 0 0 {name=l26253 lab=WL164}
N 440 32840 460 32840 {}
C {lab_pin.sym} 460 32840 0 0 {name=l26254 lab=VDD}
N 440 32760 460 32760 {}
C {lab_pin.sym} 460 32760 0 0 {name=l26255 lab=VSS}
C {bitcell_6t.sym} 600 32800 0 0 {name=Xr164c3}
N 560 32840 540 32840 {}
C {lab_pin.sym} 540 32840 0 0 {name=l26256 lab=BL3}
N 560 32800 540 32800 {}
C {lab_pin.sym} 540 32800 0 0 {name=l26257 lab=BLB3}
N 560 32760 540 32760 {}
C {lab_pin.sym} 540 32760 0 0 {name=l26258 lab=WL164}
N 640 32840 660 32840 {}
C {lab_pin.sym} 660 32840 0 0 {name=l26259 lab=VDD}
N 640 32760 660 32760 {}
C {lab_pin.sym} 660 32760 0 0 {name=l26260 lab=VSS}
C {bitcell_6t.sym} 800 32800 0 0 {name=Xr164c4}
N 760 32840 740 32840 {}
C {lab_pin.sym} 740 32840 0 0 {name=l26261 lab=BL4}
N 760 32800 740 32800 {}
C {lab_pin.sym} 740 32800 0 0 {name=l26262 lab=BLB4}
N 760 32760 740 32760 {}
C {lab_pin.sym} 740 32760 0 0 {name=l26263 lab=WL164}
N 840 32840 860 32840 {}
C {lab_pin.sym} 860 32840 0 0 {name=l26264 lab=VDD}
N 840 32760 860 32760 {}
C {lab_pin.sym} 860 32760 0 0 {name=l26265 lab=VSS}
C {bitcell_6t.sym} 1000 32800 0 0 {name=Xr164c5}
N 960 32840 940 32840 {}
C {lab_pin.sym} 940 32840 0 0 {name=l26266 lab=BL5}
N 960 32800 940 32800 {}
C {lab_pin.sym} 940 32800 0 0 {name=l26267 lab=BLB5}
N 960 32760 940 32760 {}
C {lab_pin.sym} 940 32760 0 0 {name=l26268 lab=WL164}
N 1040 32840 1060 32840 {}
C {lab_pin.sym} 1060 32840 0 0 {name=l26269 lab=VDD}
N 1040 32760 1060 32760 {}
C {lab_pin.sym} 1060 32760 0 0 {name=l26270 lab=VSS}
C {bitcell_6t.sym} 1200 32800 0 0 {name=Xr164c6}
N 1160 32840 1140 32840 {}
C {lab_pin.sym} 1140 32840 0 0 {name=l26271 lab=BL6}
N 1160 32800 1140 32800 {}
C {lab_pin.sym} 1140 32800 0 0 {name=l26272 lab=BLB6}
N 1160 32760 1140 32760 {}
C {lab_pin.sym} 1140 32760 0 0 {name=l26273 lab=WL164}
N 1240 32840 1260 32840 {}
C {lab_pin.sym} 1260 32840 0 0 {name=l26274 lab=VDD}
N 1240 32760 1260 32760 {}
C {lab_pin.sym} 1260 32760 0 0 {name=l26275 lab=VSS}
C {bitcell_6t.sym} 1400 32800 0 0 {name=Xr164c7}
N 1360 32840 1340 32840 {}
C {lab_pin.sym} 1340 32840 0 0 {name=l26276 lab=BL7}
N 1360 32800 1340 32800 {}
C {lab_pin.sym} 1340 32800 0 0 {name=l26277 lab=BLB7}
N 1360 32760 1340 32760 {}
C {lab_pin.sym} 1340 32760 0 0 {name=l26278 lab=WL164}
N 1440 32840 1460 32840 {}
C {lab_pin.sym} 1460 32840 0 0 {name=l26279 lab=VDD}
N 1440 32760 1460 32760 {}
C {lab_pin.sym} 1460 32760 0 0 {name=l26280 lab=VSS}
C {bitcell_6t.sym} 1600 32800 0 0 {name=Xr164c8}
N 1560 32840 1540 32840 {}
C {lab_pin.sym} 1540 32840 0 0 {name=l26281 lab=BL8}
N 1560 32800 1540 32800 {}
C {lab_pin.sym} 1540 32800 0 0 {name=l26282 lab=BLB8}
N 1560 32760 1540 32760 {}
C {lab_pin.sym} 1540 32760 0 0 {name=l26283 lab=WL164}
N 1640 32840 1660 32840 {}
C {lab_pin.sym} 1660 32840 0 0 {name=l26284 lab=VDD}
N 1640 32760 1660 32760 {}
C {lab_pin.sym} 1660 32760 0 0 {name=l26285 lab=VSS}
C {bitcell_6t.sym} 1800 32800 0 0 {name=Xr164c9}
N 1760 32840 1740 32840 {}
C {lab_pin.sym} 1740 32840 0 0 {name=l26286 lab=BL9}
N 1760 32800 1740 32800 {}
C {lab_pin.sym} 1740 32800 0 0 {name=l26287 lab=BLB9}
N 1760 32760 1740 32760 {}
C {lab_pin.sym} 1740 32760 0 0 {name=l26288 lab=WL164}
N 1840 32840 1860 32840 {}
C {lab_pin.sym} 1860 32840 0 0 {name=l26289 lab=VDD}
N 1840 32760 1860 32760 {}
C {lab_pin.sym} 1860 32760 0 0 {name=l26290 lab=VSS}
C {bitcell_6t.sym} 2000 32800 0 0 {name=Xr164c10}
N 1960 32840 1940 32840 {}
C {lab_pin.sym} 1940 32840 0 0 {name=l26291 lab=BL10}
N 1960 32800 1940 32800 {}
C {lab_pin.sym} 1940 32800 0 0 {name=l26292 lab=BLB10}
N 1960 32760 1940 32760 {}
C {lab_pin.sym} 1940 32760 0 0 {name=l26293 lab=WL164}
N 2040 32840 2060 32840 {}
C {lab_pin.sym} 2060 32840 0 0 {name=l26294 lab=VDD}
N 2040 32760 2060 32760 {}
C {lab_pin.sym} 2060 32760 0 0 {name=l26295 lab=VSS}
C {bitcell_6t.sym} 2200 32800 0 0 {name=Xr164c11}
N 2160 32840 2140 32840 {}
C {lab_pin.sym} 2140 32840 0 0 {name=l26296 lab=BL11}
N 2160 32800 2140 32800 {}
C {lab_pin.sym} 2140 32800 0 0 {name=l26297 lab=BLB11}
N 2160 32760 2140 32760 {}
C {lab_pin.sym} 2140 32760 0 0 {name=l26298 lab=WL164}
N 2240 32840 2260 32840 {}
C {lab_pin.sym} 2260 32840 0 0 {name=l26299 lab=VDD}
N 2240 32760 2260 32760 {}
C {lab_pin.sym} 2260 32760 0 0 {name=l26300 lab=VSS}
C {bitcell_6t.sym} 2400 32800 0 0 {name=Xr164c12}
N 2360 32840 2340 32840 {}
C {lab_pin.sym} 2340 32840 0 0 {name=l26301 lab=BL12}
N 2360 32800 2340 32800 {}
C {lab_pin.sym} 2340 32800 0 0 {name=l26302 lab=BLB12}
N 2360 32760 2340 32760 {}
C {lab_pin.sym} 2340 32760 0 0 {name=l26303 lab=WL164}
N 2440 32840 2460 32840 {}
C {lab_pin.sym} 2460 32840 0 0 {name=l26304 lab=VDD}
N 2440 32760 2460 32760 {}
C {lab_pin.sym} 2460 32760 0 0 {name=l26305 lab=VSS}
C {bitcell_6t.sym} 2600 32800 0 0 {name=Xr164c13}
N 2560 32840 2540 32840 {}
C {lab_pin.sym} 2540 32840 0 0 {name=l26306 lab=BL13}
N 2560 32800 2540 32800 {}
C {lab_pin.sym} 2540 32800 0 0 {name=l26307 lab=BLB13}
N 2560 32760 2540 32760 {}
C {lab_pin.sym} 2540 32760 0 0 {name=l26308 lab=WL164}
N 2640 32840 2660 32840 {}
C {lab_pin.sym} 2660 32840 0 0 {name=l26309 lab=VDD}
N 2640 32760 2660 32760 {}
C {lab_pin.sym} 2660 32760 0 0 {name=l26310 lab=VSS}
C {bitcell_6t.sym} 2800 32800 0 0 {name=Xr164c14}
N 2760 32840 2740 32840 {}
C {lab_pin.sym} 2740 32840 0 0 {name=l26311 lab=BL14}
N 2760 32800 2740 32800 {}
C {lab_pin.sym} 2740 32800 0 0 {name=l26312 lab=BLB14}
N 2760 32760 2740 32760 {}
C {lab_pin.sym} 2740 32760 0 0 {name=l26313 lab=WL164}
N 2840 32840 2860 32840 {}
C {lab_pin.sym} 2860 32840 0 0 {name=l26314 lab=VDD}
N 2840 32760 2860 32760 {}
C {lab_pin.sym} 2860 32760 0 0 {name=l26315 lab=VSS}
C {bitcell_6t.sym} 3000 32800 0 0 {name=Xr164c15}
N 2960 32840 2940 32840 {}
C {lab_pin.sym} 2940 32840 0 0 {name=l26316 lab=BL15}
N 2960 32800 2940 32800 {}
C {lab_pin.sym} 2940 32800 0 0 {name=l26317 lab=BLB15}
N 2960 32760 2940 32760 {}
C {lab_pin.sym} 2940 32760 0 0 {name=l26318 lab=WL164}
N 3040 32840 3060 32840 {}
C {lab_pin.sym} 3060 32840 0 0 {name=l26319 lab=VDD}
N 3040 32760 3060 32760 {}
C {lab_pin.sym} 3060 32760 0 0 {name=l26320 lab=VSS}
C {bitcell_6t.sym} 3200 32800 0 0 {name=Xr164c16}
N 3160 32840 3140 32840 {}
C {lab_pin.sym} 3140 32840 0 0 {name=l26321 lab=BL16}
N 3160 32800 3140 32800 {}
C {lab_pin.sym} 3140 32800 0 0 {name=l26322 lab=BLB16}
N 3160 32760 3140 32760 {}
C {lab_pin.sym} 3140 32760 0 0 {name=l26323 lab=WL164}
N 3240 32840 3260 32840 {}
C {lab_pin.sym} 3260 32840 0 0 {name=l26324 lab=VDD}
N 3240 32760 3260 32760 {}
C {lab_pin.sym} 3260 32760 0 0 {name=l26325 lab=VSS}
C {bitcell_6t.sym} 3400 32800 0 0 {name=Xr164c17}
N 3360 32840 3340 32840 {}
C {lab_pin.sym} 3340 32840 0 0 {name=l26326 lab=BL17}
N 3360 32800 3340 32800 {}
C {lab_pin.sym} 3340 32800 0 0 {name=l26327 lab=BLB17}
N 3360 32760 3340 32760 {}
C {lab_pin.sym} 3340 32760 0 0 {name=l26328 lab=WL164}
N 3440 32840 3460 32840 {}
C {lab_pin.sym} 3460 32840 0 0 {name=l26329 lab=VDD}
N 3440 32760 3460 32760 {}
C {lab_pin.sym} 3460 32760 0 0 {name=l26330 lab=VSS}
C {bitcell_6t.sym} 3600 32800 0 0 {name=Xr164c18}
N 3560 32840 3540 32840 {}
C {lab_pin.sym} 3540 32840 0 0 {name=l26331 lab=BL18}
N 3560 32800 3540 32800 {}
C {lab_pin.sym} 3540 32800 0 0 {name=l26332 lab=BLB18}
N 3560 32760 3540 32760 {}
C {lab_pin.sym} 3540 32760 0 0 {name=l26333 lab=WL164}
N 3640 32840 3660 32840 {}
C {lab_pin.sym} 3660 32840 0 0 {name=l26334 lab=VDD}
N 3640 32760 3660 32760 {}
C {lab_pin.sym} 3660 32760 0 0 {name=l26335 lab=VSS}
C {bitcell_6t.sym} 3800 32800 0 0 {name=Xr164c19}
N 3760 32840 3740 32840 {}
C {lab_pin.sym} 3740 32840 0 0 {name=l26336 lab=BL19}
N 3760 32800 3740 32800 {}
C {lab_pin.sym} 3740 32800 0 0 {name=l26337 lab=BLB19}
N 3760 32760 3740 32760 {}
C {lab_pin.sym} 3740 32760 0 0 {name=l26338 lab=WL164}
N 3840 32840 3860 32840 {}
C {lab_pin.sym} 3860 32840 0 0 {name=l26339 lab=VDD}
N 3840 32760 3860 32760 {}
C {lab_pin.sym} 3860 32760 0 0 {name=l26340 lab=VSS}
C {bitcell_6t.sym} 4000 32800 0 0 {name=Xr164c20}
N 3960 32840 3940 32840 {}
C {lab_pin.sym} 3940 32840 0 0 {name=l26341 lab=BL20}
N 3960 32800 3940 32800 {}
C {lab_pin.sym} 3940 32800 0 0 {name=l26342 lab=BLB20}
N 3960 32760 3940 32760 {}
C {lab_pin.sym} 3940 32760 0 0 {name=l26343 lab=WL164}
N 4040 32840 4060 32840 {}
C {lab_pin.sym} 4060 32840 0 0 {name=l26344 lab=VDD}
N 4040 32760 4060 32760 {}
C {lab_pin.sym} 4060 32760 0 0 {name=l26345 lab=VSS}
C {bitcell_6t.sym} 4200 32800 0 0 {name=Xr164c21}
N 4160 32840 4140 32840 {}
C {lab_pin.sym} 4140 32840 0 0 {name=l26346 lab=BL21}
N 4160 32800 4140 32800 {}
C {lab_pin.sym} 4140 32800 0 0 {name=l26347 lab=BLB21}
N 4160 32760 4140 32760 {}
C {lab_pin.sym} 4140 32760 0 0 {name=l26348 lab=WL164}
N 4240 32840 4260 32840 {}
C {lab_pin.sym} 4260 32840 0 0 {name=l26349 lab=VDD}
N 4240 32760 4260 32760 {}
C {lab_pin.sym} 4260 32760 0 0 {name=l26350 lab=VSS}
C {bitcell_6t.sym} 4400 32800 0 0 {name=Xr164c22}
N 4360 32840 4340 32840 {}
C {lab_pin.sym} 4340 32840 0 0 {name=l26351 lab=BL22}
N 4360 32800 4340 32800 {}
C {lab_pin.sym} 4340 32800 0 0 {name=l26352 lab=BLB22}
N 4360 32760 4340 32760 {}
C {lab_pin.sym} 4340 32760 0 0 {name=l26353 lab=WL164}
N 4440 32840 4460 32840 {}
C {lab_pin.sym} 4460 32840 0 0 {name=l26354 lab=VDD}
N 4440 32760 4460 32760 {}
C {lab_pin.sym} 4460 32760 0 0 {name=l26355 lab=VSS}
C {bitcell_6t.sym} 4600 32800 0 0 {name=Xr164c23}
N 4560 32840 4540 32840 {}
C {lab_pin.sym} 4540 32840 0 0 {name=l26356 lab=BL23}
N 4560 32800 4540 32800 {}
C {lab_pin.sym} 4540 32800 0 0 {name=l26357 lab=BLB23}
N 4560 32760 4540 32760 {}
C {lab_pin.sym} 4540 32760 0 0 {name=l26358 lab=WL164}
N 4640 32840 4660 32840 {}
C {lab_pin.sym} 4660 32840 0 0 {name=l26359 lab=VDD}
N 4640 32760 4660 32760 {}
C {lab_pin.sym} 4660 32760 0 0 {name=l26360 lab=VSS}
C {bitcell_6t.sym} 4800 32800 0 0 {name=Xr164c24}
N 4760 32840 4740 32840 {}
C {lab_pin.sym} 4740 32840 0 0 {name=l26361 lab=BL24}
N 4760 32800 4740 32800 {}
C {lab_pin.sym} 4740 32800 0 0 {name=l26362 lab=BLB24}
N 4760 32760 4740 32760 {}
C {lab_pin.sym} 4740 32760 0 0 {name=l26363 lab=WL164}
N 4840 32840 4860 32840 {}
C {lab_pin.sym} 4860 32840 0 0 {name=l26364 lab=VDD}
N 4840 32760 4860 32760 {}
C {lab_pin.sym} 4860 32760 0 0 {name=l26365 lab=VSS}
C {bitcell_6t.sym} 5000 32800 0 0 {name=Xr164c25}
N 4960 32840 4940 32840 {}
C {lab_pin.sym} 4940 32840 0 0 {name=l26366 lab=BL25}
N 4960 32800 4940 32800 {}
C {lab_pin.sym} 4940 32800 0 0 {name=l26367 lab=BLB25}
N 4960 32760 4940 32760 {}
C {lab_pin.sym} 4940 32760 0 0 {name=l26368 lab=WL164}
N 5040 32840 5060 32840 {}
C {lab_pin.sym} 5060 32840 0 0 {name=l26369 lab=VDD}
N 5040 32760 5060 32760 {}
C {lab_pin.sym} 5060 32760 0 0 {name=l26370 lab=VSS}
C {bitcell_6t.sym} 5200 32800 0 0 {name=Xr164c26}
N 5160 32840 5140 32840 {}
C {lab_pin.sym} 5140 32840 0 0 {name=l26371 lab=BL26}
N 5160 32800 5140 32800 {}
C {lab_pin.sym} 5140 32800 0 0 {name=l26372 lab=BLB26}
N 5160 32760 5140 32760 {}
C {lab_pin.sym} 5140 32760 0 0 {name=l26373 lab=WL164}
N 5240 32840 5260 32840 {}
C {lab_pin.sym} 5260 32840 0 0 {name=l26374 lab=VDD}
N 5240 32760 5260 32760 {}
C {lab_pin.sym} 5260 32760 0 0 {name=l26375 lab=VSS}
C {bitcell_6t.sym} 5400 32800 0 0 {name=Xr164c27}
N 5360 32840 5340 32840 {}
C {lab_pin.sym} 5340 32840 0 0 {name=l26376 lab=BL27}
N 5360 32800 5340 32800 {}
C {lab_pin.sym} 5340 32800 0 0 {name=l26377 lab=BLB27}
N 5360 32760 5340 32760 {}
C {lab_pin.sym} 5340 32760 0 0 {name=l26378 lab=WL164}
N 5440 32840 5460 32840 {}
C {lab_pin.sym} 5460 32840 0 0 {name=l26379 lab=VDD}
N 5440 32760 5460 32760 {}
C {lab_pin.sym} 5460 32760 0 0 {name=l26380 lab=VSS}
C {bitcell_6t.sym} 5600 32800 0 0 {name=Xr164c28}
N 5560 32840 5540 32840 {}
C {lab_pin.sym} 5540 32840 0 0 {name=l26381 lab=BL28}
N 5560 32800 5540 32800 {}
C {lab_pin.sym} 5540 32800 0 0 {name=l26382 lab=BLB28}
N 5560 32760 5540 32760 {}
C {lab_pin.sym} 5540 32760 0 0 {name=l26383 lab=WL164}
N 5640 32840 5660 32840 {}
C {lab_pin.sym} 5660 32840 0 0 {name=l26384 lab=VDD}
N 5640 32760 5660 32760 {}
C {lab_pin.sym} 5660 32760 0 0 {name=l26385 lab=VSS}
C {bitcell_6t.sym} 5800 32800 0 0 {name=Xr164c29}
N 5760 32840 5740 32840 {}
C {lab_pin.sym} 5740 32840 0 0 {name=l26386 lab=BL29}
N 5760 32800 5740 32800 {}
C {lab_pin.sym} 5740 32800 0 0 {name=l26387 lab=BLB29}
N 5760 32760 5740 32760 {}
C {lab_pin.sym} 5740 32760 0 0 {name=l26388 lab=WL164}
N 5840 32840 5860 32840 {}
C {lab_pin.sym} 5860 32840 0 0 {name=l26389 lab=VDD}
N 5840 32760 5860 32760 {}
C {lab_pin.sym} 5860 32760 0 0 {name=l26390 lab=VSS}
C {bitcell_6t.sym} 6000 32800 0 0 {name=Xr164c30}
N 5960 32840 5940 32840 {}
C {lab_pin.sym} 5940 32840 0 0 {name=l26391 lab=BL30}
N 5960 32800 5940 32800 {}
C {lab_pin.sym} 5940 32800 0 0 {name=l26392 lab=BLB30}
N 5960 32760 5940 32760 {}
C {lab_pin.sym} 5940 32760 0 0 {name=l26393 lab=WL164}
N 6040 32840 6060 32840 {}
C {lab_pin.sym} 6060 32840 0 0 {name=l26394 lab=VDD}
N 6040 32760 6060 32760 {}
C {lab_pin.sym} 6060 32760 0 0 {name=l26395 lab=VSS}
C {bitcell_6t.sym} 6200 32800 0 0 {name=Xr164c31}
N 6160 32840 6140 32840 {}
C {lab_pin.sym} 6140 32840 0 0 {name=l26396 lab=BL31}
N 6160 32800 6140 32800 {}
C {lab_pin.sym} 6140 32800 0 0 {name=l26397 lab=BLB31}
N 6160 32760 6140 32760 {}
C {lab_pin.sym} 6140 32760 0 0 {name=l26398 lab=WL164}
N 6240 32840 6260 32840 {}
C {lab_pin.sym} 6260 32840 0 0 {name=l26399 lab=VDD}
N 6240 32760 6260 32760 {}
C {lab_pin.sym} 6260 32760 0 0 {name=l26400 lab=VSS}
C {bitcell_6t.sym} 0 33000 0 0 {name=Xr165c0}
N -40 33040 -60 33040 {}
C {lab_pin.sym} -60 33040 0 0 {name=l26401 lab=BL0}
N -40 33000 -60 33000 {}
C {lab_pin.sym} -60 33000 0 0 {name=l26402 lab=BLB0}
N -40 32960 -60 32960 {}
C {lab_pin.sym} -60 32960 0 0 {name=l26403 lab=WL165}
N 40 33040 60 33040 {}
C {lab_pin.sym} 60 33040 0 0 {name=l26404 lab=VDD}
N 40 32960 60 32960 {}
C {lab_pin.sym} 60 32960 0 0 {name=l26405 lab=VSS}
C {bitcell_6t.sym} 200 33000 0 0 {name=Xr165c1}
N 160 33040 140 33040 {}
C {lab_pin.sym} 140 33040 0 0 {name=l26406 lab=BL1}
N 160 33000 140 33000 {}
C {lab_pin.sym} 140 33000 0 0 {name=l26407 lab=BLB1}
N 160 32960 140 32960 {}
C {lab_pin.sym} 140 32960 0 0 {name=l26408 lab=WL165}
N 240 33040 260 33040 {}
C {lab_pin.sym} 260 33040 0 0 {name=l26409 lab=VDD}
N 240 32960 260 32960 {}
C {lab_pin.sym} 260 32960 0 0 {name=l26410 lab=VSS}
C {bitcell_6t.sym} 400 33000 0 0 {name=Xr165c2}
N 360 33040 340 33040 {}
C {lab_pin.sym} 340 33040 0 0 {name=l26411 lab=BL2}
N 360 33000 340 33000 {}
C {lab_pin.sym} 340 33000 0 0 {name=l26412 lab=BLB2}
N 360 32960 340 32960 {}
C {lab_pin.sym} 340 32960 0 0 {name=l26413 lab=WL165}
N 440 33040 460 33040 {}
C {lab_pin.sym} 460 33040 0 0 {name=l26414 lab=VDD}
N 440 32960 460 32960 {}
C {lab_pin.sym} 460 32960 0 0 {name=l26415 lab=VSS}
C {bitcell_6t.sym} 600 33000 0 0 {name=Xr165c3}
N 560 33040 540 33040 {}
C {lab_pin.sym} 540 33040 0 0 {name=l26416 lab=BL3}
N 560 33000 540 33000 {}
C {lab_pin.sym} 540 33000 0 0 {name=l26417 lab=BLB3}
N 560 32960 540 32960 {}
C {lab_pin.sym} 540 32960 0 0 {name=l26418 lab=WL165}
N 640 33040 660 33040 {}
C {lab_pin.sym} 660 33040 0 0 {name=l26419 lab=VDD}
N 640 32960 660 32960 {}
C {lab_pin.sym} 660 32960 0 0 {name=l26420 lab=VSS}
C {bitcell_6t.sym} 800 33000 0 0 {name=Xr165c4}
N 760 33040 740 33040 {}
C {lab_pin.sym} 740 33040 0 0 {name=l26421 lab=BL4}
N 760 33000 740 33000 {}
C {lab_pin.sym} 740 33000 0 0 {name=l26422 lab=BLB4}
N 760 32960 740 32960 {}
C {lab_pin.sym} 740 32960 0 0 {name=l26423 lab=WL165}
N 840 33040 860 33040 {}
C {lab_pin.sym} 860 33040 0 0 {name=l26424 lab=VDD}
N 840 32960 860 32960 {}
C {lab_pin.sym} 860 32960 0 0 {name=l26425 lab=VSS}
C {bitcell_6t.sym} 1000 33000 0 0 {name=Xr165c5}
N 960 33040 940 33040 {}
C {lab_pin.sym} 940 33040 0 0 {name=l26426 lab=BL5}
N 960 33000 940 33000 {}
C {lab_pin.sym} 940 33000 0 0 {name=l26427 lab=BLB5}
N 960 32960 940 32960 {}
C {lab_pin.sym} 940 32960 0 0 {name=l26428 lab=WL165}
N 1040 33040 1060 33040 {}
C {lab_pin.sym} 1060 33040 0 0 {name=l26429 lab=VDD}
N 1040 32960 1060 32960 {}
C {lab_pin.sym} 1060 32960 0 0 {name=l26430 lab=VSS}
C {bitcell_6t.sym} 1200 33000 0 0 {name=Xr165c6}
N 1160 33040 1140 33040 {}
C {lab_pin.sym} 1140 33040 0 0 {name=l26431 lab=BL6}
N 1160 33000 1140 33000 {}
C {lab_pin.sym} 1140 33000 0 0 {name=l26432 lab=BLB6}
N 1160 32960 1140 32960 {}
C {lab_pin.sym} 1140 32960 0 0 {name=l26433 lab=WL165}
N 1240 33040 1260 33040 {}
C {lab_pin.sym} 1260 33040 0 0 {name=l26434 lab=VDD}
N 1240 32960 1260 32960 {}
C {lab_pin.sym} 1260 32960 0 0 {name=l26435 lab=VSS}
C {bitcell_6t.sym} 1400 33000 0 0 {name=Xr165c7}
N 1360 33040 1340 33040 {}
C {lab_pin.sym} 1340 33040 0 0 {name=l26436 lab=BL7}
N 1360 33000 1340 33000 {}
C {lab_pin.sym} 1340 33000 0 0 {name=l26437 lab=BLB7}
N 1360 32960 1340 32960 {}
C {lab_pin.sym} 1340 32960 0 0 {name=l26438 lab=WL165}
N 1440 33040 1460 33040 {}
C {lab_pin.sym} 1460 33040 0 0 {name=l26439 lab=VDD}
N 1440 32960 1460 32960 {}
C {lab_pin.sym} 1460 32960 0 0 {name=l26440 lab=VSS}
C {bitcell_6t.sym} 1600 33000 0 0 {name=Xr165c8}
N 1560 33040 1540 33040 {}
C {lab_pin.sym} 1540 33040 0 0 {name=l26441 lab=BL8}
N 1560 33000 1540 33000 {}
C {lab_pin.sym} 1540 33000 0 0 {name=l26442 lab=BLB8}
N 1560 32960 1540 32960 {}
C {lab_pin.sym} 1540 32960 0 0 {name=l26443 lab=WL165}
N 1640 33040 1660 33040 {}
C {lab_pin.sym} 1660 33040 0 0 {name=l26444 lab=VDD}
N 1640 32960 1660 32960 {}
C {lab_pin.sym} 1660 32960 0 0 {name=l26445 lab=VSS}
C {bitcell_6t.sym} 1800 33000 0 0 {name=Xr165c9}
N 1760 33040 1740 33040 {}
C {lab_pin.sym} 1740 33040 0 0 {name=l26446 lab=BL9}
N 1760 33000 1740 33000 {}
C {lab_pin.sym} 1740 33000 0 0 {name=l26447 lab=BLB9}
N 1760 32960 1740 32960 {}
C {lab_pin.sym} 1740 32960 0 0 {name=l26448 lab=WL165}
N 1840 33040 1860 33040 {}
C {lab_pin.sym} 1860 33040 0 0 {name=l26449 lab=VDD}
N 1840 32960 1860 32960 {}
C {lab_pin.sym} 1860 32960 0 0 {name=l26450 lab=VSS}
C {bitcell_6t.sym} 2000 33000 0 0 {name=Xr165c10}
N 1960 33040 1940 33040 {}
C {lab_pin.sym} 1940 33040 0 0 {name=l26451 lab=BL10}
N 1960 33000 1940 33000 {}
C {lab_pin.sym} 1940 33000 0 0 {name=l26452 lab=BLB10}
N 1960 32960 1940 32960 {}
C {lab_pin.sym} 1940 32960 0 0 {name=l26453 lab=WL165}
N 2040 33040 2060 33040 {}
C {lab_pin.sym} 2060 33040 0 0 {name=l26454 lab=VDD}
N 2040 32960 2060 32960 {}
C {lab_pin.sym} 2060 32960 0 0 {name=l26455 lab=VSS}
C {bitcell_6t.sym} 2200 33000 0 0 {name=Xr165c11}
N 2160 33040 2140 33040 {}
C {lab_pin.sym} 2140 33040 0 0 {name=l26456 lab=BL11}
N 2160 33000 2140 33000 {}
C {lab_pin.sym} 2140 33000 0 0 {name=l26457 lab=BLB11}
N 2160 32960 2140 32960 {}
C {lab_pin.sym} 2140 32960 0 0 {name=l26458 lab=WL165}
N 2240 33040 2260 33040 {}
C {lab_pin.sym} 2260 33040 0 0 {name=l26459 lab=VDD}
N 2240 32960 2260 32960 {}
C {lab_pin.sym} 2260 32960 0 0 {name=l26460 lab=VSS}
C {bitcell_6t.sym} 2400 33000 0 0 {name=Xr165c12}
N 2360 33040 2340 33040 {}
C {lab_pin.sym} 2340 33040 0 0 {name=l26461 lab=BL12}
N 2360 33000 2340 33000 {}
C {lab_pin.sym} 2340 33000 0 0 {name=l26462 lab=BLB12}
N 2360 32960 2340 32960 {}
C {lab_pin.sym} 2340 32960 0 0 {name=l26463 lab=WL165}
N 2440 33040 2460 33040 {}
C {lab_pin.sym} 2460 33040 0 0 {name=l26464 lab=VDD}
N 2440 32960 2460 32960 {}
C {lab_pin.sym} 2460 32960 0 0 {name=l26465 lab=VSS}
C {bitcell_6t.sym} 2600 33000 0 0 {name=Xr165c13}
N 2560 33040 2540 33040 {}
C {lab_pin.sym} 2540 33040 0 0 {name=l26466 lab=BL13}
N 2560 33000 2540 33000 {}
C {lab_pin.sym} 2540 33000 0 0 {name=l26467 lab=BLB13}
N 2560 32960 2540 32960 {}
C {lab_pin.sym} 2540 32960 0 0 {name=l26468 lab=WL165}
N 2640 33040 2660 33040 {}
C {lab_pin.sym} 2660 33040 0 0 {name=l26469 lab=VDD}
N 2640 32960 2660 32960 {}
C {lab_pin.sym} 2660 32960 0 0 {name=l26470 lab=VSS}
C {bitcell_6t.sym} 2800 33000 0 0 {name=Xr165c14}
N 2760 33040 2740 33040 {}
C {lab_pin.sym} 2740 33040 0 0 {name=l26471 lab=BL14}
N 2760 33000 2740 33000 {}
C {lab_pin.sym} 2740 33000 0 0 {name=l26472 lab=BLB14}
N 2760 32960 2740 32960 {}
C {lab_pin.sym} 2740 32960 0 0 {name=l26473 lab=WL165}
N 2840 33040 2860 33040 {}
C {lab_pin.sym} 2860 33040 0 0 {name=l26474 lab=VDD}
N 2840 32960 2860 32960 {}
C {lab_pin.sym} 2860 32960 0 0 {name=l26475 lab=VSS}
C {bitcell_6t.sym} 3000 33000 0 0 {name=Xr165c15}
N 2960 33040 2940 33040 {}
C {lab_pin.sym} 2940 33040 0 0 {name=l26476 lab=BL15}
N 2960 33000 2940 33000 {}
C {lab_pin.sym} 2940 33000 0 0 {name=l26477 lab=BLB15}
N 2960 32960 2940 32960 {}
C {lab_pin.sym} 2940 32960 0 0 {name=l26478 lab=WL165}
N 3040 33040 3060 33040 {}
C {lab_pin.sym} 3060 33040 0 0 {name=l26479 lab=VDD}
N 3040 32960 3060 32960 {}
C {lab_pin.sym} 3060 32960 0 0 {name=l26480 lab=VSS}
C {bitcell_6t.sym} 3200 33000 0 0 {name=Xr165c16}
N 3160 33040 3140 33040 {}
C {lab_pin.sym} 3140 33040 0 0 {name=l26481 lab=BL16}
N 3160 33000 3140 33000 {}
C {lab_pin.sym} 3140 33000 0 0 {name=l26482 lab=BLB16}
N 3160 32960 3140 32960 {}
C {lab_pin.sym} 3140 32960 0 0 {name=l26483 lab=WL165}
N 3240 33040 3260 33040 {}
C {lab_pin.sym} 3260 33040 0 0 {name=l26484 lab=VDD}
N 3240 32960 3260 32960 {}
C {lab_pin.sym} 3260 32960 0 0 {name=l26485 lab=VSS}
C {bitcell_6t.sym} 3400 33000 0 0 {name=Xr165c17}
N 3360 33040 3340 33040 {}
C {lab_pin.sym} 3340 33040 0 0 {name=l26486 lab=BL17}
N 3360 33000 3340 33000 {}
C {lab_pin.sym} 3340 33000 0 0 {name=l26487 lab=BLB17}
N 3360 32960 3340 32960 {}
C {lab_pin.sym} 3340 32960 0 0 {name=l26488 lab=WL165}
N 3440 33040 3460 33040 {}
C {lab_pin.sym} 3460 33040 0 0 {name=l26489 lab=VDD}
N 3440 32960 3460 32960 {}
C {lab_pin.sym} 3460 32960 0 0 {name=l26490 lab=VSS}
C {bitcell_6t.sym} 3600 33000 0 0 {name=Xr165c18}
N 3560 33040 3540 33040 {}
C {lab_pin.sym} 3540 33040 0 0 {name=l26491 lab=BL18}
N 3560 33000 3540 33000 {}
C {lab_pin.sym} 3540 33000 0 0 {name=l26492 lab=BLB18}
N 3560 32960 3540 32960 {}
C {lab_pin.sym} 3540 32960 0 0 {name=l26493 lab=WL165}
N 3640 33040 3660 33040 {}
C {lab_pin.sym} 3660 33040 0 0 {name=l26494 lab=VDD}
N 3640 32960 3660 32960 {}
C {lab_pin.sym} 3660 32960 0 0 {name=l26495 lab=VSS}
C {bitcell_6t.sym} 3800 33000 0 0 {name=Xr165c19}
N 3760 33040 3740 33040 {}
C {lab_pin.sym} 3740 33040 0 0 {name=l26496 lab=BL19}
N 3760 33000 3740 33000 {}
C {lab_pin.sym} 3740 33000 0 0 {name=l26497 lab=BLB19}
N 3760 32960 3740 32960 {}
C {lab_pin.sym} 3740 32960 0 0 {name=l26498 lab=WL165}
N 3840 33040 3860 33040 {}
C {lab_pin.sym} 3860 33040 0 0 {name=l26499 lab=VDD}
N 3840 32960 3860 32960 {}
C {lab_pin.sym} 3860 32960 0 0 {name=l26500 lab=VSS}
C {bitcell_6t.sym} 4000 33000 0 0 {name=Xr165c20}
N 3960 33040 3940 33040 {}
C {lab_pin.sym} 3940 33040 0 0 {name=l26501 lab=BL20}
N 3960 33000 3940 33000 {}
C {lab_pin.sym} 3940 33000 0 0 {name=l26502 lab=BLB20}
N 3960 32960 3940 32960 {}
C {lab_pin.sym} 3940 32960 0 0 {name=l26503 lab=WL165}
N 4040 33040 4060 33040 {}
C {lab_pin.sym} 4060 33040 0 0 {name=l26504 lab=VDD}
N 4040 32960 4060 32960 {}
C {lab_pin.sym} 4060 32960 0 0 {name=l26505 lab=VSS}
C {bitcell_6t.sym} 4200 33000 0 0 {name=Xr165c21}
N 4160 33040 4140 33040 {}
C {lab_pin.sym} 4140 33040 0 0 {name=l26506 lab=BL21}
N 4160 33000 4140 33000 {}
C {lab_pin.sym} 4140 33000 0 0 {name=l26507 lab=BLB21}
N 4160 32960 4140 32960 {}
C {lab_pin.sym} 4140 32960 0 0 {name=l26508 lab=WL165}
N 4240 33040 4260 33040 {}
C {lab_pin.sym} 4260 33040 0 0 {name=l26509 lab=VDD}
N 4240 32960 4260 32960 {}
C {lab_pin.sym} 4260 32960 0 0 {name=l26510 lab=VSS}
C {bitcell_6t.sym} 4400 33000 0 0 {name=Xr165c22}
N 4360 33040 4340 33040 {}
C {lab_pin.sym} 4340 33040 0 0 {name=l26511 lab=BL22}
N 4360 33000 4340 33000 {}
C {lab_pin.sym} 4340 33000 0 0 {name=l26512 lab=BLB22}
N 4360 32960 4340 32960 {}
C {lab_pin.sym} 4340 32960 0 0 {name=l26513 lab=WL165}
N 4440 33040 4460 33040 {}
C {lab_pin.sym} 4460 33040 0 0 {name=l26514 lab=VDD}
N 4440 32960 4460 32960 {}
C {lab_pin.sym} 4460 32960 0 0 {name=l26515 lab=VSS}
C {bitcell_6t.sym} 4600 33000 0 0 {name=Xr165c23}
N 4560 33040 4540 33040 {}
C {lab_pin.sym} 4540 33040 0 0 {name=l26516 lab=BL23}
N 4560 33000 4540 33000 {}
C {lab_pin.sym} 4540 33000 0 0 {name=l26517 lab=BLB23}
N 4560 32960 4540 32960 {}
C {lab_pin.sym} 4540 32960 0 0 {name=l26518 lab=WL165}
N 4640 33040 4660 33040 {}
C {lab_pin.sym} 4660 33040 0 0 {name=l26519 lab=VDD}
N 4640 32960 4660 32960 {}
C {lab_pin.sym} 4660 32960 0 0 {name=l26520 lab=VSS}
C {bitcell_6t.sym} 4800 33000 0 0 {name=Xr165c24}
N 4760 33040 4740 33040 {}
C {lab_pin.sym} 4740 33040 0 0 {name=l26521 lab=BL24}
N 4760 33000 4740 33000 {}
C {lab_pin.sym} 4740 33000 0 0 {name=l26522 lab=BLB24}
N 4760 32960 4740 32960 {}
C {lab_pin.sym} 4740 32960 0 0 {name=l26523 lab=WL165}
N 4840 33040 4860 33040 {}
C {lab_pin.sym} 4860 33040 0 0 {name=l26524 lab=VDD}
N 4840 32960 4860 32960 {}
C {lab_pin.sym} 4860 32960 0 0 {name=l26525 lab=VSS}
C {bitcell_6t.sym} 5000 33000 0 0 {name=Xr165c25}
N 4960 33040 4940 33040 {}
C {lab_pin.sym} 4940 33040 0 0 {name=l26526 lab=BL25}
N 4960 33000 4940 33000 {}
C {lab_pin.sym} 4940 33000 0 0 {name=l26527 lab=BLB25}
N 4960 32960 4940 32960 {}
C {lab_pin.sym} 4940 32960 0 0 {name=l26528 lab=WL165}
N 5040 33040 5060 33040 {}
C {lab_pin.sym} 5060 33040 0 0 {name=l26529 lab=VDD}
N 5040 32960 5060 32960 {}
C {lab_pin.sym} 5060 32960 0 0 {name=l26530 lab=VSS}
C {bitcell_6t.sym} 5200 33000 0 0 {name=Xr165c26}
N 5160 33040 5140 33040 {}
C {lab_pin.sym} 5140 33040 0 0 {name=l26531 lab=BL26}
N 5160 33000 5140 33000 {}
C {lab_pin.sym} 5140 33000 0 0 {name=l26532 lab=BLB26}
N 5160 32960 5140 32960 {}
C {lab_pin.sym} 5140 32960 0 0 {name=l26533 lab=WL165}
N 5240 33040 5260 33040 {}
C {lab_pin.sym} 5260 33040 0 0 {name=l26534 lab=VDD}
N 5240 32960 5260 32960 {}
C {lab_pin.sym} 5260 32960 0 0 {name=l26535 lab=VSS}
C {bitcell_6t.sym} 5400 33000 0 0 {name=Xr165c27}
N 5360 33040 5340 33040 {}
C {lab_pin.sym} 5340 33040 0 0 {name=l26536 lab=BL27}
N 5360 33000 5340 33000 {}
C {lab_pin.sym} 5340 33000 0 0 {name=l26537 lab=BLB27}
N 5360 32960 5340 32960 {}
C {lab_pin.sym} 5340 32960 0 0 {name=l26538 lab=WL165}
N 5440 33040 5460 33040 {}
C {lab_pin.sym} 5460 33040 0 0 {name=l26539 lab=VDD}
N 5440 32960 5460 32960 {}
C {lab_pin.sym} 5460 32960 0 0 {name=l26540 lab=VSS}
C {bitcell_6t.sym} 5600 33000 0 0 {name=Xr165c28}
N 5560 33040 5540 33040 {}
C {lab_pin.sym} 5540 33040 0 0 {name=l26541 lab=BL28}
N 5560 33000 5540 33000 {}
C {lab_pin.sym} 5540 33000 0 0 {name=l26542 lab=BLB28}
N 5560 32960 5540 32960 {}
C {lab_pin.sym} 5540 32960 0 0 {name=l26543 lab=WL165}
N 5640 33040 5660 33040 {}
C {lab_pin.sym} 5660 33040 0 0 {name=l26544 lab=VDD}
N 5640 32960 5660 32960 {}
C {lab_pin.sym} 5660 32960 0 0 {name=l26545 lab=VSS}
C {bitcell_6t.sym} 5800 33000 0 0 {name=Xr165c29}
N 5760 33040 5740 33040 {}
C {lab_pin.sym} 5740 33040 0 0 {name=l26546 lab=BL29}
N 5760 33000 5740 33000 {}
C {lab_pin.sym} 5740 33000 0 0 {name=l26547 lab=BLB29}
N 5760 32960 5740 32960 {}
C {lab_pin.sym} 5740 32960 0 0 {name=l26548 lab=WL165}
N 5840 33040 5860 33040 {}
C {lab_pin.sym} 5860 33040 0 0 {name=l26549 lab=VDD}
N 5840 32960 5860 32960 {}
C {lab_pin.sym} 5860 32960 0 0 {name=l26550 lab=VSS}
C {bitcell_6t.sym} 6000 33000 0 0 {name=Xr165c30}
N 5960 33040 5940 33040 {}
C {lab_pin.sym} 5940 33040 0 0 {name=l26551 lab=BL30}
N 5960 33000 5940 33000 {}
C {lab_pin.sym} 5940 33000 0 0 {name=l26552 lab=BLB30}
N 5960 32960 5940 32960 {}
C {lab_pin.sym} 5940 32960 0 0 {name=l26553 lab=WL165}
N 6040 33040 6060 33040 {}
C {lab_pin.sym} 6060 33040 0 0 {name=l26554 lab=VDD}
N 6040 32960 6060 32960 {}
C {lab_pin.sym} 6060 32960 0 0 {name=l26555 lab=VSS}
C {bitcell_6t.sym} 6200 33000 0 0 {name=Xr165c31}
N 6160 33040 6140 33040 {}
C {lab_pin.sym} 6140 33040 0 0 {name=l26556 lab=BL31}
N 6160 33000 6140 33000 {}
C {lab_pin.sym} 6140 33000 0 0 {name=l26557 lab=BLB31}
N 6160 32960 6140 32960 {}
C {lab_pin.sym} 6140 32960 0 0 {name=l26558 lab=WL165}
N 6240 33040 6260 33040 {}
C {lab_pin.sym} 6260 33040 0 0 {name=l26559 lab=VDD}
N 6240 32960 6260 32960 {}
C {lab_pin.sym} 6260 32960 0 0 {name=l26560 lab=VSS}
C {bitcell_6t.sym} 0 33200 0 0 {name=Xr166c0}
N -40 33240 -60 33240 {}
C {lab_pin.sym} -60 33240 0 0 {name=l26561 lab=BL0}
N -40 33200 -60 33200 {}
C {lab_pin.sym} -60 33200 0 0 {name=l26562 lab=BLB0}
N -40 33160 -60 33160 {}
C {lab_pin.sym} -60 33160 0 0 {name=l26563 lab=WL166}
N 40 33240 60 33240 {}
C {lab_pin.sym} 60 33240 0 0 {name=l26564 lab=VDD}
N 40 33160 60 33160 {}
C {lab_pin.sym} 60 33160 0 0 {name=l26565 lab=VSS}
C {bitcell_6t.sym} 200 33200 0 0 {name=Xr166c1}
N 160 33240 140 33240 {}
C {lab_pin.sym} 140 33240 0 0 {name=l26566 lab=BL1}
N 160 33200 140 33200 {}
C {lab_pin.sym} 140 33200 0 0 {name=l26567 lab=BLB1}
N 160 33160 140 33160 {}
C {lab_pin.sym} 140 33160 0 0 {name=l26568 lab=WL166}
N 240 33240 260 33240 {}
C {lab_pin.sym} 260 33240 0 0 {name=l26569 lab=VDD}
N 240 33160 260 33160 {}
C {lab_pin.sym} 260 33160 0 0 {name=l26570 lab=VSS}
C {bitcell_6t.sym} 400 33200 0 0 {name=Xr166c2}
N 360 33240 340 33240 {}
C {lab_pin.sym} 340 33240 0 0 {name=l26571 lab=BL2}
N 360 33200 340 33200 {}
C {lab_pin.sym} 340 33200 0 0 {name=l26572 lab=BLB2}
N 360 33160 340 33160 {}
C {lab_pin.sym} 340 33160 0 0 {name=l26573 lab=WL166}
N 440 33240 460 33240 {}
C {lab_pin.sym} 460 33240 0 0 {name=l26574 lab=VDD}
N 440 33160 460 33160 {}
C {lab_pin.sym} 460 33160 0 0 {name=l26575 lab=VSS}
C {bitcell_6t.sym} 600 33200 0 0 {name=Xr166c3}
N 560 33240 540 33240 {}
C {lab_pin.sym} 540 33240 0 0 {name=l26576 lab=BL3}
N 560 33200 540 33200 {}
C {lab_pin.sym} 540 33200 0 0 {name=l26577 lab=BLB3}
N 560 33160 540 33160 {}
C {lab_pin.sym} 540 33160 0 0 {name=l26578 lab=WL166}
N 640 33240 660 33240 {}
C {lab_pin.sym} 660 33240 0 0 {name=l26579 lab=VDD}
N 640 33160 660 33160 {}
C {lab_pin.sym} 660 33160 0 0 {name=l26580 lab=VSS}
C {bitcell_6t.sym} 800 33200 0 0 {name=Xr166c4}
N 760 33240 740 33240 {}
C {lab_pin.sym} 740 33240 0 0 {name=l26581 lab=BL4}
N 760 33200 740 33200 {}
C {lab_pin.sym} 740 33200 0 0 {name=l26582 lab=BLB4}
N 760 33160 740 33160 {}
C {lab_pin.sym} 740 33160 0 0 {name=l26583 lab=WL166}
N 840 33240 860 33240 {}
C {lab_pin.sym} 860 33240 0 0 {name=l26584 lab=VDD}
N 840 33160 860 33160 {}
C {lab_pin.sym} 860 33160 0 0 {name=l26585 lab=VSS}
C {bitcell_6t.sym} 1000 33200 0 0 {name=Xr166c5}
N 960 33240 940 33240 {}
C {lab_pin.sym} 940 33240 0 0 {name=l26586 lab=BL5}
N 960 33200 940 33200 {}
C {lab_pin.sym} 940 33200 0 0 {name=l26587 lab=BLB5}
N 960 33160 940 33160 {}
C {lab_pin.sym} 940 33160 0 0 {name=l26588 lab=WL166}
N 1040 33240 1060 33240 {}
C {lab_pin.sym} 1060 33240 0 0 {name=l26589 lab=VDD}
N 1040 33160 1060 33160 {}
C {lab_pin.sym} 1060 33160 0 0 {name=l26590 lab=VSS}
C {bitcell_6t.sym} 1200 33200 0 0 {name=Xr166c6}
N 1160 33240 1140 33240 {}
C {lab_pin.sym} 1140 33240 0 0 {name=l26591 lab=BL6}
N 1160 33200 1140 33200 {}
C {lab_pin.sym} 1140 33200 0 0 {name=l26592 lab=BLB6}
N 1160 33160 1140 33160 {}
C {lab_pin.sym} 1140 33160 0 0 {name=l26593 lab=WL166}
N 1240 33240 1260 33240 {}
C {lab_pin.sym} 1260 33240 0 0 {name=l26594 lab=VDD}
N 1240 33160 1260 33160 {}
C {lab_pin.sym} 1260 33160 0 0 {name=l26595 lab=VSS}
C {bitcell_6t.sym} 1400 33200 0 0 {name=Xr166c7}
N 1360 33240 1340 33240 {}
C {lab_pin.sym} 1340 33240 0 0 {name=l26596 lab=BL7}
N 1360 33200 1340 33200 {}
C {lab_pin.sym} 1340 33200 0 0 {name=l26597 lab=BLB7}
N 1360 33160 1340 33160 {}
C {lab_pin.sym} 1340 33160 0 0 {name=l26598 lab=WL166}
N 1440 33240 1460 33240 {}
C {lab_pin.sym} 1460 33240 0 0 {name=l26599 lab=VDD}
N 1440 33160 1460 33160 {}
C {lab_pin.sym} 1460 33160 0 0 {name=l26600 lab=VSS}
C {bitcell_6t.sym} 1600 33200 0 0 {name=Xr166c8}
N 1560 33240 1540 33240 {}
C {lab_pin.sym} 1540 33240 0 0 {name=l26601 lab=BL8}
N 1560 33200 1540 33200 {}
C {lab_pin.sym} 1540 33200 0 0 {name=l26602 lab=BLB8}
N 1560 33160 1540 33160 {}
C {lab_pin.sym} 1540 33160 0 0 {name=l26603 lab=WL166}
N 1640 33240 1660 33240 {}
C {lab_pin.sym} 1660 33240 0 0 {name=l26604 lab=VDD}
N 1640 33160 1660 33160 {}
C {lab_pin.sym} 1660 33160 0 0 {name=l26605 lab=VSS}
C {bitcell_6t.sym} 1800 33200 0 0 {name=Xr166c9}
N 1760 33240 1740 33240 {}
C {lab_pin.sym} 1740 33240 0 0 {name=l26606 lab=BL9}
N 1760 33200 1740 33200 {}
C {lab_pin.sym} 1740 33200 0 0 {name=l26607 lab=BLB9}
N 1760 33160 1740 33160 {}
C {lab_pin.sym} 1740 33160 0 0 {name=l26608 lab=WL166}
N 1840 33240 1860 33240 {}
C {lab_pin.sym} 1860 33240 0 0 {name=l26609 lab=VDD}
N 1840 33160 1860 33160 {}
C {lab_pin.sym} 1860 33160 0 0 {name=l26610 lab=VSS}
C {bitcell_6t.sym} 2000 33200 0 0 {name=Xr166c10}
N 1960 33240 1940 33240 {}
C {lab_pin.sym} 1940 33240 0 0 {name=l26611 lab=BL10}
N 1960 33200 1940 33200 {}
C {lab_pin.sym} 1940 33200 0 0 {name=l26612 lab=BLB10}
N 1960 33160 1940 33160 {}
C {lab_pin.sym} 1940 33160 0 0 {name=l26613 lab=WL166}
N 2040 33240 2060 33240 {}
C {lab_pin.sym} 2060 33240 0 0 {name=l26614 lab=VDD}
N 2040 33160 2060 33160 {}
C {lab_pin.sym} 2060 33160 0 0 {name=l26615 lab=VSS}
C {bitcell_6t.sym} 2200 33200 0 0 {name=Xr166c11}
N 2160 33240 2140 33240 {}
C {lab_pin.sym} 2140 33240 0 0 {name=l26616 lab=BL11}
N 2160 33200 2140 33200 {}
C {lab_pin.sym} 2140 33200 0 0 {name=l26617 lab=BLB11}
N 2160 33160 2140 33160 {}
C {lab_pin.sym} 2140 33160 0 0 {name=l26618 lab=WL166}
N 2240 33240 2260 33240 {}
C {lab_pin.sym} 2260 33240 0 0 {name=l26619 lab=VDD}
N 2240 33160 2260 33160 {}
C {lab_pin.sym} 2260 33160 0 0 {name=l26620 lab=VSS}
C {bitcell_6t.sym} 2400 33200 0 0 {name=Xr166c12}
N 2360 33240 2340 33240 {}
C {lab_pin.sym} 2340 33240 0 0 {name=l26621 lab=BL12}
N 2360 33200 2340 33200 {}
C {lab_pin.sym} 2340 33200 0 0 {name=l26622 lab=BLB12}
N 2360 33160 2340 33160 {}
C {lab_pin.sym} 2340 33160 0 0 {name=l26623 lab=WL166}
N 2440 33240 2460 33240 {}
C {lab_pin.sym} 2460 33240 0 0 {name=l26624 lab=VDD}
N 2440 33160 2460 33160 {}
C {lab_pin.sym} 2460 33160 0 0 {name=l26625 lab=VSS}
C {bitcell_6t.sym} 2600 33200 0 0 {name=Xr166c13}
N 2560 33240 2540 33240 {}
C {lab_pin.sym} 2540 33240 0 0 {name=l26626 lab=BL13}
N 2560 33200 2540 33200 {}
C {lab_pin.sym} 2540 33200 0 0 {name=l26627 lab=BLB13}
N 2560 33160 2540 33160 {}
C {lab_pin.sym} 2540 33160 0 0 {name=l26628 lab=WL166}
N 2640 33240 2660 33240 {}
C {lab_pin.sym} 2660 33240 0 0 {name=l26629 lab=VDD}
N 2640 33160 2660 33160 {}
C {lab_pin.sym} 2660 33160 0 0 {name=l26630 lab=VSS}
C {bitcell_6t.sym} 2800 33200 0 0 {name=Xr166c14}
N 2760 33240 2740 33240 {}
C {lab_pin.sym} 2740 33240 0 0 {name=l26631 lab=BL14}
N 2760 33200 2740 33200 {}
C {lab_pin.sym} 2740 33200 0 0 {name=l26632 lab=BLB14}
N 2760 33160 2740 33160 {}
C {lab_pin.sym} 2740 33160 0 0 {name=l26633 lab=WL166}
N 2840 33240 2860 33240 {}
C {lab_pin.sym} 2860 33240 0 0 {name=l26634 lab=VDD}
N 2840 33160 2860 33160 {}
C {lab_pin.sym} 2860 33160 0 0 {name=l26635 lab=VSS}
C {bitcell_6t.sym} 3000 33200 0 0 {name=Xr166c15}
N 2960 33240 2940 33240 {}
C {lab_pin.sym} 2940 33240 0 0 {name=l26636 lab=BL15}
N 2960 33200 2940 33200 {}
C {lab_pin.sym} 2940 33200 0 0 {name=l26637 lab=BLB15}
N 2960 33160 2940 33160 {}
C {lab_pin.sym} 2940 33160 0 0 {name=l26638 lab=WL166}
N 3040 33240 3060 33240 {}
C {lab_pin.sym} 3060 33240 0 0 {name=l26639 lab=VDD}
N 3040 33160 3060 33160 {}
C {lab_pin.sym} 3060 33160 0 0 {name=l26640 lab=VSS}
C {bitcell_6t.sym} 3200 33200 0 0 {name=Xr166c16}
N 3160 33240 3140 33240 {}
C {lab_pin.sym} 3140 33240 0 0 {name=l26641 lab=BL16}
N 3160 33200 3140 33200 {}
C {lab_pin.sym} 3140 33200 0 0 {name=l26642 lab=BLB16}
N 3160 33160 3140 33160 {}
C {lab_pin.sym} 3140 33160 0 0 {name=l26643 lab=WL166}
N 3240 33240 3260 33240 {}
C {lab_pin.sym} 3260 33240 0 0 {name=l26644 lab=VDD}
N 3240 33160 3260 33160 {}
C {lab_pin.sym} 3260 33160 0 0 {name=l26645 lab=VSS}
C {bitcell_6t.sym} 3400 33200 0 0 {name=Xr166c17}
N 3360 33240 3340 33240 {}
C {lab_pin.sym} 3340 33240 0 0 {name=l26646 lab=BL17}
N 3360 33200 3340 33200 {}
C {lab_pin.sym} 3340 33200 0 0 {name=l26647 lab=BLB17}
N 3360 33160 3340 33160 {}
C {lab_pin.sym} 3340 33160 0 0 {name=l26648 lab=WL166}
N 3440 33240 3460 33240 {}
C {lab_pin.sym} 3460 33240 0 0 {name=l26649 lab=VDD}
N 3440 33160 3460 33160 {}
C {lab_pin.sym} 3460 33160 0 0 {name=l26650 lab=VSS}
C {bitcell_6t.sym} 3600 33200 0 0 {name=Xr166c18}
N 3560 33240 3540 33240 {}
C {lab_pin.sym} 3540 33240 0 0 {name=l26651 lab=BL18}
N 3560 33200 3540 33200 {}
C {lab_pin.sym} 3540 33200 0 0 {name=l26652 lab=BLB18}
N 3560 33160 3540 33160 {}
C {lab_pin.sym} 3540 33160 0 0 {name=l26653 lab=WL166}
N 3640 33240 3660 33240 {}
C {lab_pin.sym} 3660 33240 0 0 {name=l26654 lab=VDD}
N 3640 33160 3660 33160 {}
C {lab_pin.sym} 3660 33160 0 0 {name=l26655 lab=VSS}
C {bitcell_6t.sym} 3800 33200 0 0 {name=Xr166c19}
N 3760 33240 3740 33240 {}
C {lab_pin.sym} 3740 33240 0 0 {name=l26656 lab=BL19}
N 3760 33200 3740 33200 {}
C {lab_pin.sym} 3740 33200 0 0 {name=l26657 lab=BLB19}
N 3760 33160 3740 33160 {}
C {lab_pin.sym} 3740 33160 0 0 {name=l26658 lab=WL166}
N 3840 33240 3860 33240 {}
C {lab_pin.sym} 3860 33240 0 0 {name=l26659 lab=VDD}
N 3840 33160 3860 33160 {}
C {lab_pin.sym} 3860 33160 0 0 {name=l26660 lab=VSS}
C {bitcell_6t.sym} 4000 33200 0 0 {name=Xr166c20}
N 3960 33240 3940 33240 {}
C {lab_pin.sym} 3940 33240 0 0 {name=l26661 lab=BL20}
N 3960 33200 3940 33200 {}
C {lab_pin.sym} 3940 33200 0 0 {name=l26662 lab=BLB20}
N 3960 33160 3940 33160 {}
C {lab_pin.sym} 3940 33160 0 0 {name=l26663 lab=WL166}
N 4040 33240 4060 33240 {}
C {lab_pin.sym} 4060 33240 0 0 {name=l26664 lab=VDD}
N 4040 33160 4060 33160 {}
C {lab_pin.sym} 4060 33160 0 0 {name=l26665 lab=VSS}
C {bitcell_6t.sym} 4200 33200 0 0 {name=Xr166c21}
N 4160 33240 4140 33240 {}
C {lab_pin.sym} 4140 33240 0 0 {name=l26666 lab=BL21}
N 4160 33200 4140 33200 {}
C {lab_pin.sym} 4140 33200 0 0 {name=l26667 lab=BLB21}
N 4160 33160 4140 33160 {}
C {lab_pin.sym} 4140 33160 0 0 {name=l26668 lab=WL166}
N 4240 33240 4260 33240 {}
C {lab_pin.sym} 4260 33240 0 0 {name=l26669 lab=VDD}
N 4240 33160 4260 33160 {}
C {lab_pin.sym} 4260 33160 0 0 {name=l26670 lab=VSS}
C {bitcell_6t.sym} 4400 33200 0 0 {name=Xr166c22}
N 4360 33240 4340 33240 {}
C {lab_pin.sym} 4340 33240 0 0 {name=l26671 lab=BL22}
N 4360 33200 4340 33200 {}
C {lab_pin.sym} 4340 33200 0 0 {name=l26672 lab=BLB22}
N 4360 33160 4340 33160 {}
C {lab_pin.sym} 4340 33160 0 0 {name=l26673 lab=WL166}
N 4440 33240 4460 33240 {}
C {lab_pin.sym} 4460 33240 0 0 {name=l26674 lab=VDD}
N 4440 33160 4460 33160 {}
C {lab_pin.sym} 4460 33160 0 0 {name=l26675 lab=VSS}
C {bitcell_6t.sym} 4600 33200 0 0 {name=Xr166c23}
N 4560 33240 4540 33240 {}
C {lab_pin.sym} 4540 33240 0 0 {name=l26676 lab=BL23}
N 4560 33200 4540 33200 {}
C {lab_pin.sym} 4540 33200 0 0 {name=l26677 lab=BLB23}
N 4560 33160 4540 33160 {}
C {lab_pin.sym} 4540 33160 0 0 {name=l26678 lab=WL166}
N 4640 33240 4660 33240 {}
C {lab_pin.sym} 4660 33240 0 0 {name=l26679 lab=VDD}
N 4640 33160 4660 33160 {}
C {lab_pin.sym} 4660 33160 0 0 {name=l26680 lab=VSS}
C {bitcell_6t.sym} 4800 33200 0 0 {name=Xr166c24}
N 4760 33240 4740 33240 {}
C {lab_pin.sym} 4740 33240 0 0 {name=l26681 lab=BL24}
N 4760 33200 4740 33200 {}
C {lab_pin.sym} 4740 33200 0 0 {name=l26682 lab=BLB24}
N 4760 33160 4740 33160 {}
C {lab_pin.sym} 4740 33160 0 0 {name=l26683 lab=WL166}
N 4840 33240 4860 33240 {}
C {lab_pin.sym} 4860 33240 0 0 {name=l26684 lab=VDD}
N 4840 33160 4860 33160 {}
C {lab_pin.sym} 4860 33160 0 0 {name=l26685 lab=VSS}
C {bitcell_6t.sym} 5000 33200 0 0 {name=Xr166c25}
N 4960 33240 4940 33240 {}
C {lab_pin.sym} 4940 33240 0 0 {name=l26686 lab=BL25}
N 4960 33200 4940 33200 {}
C {lab_pin.sym} 4940 33200 0 0 {name=l26687 lab=BLB25}
N 4960 33160 4940 33160 {}
C {lab_pin.sym} 4940 33160 0 0 {name=l26688 lab=WL166}
N 5040 33240 5060 33240 {}
C {lab_pin.sym} 5060 33240 0 0 {name=l26689 lab=VDD}
N 5040 33160 5060 33160 {}
C {lab_pin.sym} 5060 33160 0 0 {name=l26690 lab=VSS}
C {bitcell_6t.sym} 5200 33200 0 0 {name=Xr166c26}
N 5160 33240 5140 33240 {}
C {lab_pin.sym} 5140 33240 0 0 {name=l26691 lab=BL26}
N 5160 33200 5140 33200 {}
C {lab_pin.sym} 5140 33200 0 0 {name=l26692 lab=BLB26}
N 5160 33160 5140 33160 {}
C {lab_pin.sym} 5140 33160 0 0 {name=l26693 lab=WL166}
N 5240 33240 5260 33240 {}
C {lab_pin.sym} 5260 33240 0 0 {name=l26694 lab=VDD}
N 5240 33160 5260 33160 {}
C {lab_pin.sym} 5260 33160 0 0 {name=l26695 lab=VSS}
C {bitcell_6t.sym} 5400 33200 0 0 {name=Xr166c27}
N 5360 33240 5340 33240 {}
C {lab_pin.sym} 5340 33240 0 0 {name=l26696 lab=BL27}
N 5360 33200 5340 33200 {}
C {lab_pin.sym} 5340 33200 0 0 {name=l26697 lab=BLB27}
N 5360 33160 5340 33160 {}
C {lab_pin.sym} 5340 33160 0 0 {name=l26698 lab=WL166}
N 5440 33240 5460 33240 {}
C {lab_pin.sym} 5460 33240 0 0 {name=l26699 lab=VDD}
N 5440 33160 5460 33160 {}
C {lab_pin.sym} 5460 33160 0 0 {name=l26700 lab=VSS}
C {bitcell_6t.sym} 5600 33200 0 0 {name=Xr166c28}
N 5560 33240 5540 33240 {}
C {lab_pin.sym} 5540 33240 0 0 {name=l26701 lab=BL28}
N 5560 33200 5540 33200 {}
C {lab_pin.sym} 5540 33200 0 0 {name=l26702 lab=BLB28}
N 5560 33160 5540 33160 {}
C {lab_pin.sym} 5540 33160 0 0 {name=l26703 lab=WL166}
N 5640 33240 5660 33240 {}
C {lab_pin.sym} 5660 33240 0 0 {name=l26704 lab=VDD}
N 5640 33160 5660 33160 {}
C {lab_pin.sym} 5660 33160 0 0 {name=l26705 lab=VSS}
C {bitcell_6t.sym} 5800 33200 0 0 {name=Xr166c29}
N 5760 33240 5740 33240 {}
C {lab_pin.sym} 5740 33240 0 0 {name=l26706 lab=BL29}
N 5760 33200 5740 33200 {}
C {lab_pin.sym} 5740 33200 0 0 {name=l26707 lab=BLB29}
N 5760 33160 5740 33160 {}
C {lab_pin.sym} 5740 33160 0 0 {name=l26708 lab=WL166}
N 5840 33240 5860 33240 {}
C {lab_pin.sym} 5860 33240 0 0 {name=l26709 lab=VDD}
N 5840 33160 5860 33160 {}
C {lab_pin.sym} 5860 33160 0 0 {name=l26710 lab=VSS}
C {bitcell_6t.sym} 6000 33200 0 0 {name=Xr166c30}
N 5960 33240 5940 33240 {}
C {lab_pin.sym} 5940 33240 0 0 {name=l26711 lab=BL30}
N 5960 33200 5940 33200 {}
C {lab_pin.sym} 5940 33200 0 0 {name=l26712 lab=BLB30}
N 5960 33160 5940 33160 {}
C {lab_pin.sym} 5940 33160 0 0 {name=l26713 lab=WL166}
N 6040 33240 6060 33240 {}
C {lab_pin.sym} 6060 33240 0 0 {name=l26714 lab=VDD}
N 6040 33160 6060 33160 {}
C {lab_pin.sym} 6060 33160 0 0 {name=l26715 lab=VSS}
C {bitcell_6t.sym} 6200 33200 0 0 {name=Xr166c31}
N 6160 33240 6140 33240 {}
C {lab_pin.sym} 6140 33240 0 0 {name=l26716 lab=BL31}
N 6160 33200 6140 33200 {}
C {lab_pin.sym} 6140 33200 0 0 {name=l26717 lab=BLB31}
N 6160 33160 6140 33160 {}
C {lab_pin.sym} 6140 33160 0 0 {name=l26718 lab=WL166}
N 6240 33240 6260 33240 {}
C {lab_pin.sym} 6260 33240 0 0 {name=l26719 lab=VDD}
N 6240 33160 6260 33160 {}
C {lab_pin.sym} 6260 33160 0 0 {name=l26720 lab=VSS}
C {bitcell_6t.sym} 0 33400 0 0 {name=Xr167c0}
N -40 33440 -60 33440 {}
C {lab_pin.sym} -60 33440 0 0 {name=l26721 lab=BL0}
N -40 33400 -60 33400 {}
C {lab_pin.sym} -60 33400 0 0 {name=l26722 lab=BLB0}
N -40 33360 -60 33360 {}
C {lab_pin.sym} -60 33360 0 0 {name=l26723 lab=WL167}
N 40 33440 60 33440 {}
C {lab_pin.sym} 60 33440 0 0 {name=l26724 lab=VDD}
N 40 33360 60 33360 {}
C {lab_pin.sym} 60 33360 0 0 {name=l26725 lab=VSS}
C {bitcell_6t.sym} 200 33400 0 0 {name=Xr167c1}
N 160 33440 140 33440 {}
C {lab_pin.sym} 140 33440 0 0 {name=l26726 lab=BL1}
N 160 33400 140 33400 {}
C {lab_pin.sym} 140 33400 0 0 {name=l26727 lab=BLB1}
N 160 33360 140 33360 {}
C {lab_pin.sym} 140 33360 0 0 {name=l26728 lab=WL167}
N 240 33440 260 33440 {}
C {lab_pin.sym} 260 33440 0 0 {name=l26729 lab=VDD}
N 240 33360 260 33360 {}
C {lab_pin.sym} 260 33360 0 0 {name=l26730 lab=VSS}
C {bitcell_6t.sym} 400 33400 0 0 {name=Xr167c2}
N 360 33440 340 33440 {}
C {lab_pin.sym} 340 33440 0 0 {name=l26731 lab=BL2}
N 360 33400 340 33400 {}
C {lab_pin.sym} 340 33400 0 0 {name=l26732 lab=BLB2}
N 360 33360 340 33360 {}
C {lab_pin.sym} 340 33360 0 0 {name=l26733 lab=WL167}
N 440 33440 460 33440 {}
C {lab_pin.sym} 460 33440 0 0 {name=l26734 lab=VDD}
N 440 33360 460 33360 {}
C {lab_pin.sym} 460 33360 0 0 {name=l26735 lab=VSS}
C {bitcell_6t.sym} 600 33400 0 0 {name=Xr167c3}
N 560 33440 540 33440 {}
C {lab_pin.sym} 540 33440 0 0 {name=l26736 lab=BL3}
N 560 33400 540 33400 {}
C {lab_pin.sym} 540 33400 0 0 {name=l26737 lab=BLB3}
N 560 33360 540 33360 {}
C {lab_pin.sym} 540 33360 0 0 {name=l26738 lab=WL167}
N 640 33440 660 33440 {}
C {lab_pin.sym} 660 33440 0 0 {name=l26739 lab=VDD}
N 640 33360 660 33360 {}
C {lab_pin.sym} 660 33360 0 0 {name=l26740 lab=VSS}
C {bitcell_6t.sym} 800 33400 0 0 {name=Xr167c4}
N 760 33440 740 33440 {}
C {lab_pin.sym} 740 33440 0 0 {name=l26741 lab=BL4}
N 760 33400 740 33400 {}
C {lab_pin.sym} 740 33400 0 0 {name=l26742 lab=BLB4}
N 760 33360 740 33360 {}
C {lab_pin.sym} 740 33360 0 0 {name=l26743 lab=WL167}
N 840 33440 860 33440 {}
C {lab_pin.sym} 860 33440 0 0 {name=l26744 lab=VDD}
N 840 33360 860 33360 {}
C {lab_pin.sym} 860 33360 0 0 {name=l26745 lab=VSS}
C {bitcell_6t.sym} 1000 33400 0 0 {name=Xr167c5}
N 960 33440 940 33440 {}
C {lab_pin.sym} 940 33440 0 0 {name=l26746 lab=BL5}
N 960 33400 940 33400 {}
C {lab_pin.sym} 940 33400 0 0 {name=l26747 lab=BLB5}
N 960 33360 940 33360 {}
C {lab_pin.sym} 940 33360 0 0 {name=l26748 lab=WL167}
N 1040 33440 1060 33440 {}
C {lab_pin.sym} 1060 33440 0 0 {name=l26749 lab=VDD}
N 1040 33360 1060 33360 {}
C {lab_pin.sym} 1060 33360 0 0 {name=l26750 lab=VSS}
C {bitcell_6t.sym} 1200 33400 0 0 {name=Xr167c6}
N 1160 33440 1140 33440 {}
C {lab_pin.sym} 1140 33440 0 0 {name=l26751 lab=BL6}
N 1160 33400 1140 33400 {}
C {lab_pin.sym} 1140 33400 0 0 {name=l26752 lab=BLB6}
N 1160 33360 1140 33360 {}
C {lab_pin.sym} 1140 33360 0 0 {name=l26753 lab=WL167}
N 1240 33440 1260 33440 {}
C {lab_pin.sym} 1260 33440 0 0 {name=l26754 lab=VDD}
N 1240 33360 1260 33360 {}
C {lab_pin.sym} 1260 33360 0 0 {name=l26755 lab=VSS}
C {bitcell_6t.sym} 1400 33400 0 0 {name=Xr167c7}
N 1360 33440 1340 33440 {}
C {lab_pin.sym} 1340 33440 0 0 {name=l26756 lab=BL7}
N 1360 33400 1340 33400 {}
C {lab_pin.sym} 1340 33400 0 0 {name=l26757 lab=BLB7}
N 1360 33360 1340 33360 {}
C {lab_pin.sym} 1340 33360 0 0 {name=l26758 lab=WL167}
N 1440 33440 1460 33440 {}
C {lab_pin.sym} 1460 33440 0 0 {name=l26759 lab=VDD}
N 1440 33360 1460 33360 {}
C {lab_pin.sym} 1460 33360 0 0 {name=l26760 lab=VSS}
C {bitcell_6t.sym} 1600 33400 0 0 {name=Xr167c8}
N 1560 33440 1540 33440 {}
C {lab_pin.sym} 1540 33440 0 0 {name=l26761 lab=BL8}
N 1560 33400 1540 33400 {}
C {lab_pin.sym} 1540 33400 0 0 {name=l26762 lab=BLB8}
N 1560 33360 1540 33360 {}
C {lab_pin.sym} 1540 33360 0 0 {name=l26763 lab=WL167}
N 1640 33440 1660 33440 {}
C {lab_pin.sym} 1660 33440 0 0 {name=l26764 lab=VDD}
N 1640 33360 1660 33360 {}
C {lab_pin.sym} 1660 33360 0 0 {name=l26765 lab=VSS}
C {bitcell_6t.sym} 1800 33400 0 0 {name=Xr167c9}
N 1760 33440 1740 33440 {}
C {lab_pin.sym} 1740 33440 0 0 {name=l26766 lab=BL9}
N 1760 33400 1740 33400 {}
C {lab_pin.sym} 1740 33400 0 0 {name=l26767 lab=BLB9}
N 1760 33360 1740 33360 {}
C {lab_pin.sym} 1740 33360 0 0 {name=l26768 lab=WL167}
N 1840 33440 1860 33440 {}
C {lab_pin.sym} 1860 33440 0 0 {name=l26769 lab=VDD}
N 1840 33360 1860 33360 {}
C {lab_pin.sym} 1860 33360 0 0 {name=l26770 lab=VSS}
C {bitcell_6t.sym} 2000 33400 0 0 {name=Xr167c10}
N 1960 33440 1940 33440 {}
C {lab_pin.sym} 1940 33440 0 0 {name=l26771 lab=BL10}
N 1960 33400 1940 33400 {}
C {lab_pin.sym} 1940 33400 0 0 {name=l26772 lab=BLB10}
N 1960 33360 1940 33360 {}
C {lab_pin.sym} 1940 33360 0 0 {name=l26773 lab=WL167}
N 2040 33440 2060 33440 {}
C {lab_pin.sym} 2060 33440 0 0 {name=l26774 lab=VDD}
N 2040 33360 2060 33360 {}
C {lab_pin.sym} 2060 33360 0 0 {name=l26775 lab=VSS}
C {bitcell_6t.sym} 2200 33400 0 0 {name=Xr167c11}
N 2160 33440 2140 33440 {}
C {lab_pin.sym} 2140 33440 0 0 {name=l26776 lab=BL11}
N 2160 33400 2140 33400 {}
C {lab_pin.sym} 2140 33400 0 0 {name=l26777 lab=BLB11}
N 2160 33360 2140 33360 {}
C {lab_pin.sym} 2140 33360 0 0 {name=l26778 lab=WL167}
N 2240 33440 2260 33440 {}
C {lab_pin.sym} 2260 33440 0 0 {name=l26779 lab=VDD}
N 2240 33360 2260 33360 {}
C {lab_pin.sym} 2260 33360 0 0 {name=l26780 lab=VSS}
C {bitcell_6t.sym} 2400 33400 0 0 {name=Xr167c12}
N 2360 33440 2340 33440 {}
C {lab_pin.sym} 2340 33440 0 0 {name=l26781 lab=BL12}
N 2360 33400 2340 33400 {}
C {lab_pin.sym} 2340 33400 0 0 {name=l26782 lab=BLB12}
N 2360 33360 2340 33360 {}
C {lab_pin.sym} 2340 33360 0 0 {name=l26783 lab=WL167}
N 2440 33440 2460 33440 {}
C {lab_pin.sym} 2460 33440 0 0 {name=l26784 lab=VDD}
N 2440 33360 2460 33360 {}
C {lab_pin.sym} 2460 33360 0 0 {name=l26785 lab=VSS}
C {bitcell_6t.sym} 2600 33400 0 0 {name=Xr167c13}
N 2560 33440 2540 33440 {}
C {lab_pin.sym} 2540 33440 0 0 {name=l26786 lab=BL13}
N 2560 33400 2540 33400 {}
C {lab_pin.sym} 2540 33400 0 0 {name=l26787 lab=BLB13}
N 2560 33360 2540 33360 {}
C {lab_pin.sym} 2540 33360 0 0 {name=l26788 lab=WL167}
N 2640 33440 2660 33440 {}
C {lab_pin.sym} 2660 33440 0 0 {name=l26789 lab=VDD}
N 2640 33360 2660 33360 {}
C {lab_pin.sym} 2660 33360 0 0 {name=l26790 lab=VSS}
C {bitcell_6t.sym} 2800 33400 0 0 {name=Xr167c14}
N 2760 33440 2740 33440 {}
C {lab_pin.sym} 2740 33440 0 0 {name=l26791 lab=BL14}
N 2760 33400 2740 33400 {}
C {lab_pin.sym} 2740 33400 0 0 {name=l26792 lab=BLB14}
N 2760 33360 2740 33360 {}
C {lab_pin.sym} 2740 33360 0 0 {name=l26793 lab=WL167}
N 2840 33440 2860 33440 {}
C {lab_pin.sym} 2860 33440 0 0 {name=l26794 lab=VDD}
N 2840 33360 2860 33360 {}
C {lab_pin.sym} 2860 33360 0 0 {name=l26795 lab=VSS}
C {bitcell_6t.sym} 3000 33400 0 0 {name=Xr167c15}
N 2960 33440 2940 33440 {}
C {lab_pin.sym} 2940 33440 0 0 {name=l26796 lab=BL15}
N 2960 33400 2940 33400 {}
C {lab_pin.sym} 2940 33400 0 0 {name=l26797 lab=BLB15}
N 2960 33360 2940 33360 {}
C {lab_pin.sym} 2940 33360 0 0 {name=l26798 lab=WL167}
N 3040 33440 3060 33440 {}
C {lab_pin.sym} 3060 33440 0 0 {name=l26799 lab=VDD}
N 3040 33360 3060 33360 {}
C {lab_pin.sym} 3060 33360 0 0 {name=l26800 lab=VSS}
C {bitcell_6t.sym} 3200 33400 0 0 {name=Xr167c16}
N 3160 33440 3140 33440 {}
C {lab_pin.sym} 3140 33440 0 0 {name=l26801 lab=BL16}
N 3160 33400 3140 33400 {}
C {lab_pin.sym} 3140 33400 0 0 {name=l26802 lab=BLB16}
N 3160 33360 3140 33360 {}
C {lab_pin.sym} 3140 33360 0 0 {name=l26803 lab=WL167}
N 3240 33440 3260 33440 {}
C {lab_pin.sym} 3260 33440 0 0 {name=l26804 lab=VDD}
N 3240 33360 3260 33360 {}
C {lab_pin.sym} 3260 33360 0 0 {name=l26805 lab=VSS}
C {bitcell_6t.sym} 3400 33400 0 0 {name=Xr167c17}
N 3360 33440 3340 33440 {}
C {lab_pin.sym} 3340 33440 0 0 {name=l26806 lab=BL17}
N 3360 33400 3340 33400 {}
C {lab_pin.sym} 3340 33400 0 0 {name=l26807 lab=BLB17}
N 3360 33360 3340 33360 {}
C {lab_pin.sym} 3340 33360 0 0 {name=l26808 lab=WL167}
N 3440 33440 3460 33440 {}
C {lab_pin.sym} 3460 33440 0 0 {name=l26809 lab=VDD}
N 3440 33360 3460 33360 {}
C {lab_pin.sym} 3460 33360 0 0 {name=l26810 lab=VSS}
C {bitcell_6t.sym} 3600 33400 0 0 {name=Xr167c18}
N 3560 33440 3540 33440 {}
C {lab_pin.sym} 3540 33440 0 0 {name=l26811 lab=BL18}
N 3560 33400 3540 33400 {}
C {lab_pin.sym} 3540 33400 0 0 {name=l26812 lab=BLB18}
N 3560 33360 3540 33360 {}
C {lab_pin.sym} 3540 33360 0 0 {name=l26813 lab=WL167}
N 3640 33440 3660 33440 {}
C {lab_pin.sym} 3660 33440 0 0 {name=l26814 lab=VDD}
N 3640 33360 3660 33360 {}
C {lab_pin.sym} 3660 33360 0 0 {name=l26815 lab=VSS}
C {bitcell_6t.sym} 3800 33400 0 0 {name=Xr167c19}
N 3760 33440 3740 33440 {}
C {lab_pin.sym} 3740 33440 0 0 {name=l26816 lab=BL19}
N 3760 33400 3740 33400 {}
C {lab_pin.sym} 3740 33400 0 0 {name=l26817 lab=BLB19}
N 3760 33360 3740 33360 {}
C {lab_pin.sym} 3740 33360 0 0 {name=l26818 lab=WL167}
N 3840 33440 3860 33440 {}
C {lab_pin.sym} 3860 33440 0 0 {name=l26819 lab=VDD}
N 3840 33360 3860 33360 {}
C {lab_pin.sym} 3860 33360 0 0 {name=l26820 lab=VSS}
C {bitcell_6t.sym} 4000 33400 0 0 {name=Xr167c20}
N 3960 33440 3940 33440 {}
C {lab_pin.sym} 3940 33440 0 0 {name=l26821 lab=BL20}
N 3960 33400 3940 33400 {}
C {lab_pin.sym} 3940 33400 0 0 {name=l26822 lab=BLB20}
N 3960 33360 3940 33360 {}
C {lab_pin.sym} 3940 33360 0 0 {name=l26823 lab=WL167}
N 4040 33440 4060 33440 {}
C {lab_pin.sym} 4060 33440 0 0 {name=l26824 lab=VDD}
N 4040 33360 4060 33360 {}
C {lab_pin.sym} 4060 33360 0 0 {name=l26825 lab=VSS}
C {bitcell_6t.sym} 4200 33400 0 0 {name=Xr167c21}
N 4160 33440 4140 33440 {}
C {lab_pin.sym} 4140 33440 0 0 {name=l26826 lab=BL21}
N 4160 33400 4140 33400 {}
C {lab_pin.sym} 4140 33400 0 0 {name=l26827 lab=BLB21}
N 4160 33360 4140 33360 {}
C {lab_pin.sym} 4140 33360 0 0 {name=l26828 lab=WL167}
N 4240 33440 4260 33440 {}
C {lab_pin.sym} 4260 33440 0 0 {name=l26829 lab=VDD}
N 4240 33360 4260 33360 {}
C {lab_pin.sym} 4260 33360 0 0 {name=l26830 lab=VSS}
C {bitcell_6t.sym} 4400 33400 0 0 {name=Xr167c22}
N 4360 33440 4340 33440 {}
C {lab_pin.sym} 4340 33440 0 0 {name=l26831 lab=BL22}
N 4360 33400 4340 33400 {}
C {lab_pin.sym} 4340 33400 0 0 {name=l26832 lab=BLB22}
N 4360 33360 4340 33360 {}
C {lab_pin.sym} 4340 33360 0 0 {name=l26833 lab=WL167}
N 4440 33440 4460 33440 {}
C {lab_pin.sym} 4460 33440 0 0 {name=l26834 lab=VDD}
N 4440 33360 4460 33360 {}
C {lab_pin.sym} 4460 33360 0 0 {name=l26835 lab=VSS}
C {bitcell_6t.sym} 4600 33400 0 0 {name=Xr167c23}
N 4560 33440 4540 33440 {}
C {lab_pin.sym} 4540 33440 0 0 {name=l26836 lab=BL23}
N 4560 33400 4540 33400 {}
C {lab_pin.sym} 4540 33400 0 0 {name=l26837 lab=BLB23}
N 4560 33360 4540 33360 {}
C {lab_pin.sym} 4540 33360 0 0 {name=l26838 lab=WL167}
N 4640 33440 4660 33440 {}
C {lab_pin.sym} 4660 33440 0 0 {name=l26839 lab=VDD}
N 4640 33360 4660 33360 {}
C {lab_pin.sym} 4660 33360 0 0 {name=l26840 lab=VSS}
C {bitcell_6t.sym} 4800 33400 0 0 {name=Xr167c24}
N 4760 33440 4740 33440 {}
C {lab_pin.sym} 4740 33440 0 0 {name=l26841 lab=BL24}
N 4760 33400 4740 33400 {}
C {lab_pin.sym} 4740 33400 0 0 {name=l26842 lab=BLB24}
N 4760 33360 4740 33360 {}
C {lab_pin.sym} 4740 33360 0 0 {name=l26843 lab=WL167}
N 4840 33440 4860 33440 {}
C {lab_pin.sym} 4860 33440 0 0 {name=l26844 lab=VDD}
N 4840 33360 4860 33360 {}
C {lab_pin.sym} 4860 33360 0 0 {name=l26845 lab=VSS}
C {bitcell_6t.sym} 5000 33400 0 0 {name=Xr167c25}
N 4960 33440 4940 33440 {}
C {lab_pin.sym} 4940 33440 0 0 {name=l26846 lab=BL25}
N 4960 33400 4940 33400 {}
C {lab_pin.sym} 4940 33400 0 0 {name=l26847 lab=BLB25}
N 4960 33360 4940 33360 {}
C {lab_pin.sym} 4940 33360 0 0 {name=l26848 lab=WL167}
N 5040 33440 5060 33440 {}
C {lab_pin.sym} 5060 33440 0 0 {name=l26849 lab=VDD}
N 5040 33360 5060 33360 {}
C {lab_pin.sym} 5060 33360 0 0 {name=l26850 lab=VSS}
C {bitcell_6t.sym} 5200 33400 0 0 {name=Xr167c26}
N 5160 33440 5140 33440 {}
C {lab_pin.sym} 5140 33440 0 0 {name=l26851 lab=BL26}
N 5160 33400 5140 33400 {}
C {lab_pin.sym} 5140 33400 0 0 {name=l26852 lab=BLB26}
N 5160 33360 5140 33360 {}
C {lab_pin.sym} 5140 33360 0 0 {name=l26853 lab=WL167}
N 5240 33440 5260 33440 {}
C {lab_pin.sym} 5260 33440 0 0 {name=l26854 lab=VDD}
N 5240 33360 5260 33360 {}
C {lab_pin.sym} 5260 33360 0 0 {name=l26855 lab=VSS}
C {bitcell_6t.sym} 5400 33400 0 0 {name=Xr167c27}
N 5360 33440 5340 33440 {}
C {lab_pin.sym} 5340 33440 0 0 {name=l26856 lab=BL27}
N 5360 33400 5340 33400 {}
C {lab_pin.sym} 5340 33400 0 0 {name=l26857 lab=BLB27}
N 5360 33360 5340 33360 {}
C {lab_pin.sym} 5340 33360 0 0 {name=l26858 lab=WL167}
N 5440 33440 5460 33440 {}
C {lab_pin.sym} 5460 33440 0 0 {name=l26859 lab=VDD}
N 5440 33360 5460 33360 {}
C {lab_pin.sym} 5460 33360 0 0 {name=l26860 lab=VSS}
C {bitcell_6t.sym} 5600 33400 0 0 {name=Xr167c28}
N 5560 33440 5540 33440 {}
C {lab_pin.sym} 5540 33440 0 0 {name=l26861 lab=BL28}
N 5560 33400 5540 33400 {}
C {lab_pin.sym} 5540 33400 0 0 {name=l26862 lab=BLB28}
N 5560 33360 5540 33360 {}
C {lab_pin.sym} 5540 33360 0 0 {name=l26863 lab=WL167}
N 5640 33440 5660 33440 {}
C {lab_pin.sym} 5660 33440 0 0 {name=l26864 lab=VDD}
N 5640 33360 5660 33360 {}
C {lab_pin.sym} 5660 33360 0 0 {name=l26865 lab=VSS}
C {bitcell_6t.sym} 5800 33400 0 0 {name=Xr167c29}
N 5760 33440 5740 33440 {}
C {lab_pin.sym} 5740 33440 0 0 {name=l26866 lab=BL29}
N 5760 33400 5740 33400 {}
C {lab_pin.sym} 5740 33400 0 0 {name=l26867 lab=BLB29}
N 5760 33360 5740 33360 {}
C {lab_pin.sym} 5740 33360 0 0 {name=l26868 lab=WL167}
N 5840 33440 5860 33440 {}
C {lab_pin.sym} 5860 33440 0 0 {name=l26869 lab=VDD}
N 5840 33360 5860 33360 {}
C {lab_pin.sym} 5860 33360 0 0 {name=l26870 lab=VSS}
C {bitcell_6t.sym} 6000 33400 0 0 {name=Xr167c30}
N 5960 33440 5940 33440 {}
C {lab_pin.sym} 5940 33440 0 0 {name=l26871 lab=BL30}
N 5960 33400 5940 33400 {}
C {lab_pin.sym} 5940 33400 0 0 {name=l26872 lab=BLB30}
N 5960 33360 5940 33360 {}
C {lab_pin.sym} 5940 33360 0 0 {name=l26873 lab=WL167}
N 6040 33440 6060 33440 {}
C {lab_pin.sym} 6060 33440 0 0 {name=l26874 lab=VDD}
N 6040 33360 6060 33360 {}
C {lab_pin.sym} 6060 33360 0 0 {name=l26875 lab=VSS}
C {bitcell_6t.sym} 6200 33400 0 0 {name=Xr167c31}
N 6160 33440 6140 33440 {}
C {lab_pin.sym} 6140 33440 0 0 {name=l26876 lab=BL31}
N 6160 33400 6140 33400 {}
C {lab_pin.sym} 6140 33400 0 0 {name=l26877 lab=BLB31}
N 6160 33360 6140 33360 {}
C {lab_pin.sym} 6140 33360 0 0 {name=l26878 lab=WL167}
N 6240 33440 6260 33440 {}
C {lab_pin.sym} 6260 33440 0 0 {name=l26879 lab=VDD}
N 6240 33360 6260 33360 {}
C {lab_pin.sym} 6260 33360 0 0 {name=l26880 lab=VSS}
C {bitcell_6t.sym} 0 33600 0 0 {name=Xr168c0}
N -40 33640 -60 33640 {}
C {lab_pin.sym} -60 33640 0 0 {name=l26881 lab=BL0}
N -40 33600 -60 33600 {}
C {lab_pin.sym} -60 33600 0 0 {name=l26882 lab=BLB0}
N -40 33560 -60 33560 {}
C {lab_pin.sym} -60 33560 0 0 {name=l26883 lab=WL168}
N 40 33640 60 33640 {}
C {lab_pin.sym} 60 33640 0 0 {name=l26884 lab=VDD}
N 40 33560 60 33560 {}
C {lab_pin.sym} 60 33560 0 0 {name=l26885 lab=VSS}
C {bitcell_6t.sym} 200 33600 0 0 {name=Xr168c1}
N 160 33640 140 33640 {}
C {lab_pin.sym} 140 33640 0 0 {name=l26886 lab=BL1}
N 160 33600 140 33600 {}
C {lab_pin.sym} 140 33600 0 0 {name=l26887 lab=BLB1}
N 160 33560 140 33560 {}
C {lab_pin.sym} 140 33560 0 0 {name=l26888 lab=WL168}
N 240 33640 260 33640 {}
C {lab_pin.sym} 260 33640 0 0 {name=l26889 lab=VDD}
N 240 33560 260 33560 {}
C {lab_pin.sym} 260 33560 0 0 {name=l26890 lab=VSS}
C {bitcell_6t.sym} 400 33600 0 0 {name=Xr168c2}
N 360 33640 340 33640 {}
C {lab_pin.sym} 340 33640 0 0 {name=l26891 lab=BL2}
N 360 33600 340 33600 {}
C {lab_pin.sym} 340 33600 0 0 {name=l26892 lab=BLB2}
N 360 33560 340 33560 {}
C {lab_pin.sym} 340 33560 0 0 {name=l26893 lab=WL168}
N 440 33640 460 33640 {}
C {lab_pin.sym} 460 33640 0 0 {name=l26894 lab=VDD}
N 440 33560 460 33560 {}
C {lab_pin.sym} 460 33560 0 0 {name=l26895 lab=VSS}
C {bitcell_6t.sym} 600 33600 0 0 {name=Xr168c3}
N 560 33640 540 33640 {}
C {lab_pin.sym} 540 33640 0 0 {name=l26896 lab=BL3}
N 560 33600 540 33600 {}
C {lab_pin.sym} 540 33600 0 0 {name=l26897 lab=BLB3}
N 560 33560 540 33560 {}
C {lab_pin.sym} 540 33560 0 0 {name=l26898 lab=WL168}
N 640 33640 660 33640 {}
C {lab_pin.sym} 660 33640 0 0 {name=l26899 lab=VDD}
N 640 33560 660 33560 {}
C {lab_pin.sym} 660 33560 0 0 {name=l26900 lab=VSS}
C {bitcell_6t.sym} 800 33600 0 0 {name=Xr168c4}
N 760 33640 740 33640 {}
C {lab_pin.sym} 740 33640 0 0 {name=l26901 lab=BL4}
N 760 33600 740 33600 {}
C {lab_pin.sym} 740 33600 0 0 {name=l26902 lab=BLB4}
N 760 33560 740 33560 {}
C {lab_pin.sym} 740 33560 0 0 {name=l26903 lab=WL168}
N 840 33640 860 33640 {}
C {lab_pin.sym} 860 33640 0 0 {name=l26904 lab=VDD}
N 840 33560 860 33560 {}
C {lab_pin.sym} 860 33560 0 0 {name=l26905 lab=VSS}
C {bitcell_6t.sym} 1000 33600 0 0 {name=Xr168c5}
N 960 33640 940 33640 {}
C {lab_pin.sym} 940 33640 0 0 {name=l26906 lab=BL5}
N 960 33600 940 33600 {}
C {lab_pin.sym} 940 33600 0 0 {name=l26907 lab=BLB5}
N 960 33560 940 33560 {}
C {lab_pin.sym} 940 33560 0 0 {name=l26908 lab=WL168}
N 1040 33640 1060 33640 {}
C {lab_pin.sym} 1060 33640 0 0 {name=l26909 lab=VDD}
N 1040 33560 1060 33560 {}
C {lab_pin.sym} 1060 33560 0 0 {name=l26910 lab=VSS}
C {bitcell_6t.sym} 1200 33600 0 0 {name=Xr168c6}
N 1160 33640 1140 33640 {}
C {lab_pin.sym} 1140 33640 0 0 {name=l26911 lab=BL6}
N 1160 33600 1140 33600 {}
C {lab_pin.sym} 1140 33600 0 0 {name=l26912 lab=BLB6}
N 1160 33560 1140 33560 {}
C {lab_pin.sym} 1140 33560 0 0 {name=l26913 lab=WL168}
N 1240 33640 1260 33640 {}
C {lab_pin.sym} 1260 33640 0 0 {name=l26914 lab=VDD}
N 1240 33560 1260 33560 {}
C {lab_pin.sym} 1260 33560 0 0 {name=l26915 lab=VSS}
C {bitcell_6t.sym} 1400 33600 0 0 {name=Xr168c7}
N 1360 33640 1340 33640 {}
C {lab_pin.sym} 1340 33640 0 0 {name=l26916 lab=BL7}
N 1360 33600 1340 33600 {}
C {lab_pin.sym} 1340 33600 0 0 {name=l26917 lab=BLB7}
N 1360 33560 1340 33560 {}
C {lab_pin.sym} 1340 33560 0 0 {name=l26918 lab=WL168}
N 1440 33640 1460 33640 {}
C {lab_pin.sym} 1460 33640 0 0 {name=l26919 lab=VDD}
N 1440 33560 1460 33560 {}
C {lab_pin.sym} 1460 33560 0 0 {name=l26920 lab=VSS}
C {bitcell_6t.sym} 1600 33600 0 0 {name=Xr168c8}
N 1560 33640 1540 33640 {}
C {lab_pin.sym} 1540 33640 0 0 {name=l26921 lab=BL8}
N 1560 33600 1540 33600 {}
C {lab_pin.sym} 1540 33600 0 0 {name=l26922 lab=BLB8}
N 1560 33560 1540 33560 {}
C {lab_pin.sym} 1540 33560 0 0 {name=l26923 lab=WL168}
N 1640 33640 1660 33640 {}
C {lab_pin.sym} 1660 33640 0 0 {name=l26924 lab=VDD}
N 1640 33560 1660 33560 {}
C {lab_pin.sym} 1660 33560 0 0 {name=l26925 lab=VSS}
C {bitcell_6t.sym} 1800 33600 0 0 {name=Xr168c9}
N 1760 33640 1740 33640 {}
C {lab_pin.sym} 1740 33640 0 0 {name=l26926 lab=BL9}
N 1760 33600 1740 33600 {}
C {lab_pin.sym} 1740 33600 0 0 {name=l26927 lab=BLB9}
N 1760 33560 1740 33560 {}
C {lab_pin.sym} 1740 33560 0 0 {name=l26928 lab=WL168}
N 1840 33640 1860 33640 {}
C {lab_pin.sym} 1860 33640 0 0 {name=l26929 lab=VDD}
N 1840 33560 1860 33560 {}
C {lab_pin.sym} 1860 33560 0 0 {name=l26930 lab=VSS}
C {bitcell_6t.sym} 2000 33600 0 0 {name=Xr168c10}
N 1960 33640 1940 33640 {}
C {lab_pin.sym} 1940 33640 0 0 {name=l26931 lab=BL10}
N 1960 33600 1940 33600 {}
C {lab_pin.sym} 1940 33600 0 0 {name=l26932 lab=BLB10}
N 1960 33560 1940 33560 {}
C {lab_pin.sym} 1940 33560 0 0 {name=l26933 lab=WL168}
N 2040 33640 2060 33640 {}
C {lab_pin.sym} 2060 33640 0 0 {name=l26934 lab=VDD}
N 2040 33560 2060 33560 {}
C {lab_pin.sym} 2060 33560 0 0 {name=l26935 lab=VSS}
C {bitcell_6t.sym} 2200 33600 0 0 {name=Xr168c11}
N 2160 33640 2140 33640 {}
C {lab_pin.sym} 2140 33640 0 0 {name=l26936 lab=BL11}
N 2160 33600 2140 33600 {}
C {lab_pin.sym} 2140 33600 0 0 {name=l26937 lab=BLB11}
N 2160 33560 2140 33560 {}
C {lab_pin.sym} 2140 33560 0 0 {name=l26938 lab=WL168}
N 2240 33640 2260 33640 {}
C {lab_pin.sym} 2260 33640 0 0 {name=l26939 lab=VDD}
N 2240 33560 2260 33560 {}
C {lab_pin.sym} 2260 33560 0 0 {name=l26940 lab=VSS}
C {bitcell_6t.sym} 2400 33600 0 0 {name=Xr168c12}
N 2360 33640 2340 33640 {}
C {lab_pin.sym} 2340 33640 0 0 {name=l26941 lab=BL12}
N 2360 33600 2340 33600 {}
C {lab_pin.sym} 2340 33600 0 0 {name=l26942 lab=BLB12}
N 2360 33560 2340 33560 {}
C {lab_pin.sym} 2340 33560 0 0 {name=l26943 lab=WL168}
N 2440 33640 2460 33640 {}
C {lab_pin.sym} 2460 33640 0 0 {name=l26944 lab=VDD}
N 2440 33560 2460 33560 {}
C {lab_pin.sym} 2460 33560 0 0 {name=l26945 lab=VSS}
C {bitcell_6t.sym} 2600 33600 0 0 {name=Xr168c13}
N 2560 33640 2540 33640 {}
C {lab_pin.sym} 2540 33640 0 0 {name=l26946 lab=BL13}
N 2560 33600 2540 33600 {}
C {lab_pin.sym} 2540 33600 0 0 {name=l26947 lab=BLB13}
N 2560 33560 2540 33560 {}
C {lab_pin.sym} 2540 33560 0 0 {name=l26948 lab=WL168}
N 2640 33640 2660 33640 {}
C {lab_pin.sym} 2660 33640 0 0 {name=l26949 lab=VDD}
N 2640 33560 2660 33560 {}
C {lab_pin.sym} 2660 33560 0 0 {name=l26950 lab=VSS}
C {bitcell_6t.sym} 2800 33600 0 0 {name=Xr168c14}
N 2760 33640 2740 33640 {}
C {lab_pin.sym} 2740 33640 0 0 {name=l26951 lab=BL14}
N 2760 33600 2740 33600 {}
C {lab_pin.sym} 2740 33600 0 0 {name=l26952 lab=BLB14}
N 2760 33560 2740 33560 {}
C {lab_pin.sym} 2740 33560 0 0 {name=l26953 lab=WL168}
N 2840 33640 2860 33640 {}
C {lab_pin.sym} 2860 33640 0 0 {name=l26954 lab=VDD}
N 2840 33560 2860 33560 {}
C {lab_pin.sym} 2860 33560 0 0 {name=l26955 lab=VSS}
C {bitcell_6t.sym} 3000 33600 0 0 {name=Xr168c15}
N 2960 33640 2940 33640 {}
C {lab_pin.sym} 2940 33640 0 0 {name=l26956 lab=BL15}
N 2960 33600 2940 33600 {}
C {lab_pin.sym} 2940 33600 0 0 {name=l26957 lab=BLB15}
N 2960 33560 2940 33560 {}
C {lab_pin.sym} 2940 33560 0 0 {name=l26958 lab=WL168}
N 3040 33640 3060 33640 {}
C {lab_pin.sym} 3060 33640 0 0 {name=l26959 lab=VDD}
N 3040 33560 3060 33560 {}
C {lab_pin.sym} 3060 33560 0 0 {name=l26960 lab=VSS}
C {bitcell_6t.sym} 3200 33600 0 0 {name=Xr168c16}
N 3160 33640 3140 33640 {}
C {lab_pin.sym} 3140 33640 0 0 {name=l26961 lab=BL16}
N 3160 33600 3140 33600 {}
C {lab_pin.sym} 3140 33600 0 0 {name=l26962 lab=BLB16}
N 3160 33560 3140 33560 {}
C {lab_pin.sym} 3140 33560 0 0 {name=l26963 lab=WL168}
N 3240 33640 3260 33640 {}
C {lab_pin.sym} 3260 33640 0 0 {name=l26964 lab=VDD}
N 3240 33560 3260 33560 {}
C {lab_pin.sym} 3260 33560 0 0 {name=l26965 lab=VSS}
C {bitcell_6t.sym} 3400 33600 0 0 {name=Xr168c17}
N 3360 33640 3340 33640 {}
C {lab_pin.sym} 3340 33640 0 0 {name=l26966 lab=BL17}
N 3360 33600 3340 33600 {}
C {lab_pin.sym} 3340 33600 0 0 {name=l26967 lab=BLB17}
N 3360 33560 3340 33560 {}
C {lab_pin.sym} 3340 33560 0 0 {name=l26968 lab=WL168}
N 3440 33640 3460 33640 {}
C {lab_pin.sym} 3460 33640 0 0 {name=l26969 lab=VDD}
N 3440 33560 3460 33560 {}
C {lab_pin.sym} 3460 33560 0 0 {name=l26970 lab=VSS}
C {bitcell_6t.sym} 3600 33600 0 0 {name=Xr168c18}
N 3560 33640 3540 33640 {}
C {lab_pin.sym} 3540 33640 0 0 {name=l26971 lab=BL18}
N 3560 33600 3540 33600 {}
C {lab_pin.sym} 3540 33600 0 0 {name=l26972 lab=BLB18}
N 3560 33560 3540 33560 {}
C {lab_pin.sym} 3540 33560 0 0 {name=l26973 lab=WL168}
N 3640 33640 3660 33640 {}
C {lab_pin.sym} 3660 33640 0 0 {name=l26974 lab=VDD}
N 3640 33560 3660 33560 {}
C {lab_pin.sym} 3660 33560 0 0 {name=l26975 lab=VSS}
C {bitcell_6t.sym} 3800 33600 0 0 {name=Xr168c19}
N 3760 33640 3740 33640 {}
C {lab_pin.sym} 3740 33640 0 0 {name=l26976 lab=BL19}
N 3760 33600 3740 33600 {}
C {lab_pin.sym} 3740 33600 0 0 {name=l26977 lab=BLB19}
N 3760 33560 3740 33560 {}
C {lab_pin.sym} 3740 33560 0 0 {name=l26978 lab=WL168}
N 3840 33640 3860 33640 {}
C {lab_pin.sym} 3860 33640 0 0 {name=l26979 lab=VDD}
N 3840 33560 3860 33560 {}
C {lab_pin.sym} 3860 33560 0 0 {name=l26980 lab=VSS}
C {bitcell_6t.sym} 4000 33600 0 0 {name=Xr168c20}
N 3960 33640 3940 33640 {}
C {lab_pin.sym} 3940 33640 0 0 {name=l26981 lab=BL20}
N 3960 33600 3940 33600 {}
C {lab_pin.sym} 3940 33600 0 0 {name=l26982 lab=BLB20}
N 3960 33560 3940 33560 {}
C {lab_pin.sym} 3940 33560 0 0 {name=l26983 lab=WL168}
N 4040 33640 4060 33640 {}
C {lab_pin.sym} 4060 33640 0 0 {name=l26984 lab=VDD}
N 4040 33560 4060 33560 {}
C {lab_pin.sym} 4060 33560 0 0 {name=l26985 lab=VSS}
C {bitcell_6t.sym} 4200 33600 0 0 {name=Xr168c21}
N 4160 33640 4140 33640 {}
C {lab_pin.sym} 4140 33640 0 0 {name=l26986 lab=BL21}
N 4160 33600 4140 33600 {}
C {lab_pin.sym} 4140 33600 0 0 {name=l26987 lab=BLB21}
N 4160 33560 4140 33560 {}
C {lab_pin.sym} 4140 33560 0 0 {name=l26988 lab=WL168}
N 4240 33640 4260 33640 {}
C {lab_pin.sym} 4260 33640 0 0 {name=l26989 lab=VDD}
N 4240 33560 4260 33560 {}
C {lab_pin.sym} 4260 33560 0 0 {name=l26990 lab=VSS}
C {bitcell_6t.sym} 4400 33600 0 0 {name=Xr168c22}
N 4360 33640 4340 33640 {}
C {lab_pin.sym} 4340 33640 0 0 {name=l26991 lab=BL22}
N 4360 33600 4340 33600 {}
C {lab_pin.sym} 4340 33600 0 0 {name=l26992 lab=BLB22}
N 4360 33560 4340 33560 {}
C {lab_pin.sym} 4340 33560 0 0 {name=l26993 lab=WL168}
N 4440 33640 4460 33640 {}
C {lab_pin.sym} 4460 33640 0 0 {name=l26994 lab=VDD}
N 4440 33560 4460 33560 {}
C {lab_pin.sym} 4460 33560 0 0 {name=l26995 lab=VSS}
C {bitcell_6t.sym} 4600 33600 0 0 {name=Xr168c23}
N 4560 33640 4540 33640 {}
C {lab_pin.sym} 4540 33640 0 0 {name=l26996 lab=BL23}
N 4560 33600 4540 33600 {}
C {lab_pin.sym} 4540 33600 0 0 {name=l26997 lab=BLB23}
N 4560 33560 4540 33560 {}
C {lab_pin.sym} 4540 33560 0 0 {name=l26998 lab=WL168}
N 4640 33640 4660 33640 {}
C {lab_pin.sym} 4660 33640 0 0 {name=l26999 lab=VDD}
N 4640 33560 4660 33560 {}
C {lab_pin.sym} 4660 33560 0 0 {name=l27000 lab=VSS}
C {bitcell_6t.sym} 4800 33600 0 0 {name=Xr168c24}
N 4760 33640 4740 33640 {}
C {lab_pin.sym} 4740 33640 0 0 {name=l27001 lab=BL24}
N 4760 33600 4740 33600 {}
C {lab_pin.sym} 4740 33600 0 0 {name=l27002 lab=BLB24}
N 4760 33560 4740 33560 {}
C {lab_pin.sym} 4740 33560 0 0 {name=l27003 lab=WL168}
N 4840 33640 4860 33640 {}
C {lab_pin.sym} 4860 33640 0 0 {name=l27004 lab=VDD}
N 4840 33560 4860 33560 {}
C {lab_pin.sym} 4860 33560 0 0 {name=l27005 lab=VSS}
C {bitcell_6t.sym} 5000 33600 0 0 {name=Xr168c25}
N 4960 33640 4940 33640 {}
C {lab_pin.sym} 4940 33640 0 0 {name=l27006 lab=BL25}
N 4960 33600 4940 33600 {}
C {lab_pin.sym} 4940 33600 0 0 {name=l27007 lab=BLB25}
N 4960 33560 4940 33560 {}
C {lab_pin.sym} 4940 33560 0 0 {name=l27008 lab=WL168}
N 5040 33640 5060 33640 {}
C {lab_pin.sym} 5060 33640 0 0 {name=l27009 lab=VDD}
N 5040 33560 5060 33560 {}
C {lab_pin.sym} 5060 33560 0 0 {name=l27010 lab=VSS}
C {bitcell_6t.sym} 5200 33600 0 0 {name=Xr168c26}
N 5160 33640 5140 33640 {}
C {lab_pin.sym} 5140 33640 0 0 {name=l27011 lab=BL26}
N 5160 33600 5140 33600 {}
C {lab_pin.sym} 5140 33600 0 0 {name=l27012 lab=BLB26}
N 5160 33560 5140 33560 {}
C {lab_pin.sym} 5140 33560 0 0 {name=l27013 lab=WL168}
N 5240 33640 5260 33640 {}
C {lab_pin.sym} 5260 33640 0 0 {name=l27014 lab=VDD}
N 5240 33560 5260 33560 {}
C {lab_pin.sym} 5260 33560 0 0 {name=l27015 lab=VSS}
C {bitcell_6t.sym} 5400 33600 0 0 {name=Xr168c27}
N 5360 33640 5340 33640 {}
C {lab_pin.sym} 5340 33640 0 0 {name=l27016 lab=BL27}
N 5360 33600 5340 33600 {}
C {lab_pin.sym} 5340 33600 0 0 {name=l27017 lab=BLB27}
N 5360 33560 5340 33560 {}
C {lab_pin.sym} 5340 33560 0 0 {name=l27018 lab=WL168}
N 5440 33640 5460 33640 {}
C {lab_pin.sym} 5460 33640 0 0 {name=l27019 lab=VDD}
N 5440 33560 5460 33560 {}
C {lab_pin.sym} 5460 33560 0 0 {name=l27020 lab=VSS}
C {bitcell_6t.sym} 5600 33600 0 0 {name=Xr168c28}
N 5560 33640 5540 33640 {}
C {lab_pin.sym} 5540 33640 0 0 {name=l27021 lab=BL28}
N 5560 33600 5540 33600 {}
C {lab_pin.sym} 5540 33600 0 0 {name=l27022 lab=BLB28}
N 5560 33560 5540 33560 {}
C {lab_pin.sym} 5540 33560 0 0 {name=l27023 lab=WL168}
N 5640 33640 5660 33640 {}
C {lab_pin.sym} 5660 33640 0 0 {name=l27024 lab=VDD}
N 5640 33560 5660 33560 {}
C {lab_pin.sym} 5660 33560 0 0 {name=l27025 lab=VSS}
C {bitcell_6t.sym} 5800 33600 0 0 {name=Xr168c29}
N 5760 33640 5740 33640 {}
C {lab_pin.sym} 5740 33640 0 0 {name=l27026 lab=BL29}
N 5760 33600 5740 33600 {}
C {lab_pin.sym} 5740 33600 0 0 {name=l27027 lab=BLB29}
N 5760 33560 5740 33560 {}
C {lab_pin.sym} 5740 33560 0 0 {name=l27028 lab=WL168}
N 5840 33640 5860 33640 {}
C {lab_pin.sym} 5860 33640 0 0 {name=l27029 lab=VDD}
N 5840 33560 5860 33560 {}
C {lab_pin.sym} 5860 33560 0 0 {name=l27030 lab=VSS}
C {bitcell_6t.sym} 6000 33600 0 0 {name=Xr168c30}
N 5960 33640 5940 33640 {}
C {lab_pin.sym} 5940 33640 0 0 {name=l27031 lab=BL30}
N 5960 33600 5940 33600 {}
C {lab_pin.sym} 5940 33600 0 0 {name=l27032 lab=BLB30}
N 5960 33560 5940 33560 {}
C {lab_pin.sym} 5940 33560 0 0 {name=l27033 lab=WL168}
N 6040 33640 6060 33640 {}
C {lab_pin.sym} 6060 33640 0 0 {name=l27034 lab=VDD}
N 6040 33560 6060 33560 {}
C {lab_pin.sym} 6060 33560 0 0 {name=l27035 lab=VSS}
C {bitcell_6t.sym} 6200 33600 0 0 {name=Xr168c31}
N 6160 33640 6140 33640 {}
C {lab_pin.sym} 6140 33640 0 0 {name=l27036 lab=BL31}
N 6160 33600 6140 33600 {}
C {lab_pin.sym} 6140 33600 0 0 {name=l27037 lab=BLB31}
N 6160 33560 6140 33560 {}
C {lab_pin.sym} 6140 33560 0 0 {name=l27038 lab=WL168}
N 6240 33640 6260 33640 {}
C {lab_pin.sym} 6260 33640 0 0 {name=l27039 lab=VDD}
N 6240 33560 6260 33560 {}
C {lab_pin.sym} 6260 33560 0 0 {name=l27040 lab=VSS}
C {bitcell_6t.sym} 0 33800 0 0 {name=Xr169c0}
N -40 33840 -60 33840 {}
C {lab_pin.sym} -60 33840 0 0 {name=l27041 lab=BL0}
N -40 33800 -60 33800 {}
C {lab_pin.sym} -60 33800 0 0 {name=l27042 lab=BLB0}
N -40 33760 -60 33760 {}
C {lab_pin.sym} -60 33760 0 0 {name=l27043 lab=WL169}
N 40 33840 60 33840 {}
C {lab_pin.sym} 60 33840 0 0 {name=l27044 lab=VDD}
N 40 33760 60 33760 {}
C {lab_pin.sym} 60 33760 0 0 {name=l27045 lab=VSS}
C {bitcell_6t.sym} 200 33800 0 0 {name=Xr169c1}
N 160 33840 140 33840 {}
C {lab_pin.sym} 140 33840 0 0 {name=l27046 lab=BL1}
N 160 33800 140 33800 {}
C {lab_pin.sym} 140 33800 0 0 {name=l27047 lab=BLB1}
N 160 33760 140 33760 {}
C {lab_pin.sym} 140 33760 0 0 {name=l27048 lab=WL169}
N 240 33840 260 33840 {}
C {lab_pin.sym} 260 33840 0 0 {name=l27049 lab=VDD}
N 240 33760 260 33760 {}
C {lab_pin.sym} 260 33760 0 0 {name=l27050 lab=VSS}
C {bitcell_6t.sym} 400 33800 0 0 {name=Xr169c2}
N 360 33840 340 33840 {}
C {lab_pin.sym} 340 33840 0 0 {name=l27051 lab=BL2}
N 360 33800 340 33800 {}
C {lab_pin.sym} 340 33800 0 0 {name=l27052 lab=BLB2}
N 360 33760 340 33760 {}
C {lab_pin.sym} 340 33760 0 0 {name=l27053 lab=WL169}
N 440 33840 460 33840 {}
C {lab_pin.sym} 460 33840 0 0 {name=l27054 lab=VDD}
N 440 33760 460 33760 {}
C {lab_pin.sym} 460 33760 0 0 {name=l27055 lab=VSS}
C {bitcell_6t.sym} 600 33800 0 0 {name=Xr169c3}
N 560 33840 540 33840 {}
C {lab_pin.sym} 540 33840 0 0 {name=l27056 lab=BL3}
N 560 33800 540 33800 {}
C {lab_pin.sym} 540 33800 0 0 {name=l27057 lab=BLB3}
N 560 33760 540 33760 {}
C {lab_pin.sym} 540 33760 0 0 {name=l27058 lab=WL169}
N 640 33840 660 33840 {}
C {lab_pin.sym} 660 33840 0 0 {name=l27059 lab=VDD}
N 640 33760 660 33760 {}
C {lab_pin.sym} 660 33760 0 0 {name=l27060 lab=VSS}
C {bitcell_6t.sym} 800 33800 0 0 {name=Xr169c4}
N 760 33840 740 33840 {}
C {lab_pin.sym} 740 33840 0 0 {name=l27061 lab=BL4}
N 760 33800 740 33800 {}
C {lab_pin.sym} 740 33800 0 0 {name=l27062 lab=BLB4}
N 760 33760 740 33760 {}
C {lab_pin.sym} 740 33760 0 0 {name=l27063 lab=WL169}
N 840 33840 860 33840 {}
C {lab_pin.sym} 860 33840 0 0 {name=l27064 lab=VDD}
N 840 33760 860 33760 {}
C {lab_pin.sym} 860 33760 0 0 {name=l27065 lab=VSS}
C {bitcell_6t.sym} 1000 33800 0 0 {name=Xr169c5}
N 960 33840 940 33840 {}
C {lab_pin.sym} 940 33840 0 0 {name=l27066 lab=BL5}
N 960 33800 940 33800 {}
C {lab_pin.sym} 940 33800 0 0 {name=l27067 lab=BLB5}
N 960 33760 940 33760 {}
C {lab_pin.sym} 940 33760 0 0 {name=l27068 lab=WL169}
N 1040 33840 1060 33840 {}
C {lab_pin.sym} 1060 33840 0 0 {name=l27069 lab=VDD}
N 1040 33760 1060 33760 {}
C {lab_pin.sym} 1060 33760 0 0 {name=l27070 lab=VSS}
C {bitcell_6t.sym} 1200 33800 0 0 {name=Xr169c6}
N 1160 33840 1140 33840 {}
C {lab_pin.sym} 1140 33840 0 0 {name=l27071 lab=BL6}
N 1160 33800 1140 33800 {}
C {lab_pin.sym} 1140 33800 0 0 {name=l27072 lab=BLB6}
N 1160 33760 1140 33760 {}
C {lab_pin.sym} 1140 33760 0 0 {name=l27073 lab=WL169}
N 1240 33840 1260 33840 {}
C {lab_pin.sym} 1260 33840 0 0 {name=l27074 lab=VDD}
N 1240 33760 1260 33760 {}
C {lab_pin.sym} 1260 33760 0 0 {name=l27075 lab=VSS}
C {bitcell_6t.sym} 1400 33800 0 0 {name=Xr169c7}
N 1360 33840 1340 33840 {}
C {lab_pin.sym} 1340 33840 0 0 {name=l27076 lab=BL7}
N 1360 33800 1340 33800 {}
C {lab_pin.sym} 1340 33800 0 0 {name=l27077 lab=BLB7}
N 1360 33760 1340 33760 {}
C {lab_pin.sym} 1340 33760 0 0 {name=l27078 lab=WL169}
N 1440 33840 1460 33840 {}
C {lab_pin.sym} 1460 33840 0 0 {name=l27079 lab=VDD}
N 1440 33760 1460 33760 {}
C {lab_pin.sym} 1460 33760 0 0 {name=l27080 lab=VSS}
C {bitcell_6t.sym} 1600 33800 0 0 {name=Xr169c8}
N 1560 33840 1540 33840 {}
C {lab_pin.sym} 1540 33840 0 0 {name=l27081 lab=BL8}
N 1560 33800 1540 33800 {}
C {lab_pin.sym} 1540 33800 0 0 {name=l27082 lab=BLB8}
N 1560 33760 1540 33760 {}
C {lab_pin.sym} 1540 33760 0 0 {name=l27083 lab=WL169}
N 1640 33840 1660 33840 {}
C {lab_pin.sym} 1660 33840 0 0 {name=l27084 lab=VDD}
N 1640 33760 1660 33760 {}
C {lab_pin.sym} 1660 33760 0 0 {name=l27085 lab=VSS}
C {bitcell_6t.sym} 1800 33800 0 0 {name=Xr169c9}
N 1760 33840 1740 33840 {}
C {lab_pin.sym} 1740 33840 0 0 {name=l27086 lab=BL9}
N 1760 33800 1740 33800 {}
C {lab_pin.sym} 1740 33800 0 0 {name=l27087 lab=BLB9}
N 1760 33760 1740 33760 {}
C {lab_pin.sym} 1740 33760 0 0 {name=l27088 lab=WL169}
N 1840 33840 1860 33840 {}
C {lab_pin.sym} 1860 33840 0 0 {name=l27089 lab=VDD}
N 1840 33760 1860 33760 {}
C {lab_pin.sym} 1860 33760 0 0 {name=l27090 lab=VSS}
C {bitcell_6t.sym} 2000 33800 0 0 {name=Xr169c10}
N 1960 33840 1940 33840 {}
C {lab_pin.sym} 1940 33840 0 0 {name=l27091 lab=BL10}
N 1960 33800 1940 33800 {}
C {lab_pin.sym} 1940 33800 0 0 {name=l27092 lab=BLB10}
N 1960 33760 1940 33760 {}
C {lab_pin.sym} 1940 33760 0 0 {name=l27093 lab=WL169}
N 2040 33840 2060 33840 {}
C {lab_pin.sym} 2060 33840 0 0 {name=l27094 lab=VDD}
N 2040 33760 2060 33760 {}
C {lab_pin.sym} 2060 33760 0 0 {name=l27095 lab=VSS}
C {bitcell_6t.sym} 2200 33800 0 0 {name=Xr169c11}
N 2160 33840 2140 33840 {}
C {lab_pin.sym} 2140 33840 0 0 {name=l27096 lab=BL11}
N 2160 33800 2140 33800 {}
C {lab_pin.sym} 2140 33800 0 0 {name=l27097 lab=BLB11}
N 2160 33760 2140 33760 {}
C {lab_pin.sym} 2140 33760 0 0 {name=l27098 lab=WL169}
N 2240 33840 2260 33840 {}
C {lab_pin.sym} 2260 33840 0 0 {name=l27099 lab=VDD}
N 2240 33760 2260 33760 {}
C {lab_pin.sym} 2260 33760 0 0 {name=l27100 lab=VSS}
C {bitcell_6t.sym} 2400 33800 0 0 {name=Xr169c12}
N 2360 33840 2340 33840 {}
C {lab_pin.sym} 2340 33840 0 0 {name=l27101 lab=BL12}
N 2360 33800 2340 33800 {}
C {lab_pin.sym} 2340 33800 0 0 {name=l27102 lab=BLB12}
N 2360 33760 2340 33760 {}
C {lab_pin.sym} 2340 33760 0 0 {name=l27103 lab=WL169}
N 2440 33840 2460 33840 {}
C {lab_pin.sym} 2460 33840 0 0 {name=l27104 lab=VDD}
N 2440 33760 2460 33760 {}
C {lab_pin.sym} 2460 33760 0 0 {name=l27105 lab=VSS}
C {bitcell_6t.sym} 2600 33800 0 0 {name=Xr169c13}
N 2560 33840 2540 33840 {}
C {lab_pin.sym} 2540 33840 0 0 {name=l27106 lab=BL13}
N 2560 33800 2540 33800 {}
C {lab_pin.sym} 2540 33800 0 0 {name=l27107 lab=BLB13}
N 2560 33760 2540 33760 {}
C {lab_pin.sym} 2540 33760 0 0 {name=l27108 lab=WL169}
N 2640 33840 2660 33840 {}
C {lab_pin.sym} 2660 33840 0 0 {name=l27109 lab=VDD}
N 2640 33760 2660 33760 {}
C {lab_pin.sym} 2660 33760 0 0 {name=l27110 lab=VSS}
C {bitcell_6t.sym} 2800 33800 0 0 {name=Xr169c14}
N 2760 33840 2740 33840 {}
